* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_22x64.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_22x64 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 a0_0 a0_1 a0_2 a0_3 a0_4 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 vdd gnd freepdk45_sram_1rw0r_22x64

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f
CD040 dout0_40  0 0.8364f
CD041 dout0_41  0 0.8364f
CD042 dout0_42  0 0.8364f
CD043 dout0_43  0 0.8364f
CD044 dout0_44  0 0.8364f
CD045 dout0_45  0 0.8364f
CD046 dout0_46  0 0.8364f
CD047 dout0_47  0 0.8364f
CD048 dout0_48  0 0.8364f
CD049 dout0_49  0 0.8364f
CD050 dout0_50  0 0.8364f
CD051 dout0_51  0 0.8364f
CD052 dout0_52  0 0.8364f
CD053 dout0_53  0 0.8364f
CD054 dout0_54  0 0.8364f
CD055 dout0_55  0 0.8364f
CD056 dout0_56  0 0.8364f
CD057 dout0_57  0 0.8364f
CD058 dout0_58  0 0.8364f
CD059 dout0_59  0 0.8364f
CD060 dout0_60  0 0.8364f
CD061 dout0_61  0 0.8364f
CD062 dout0_62  0 0.8364f
CD063 dout0_63  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_22x64.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_22x64.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_22x64.s_en
* q:	xfreepdk45_sram_1rw0r_22x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_22x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 1010101001100110110111001110111110011101101001101010010011011101  to  address 00000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 0101110111001111101011101011011111100000111111011100011001010001  to  address 00000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 1010010100101001001000000001000110001010010110010111010101010110  to  address 00000 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 1010010100101001001000000001000110001010010110010111010101010110 from address 00000 (from port 0) during cycle 4 (20ns - 25ns)
*	Reading 1010010100101001001000000001000110001010010110010111010101010110 from address 00000 (from port 0) during cycle 6 (30ns - 35ns)
*	Reading 1010010100101001001000000001000110001010010110010111010101010110 from address 00000 (from port 0) during cycle 7 (35ns - 40ns)
*	Reading 1010010100101001001000000001000110001010010110010111010101010110 from address 00000 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing 0111110100111100101101111101011001101001101001000110011110110000  to  address 00000 (from port 0) during cycle 9 (45ns - 50ns)
*	Reading 0111110100111100101101111101011001101001101001000110011110110000 from address 00000 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 0111110100111100101101111101011001101001101001000110011110110000 from address 00000 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 0111110100111100101101111101011001101001101001000110011110110000 from address 00000 (from port 0) during cycle 13 (65ns - 70ns)
*	Reading 0111110100111100101101111101011001101001101001000110011110110000 from address 00000 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 0111110100111100101101111101011001101001101001000110011110110000 from address 00000 (from port 0) during cycle 15 (75ns - 80ns)
*	Reading 0111110100111100101101111101011001101001101001000110011110110000 from address 00000 (from port 0) during cycle 16 (80ns - 85ns)
*	Writing 1101111000111100011010010101001101001010010100000011010011111010  to  address 00000 (from port 0) during cycle 17 (85ns - 90ns)
*	Writing 0000111100111001101101101110010011011101001010011100110011001010  to  address 00000 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 0000111100111001101101101110010011011101001010011100110011001010 from address 00000 (from port 0) during cycle 21 (105ns - 110ns)
*	Writing 0000110010001110101011000011000001010011010000100101111100100000  to  address 00000 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 1100101111000110110110001101001001011100000000000010010011111100  to  address 00000 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 1100101111000110110110001101001001011100000000000010010011111100 from address 00000 (from port 0) during cycle 24 (120ns - 125ns)
*	Reading 1100101111000110110110001101001001011100000000000010010011111100 from address 00000 (from port 0) during cycle 25 (125ns - 130ns)
*	Writing 1011110110110101010110101001001000100011001100111100101010001110  to  address 00000 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing 0101000111110011100010110100011000110011011000010110000010011011  to  address 10100 (from port 0) during cycle 29 (145ns - 150ns)
*	Writing 0011001111100100011011000110111100001110000100110111100001001111  to  address 00000 (from port 0) during cycle 30 (150ns - 155ns)
*	Writing 1100101000111111000000111101011101001100010001101010011111111010  to  address 10100 (from port 0) during cycle 31 (155ns - 160ns)
*	Writing 1000001000101111000110001111110111011001011001100000100001100011  to  address 00000 (from port 0) during cycle 32 (160ns - 165ns)
*	Writing 1010000001111001100011100000100111111110001111000101000000101011  to  address 10100 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing 1001110001010001111001111010010000101100010001111000110111001100  to  address 10100 (from port 0) during cycle 35 (175ns - 180ns)
*	Reading 1001110001010001111001111010010000101100010001111000110111001100 from address 10100 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 1001110001010001111001111010010000101100010001111000110111001100 from address 10100 (from port 0) during cycle 37 (185ns - 190ns)
*	Reading 1000001000101111000110001111110111011001011001100000100001100011 from address 00000 (from port 0) during cycle 39 (195ns - 200ns)
*	Writing 0011100110110110011000011011111001001001101000000000011110010101  to  address 00000 (from port 0) during cycle 40 (200ns - 205ns)
*	Reading 1001110001010001111001111010010000101100010001111000110111001100 from address 10100 (from port 0) during cycle 41 (205ns - 210ns)
*	Reading 0011100110110110011000011011111001001001101000000000011110010101 from address 00000 (from port 0) during cycle 42 (210ns - 215ns)
*	Reading 1001110001010001111001111010010000101100010001111000110111001100 from address 10100 (from port 0) during cycle 43 (215ns - 220ns)
*	Writing 0110010000011101001010010111010011101110000110000110001110101011  to  address 10100 (from port 0) during cycle 44 (220ns - 225ns)
*	Reading 0110010000011101001010010111010011101110000110000110001110101011 from address 10100 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 0011100110110110011000011011111001001001101000000000011110010101 from address 00000 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing 0110001101000100011111111001100001010010000000101100111111100111  to  address 00000 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing 0101111111100001010101111010010010000110010000100001000001110110  to  address 10100 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 0101111111100001010101111010010010000110010000100001000001110110 from address 10100 (from port 0) during cycle 53 (265ns - 270ns)
*	Reading 0101111111100001010101111010010010000110010000100001000001110110 from address 10100 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing 1111111011111011110010011100100000010000001111100101001111101011  to  address 10100 (from port 0) during cycle 55 (275ns - 280ns)
*	Reading 0110001101000100011111111001100001010010000000101100111111100111 from address 00000 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 0110001101000100011111111001100001010010000000101100111111100111 from address 00000 (from port 0) during cycle 58 (290ns - 295ns)
*	Reading 1111111011111011110010011100100000010000001111100101001111101011 from address 10100 (from port 0) during cycle 59 (295ns - 300ns)
*	Reading 0110001101000100011111111001100001010010000000101100111111100111 from address 00000 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 0110001101000100011111111001100001010010000000101100111111100111 from address 00000 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 0110111111011001011110011110111000111010010100010000001111010000  to  address 10100 (from port 0) during cycle 64 (320ns - 325ns)
*	Writing 0101001010110010111000100101011011110100001001111001011101110101  to  address 10100 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 0101001010110010111000100101011011110100001001111001011101110101 from address 10100 (from port 0) during cycle 67 (335ns - 340ns)
*	Reading 0101001010110010111000100101011011110100001001111001011101110101 from address 10100 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 0101001010110010111000100101011011110100001001111001011101110101 from address 10100 (from port 0) during cycle 69 (345ns - 350ns)
*	Writing 1010010110110010101111100001111011101111001001011111000011101100  to  address 10100 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 0110001101000100011111111001100001010010000000101100111111100111 from address 00000 (from port 0) during cycle 71 (355ns - 360ns)
*	Writing 1111101101110101011010100011110100000001010111111101010111010101  to  address 00000 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 0001010000010111101110000010101100000000101110110111011111010001  to  address 00000 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 0001001011011101001101010110111111001100011111110011111001100010  to  address 10100 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing 0011011100110000111000011010001110001111101110010011110100101111  to  address 10100 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 0011011100110000111000011010001110001111101110010011110100101111 from address 10100 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 0001010000010111101110000010101100000000101110110111011111010001 from address 00000 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing 0011011100101101011001101111010000001010001000101101100010110100  to  address 00000 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 0011011100110000111000011010001110001111101110010011110100101111 from address 10100 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 1101000100100100111101010011111100110001011101101100110110101011  to  address 00000 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing 0000111100100001000111110100101001010011000001101111111111011011  to  address 10100 (from port 0) during cycle 83 (415ns - 420ns)
*	Writing 0001011010110100100100001100101001011000010010011010101010100111  to  address 00000 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing 0000011010000001100100011001011101001000101111000101101111010111  to  address 00000 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing 1001110111111000101111000100101010111111010001001111101101110001  to  address 00000 (from port 0) during cycle 87 (435ns - 440ns)
*	Reading 1001110111111000101111000100101010111111010001001111101101110001 from address 00000 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 1001110111111000101111000100101010111111010001001111101101110001 from address 00000 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 1001110111111000101111000100101010111111010001001111101101110001 from address 00000 (from port 0) during cycle 90 (450ns - 455ns)
*	Reading 0000111100100001000111110100101001010011000001101111111111011011 from address 10100 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 0000111100100001000111110100101001010011000001101111111111011011 from address 10100 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 1001110111111000101111000100101010111111010001001111101101110001 from address 00000 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 0000111100100001000111110100101001010011000001101111111111011011 from address 10100 (from port 0) during cycle 94 (470ns - 475ns)
*	Writing 1001000001110111110010110010010100101110101100010000101010100010  to  address 00000 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 1001000001110111110010110010010100101110101100010000101010100010 from address 00000 (from port 0) during cycle 96 (480ns - 485ns)
*	Writing 0110011000001010010110110000110000101101100110110011000001010101  to  address 10100 (from port 0) during cycle 97 (485ns - 490ns)
*	Writing 0010000010110110111111001000111001111011000111010001000110111000  to  address 10100 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 0011011000010001000010000000000101001110011100011101110100010000  to  address 10100 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 1001000001110111110010110010010100101110101100010000101010100010 from address 00000 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 1001000001110111110010110010010100101110101100010000101010100010 from address 00000 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 1001000001110111110010110010010100101110101100010000101010100010 from address 00000 (from port 0) during cycle 103 (515ns - 520ns)
*	Reading 0011011000010001000010000000000101001110011100011101110100010000 from address 10100 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 1001000001110111110010110010010100101110101100010000101010100010 from address 00000 (from port 0) during cycle 105 (525ns - 530ns)
*	Reading 0011011000010001000010000000000101001110011100011101110100010000 from address 10100 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 1001000001110111110010110010010100101110101100010000101010100010 from address 00000 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 0011011000010001000010000000000101001110011100011101110100010000 from address 10100 (from port 0) during cycle 110 (550ns - 555ns)
*	Writing 1000011111010100010000000111101101111111011110000101001110111100  to  address 00000 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 1000011111010100010000000111101101111111011110000101001110111100 from address 00000 (from port 0) during cycle 113 (565ns - 570ns)
*	Writing 0000101000111001101010111000000110001010011100001010110001010001  to  address 00000 (from port 0) during cycle 114 (570ns - 575ns)
*	Writing 0100001001000111000110011001101011010010010100101010100000111001  to  address 10100 (from port 0) during cycle 115 (575ns - 580ns)
*	Reading 0100001001000111000110011001101011010010010100101010100000111001 from address 10100 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 0010100011010111100110101101001100111011000011011111110011001010  to  address 10100 (from port 0) during cycle 117 (585ns - 590ns)
*	Writing 0111100001100101100011100000011100001111010110001110001000111111  to  address 00000 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 0111100001100101100011100000011100001111010110001110001000111111 from address 00000 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 0010100011010111100110101101001100111011000011011111110011001010 from address 10100 (from port 0) during cycle 123 (615ns - 620ns)
*	Reading 0010100011010111100110101101001100111011000011011111110011001010 from address 10100 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 0111100001100101100011100000011100001111010110001110001000111111 from address 00000 (from port 0) during cycle 125 (625ns - 630ns)
*	Reading 0111100001100101100011100000011100001111010110001110001000111111 from address 00000 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 1001110111011101111101010101011010111110110100011110010110100010  to  address 00000 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 0010100011010111100110101101001100111011000011011111110011001010 from address 10100 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 1001110111011101111101010101011010111110110100011110010110100010 from address 00000 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 0010100011010111100110101101001100111011000011011111110011001010 from address 10100 (from port 0) during cycle 132 (660ns - 665ns)
*	Reading 1001110111011101111101010101011010111110110100011110010110100010 from address 00000 (from port 0) during cycle 133 (665ns - 670ns)
*	Reading 1001110111011101111101010101011010111110110100011110010110100010 from address 00000 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing 1110000001010010001011010111000111101101000100001100000010000111  to  address 00000 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 1110000001010010001011010111000111101101000100001100000010000111 from address 00000 (from port 0) during cycle 139 (695ns - 700ns)
*	Reading 1110000001010010001011010111000111101101000100001100000010000111 from address 00000 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 1110000001010010001011010111000111101101000100001100000010000111 from address 00000 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 1110000001010010001011010111000111101101000100001100000010000111 from address 00000 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 1110000001010010001011010111000111101101000100001100000010000111 from address 00000 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 1110000001010010001011010111000111101101000100001100000010000111 from address 00000 (from port 0) during cycle 146 (730ns - 735ns)
*	Reading 0010100011010111100110101101001100111011000011011111110011001010 from address 10100 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 0010100011010111100110101101001100111011000011011111110011001010 from address 10100 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing 0000010001010101111110110010101111110000001101000001010000110110  to  address 10100 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 1010101001011110100010100001110010110110100101010101100011110111  to  address 00000 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 1010101001011110100010100001110010110110100101010101100011110111 from address 00000 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 1010101001011110100010100001110010110110100101010101100011110111 from address 00000 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 0101010100110101101100001110110001100111001101010101011010111111  to  address 00000 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 157 (785ns - 790ns)
*	Writing 0000011011100010111010011000111110011010111000100001100011000011  to  address 10100 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 0000011011100010111010011000111110011010111000100001100011000011 from address 10100 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 0000011011100010111010011000111110011010111000100001100011000011 from address 10100 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 0000011011100010111010011000111110011010111000100001100011000011 from address 10100 (from port 0) during cycle 171 (855ns - 860ns)
*	Writing 0101101000010010100000011000101010001110101010010010100000011110  to  address 10100 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 0101010100110101101100001110110001100111001101010101011010111111 from address 00000 (from port 0) during cycle 176 (880ns - 885ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 0000010011010000000111011111010010110011101110010111110100101000  to  address 00000 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 181 (905ns - 910ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 183 (915ns - 920ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 186 (930ns - 935ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 188 (940ns - 945ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 190 (950ns - 955ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 191 (955ns - 960ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 0101101000010010100000011000101010001110101010010010100000011110 from address 10100 (from port 0) during cycle 194 (970ns - 975ns)
*	Writing 0110100010000100100011001000101111110001110100111101000001100110  to  address 10100 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 0110100010000100100011001000101111110001110100111101000001100110 from address 10100 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 0110100010000100100011001000101111110001110100111101000001100110 from address 10100 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 0000010011010000000111011111010010110011101110010111110100101000 from address 00000 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Writing 0011001010111001000010011110000001011011100100100000110100010011  to  address 10100 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0.9 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0.9 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0.9 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0.9 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0.9 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0.9 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0.9 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0.9 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0.9 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0.9 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0.9 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0.9 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0.9 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0.9 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0.9 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0.9 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0.9 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0.9 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_40 Vdout0_40ck4 = 0 time = 25
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=25.025n

* CHECK dout0_41 Vdout0_41ck4 = 0 time = 25
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=25.025n

* CHECK dout0_42 Vdout0_42ck4 = 0 time = 25
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=25.025n

* CHECK dout0_43 Vdout0_43ck4 = 0 time = 25
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=25.025n

* CHECK dout0_44 Vdout0_44ck4 = 0 time = 25
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=25.025n

* CHECK dout0_45 Vdout0_45ck4 = 0.9 time = 25
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=25.025n

* CHECK dout0_46 Vdout0_46ck4 = 0 time = 25
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=25.025n

* CHECK dout0_47 Vdout0_47ck4 = 0 time = 25
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=25.025n

* CHECK dout0_48 Vdout0_48ck4 = 0.9 time = 25
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=25.025n

* CHECK dout0_49 Vdout0_49ck4 = 0 time = 25
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=25.025n

* CHECK dout0_50 Vdout0_50ck4 = 0 time = 25
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=25.025n

* CHECK dout0_51 Vdout0_51ck4 = 0.9 time = 25
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=25.025n

* CHECK dout0_52 Vdout0_52ck4 = 0 time = 25
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=25.025n

* CHECK dout0_53 Vdout0_53ck4 = 0.9 time = 25
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=25.025n

* CHECK dout0_54 Vdout0_54ck4 = 0 time = 25
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=25.025n

* CHECK dout0_55 Vdout0_55ck4 = 0 time = 25
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=25.025n

* CHECK dout0_56 Vdout0_56ck4 = 0.9 time = 25
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=25.025n

* CHECK dout0_57 Vdout0_57ck4 = 0 time = 25
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=25.025n

* CHECK dout0_58 Vdout0_58ck4 = 0.9 time = 25
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=25.025n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 25
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=25.025n

* CHECK dout0_60 Vdout0_60ck4 = 0 time = 25
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=25.025n

* CHECK dout0_61 Vdout0_61ck4 = 0.9 time = 25
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=25.025n

* CHECK dout0_62 Vdout0_62ck4 = 0 time = 25
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=25.025n

* CHECK dout0_63 Vdout0_63ck4 = 0.9 time = 25
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=25.025n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 35
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=35.025n

* CHECK dout0_1 Vdout0_1ck6 = 0.9 time = 35
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=35.025n

* CHECK dout0_2 Vdout0_2ck6 = 0.9 time = 35
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=35.025n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 35
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=35.025n

* CHECK dout0_4 Vdout0_4ck6 = 0.9 time = 35
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=35.025n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 35
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=35.025n

* CHECK dout0_6 Vdout0_6ck6 = 0.9 time = 35
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=35.025n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 35
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=35.025n

* CHECK dout0_8 Vdout0_8ck6 = 0.9 time = 35
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=35.025n

* CHECK dout0_9 Vdout0_9ck6 = 0 time = 35
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=35.025n

* CHECK dout0_10 Vdout0_10ck6 = 0.9 time = 35
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=35.025n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 35
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=35.025n

* CHECK dout0_12 Vdout0_12ck6 = 0.9 time = 35
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=35.025n

* CHECK dout0_13 Vdout0_13ck6 = 0.9 time = 35
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=35.025n

* CHECK dout0_14 Vdout0_14ck6 = 0.9 time = 35
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=35.025n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 35
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=35.025n

* CHECK dout0_16 Vdout0_16ck6 = 0.9 time = 35
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=35.025n

* CHECK dout0_17 Vdout0_17ck6 = 0 time = 35
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=35.025n

* CHECK dout0_18 Vdout0_18ck6 = 0 time = 35
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=35.025n

* CHECK dout0_19 Vdout0_19ck6 = 0.9 time = 35
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=35.025n

* CHECK dout0_20 Vdout0_20ck6 = 0.9 time = 35
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=35.025n

* CHECK dout0_21 Vdout0_21ck6 = 0 time = 35
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=35.025n

* CHECK dout0_22 Vdout0_22ck6 = 0.9 time = 35
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=35.025n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 35
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=35.025n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 35
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=35.025n

* CHECK dout0_25 Vdout0_25ck6 = 0.9 time = 35
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=35.025n

* CHECK dout0_26 Vdout0_26ck6 = 0 time = 35
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=35.025n

* CHECK dout0_27 Vdout0_27ck6 = 0.9 time = 35
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=35.025n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 35
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=35.025n

* CHECK dout0_29 Vdout0_29ck6 = 0 time = 35
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=35.025n

* CHECK dout0_30 Vdout0_30ck6 = 0 time = 35
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=35.025n

* CHECK dout0_31 Vdout0_31ck6 = 0.9 time = 35
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=35.025n

* CHECK dout0_32 Vdout0_32ck6 = 0.9 time = 35
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=35.025n

* CHECK dout0_33 Vdout0_33ck6 = 0 time = 35
.meas tran vdout0_33ck6 FIND v(dout0_33) AT=35.025n

* CHECK dout0_34 Vdout0_34ck6 = 0 time = 35
.meas tran vdout0_34ck6 FIND v(dout0_34) AT=35.025n

* CHECK dout0_35 Vdout0_35ck6 = 0 time = 35
.meas tran vdout0_35ck6 FIND v(dout0_35) AT=35.025n

* CHECK dout0_36 Vdout0_36ck6 = 0.9 time = 35
.meas tran vdout0_36ck6 FIND v(dout0_36) AT=35.025n

* CHECK dout0_37 Vdout0_37ck6 = 0 time = 35
.meas tran vdout0_37ck6 FIND v(dout0_37) AT=35.025n

* CHECK dout0_38 Vdout0_38ck6 = 0 time = 35
.meas tran vdout0_38ck6 FIND v(dout0_38) AT=35.025n

* CHECK dout0_39 Vdout0_39ck6 = 0 time = 35
.meas tran vdout0_39ck6 FIND v(dout0_39) AT=35.025n

* CHECK dout0_40 Vdout0_40ck6 = 0 time = 35
.meas tran vdout0_40ck6 FIND v(dout0_40) AT=35.025n

* CHECK dout0_41 Vdout0_41ck6 = 0 time = 35
.meas tran vdout0_41ck6 FIND v(dout0_41) AT=35.025n

* CHECK dout0_42 Vdout0_42ck6 = 0 time = 35
.meas tran vdout0_42ck6 FIND v(dout0_42) AT=35.025n

* CHECK dout0_43 Vdout0_43ck6 = 0 time = 35
.meas tran vdout0_43ck6 FIND v(dout0_43) AT=35.025n

* CHECK dout0_44 Vdout0_44ck6 = 0 time = 35
.meas tran vdout0_44ck6 FIND v(dout0_44) AT=35.025n

* CHECK dout0_45 Vdout0_45ck6 = 0.9 time = 35
.meas tran vdout0_45ck6 FIND v(dout0_45) AT=35.025n

* CHECK dout0_46 Vdout0_46ck6 = 0 time = 35
.meas tran vdout0_46ck6 FIND v(dout0_46) AT=35.025n

* CHECK dout0_47 Vdout0_47ck6 = 0 time = 35
.meas tran vdout0_47ck6 FIND v(dout0_47) AT=35.025n

* CHECK dout0_48 Vdout0_48ck6 = 0.9 time = 35
.meas tran vdout0_48ck6 FIND v(dout0_48) AT=35.025n

* CHECK dout0_49 Vdout0_49ck6 = 0 time = 35
.meas tran vdout0_49ck6 FIND v(dout0_49) AT=35.025n

* CHECK dout0_50 Vdout0_50ck6 = 0 time = 35
.meas tran vdout0_50ck6 FIND v(dout0_50) AT=35.025n

* CHECK dout0_51 Vdout0_51ck6 = 0.9 time = 35
.meas tran vdout0_51ck6 FIND v(dout0_51) AT=35.025n

* CHECK dout0_52 Vdout0_52ck6 = 0 time = 35
.meas tran vdout0_52ck6 FIND v(dout0_52) AT=35.025n

* CHECK dout0_53 Vdout0_53ck6 = 0.9 time = 35
.meas tran vdout0_53ck6 FIND v(dout0_53) AT=35.025n

* CHECK dout0_54 Vdout0_54ck6 = 0 time = 35
.meas tran vdout0_54ck6 FIND v(dout0_54) AT=35.025n

* CHECK dout0_55 Vdout0_55ck6 = 0 time = 35
.meas tran vdout0_55ck6 FIND v(dout0_55) AT=35.025n

* CHECK dout0_56 Vdout0_56ck6 = 0.9 time = 35
.meas tran vdout0_56ck6 FIND v(dout0_56) AT=35.025n

* CHECK dout0_57 Vdout0_57ck6 = 0 time = 35
.meas tran vdout0_57ck6 FIND v(dout0_57) AT=35.025n

* CHECK dout0_58 Vdout0_58ck6 = 0.9 time = 35
.meas tran vdout0_58ck6 FIND v(dout0_58) AT=35.025n

* CHECK dout0_59 Vdout0_59ck6 = 0 time = 35
.meas tran vdout0_59ck6 FIND v(dout0_59) AT=35.025n

* CHECK dout0_60 Vdout0_60ck6 = 0 time = 35
.meas tran vdout0_60ck6 FIND v(dout0_60) AT=35.025n

* CHECK dout0_61 Vdout0_61ck6 = 0.9 time = 35
.meas tran vdout0_61ck6 FIND v(dout0_61) AT=35.025n

* CHECK dout0_62 Vdout0_62ck6 = 0 time = 35
.meas tran vdout0_62ck6 FIND v(dout0_62) AT=35.025n

* CHECK dout0_63 Vdout0_63ck6 = 0.9 time = 35
.meas tran vdout0_63ck6 FIND v(dout0_63) AT=35.025n

* CHECK dout0_0 Vdout0_0ck7 = 0 time = 40
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=40.025n

* CHECK dout0_1 Vdout0_1ck7 = 0.9 time = 40
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=40.025n

* CHECK dout0_2 Vdout0_2ck7 = 0.9 time = 40
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=40.025n

* CHECK dout0_3 Vdout0_3ck7 = 0 time = 40
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=40.025n

* CHECK dout0_4 Vdout0_4ck7 = 0.9 time = 40
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=40.025n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 40
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=40.025n

* CHECK dout0_6 Vdout0_6ck7 = 0.9 time = 40
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=40.025n

* CHECK dout0_7 Vdout0_7ck7 = 0 time = 40
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=40.025n

* CHECK dout0_8 Vdout0_8ck7 = 0.9 time = 40
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=40.025n

* CHECK dout0_9 Vdout0_9ck7 = 0 time = 40
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=40.025n

* CHECK dout0_10 Vdout0_10ck7 = 0.9 time = 40
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=40.025n

* CHECK dout0_11 Vdout0_11ck7 = 0 time = 40
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=40.025n

* CHECK dout0_12 Vdout0_12ck7 = 0.9 time = 40
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=40.025n

* CHECK dout0_13 Vdout0_13ck7 = 0.9 time = 40
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=40.025n

* CHECK dout0_14 Vdout0_14ck7 = 0.9 time = 40
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=40.025n

* CHECK dout0_15 Vdout0_15ck7 = 0 time = 40
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=40.025n

* CHECK dout0_16 Vdout0_16ck7 = 0.9 time = 40
.meas tran vdout0_16ck7 FIND v(dout0_16) AT=40.025n

* CHECK dout0_17 Vdout0_17ck7 = 0 time = 40
.meas tran vdout0_17ck7 FIND v(dout0_17) AT=40.025n

* CHECK dout0_18 Vdout0_18ck7 = 0 time = 40
.meas tran vdout0_18ck7 FIND v(dout0_18) AT=40.025n

* CHECK dout0_19 Vdout0_19ck7 = 0.9 time = 40
.meas tran vdout0_19ck7 FIND v(dout0_19) AT=40.025n

* CHECK dout0_20 Vdout0_20ck7 = 0.9 time = 40
.meas tran vdout0_20ck7 FIND v(dout0_20) AT=40.025n

* CHECK dout0_21 Vdout0_21ck7 = 0 time = 40
.meas tran vdout0_21ck7 FIND v(dout0_21) AT=40.025n

* CHECK dout0_22 Vdout0_22ck7 = 0.9 time = 40
.meas tran vdout0_22ck7 FIND v(dout0_22) AT=40.025n

* CHECK dout0_23 Vdout0_23ck7 = 0 time = 40
.meas tran vdout0_23ck7 FIND v(dout0_23) AT=40.025n

* CHECK dout0_24 Vdout0_24ck7 = 0 time = 40
.meas tran vdout0_24ck7 FIND v(dout0_24) AT=40.025n

* CHECK dout0_25 Vdout0_25ck7 = 0.9 time = 40
.meas tran vdout0_25ck7 FIND v(dout0_25) AT=40.025n

* CHECK dout0_26 Vdout0_26ck7 = 0 time = 40
.meas tran vdout0_26ck7 FIND v(dout0_26) AT=40.025n

* CHECK dout0_27 Vdout0_27ck7 = 0.9 time = 40
.meas tran vdout0_27ck7 FIND v(dout0_27) AT=40.025n

* CHECK dout0_28 Vdout0_28ck7 = 0 time = 40
.meas tran vdout0_28ck7 FIND v(dout0_28) AT=40.025n

* CHECK dout0_29 Vdout0_29ck7 = 0 time = 40
.meas tran vdout0_29ck7 FIND v(dout0_29) AT=40.025n

* CHECK dout0_30 Vdout0_30ck7 = 0 time = 40
.meas tran vdout0_30ck7 FIND v(dout0_30) AT=40.025n

* CHECK dout0_31 Vdout0_31ck7 = 0.9 time = 40
.meas tran vdout0_31ck7 FIND v(dout0_31) AT=40.025n

* CHECK dout0_32 Vdout0_32ck7 = 0.9 time = 40
.meas tran vdout0_32ck7 FIND v(dout0_32) AT=40.025n

* CHECK dout0_33 Vdout0_33ck7 = 0 time = 40
.meas tran vdout0_33ck7 FIND v(dout0_33) AT=40.025n

* CHECK dout0_34 Vdout0_34ck7 = 0 time = 40
.meas tran vdout0_34ck7 FIND v(dout0_34) AT=40.025n

* CHECK dout0_35 Vdout0_35ck7 = 0 time = 40
.meas tran vdout0_35ck7 FIND v(dout0_35) AT=40.025n

* CHECK dout0_36 Vdout0_36ck7 = 0.9 time = 40
.meas tran vdout0_36ck7 FIND v(dout0_36) AT=40.025n

* CHECK dout0_37 Vdout0_37ck7 = 0 time = 40
.meas tran vdout0_37ck7 FIND v(dout0_37) AT=40.025n

* CHECK dout0_38 Vdout0_38ck7 = 0 time = 40
.meas tran vdout0_38ck7 FIND v(dout0_38) AT=40.025n

* CHECK dout0_39 Vdout0_39ck7 = 0 time = 40
.meas tran vdout0_39ck7 FIND v(dout0_39) AT=40.025n

* CHECK dout0_40 Vdout0_40ck7 = 0 time = 40
.meas tran vdout0_40ck7 FIND v(dout0_40) AT=40.025n

* CHECK dout0_41 Vdout0_41ck7 = 0 time = 40
.meas tran vdout0_41ck7 FIND v(dout0_41) AT=40.025n

* CHECK dout0_42 Vdout0_42ck7 = 0 time = 40
.meas tran vdout0_42ck7 FIND v(dout0_42) AT=40.025n

* CHECK dout0_43 Vdout0_43ck7 = 0 time = 40
.meas tran vdout0_43ck7 FIND v(dout0_43) AT=40.025n

* CHECK dout0_44 Vdout0_44ck7 = 0 time = 40
.meas tran vdout0_44ck7 FIND v(dout0_44) AT=40.025n

* CHECK dout0_45 Vdout0_45ck7 = 0.9 time = 40
.meas tran vdout0_45ck7 FIND v(dout0_45) AT=40.025n

* CHECK dout0_46 Vdout0_46ck7 = 0 time = 40
.meas tran vdout0_46ck7 FIND v(dout0_46) AT=40.025n

* CHECK dout0_47 Vdout0_47ck7 = 0 time = 40
.meas tran vdout0_47ck7 FIND v(dout0_47) AT=40.025n

* CHECK dout0_48 Vdout0_48ck7 = 0.9 time = 40
.meas tran vdout0_48ck7 FIND v(dout0_48) AT=40.025n

* CHECK dout0_49 Vdout0_49ck7 = 0 time = 40
.meas tran vdout0_49ck7 FIND v(dout0_49) AT=40.025n

* CHECK dout0_50 Vdout0_50ck7 = 0 time = 40
.meas tran vdout0_50ck7 FIND v(dout0_50) AT=40.025n

* CHECK dout0_51 Vdout0_51ck7 = 0.9 time = 40
.meas tran vdout0_51ck7 FIND v(dout0_51) AT=40.025n

* CHECK dout0_52 Vdout0_52ck7 = 0 time = 40
.meas tran vdout0_52ck7 FIND v(dout0_52) AT=40.025n

* CHECK dout0_53 Vdout0_53ck7 = 0.9 time = 40
.meas tran vdout0_53ck7 FIND v(dout0_53) AT=40.025n

* CHECK dout0_54 Vdout0_54ck7 = 0 time = 40
.meas tran vdout0_54ck7 FIND v(dout0_54) AT=40.025n

* CHECK dout0_55 Vdout0_55ck7 = 0 time = 40
.meas tran vdout0_55ck7 FIND v(dout0_55) AT=40.025n

* CHECK dout0_56 Vdout0_56ck7 = 0.9 time = 40
.meas tran vdout0_56ck7 FIND v(dout0_56) AT=40.025n

* CHECK dout0_57 Vdout0_57ck7 = 0 time = 40
.meas tran vdout0_57ck7 FIND v(dout0_57) AT=40.025n

* CHECK dout0_58 Vdout0_58ck7 = 0.9 time = 40
.meas tran vdout0_58ck7 FIND v(dout0_58) AT=40.025n

* CHECK dout0_59 Vdout0_59ck7 = 0 time = 40
.meas tran vdout0_59ck7 FIND v(dout0_59) AT=40.025n

* CHECK dout0_60 Vdout0_60ck7 = 0 time = 40
.meas tran vdout0_60ck7 FIND v(dout0_60) AT=40.025n

* CHECK dout0_61 Vdout0_61ck7 = 0.9 time = 40
.meas tran vdout0_61ck7 FIND v(dout0_61) AT=40.025n

* CHECK dout0_62 Vdout0_62ck7 = 0 time = 40
.meas tran vdout0_62ck7 FIND v(dout0_62) AT=40.025n

* CHECK dout0_63 Vdout0_63ck7 = 0.9 time = 40
.meas tran vdout0_63ck7 FIND v(dout0_63) AT=40.025n

* CHECK dout0_0 Vdout0_0ck8 = 0 time = 45
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=45.025n

* CHECK dout0_1 Vdout0_1ck8 = 0.9 time = 45
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=45.025n

* CHECK dout0_2 Vdout0_2ck8 = 0.9 time = 45
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=45.025n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 45
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=45.025n

* CHECK dout0_4 Vdout0_4ck8 = 0.9 time = 45
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=45.025n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 45
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=45.025n

* CHECK dout0_6 Vdout0_6ck8 = 0.9 time = 45
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=45.025n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 45
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=45.025n

* CHECK dout0_8 Vdout0_8ck8 = 0.9 time = 45
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=45.025n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 45
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=45.025n

* CHECK dout0_10 Vdout0_10ck8 = 0.9 time = 45
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=45.025n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 45
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=45.025n

* CHECK dout0_12 Vdout0_12ck8 = 0.9 time = 45
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=45.025n

* CHECK dout0_13 Vdout0_13ck8 = 0.9 time = 45
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=45.025n

* CHECK dout0_14 Vdout0_14ck8 = 0.9 time = 45
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=45.025n

* CHECK dout0_15 Vdout0_15ck8 = 0 time = 45
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=45.025n

* CHECK dout0_16 Vdout0_16ck8 = 0.9 time = 45
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=45.025n

* CHECK dout0_17 Vdout0_17ck8 = 0 time = 45
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=45.025n

* CHECK dout0_18 Vdout0_18ck8 = 0 time = 45
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=45.025n

* CHECK dout0_19 Vdout0_19ck8 = 0.9 time = 45
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=45.025n

* CHECK dout0_20 Vdout0_20ck8 = 0.9 time = 45
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=45.025n

* CHECK dout0_21 Vdout0_21ck8 = 0 time = 45
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=45.025n

* CHECK dout0_22 Vdout0_22ck8 = 0.9 time = 45
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=45.025n

* CHECK dout0_23 Vdout0_23ck8 = 0 time = 45
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=45.025n

* CHECK dout0_24 Vdout0_24ck8 = 0 time = 45
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=45.025n

* CHECK dout0_25 Vdout0_25ck8 = 0.9 time = 45
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=45.025n

* CHECK dout0_26 Vdout0_26ck8 = 0 time = 45
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=45.025n

* CHECK dout0_27 Vdout0_27ck8 = 0.9 time = 45
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=45.025n

* CHECK dout0_28 Vdout0_28ck8 = 0 time = 45
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=45.025n

* CHECK dout0_29 Vdout0_29ck8 = 0 time = 45
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=45.025n

* CHECK dout0_30 Vdout0_30ck8 = 0 time = 45
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=45.025n

* CHECK dout0_31 Vdout0_31ck8 = 0.9 time = 45
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=45.025n

* CHECK dout0_32 Vdout0_32ck8 = 0.9 time = 45
.meas tran vdout0_32ck8 FIND v(dout0_32) AT=45.025n

* CHECK dout0_33 Vdout0_33ck8 = 0 time = 45
.meas tran vdout0_33ck8 FIND v(dout0_33) AT=45.025n

* CHECK dout0_34 Vdout0_34ck8 = 0 time = 45
.meas tran vdout0_34ck8 FIND v(dout0_34) AT=45.025n

* CHECK dout0_35 Vdout0_35ck8 = 0 time = 45
.meas tran vdout0_35ck8 FIND v(dout0_35) AT=45.025n

* CHECK dout0_36 Vdout0_36ck8 = 0.9 time = 45
.meas tran vdout0_36ck8 FIND v(dout0_36) AT=45.025n

* CHECK dout0_37 Vdout0_37ck8 = 0 time = 45
.meas tran vdout0_37ck8 FIND v(dout0_37) AT=45.025n

* CHECK dout0_38 Vdout0_38ck8 = 0 time = 45
.meas tran vdout0_38ck8 FIND v(dout0_38) AT=45.025n

* CHECK dout0_39 Vdout0_39ck8 = 0 time = 45
.meas tran vdout0_39ck8 FIND v(dout0_39) AT=45.025n

* CHECK dout0_40 Vdout0_40ck8 = 0 time = 45
.meas tran vdout0_40ck8 FIND v(dout0_40) AT=45.025n

* CHECK dout0_41 Vdout0_41ck8 = 0 time = 45
.meas tran vdout0_41ck8 FIND v(dout0_41) AT=45.025n

* CHECK dout0_42 Vdout0_42ck8 = 0 time = 45
.meas tran vdout0_42ck8 FIND v(dout0_42) AT=45.025n

* CHECK dout0_43 Vdout0_43ck8 = 0 time = 45
.meas tran vdout0_43ck8 FIND v(dout0_43) AT=45.025n

* CHECK dout0_44 Vdout0_44ck8 = 0 time = 45
.meas tran vdout0_44ck8 FIND v(dout0_44) AT=45.025n

* CHECK dout0_45 Vdout0_45ck8 = 0.9 time = 45
.meas tran vdout0_45ck8 FIND v(dout0_45) AT=45.025n

* CHECK dout0_46 Vdout0_46ck8 = 0 time = 45
.meas tran vdout0_46ck8 FIND v(dout0_46) AT=45.025n

* CHECK dout0_47 Vdout0_47ck8 = 0 time = 45
.meas tran vdout0_47ck8 FIND v(dout0_47) AT=45.025n

* CHECK dout0_48 Vdout0_48ck8 = 0.9 time = 45
.meas tran vdout0_48ck8 FIND v(dout0_48) AT=45.025n

* CHECK dout0_49 Vdout0_49ck8 = 0 time = 45
.meas tran vdout0_49ck8 FIND v(dout0_49) AT=45.025n

* CHECK dout0_50 Vdout0_50ck8 = 0 time = 45
.meas tran vdout0_50ck8 FIND v(dout0_50) AT=45.025n

* CHECK dout0_51 Vdout0_51ck8 = 0.9 time = 45
.meas tran vdout0_51ck8 FIND v(dout0_51) AT=45.025n

* CHECK dout0_52 Vdout0_52ck8 = 0 time = 45
.meas tran vdout0_52ck8 FIND v(dout0_52) AT=45.025n

* CHECK dout0_53 Vdout0_53ck8 = 0.9 time = 45
.meas tran vdout0_53ck8 FIND v(dout0_53) AT=45.025n

* CHECK dout0_54 Vdout0_54ck8 = 0 time = 45
.meas tran vdout0_54ck8 FIND v(dout0_54) AT=45.025n

* CHECK dout0_55 Vdout0_55ck8 = 0 time = 45
.meas tran vdout0_55ck8 FIND v(dout0_55) AT=45.025n

* CHECK dout0_56 Vdout0_56ck8 = 0.9 time = 45
.meas tran vdout0_56ck8 FIND v(dout0_56) AT=45.025n

* CHECK dout0_57 Vdout0_57ck8 = 0 time = 45
.meas tran vdout0_57ck8 FIND v(dout0_57) AT=45.025n

* CHECK dout0_58 Vdout0_58ck8 = 0.9 time = 45
.meas tran vdout0_58ck8 FIND v(dout0_58) AT=45.025n

* CHECK dout0_59 Vdout0_59ck8 = 0 time = 45
.meas tran vdout0_59ck8 FIND v(dout0_59) AT=45.025n

* CHECK dout0_60 Vdout0_60ck8 = 0 time = 45
.meas tran vdout0_60ck8 FIND v(dout0_60) AT=45.025n

* CHECK dout0_61 Vdout0_61ck8 = 0.9 time = 45
.meas tran vdout0_61ck8 FIND v(dout0_61) AT=45.025n

* CHECK dout0_62 Vdout0_62ck8 = 0 time = 45
.meas tran vdout0_62ck8 FIND v(dout0_62) AT=45.025n

* CHECK dout0_63 Vdout0_63ck8 = 0.9 time = 45
.meas tran vdout0_63ck8 FIND v(dout0_63) AT=45.025n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 55
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=55.025n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 55
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=55.025n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 55
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=55.025n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 55
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=55.025n

* CHECK dout0_4 Vdout0_4ck10 = 0.9 time = 55
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=55.025n

* CHECK dout0_5 Vdout0_5ck10 = 0.9 time = 55
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=55.025n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 55
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=55.025n

* CHECK dout0_7 Vdout0_7ck10 = 0.9 time = 55
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=55.025n

* CHECK dout0_8 Vdout0_8ck10 = 0.9 time = 55
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=55.025n

* CHECK dout0_9 Vdout0_9ck10 = 0.9 time = 55
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=55.025n

* CHECK dout0_10 Vdout0_10ck10 = 0.9 time = 55
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=55.025n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 55
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=55.025n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 55
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=55.025n

* CHECK dout0_13 Vdout0_13ck10 = 0.9 time = 55
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=55.025n

* CHECK dout0_14 Vdout0_14ck10 = 0.9 time = 55
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=55.025n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 55
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=55.025n

* CHECK dout0_16 Vdout0_16ck10 = 0 time = 55
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=55.025n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 55
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=55.025n

* CHECK dout0_18 Vdout0_18ck10 = 0.9 time = 55
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=55.025n

* CHECK dout0_19 Vdout0_19ck10 = 0 time = 55
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=55.025n

* CHECK dout0_20 Vdout0_20ck10 = 0 time = 55
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=55.025n

* CHECK dout0_21 Vdout0_21ck10 = 0.9 time = 55
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=55.025n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 55
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=55.025n

* CHECK dout0_23 Vdout0_23ck10 = 0.9 time = 55
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=55.025n

* CHECK dout0_24 Vdout0_24ck10 = 0.9 time = 55
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=55.025n

* CHECK dout0_25 Vdout0_25ck10 = 0 time = 55
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=55.025n

* CHECK dout0_26 Vdout0_26ck10 = 0 time = 55
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=55.025n

* CHECK dout0_27 Vdout0_27ck10 = 0.9 time = 55
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=55.025n

* CHECK dout0_28 Vdout0_28ck10 = 0 time = 55
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=55.025n

* CHECK dout0_29 Vdout0_29ck10 = 0.9 time = 55
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=55.025n

* CHECK dout0_30 Vdout0_30ck10 = 0.9 time = 55
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=55.025n

* CHECK dout0_31 Vdout0_31ck10 = 0 time = 55
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=55.025n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 55
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=55.025n

* CHECK dout0_33 Vdout0_33ck10 = 0.9 time = 55
.meas tran vdout0_33ck10 FIND v(dout0_33) AT=55.025n

* CHECK dout0_34 Vdout0_34ck10 = 0.9 time = 55
.meas tran vdout0_34ck10 FIND v(dout0_34) AT=55.025n

* CHECK dout0_35 Vdout0_35ck10 = 0 time = 55
.meas tran vdout0_35ck10 FIND v(dout0_35) AT=55.025n

* CHECK dout0_36 Vdout0_36ck10 = 0.9 time = 55
.meas tran vdout0_36ck10 FIND v(dout0_36) AT=55.025n

* CHECK dout0_37 Vdout0_37ck10 = 0 time = 55
.meas tran vdout0_37ck10 FIND v(dout0_37) AT=55.025n

* CHECK dout0_38 Vdout0_38ck10 = 0.9 time = 55
.meas tran vdout0_38ck10 FIND v(dout0_38) AT=55.025n

* CHECK dout0_39 Vdout0_39ck10 = 0.9 time = 55
.meas tran vdout0_39ck10 FIND v(dout0_39) AT=55.025n

* CHECK dout0_40 Vdout0_40ck10 = 0.9 time = 55
.meas tran vdout0_40ck10 FIND v(dout0_40) AT=55.025n

* CHECK dout0_41 Vdout0_41ck10 = 0.9 time = 55
.meas tran vdout0_41ck10 FIND v(dout0_41) AT=55.025n

* CHECK dout0_42 Vdout0_42ck10 = 0.9 time = 55
.meas tran vdout0_42ck10 FIND v(dout0_42) AT=55.025n

* CHECK dout0_43 Vdout0_43ck10 = 0 time = 55
.meas tran vdout0_43ck10 FIND v(dout0_43) AT=55.025n

* CHECK dout0_44 Vdout0_44ck10 = 0.9 time = 55
.meas tran vdout0_44ck10 FIND v(dout0_44) AT=55.025n

* CHECK dout0_45 Vdout0_45ck10 = 0.9 time = 55
.meas tran vdout0_45ck10 FIND v(dout0_45) AT=55.025n

* CHECK dout0_46 Vdout0_46ck10 = 0 time = 55
.meas tran vdout0_46ck10 FIND v(dout0_46) AT=55.025n

* CHECK dout0_47 Vdout0_47ck10 = 0.9 time = 55
.meas tran vdout0_47ck10 FIND v(dout0_47) AT=55.025n

* CHECK dout0_48 Vdout0_48ck10 = 0 time = 55
.meas tran vdout0_48ck10 FIND v(dout0_48) AT=55.025n

* CHECK dout0_49 Vdout0_49ck10 = 0 time = 55
.meas tran vdout0_49ck10 FIND v(dout0_49) AT=55.025n

* CHECK dout0_50 Vdout0_50ck10 = 0.9 time = 55
.meas tran vdout0_50ck10 FIND v(dout0_50) AT=55.025n

* CHECK dout0_51 Vdout0_51ck10 = 0.9 time = 55
.meas tran vdout0_51ck10 FIND v(dout0_51) AT=55.025n

* CHECK dout0_52 Vdout0_52ck10 = 0.9 time = 55
.meas tran vdout0_52ck10 FIND v(dout0_52) AT=55.025n

* CHECK dout0_53 Vdout0_53ck10 = 0.9 time = 55
.meas tran vdout0_53ck10 FIND v(dout0_53) AT=55.025n

* CHECK dout0_54 Vdout0_54ck10 = 0 time = 55
.meas tran vdout0_54ck10 FIND v(dout0_54) AT=55.025n

* CHECK dout0_55 Vdout0_55ck10 = 0 time = 55
.meas tran vdout0_55ck10 FIND v(dout0_55) AT=55.025n

* CHECK dout0_56 Vdout0_56ck10 = 0.9 time = 55
.meas tran vdout0_56ck10 FIND v(dout0_56) AT=55.025n

* CHECK dout0_57 Vdout0_57ck10 = 0 time = 55
.meas tran vdout0_57ck10 FIND v(dout0_57) AT=55.025n

* CHECK dout0_58 Vdout0_58ck10 = 0.9 time = 55
.meas tran vdout0_58ck10 FIND v(dout0_58) AT=55.025n

* CHECK dout0_59 Vdout0_59ck10 = 0.9 time = 55
.meas tran vdout0_59ck10 FIND v(dout0_59) AT=55.025n

* CHECK dout0_60 Vdout0_60ck10 = 0.9 time = 55
.meas tran vdout0_60ck10 FIND v(dout0_60) AT=55.025n

* CHECK dout0_61 Vdout0_61ck10 = 0.9 time = 55
.meas tran vdout0_61ck10 FIND v(dout0_61) AT=55.025n

* CHECK dout0_62 Vdout0_62ck10 = 0.9 time = 55
.meas tran vdout0_62ck10 FIND v(dout0_62) AT=55.025n

* CHECK dout0_63 Vdout0_63ck10 = 0 time = 55
.meas tran vdout0_63ck10 FIND v(dout0_63) AT=55.025n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 65
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=65.025n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 65
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=65.025n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 65
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=65.025n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 65
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=65.025n

* CHECK dout0_4 Vdout0_4ck12 = 0.9 time = 65
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=65.025n

* CHECK dout0_5 Vdout0_5ck12 = 0.9 time = 65
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=65.025n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 65
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=65.025n

* CHECK dout0_7 Vdout0_7ck12 = 0.9 time = 65
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=65.025n

* CHECK dout0_8 Vdout0_8ck12 = 0.9 time = 65
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=65.025n

* CHECK dout0_9 Vdout0_9ck12 = 0.9 time = 65
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=65.025n

* CHECK dout0_10 Vdout0_10ck12 = 0.9 time = 65
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=65.025n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 65
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=65.025n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 65
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=65.025n

* CHECK dout0_13 Vdout0_13ck12 = 0.9 time = 65
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=65.025n

* CHECK dout0_14 Vdout0_14ck12 = 0.9 time = 65
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=65.025n

* CHECK dout0_15 Vdout0_15ck12 = 0 time = 65
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=65.025n

* CHECK dout0_16 Vdout0_16ck12 = 0 time = 65
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=65.025n

* CHECK dout0_17 Vdout0_17ck12 = 0 time = 65
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=65.025n

* CHECK dout0_18 Vdout0_18ck12 = 0.9 time = 65
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=65.025n

* CHECK dout0_19 Vdout0_19ck12 = 0 time = 65
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=65.025n

* CHECK dout0_20 Vdout0_20ck12 = 0 time = 65
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=65.025n

* CHECK dout0_21 Vdout0_21ck12 = 0.9 time = 65
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=65.025n

* CHECK dout0_22 Vdout0_22ck12 = 0 time = 65
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=65.025n

* CHECK dout0_23 Vdout0_23ck12 = 0.9 time = 65
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=65.025n

* CHECK dout0_24 Vdout0_24ck12 = 0.9 time = 65
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=65.025n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 65
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=65.025n

* CHECK dout0_26 Vdout0_26ck12 = 0 time = 65
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=65.025n

* CHECK dout0_27 Vdout0_27ck12 = 0.9 time = 65
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=65.025n

* CHECK dout0_28 Vdout0_28ck12 = 0 time = 65
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=65.025n

* CHECK dout0_29 Vdout0_29ck12 = 0.9 time = 65
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=65.025n

* CHECK dout0_30 Vdout0_30ck12 = 0.9 time = 65
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=65.025n

* CHECK dout0_31 Vdout0_31ck12 = 0 time = 65
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=65.025n

* CHECK dout0_32 Vdout0_32ck12 = 0 time = 65
.meas tran vdout0_32ck12 FIND v(dout0_32) AT=65.025n

* CHECK dout0_33 Vdout0_33ck12 = 0.9 time = 65
.meas tran vdout0_33ck12 FIND v(dout0_33) AT=65.025n

* CHECK dout0_34 Vdout0_34ck12 = 0.9 time = 65
.meas tran vdout0_34ck12 FIND v(dout0_34) AT=65.025n

* CHECK dout0_35 Vdout0_35ck12 = 0 time = 65
.meas tran vdout0_35ck12 FIND v(dout0_35) AT=65.025n

* CHECK dout0_36 Vdout0_36ck12 = 0.9 time = 65
.meas tran vdout0_36ck12 FIND v(dout0_36) AT=65.025n

* CHECK dout0_37 Vdout0_37ck12 = 0 time = 65
.meas tran vdout0_37ck12 FIND v(dout0_37) AT=65.025n

* CHECK dout0_38 Vdout0_38ck12 = 0.9 time = 65
.meas tran vdout0_38ck12 FIND v(dout0_38) AT=65.025n

* CHECK dout0_39 Vdout0_39ck12 = 0.9 time = 65
.meas tran vdout0_39ck12 FIND v(dout0_39) AT=65.025n

* CHECK dout0_40 Vdout0_40ck12 = 0.9 time = 65
.meas tran vdout0_40ck12 FIND v(dout0_40) AT=65.025n

* CHECK dout0_41 Vdout0_41ck12 = 0.9 time = 65
.meas tran vdout0_41ck12 FIND v(dout0_41) AT=65.025n

* CHECK dout0_42 Vdout0_42ck12 = 0.9 time = 65
.meas tran vdout0_42ck12 FIND v(dout0_42) AT=65.025n

* CHECK dout0_43 Vdout0_43ck12 = 0 time = 65
.meas tran vdout0_43ck12 FIND v(dout0_43) AT=65.025n

* CHECK dout0_44 Vdout0_44ck12 = 0.9 time = 65
.meas tran vdout0_44ck12 FIND v(dout0_44) AT=65.025n

* CHECK dout0_45 Vdout0_45ck12 = 0.9 time = 65
.meas tran vdout0_45ck12 FIND v(dout0_45) AT=65.025n

* CHECK dout0_46 Vdout0_46ck12 = 0 time = 65
.meas tran vdout0_46ck12 FIND v(dout0_46) AT=65.025n

* CHECK dout0_47 Vdout0_47ck12 = 0.9 time = 65
.meas tran vdout0_47ck12 FIND v(dout0_47) AT=65.025n

* CHECK dout0_48 Vdout0_48ck12 = 0 time = 65
.meas tran vdout0_48ck12 FIND v(dout0_48) AT=65.025n

* CHECK dout0_49 Vdout0_49ck12 = 0 time = 65
.meas tran vdout0_49ck12 FIND v(dout0_49) AT=65.025n

* CHECK dout0_50 Vdout0_50ck12 = 0.9 time = 65
.meas tran vdout0_50ck12 FIND v(dout0_50) AT=65.025n

* CHECK dout0_51 Vdout0_51ck12 = 0.9 time = 65
.meas tran vdout0_51ck12 FIND v(dout0_51) AT=65.025n

* CHECK dout0_52 Vdout0_52ck12 = 0.9 time = 65
.meas tran vdout0_52ck12 FIND v(dout0_52) AT=65.025n

* CHECK dout0_53 Vdout0_53ck12 = 0.9 time = 65
.meas tran vdout0_53ck12 FIND v(dout0_53) AT=65.025n

* CHECK dout0_54 Vdout0_54ck12 = 0 time = 65
.meas tran vdout0_54ck12 FIND v(dout0_54) AT=65.025n

* CHECK dout0_55 Vdout0_55ck12 = 0 time = 65
.meas tran vdout0_55ck12 FIND v(dout0_55) AT=65.025n

* CHECK dout0_56 Vdout0_56ck12 = 0.9 time = 65
.meas tran vdout0_56ck12 FIND v(dout0_56) AT=65.025n

* CHECK dout0_57 Vdout0_57ck12 = 0 time = 65
.meas tran vdout0_57ck12 FIND v(dout0_57) AT=65.025n

* CHECK dout0_58 Vdout0_58ck12 = 0.9 time = 65
.meas tran vdout0_58ck12 FIND v(dout0_58) AT=65.025n

* CHECK dout0_59 Vdout0_59ck12 = 0.9 time = 65
.meas tran vdout0_59ck12 FIND v(dout0_59) AT=65.025n

* CHECK dout0_60 Vdout0_60ck12 = 0.9 time = 65
.meas tran vdout0_60ck12 FIND v(dout0_60) AT=65.025n

* CHECK dout0_61 Vdout0_61ck12 = 0.9 time = 65
.meas tran vdout0_61ck12 FIND v(dout0_61) AT=65.025n

* CHECK dout0_62 Vdout0_62ck12 = 0.9 time = 65
.meas tran vdout0_62ck12 FIND v(dout0_62) AT=65.025n

* CHECK dout0_63 Vdout0_63ck12 = 0 time = 65
.meas tran vdout0_63ck12 FIND v(dout0_63) AT=65.025n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 70
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=70.025n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 70
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=70.025n

* CHECK dout0_2 Vdout0_2ck13 = 0 time = 70
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=70.025n

* CHECK dout0_3 Vdout0_3ck13 = 0 time = 70
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=70.025n

* CHECK dout0_4 Vdout0_4ck13 = 0.9 time = 70
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=70.025n

* CHECK dout0_5 Vdout0_5ck13 = 0.9 time = 70
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=70.025n

* CHECK dout0_6 Vdout0_6ck13 = 0 time = 70
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=70.025n

* CHECK dout0_7 Vdout0_7ck13 = 0.9 time = 70
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=70.025n

* CHECK dout0_8 Vdout0_8ck13 = 0.9 time = 70
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=70.025n

* CHECK dout0_9 Vdout0_9ck13 = 0.9 time = 70
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=70.025n

* CHECK dout0_10 Vdout0_10ck13 = 0.9 time = 70
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=70.025n

* CHECK dout0_11 Vdout0_11ck13 = 0 time = 70
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=70.025n

* CHECK dout0_12 Vdout0_12ck13 = 0 time = 70
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=70.025n

* CHECK dout0_13 Vdout0_13ck13 = 0.9 time = 70
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=70.025n

* CHECK dout0_14 Vdout0_14ck13 = 0.9 time = 70
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=70.025n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 70
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=70.025n

* CHECK dout0_16 Vdout0_16ck13 = 0 time = 70
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=70.025n

* CHECK dout0_17 Vdout0_17ck13 = 0 time = 70
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=70.025n

* CHECK dout0_18 Vdout0_18ck13 = 0.9 time = 70
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=70.025n

* CHECK dout0_19 Vdout0_19ck13 = 0 time = 70
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=70.025n

* CHECK dout0_20 Vdout0_20ck13 = 0 time = 70
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=70.025n

* CHECK dout0_21 Vdout0_21ck13 = 0.9 time = 70
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=70.025n

* CHECK dout0_22 Vdout0_22ck13 = 0 time = 70
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=70.025n

* CHECK dout0_23 Vdout0_23ck13 = 0.9 time = 70
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=70.025n

* CHECK dout0_24 Vdout0_24ck13 = 0.9 time = 70
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=70.025n

* CHECK dout0_25 Vdout0_25ck13 = 0 time = 70
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=70.025n

* CHECK dout0_26 Vdout0_26ck13 = 0 time = 70
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=70.025n

* CHECK dout0_27 Vdout0_27ck13 = 0.9 time = 70
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=70.025n

* CHECK dout0_28 Vdout0_28ck13 = 0 time = 70
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=70.025n

* CHECK dout0_29 Vdout0_29ck13 = 0.9 time = 70
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=70.025n

* CHECK dout0_30 Vdout0_30ck13 = 0.9 time = 70
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=70.025n

* CHECK dout0_31 Vdout0_31ck13 = 0 time = 70
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=70.025n

* CHECK dout0_32 Vdout0_32ck13 = 0 time = 70
.meas tran vdout0_32ck13 FIND v(dout0_32) AT=70.025n

* CHECK dout0_33 Vdout0_33ck13 = 0.9 time = 70
.meas tran vdout0_33ck13 FIND v(dout0_33) AT=70.025n

* CHECK dout0_34 Vdout0_34ck13 = 0.9 time = 70
.meas tran vdout0_34ck13 FIND v(dout0_34) AT=70.025n

* CHECK dout0_35 Vdout0_35ck13 = 0 time = 70
.meas tran vdout0_35ck13 FIND v(dout0_35) AT=70.025n

* CHECK dout0_36 Vdout0_36ck13 = 0.9 time = 70
.meas tran vdout0_36ck13 FIND v(dout0_36) AT=70.025n

* CHECK dout0_37 Vdout0_37ck13 = 0 time = 70
.meas tran vdout0_37ck13 FIND v(dout0_37) AT=70.025n

* CHECK dout0_38 Vdout0_38ck13 = 0.9 time = 70
.meas tran vdout0_38ck13 FIND v(dout0_38) AT=70.025n

* CHECK dout0_39 Vdout0_39ck13 = 0.9 time = 70
.meas tran vdout0_39ck13 FIND v(dout0_39) AT=70.025n

* CHECK dout0_40 Vdout0_40ck13 = 0.9 time = 70
.meas tran vdout0_40ck13 FIND v(dout0_40) AT=70.025n

* CHECK dout0_41 Vdout0_41ck13 = 0.9 time = 70
.meas tran vdout0_41ck13 FIND v(dout0_41) AT=70.025n

* CHECK dout0_42 Vdout0_42ck13 = 0.9 time = 70
.meas tran vdout0_42ck13 FIND v(dout0_42) AT=70.025n

* CHECK dout0_43 Vdout0_43ck13 = 0 time = 70
.meas tran vdout0_43ck13 FIND v(dout0_43) AT=70.025n

* CHECK dout0_44 Vdout0_44ck13 = 0.9 time = 70
.meas tran vdout0_44ck13 FIND v(dout0_44) AT=70.025n

* CHECK dout0_45 Vdout0_45ck13 = 0.9 time = 70
.meas tran vdout0_45ck13 FIND v(dout0_45) AT=70.025n

* CHECK dout0_46 Vdout0_46ck13 = 0 time = 70
.meas tran vdout0_46ck13 FIND v(dout0_46) AT=70.025n

* CHECK dout0_47 Vdout0_47ck13 = 0.9 time = 70
.meas tran vdout0_47ck13 FIND v(dout0_47) AT=70.025n

* CHECK dout0_48 Vdout0_48ck13 = 0 time = 70
.meas tran vdout0_48ck13 FIND v(dout0_48) AT=70.025n

* CHECK dout0_49 Vdout0_49ck13 = 0 time = 70
.meas tran vdout0_49ck13 FIND v(dout0_49) AT=70.025n

* CHECK dout0_50 Vdout0_50ck13 = 0.9 time = 70
.meas tran vdout0_50ck13 FIND v(dout0_50) AT=70.025n

* CHECK dout0_51 Vdout0_51ck13 = 0.9 time = 70
.meas tran vdout0_51ck13 FIND v(dout0_51) AT=70.025n

* CHECK dout0_52 Vdout0_52ck13 = 0.9 time = 70
.meas tran vdout0_52ck13 FIND v(dout0_52) AT=70.025n

* CHECK dout0_53 Vdout0_53ck13 = 0.9 time = 70
.meas tran vdout0_53ck13 FIND v(dout0_53) AT=70.025n

* CHECK dout0_54 Vdout0_54ck13 = 0 time = 70
.meas tran vdout0_54ck13 FIND v(dout0_54) AT=70.025n

* CHECK dout0_55 Vdout0_55ck13 = 0 time = 70
.meas tran vdout0_55ck13 FIND v(dout0_55) AT=70.025n

* CHECK dout0_56 Vdout0_56ck13 = 0.9 time = 70
.meas tran vdout0_56ck13 FIND v(dout0_56) AT=70.025n

* CHECK dout0_57 Vdout0_57ck13 = 0 time = 70
.meas tran vdout0_57ck13 FIND v(dout0_57) AT=70.025n

* CHECK dout0_58 Vdout0_58ck13 = 0.9 time = 70
.meas tran vdout0_58ck13 FIND v(dout0_58) AT=70.025n

* CHECK dout0_59 Vdout0_59ck13 = 0.9 time = 70
.meas tran vdout0_59ck13 FIND v(dout0_59) AT=70.025n

* CHECK dout0_60 Vdout0_60ck13 = 0.9 time = 70
.meas tran vdout0_60ck13 FIND v(dout0_60) AT=70.025n

* CHECK dout0_61 Vdout0_61ck13 = 0.9 time = 70
.meas tran vdout0_61ck13 FIND v(dout0_61) AT=70.025n

* CHECK dout0_62 Vdout0_62ck13 = 0.9 time = 70
.meas tran vdout0_62ck13 FIND v(dout0_62) AT=70.025n

* CHECK dout0_63 Vdout0_63ck13 = 0 time = 70
.meas tran vdout0_63ck13 FIND v(dout0_63) AT=70.025n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 75
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=75.025n

* CHECK dout0_1 Vdout0_1ck14 = 0 time = 75
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=75.025n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 75
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=75.025n

* CHECK dout0_3 Vdout0_3ck14 = 0 time = 75
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=75.025n

* CHECK dout0_4 Vdout0_4ck14 = 0.9 time = 75
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=75.025n

* CHECK dout0_5 Vdout0_5ck14 = 0.9 time = 75
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=75.025n

* CHECK dout0_6 Vdout0_6ck14 = 0 time = 75
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=75.025n

* CHECK dout0_7 Vdout0_7ck14 = 0.9 time = 75
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=75.025n

* CHECK dout0_8 Vdout0_8ck14 = 0.9 time = 75
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=75.025n

* CHECK dout0_9 Vdout0_9ck14 = 0.9 time = 75
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=75.025n

* CHECK dout0_10 Vdout0_10ck14 = 0.9 time = 75
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=75.025n

* CHECK dout0_11 Vdout0_11ck14 = 0 time = 75
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=75.025n

* CHECK dout0_12 Vdout0_12ck14 = 0 time = 75
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=75.025n

* CHECK dout0_13 Vdout0_13ck14 = 0.9 time = 75
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=75.025n

* CHECK dout0_14 Vdout0_14ck14 = 0.9 time = 75
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=75.025n

* CHECK dout0_15 Vdout0_15ck14 = 0 time = 75
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=75.025n

* CHECK dout0_16 Vdout0_16ck14 = 0 time = 75
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=75.025n

* CHECK dout0_17 Vdout0_17ck14 = 0 time = 75
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=75.025n

* CHECK dout0_18 Vdout0_18ck14 = 0.9 time = 75
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=75.025n

* CHECK dout0_19 Vdout0_19ck14 = 0 time = 75
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=75.025n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 75
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=75.025n

* CHECK dout0_21 Vdout0_21ck14 = 0.9 time = 75
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=75.025n

* CHECK dout0_22 Vdout0_22ck14 = 0 time = 75
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=75.025n

* CHECK dout0_23 Vdout0_23ck14 = 0.9 time = 75
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=75.025n

* CHECK dout0_24 Vdout0_24ck14 = 0.9 time = 75
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=75.025n

* CHECK dout0_25 Vdout0_25ck14 = 0 time = 75
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=75.025n

* CHECK dout0_26 Vdout0_26ck14 = 0 time = 75
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=75.025n

* CHECK dout0_27 Vdout0_27ck14 = 0.9 time = 75
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=75.025n

* CHECK dout0_28 Vdout0_28ck14 = 0 time = 75
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=75.025n

* CHECK dout0_29 Vdout0_29ck14 = 0.9 time = 75
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=75.025n

* CHECK dout0_30 Vdout0_30ck14 = 0.9 time = 75
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=75.025n

* CHECK dout0_31 Vdout0_31ck14 = 0 time = 75
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=75.025n

* CHECK dout0_32 Vdout0_32ck14 = 0 time = 75
.meas tran vdout0_32ck14 FIND v(dout0_32) AT=75.025n

* CHECK dout0_33 Vdout0_33ck14 = 0.9 time = 75
.meas tran vdout0_33ck14 FIND v(dout0_33) AT=75.025n

* CHECK dout0_34 Vdout0_34ck14 = 0.9 time = 75
.meas tran vdout0_34ck14 FIND v(dout0_34) AT=75.025n

* CHECK dout0_35 Vdout0_35ck14 = 0 time = 75
.meas tran vdout0_35ck14 FIND v(dout0_35) AT=75.025n

* CHECK dout0_36 Vdout0_36ck14 = 0.9 time = 75
.meas tran vdout0_36ck14 FIND v(dout0_36) AT=75.025n

* CHECK dout0_37 Vdout0_37ck14 = 0 time = 75
.meas tran vdout0_37ck14 FIND v(dout0_37) AT=75.025n

* CHECK dout0_38 Vdout0_38ck14 = 0.9 time = 75
.meas tran vdout0_38ck14 FIND v(dout0_38) AT=75.025n

* CHECK dout0_39 Vdout0_39ck14 = 0.9 time = 75
.meas tran vdout0_39ck14 FIND v(dout0_39) AT=75.025n

* CHECK dout0_40 Vdout0_40ck14 = 0.9 time = 75
.meas tran vdout0_40ck14 FIND v(dout0_40) AT=75.025n

* CHECK dout0_41 Vdout0_41ck14 = 0.9 time = 75
.meas tran vdout0_41ck14 FIND v(dout0_41) AT=75.025n

* CHECK dout0_42 Vdout0_42ck14 = 0.9 time = 75
.meas tran vdout0_42ck14 FIND v(dout0_42) AT=75.025n

* CHECK dout0_43 Vdout0_43ck14 = 0 time = 75
.meas tran vdout0_43ck14 FIND v(dout0_43) AT=75.025n

* CHECK dout0_44 Vdout0_44ck14 = 0.9 time = 75
.meas tran vdout0_44ck14 FIND v(dout0_44) AT=75.025n

* CHECK dout0_45 Vdout0_45ck14 = 0.9 time = 75
.meas tran vdout0_45ck14 FIND v(dout0_45) AT=75.025n

* CHECK dout0_46 Vdout0_46ck14 = 0 time = 75
.meas tran vdout0_46ck14 FIND v(dout0_46) AT=75.025n

* CHECK dout0_47 Vdout0_47ck14 = 0.9 time = 75
.meas tran vdout0_47ck14 FIND v(dout0_47) AT=75.025n

* CHECK dout0_48 Vdout0_48ck14 = 0 time = 75
.meas tran vdout0_48ck14 FIND v(dout0_48) AT=75.025n

* CHECK dout0_49 Vdout0_49ck14 = 0 time = 75
.meas tran vdout0_49ck14 FIND v(dout0_49) AT=75.025n

* CHECK dout0_50 Vdout0_50ck14 = 0.9 time = 75
.meas tran vdout0_50ck14 FIND v(dout0_50) AT=75.025n

* CHECK dout0_51 Vdout0_51ck14 = 0.9 time = 75
.meas tran vdout0_51ck14 FIND v(dout0_51) AT=75.025n

* CHECK dout0_52 Vdout0_52ck14 = 0.9 time = 75
.meas tran vdout0_52ck14 FIND v(dout0_52) AT=75.025n

* CHECK dout0_53 Vdout0_53ck14 = 0.9 time = 75
.meas tran vdout0_53ck14 FIND v(dout0_53) AT=75.025n

* CHECK dout0_54 Vdout0_54ck14 = 0 time = 75
.meas tran vdout0_54ck14 FIND v(dout0_54) AT=75.025n

* CHECK dout0_55 Vdout0_55ck14 = 0 time = 75
.meas tran vdout0_55ck14 FIND v(dout0_55) AT=75.025n

* CHECK dout0_56 Vdout0_56ck14 = 0.9 time = 75
.meas tran vdout0_56ck14 FIND v(dout0_56) AT=75.025n

* CHECK dout0_57 Vdout0_57ck14 = 0 time = 75
.meas tran vdout0_57ck14 FIND v(dout0_57) AT=75.025n

* CHECK dout0_58 Vdout0_58ck14 = 0.9 time = 75
.meas tran vdout0_58ck14 FIND v(dout0_58) AT=75.025n

* CHECK dout0_59 Vdout0_59ck14 = 0.9 time = 75
.meas tran vdout0_59ck14 FIND v(dout0_59) AT=75.025n

* CHECK dout0_60 Vdout0_60ck14 = 0.9 time = 75
.meas tran vdout0_60ck14 FIND v(dout0_60) AT=75.025n

* CHECK dout0_61 Vdout0_61ck14 = 0.9 time = 75
.meas tran vdout0_61ck14 FIND v(dout0_61) AT=75.025n

* CHECK dout0_62 Vdout0_62ck14 = 0.9 time = 75
.meas tran vdout0_62ck14 FIND v(dout0_62) AT=75.025n

* CHECK dout0_63 Vdout0_63ck14 = 0 time = 75
.meas tran vdout0_63ck14 FIND v(dout0_63) AT=75.025n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 0.9 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 0.9 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0.9 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 0.9 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0.9 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0.9 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 0 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 0.9 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 0.9 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 0 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 0.9 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 0 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 0 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 0.9 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 0 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0.9 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0.9 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 0 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 0 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0.9 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 0 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 0.9 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0.9 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 0 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_32 Vdout0_32ck15 = 0 time = 80
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=80.025n

* CHECK dout0_33 Vdout0_33ck15 = 0.9 time = 80
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=80.025n

* CHECK dout0_34 Vdout0_34ck15 = 0.9 time = 80
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=80.025n

* CHECK dout0_35 Vdout0_35ck15 = 0 time = 80
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=80.025n

* CHECK dout0_36 Vdout0_36ck15 = 0.9 time = 80
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=80.025n

* CHECK dout0_37 Vdout0_37ck15 = 0 time = 80
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=80.025n

* CHECK dout0_38 Vdout0_38ck15 = 0.9 time = 80
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=80.025n

* CHECK dout0_39 Vdout0_39ck15 = 0.9 time = 80
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=80.025n

* CHECK dout0_40 Vdout0_40ck15 = 0.9 time = 80
.meas tran vdout0_40ck15 FIND v(dout0_40) AT=80.025n

* CHECK dout0_41 Vdout0_41ck15 = 0.9 time = 80
.meas tran vdout0_41ck15 FIND v(dout0_41) AT=80.025n

* CHECK dout0_42 Vdout0_42ck15 = 0.9 time = 80
.meas tran vdout0_42ck15 FIND v(dout0_42) AT=80.025n

* CHECK dout0_43 Vdout0_43ck15 = 0 time = 80
.meas tran vdout0_43ck15 FIND v(dout0_43) AT=80.025n

* CHECK dout0_44 Vdout0_44ck15 = 0.9 time = 80
.meas tran vdout0_44ck15 FIND v(dout0_44) AT=80.025n

* CHECK dout0_45 Vdout0_45ck15 = 0.9 time = 80
.meas tran vdout0_45ck15 FIND v(dout0_45) AT=80.025n

* CHECK dout0_46 Vdout0_46ck15 = 0 time = 80
.meas tran vdout0_46ck15 FIND v(dout0_46) AT=80.025n

* CHECK dout0_47 Vdout0_47ck15 = 0.9 time = 80
.meas tran vdout0_47ck15 FIND v(dout0_47) AT=80.025n

* CHECK dout0_48 Vdout0_48ck15 = 0 time = 80
.meas tran vdout0_48ck15 FIND v(dout0_48) AT=80.025n

* CHECK dout0_49 Vdout0_49ck15 = 0 time = 80
.meas tran vdout0_49ck15 FIND v(dout0_49) AT=80.025n

* CHECK dout0_50 Vdout0_50ck15 = 0.9 time = 80
.meas tran vdout0_50ck15 FIND v(dout0_50) AT=80.025n

* CHECK dout0_51 Vdout0_51ck15 = 0.9 time = 80
.meas tran vdout0_51ck15 FIND v(dout0_51) AT=80.025n

* CHECK dout0_52 Vdout0_52ck15 = 0.9 time = 80
.meas tran vdout0_52ck15 FIND v(dout0_52) AT=80.025n

* CHECK dout0_53 Vdout0_53ck15 = 0.9 time = 80
.meas tran vdout0_53ck15 FIND v(dout0_53) AT=80.025n

* CHECK dout0_54 Vdout0_54ck15 = 0 time = 80
.meas tran vdout0_54ck15 FIND v(dout0_54) AT=80.025n

* CHECK dout0_55 Vdout0_55ck15 = 0 time = 80
.meas tran vdout0_55ck15 FIND v(dout0_55) AT=80.025n

* CHECK dout0_56 Vdout0_56ck15 = 0.9 time = 80
.meas tran vdout0_56ck15 FIND v(dout0_56) AT=80.025n

* CHECK dout0_57 Vdout0_57ck15 = 0 time = 80
.meas tran vdout0_57ck15 FIND v(dout0_57) AT=80.025n

* CHECK dout0_58 Vdout0_58ck15 = 0.9 time = 80
.meas tran vdout0_58ck15 FIND v(dout0_58) AT=80.025n

* CHECK dout0_59 Vdout0_59ck15 = 0.9 time = 80
.meas tran vdout0_59ck15 FIND v(dout0_59) AT=80.025n

* CHECK dout0_60 Vdout0_60ck15 = 0.9 time = 80
.meas tran vdout0_60ck15 FIND v(dout0_60) AT=80.025n

* CHECK dout0_61 Vdout0_61ck15 = 0.9 time = 80
.meas tran vdout0_61ck15 FIND v(dout0_61) AT=80.025n

* CHECK dout0_62 Vdout0_62ck15 = 0.9 time = 80
.meas tran vdout0_62ck15 FIND v(dout0_62) AT=80.025n

* CHECK dout0_63 Vdout0_63ck15 = 0 time = 80
.meas tran vdout0_63ck15 FIND v(dout0_63) AT=80.025n

* CHECK dout0_0 Vdout0_0ck16 = 0 time = 85
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=85.025n

* CHECK dout0_1 Vdout0_1ck16 = 0 time = 85
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=85.025n

* CHECK dout0_2 Vdout0_2ck16 = 0 time = 85
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=85.025n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 85
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=85.025n

* CHECK dout0_4 Vdout0_4ck16 = 0.9 time = 85
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=85.025n

* CHECK dout0_5 Vdout0_5ck16 = 0.9 time = 85
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=85.025n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 85
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=85.025n

* CHECK dout0_7 Vdout0_7ck16 = 0.9 time = 85
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=85.025n

* CHECK dout0_8 Vdout0_8ck16 = 0.9 time = 85
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=85.025n

* CHECK dout0_9 Vdout0_9ck16 = 0.9 time = 85
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=85.025n

* CHECK dout0_10 Vdout0_10ck16 = 0.9 time = 85
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=85.025n

* CHECK dout0_11 Vdout0_11ck16 = 0 time = 85
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=85.025n

* CHECK dout0_12 Vdout0_12ck16 = 0 time = 85
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=85.025n

* CHECK dout0_13 Vdout0_13ck16 = 0.9 time = 85
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=85.025n

* CHECK dout0_14 Vdout0_14ck16 = 0.9 time = 85
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=85.025n

* CHECK dout0_15 Vdout0_15ck16 = 0 time = 85
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=85.025n

* CHECK dout0_16 Vdout0_16ck16 = 0 time = 85
.meas tran vdout0_16ck16 FIND v(dout0_16) AT=85.025n

* CHECK dout0_17 Vdout0_17ck16 = 0 time = 85
.meas tran vdout0_17ck16 FIND v(dout0_17) AT=85.025n

* CHECK dout0_18 Vdout0_18ck16 = 0.9 time = 85
.meas tran vdout0_18ck16 FIND v(dout0_18) AT=85.025n

* CHECK dout0_19 Vdout0_19ck16 = 0 time = 85
.meas tran vdout0_19ck16 FIND v(dout0_19) AT=85.025n

* CHECK dout0_20 Vdout0_20ck16 = 0 time = 85
.meas tran vdout0_20ck16 FIND v(dout0_20) AT=85.025n

* CHECK dout0_21 Vdout0_21ck16 = 0.9 time = 85
.meas tran vdout0_21ck16 FIND v(dout0_21) AT=85.025n

* CHECK dout0_22 Vdout0_22ck16 = 0 time = 85
.meas tran vdout0_22ck16 FIND v(dout0_22) AT=85.025n

* CHECK dout0_23 Vdout0_23ck16 = 0.9 time = 85
.meas tran vdout0_23ck16 FIND v(dout0_23) AT=85.025n

* CHECK dout0_24 Vdout0_24ck16 = 0.9 time = 85
.meas tran vdout0_24ck16 FIND v(dout0_24) AT=85.025n

* CHECK dout0_25 Vdout0_25ck16 = 0 time = 85
.meas tran vdout0_25ck16 FIND v(dout0_25) AT=85.025n

* CHECK dout0_26 Vdout0_26ck16 = 0 time = 85
.meas tran vdout0_26ck16 FIND v(dout0_26) AT=85.025n

* CHECK dout0_27 Vdout0_27ck16 = 0.9 time = 85
.meas tran vdout0_27ck16 FIND v(dout0_27) AT=85.025n

* CHECK dout0_28 Vdout0_28ck16 = 0 time = 85
.meas tran vdout0_28ck16 FIND v(dout0_28) AT=85.025n

* CHECK dout0_29 Vdout0_29ck16 = 0.9 time = 85
.meas tran vdout0_29ck16 FIND v(dout0_29) AT=85.025n

* CHECK dout0_30 Vdout0_30ck16 = 0.9 time = 85
.meas tran vdout0_30ck16 FIND v(dout0_30) AT=85.025n

* CHECK dout0_31 Vdout0_31ck16 = 0 time = 85
.meas tran vdout0_31ck16 FIND v(dout0_31) AT=85.025n

* CHECK dout0_32 Vdout0_32ck16 = 0 time = 85
.meas tran vdout0_32ck16 FIND v(dout0_32) AT=85.025n

* CHECK dout0_33 Vdout0_33ck16 = 0.9 time = 85
.meas tran vdout0_33ck16 FIND v(dout0_33) AT=85.025n

* CHECK dout0_34 Vdout0_34ck16 = 0.9 time = 85
.meas tran vdout0_34ck16 FIND v(dout0_34) AT=85.025n

* CHECK dout0_35 Vdout0_35ck16 = 0 time = 85
.meas tran vdout0_35ck16 FIND v(dout0_35) AT=85.025n

* CHECK dout0_36 Vdout0_36ck16 = 0.9 time = 85
.meas tran vdout0_36ck16 FIND v(dout0_36) AT=85.025n

* CHECK dout0_37 Vdout0_37ck16 = 0 time = 85
.meas tran vdout0_37ck16 FIND v(dout0_37) AT=85.025n

* CHECK dout0_38 Vdout0_38ck16 = 0.9 time = 85
.meas tran vdout0_38ck16 FIND v(dout0_38) AT=85.025n

* CHECK dout0_39 Vdout0_39ck16 = 0.9 time = 85
.meas tran vdout0_39ck16 FIND v(dout0_39) AT=85.025n

* CHECK dout0_40 Vdout0_40ck16 = 0.9 time = 85
.meas tran vdout0_40ck16 FIND v(dout0_40) AT=85.025n

* CHECK dout0_41 Vdout0_41ck16 = 0.9 time = 85
.meas tran vdout0_41ck16 FIND v(dout0_41) AT=85.025n

* CHECK dout0_42 Vdout0_42ck16 = 0.9 time = 85
.meas tran vdout0_42ck16 FIND v(dout0_42) AT=85.025n

* CHECK dout0_43 Vdout0_43ck16 = 0 time = 85
.meas tran vdout0_43ck16 FIND v(dout0_43) AT=85.025n

* CHECK dout0_44 Vdout0_44ck16 = 0.9 time = 85
.meas tran vdout0_44ck16 FIND v(dout0_44) AT=85.025n

* CHECK dout0_45 Vdout0_45ck16 = 0.9 time = 85
.meas tran vdout0_45ck16 FIND v(dout0_45) AT=85.025n

* CHECK dout0_46 Vdout0_46ck16 = 0 time = 85
.meas tran vdout0_46ck16 FIND v(dout0_46) AT=85.025n

* CHECK dout0_47 Vdout0_47ck16 = 0.9 time = 85
.meas tran vdout0_47ck16 FIND v(dout0_47) AT=85.025n

* CHECK dout0_48 Vdout0_48ck16 = 0 time = 85
.meas tran vdout0_48ck16 FIND v(dout0_48) AT=85.025n

* CHECK dout0_49 Vdout0_49ck16 = 0 time = 85
.meas tran vdout0_49ck16 FIND v(dout0_49) AT=85.025n

* CHECK dout0_50 Vdout0_50ck16 = 0.9 time = 85
.meas tran vdout0_50ck16 FIND v(dout0_50) AT=85.025n

* CHECK dout0_51 Vdout0_51ck16 = 0.9 time = 85
.meas tran vdout0_51ck16 FIND v(dout0_51) AT=85.025n

* CHECK dout0_52 Vdout0_52ck16 = 0.9 time = 85
.meas tran vdout0_52ck16 FIND v(dout0_52) AT=85.025n

* CHECK dout0_53 Vdout0_53ck16 = 0.9 time = 85
.meas tran vdout0_53ck16 FIND v(dout0_53) AT=85.025n

* CHECK dout0_54 Vdout0_54ck16 = 0 time = 85
.meas tran vdout0_54ck16 FIND v(dout0_54) AT=85.025n

* CHECK dout0_55 Vdout0_55ck16 = 0 time = 85
.meas tran vdout0_55ck16 FIND v(dout0_55) AT=85.025n

* CHECK dout0_56 Vdout0_56ck16 = 0.9 time = 85
.meas tran vdout0_56ck16 FIND v(dout0_56) AT=85.025n

* CHECK dout0_57 Vdout0_57ck16 = 0 time = 85
.meas tran vdout0_57ck16 FIND v(dout0_57) AT=85.025n

* CHECK dout0_58 Vdout0_58ck16 = 0.9 time = 85
.meas tran vdout0_58ck16 FIND v(dout0_58) AT=85.025n

* CHECK dout0_59 Vdout0_59ck16 = 0.9 time = 85
.meas tran vdout0_59ck16 FIND v(dout0_59) AT=85.025n

* CHECK dout0_60 Vdout0_60ck16 = 0.9 time = 85
.meas tran vdout0_60ck16 FIND v(dout0_60) AT=85.025n

* CHECK dout0_61 Vdout0_61ck16 = 0.9 time = 85
.meas tran vdout0_61ck16 FIND v(dout0_61) AT=85.025n

* CHECK dout0_62 Vdout0_62ck16 = 0.9 time = 85
.meas tran vdout0_62ck16 FIND v(dout0_62) AT=85.025n

* CHECK dout0_63 Vdout0_63ck16 = 0 time = 85
.meas tran vdout0_63ck16 FIND v(dout0_63) AT=85.025n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 110
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=110.025n

* CHECK dout0_1 Vdout0_1ck21 = 0.9 time = 110
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=110.025n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 110
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=110.025n

* CHECK dout0_3 Vdout0_3ck21 = 0.9 time = 110
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=110.025n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 110
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=110.025n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 110
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=110.025n

* CHECK dout0_6 Vdout0_6ck21 = 0.9 time = 110
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=110.025n

* CHECK dout0_7 Vdout0_7ck21 = 0.9 time = 110
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=110.025n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 110
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=110.025n

* CHECK dout0_9 Vdout0_9ck21 = 0 time = 110
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=110.025n

* CHECK dout0_10 Vdout0_10ck21 = 0.9 time = 110
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=110.025n

* CHECK dout0_11 Vdout0_11ck21 = 0.9 time = 110
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=110.025n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 110
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=110.025n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 110
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=110.025n

* CHECK dout0_14 Vdout0_14ck21 = 0.9 time = 110
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=110.025n

* CHECK dout0_15 Vdout0_15ck21 = 0.9 time = 110
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=110.025n

* CHECK dout0_16 Vdout0_16ck21 = 0.9 time = 110
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=110.025n

* CHECK dout0_17 Vdout0_17ck21 = 0 time = 110
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=110.025n

* CHECK dout0_18 Vdout0_18ck21 = 0 time = 110
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=110.025n

* CHECK dout0_19 Vdout0_19ck21 = 0.9 time = 110
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=110.025n

* CHECK dout0_20 Vdout0_20ck21 = 0 time = 110
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=110.025n

* CHECK dout0_21 Vdout0_21ck21 = 0.9 time = 110
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=110.025n

* CHECK dout0_22 Vdout0_22ck21 = 0 time = 110
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=110.025n

* CHECK dout0_23 Vdout0_23ck21 = 0 time = 110
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=110.025n

* CHECK dout0_24 Vdout0_24ck21 = 0.9 time = 110
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=110.025n

* CHECK dout0_25 Vdout0_25ck21 = 0 time = 110
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=110.025n

* CHECK dout0_26 Vdout0_26ck21 = 0.9 time = 110
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=110.025n

* CHECK dout0_27 Vdout0_27ck21 = 0.9 time = 110
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=110.025n

* CHECK dout0_28 Vdout0_28ck21 = 0.9 time = 110
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=110.025n

* CHECK dout0_29 Vdout0_29ck21 = 0 time = 110
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=110.025n

* CHECK dout0_30 Vdout0_30ck21 = 0.9 time = 110
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=110.025n

* CHECK dout0_31 Vdout0_31ck21 = 0.9 time = 110
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=110.025n

* CHECK dout0_32 Vdout0_32ck21 = 0 time = 110
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=110.025n

* CHECK dout0_33 Vdout0_33ck21 = 0 time = 110
.meas tran vdout0_33ck21 FIND v(dout0_33) AT=110.025n

* CHECK dout0_34 Vdout0_34ck21 = 0.9 time = 110
.meas tran vdout0_34ck21 FIND v(dout0_34) AT=110.025n

* CHECK dout0_35 Vdout0_35ck21 = 0 time = 110
.meas tran vdout0_35ck21 FIND v(dout0_35) AT=110.025n

* CHECK dout0_36 Vdout0_36ck21 = 0 time = 110
.meas tran vdout0_36ck21 FIND v(dout0_36) AT=110.025n

* CHECK dout0_37 Vdout0_37ck21 = 0.9 time = 110
.meas tran vdout0_37ck21 FIND v(dout0_37) AT=110.025n

* CHECK dout0_38 Vdout0_38ck21 = 0.9 time = 110
.meas tran vdout0_38ck21 FIND v(dout0_38) AT=110.025n

* CHECK dout0_39 Vdout0_39ck21 = 0.9 time = 110
.meas tran vdout0_39ck21 FIND v(dout0_39) AT=110.025n

* CHECK dout0_40 Vdout0_40ck21 = 0 time = 110
.meas tran vdout0_40ck21 FIND v(dout0_40) AT=110.025n

* CHECK dout0_41 Vdout0_41ck21 = 0.9 time = 110
.meas tran vdout0_41ck21 FIND v(dout0_41) AT=110.025n

* CHECK dout0_42 Vdout0_42ck21 = 0.9 time = 110
.meas tran vdout0_42ck21 FIND v(dout0_42) AT=110.025n

* CHECK dout0_43 Vdout0_43ck21 = 0 time = 110
.meas tran vdout0_43ck21 FIND v(dout0_43) AT=110.025n

* CHECK dout0_44 Vdout0_44ck21 = 0.9 time = 110
.meas tran vdout0_44ck21 FIND v(dout0_44) AT=110.025n

* CHECK dout0_45 Vdout0_45ck21 = 0.9 time = 110
.meas tran vdout0_45ck21 FIND v(dout0_45) AT=110.025n

* CHECK dout0_46 Vdout0_46ck21 = 0 time = 110
.meas tran vdout0_46ck21 FIND v(dout0_46) AT=110.025n

* CHECK dout0_47 Vdout0_47ck21 = 0.9 time = 110
.meas tran vdout0_47ck21 FIND v(dout0_47) AT=110.025n

* CHECK dout0_48 Vdout0_48ck21 = 0.9 time = 110
.meas tran vdout0_48ck21 FIND v(dout0_48) AT=110.025n

* CHECK dout0_49 Vdout0_49ck21 = 0 time = 110
.meas tran vdout0_49ck21 FIND v(dout0_49) AT=110.025n

* CHECK dout0_50 Vdout0_50ck21 = 0 time = 110
.meas tran vdout0_50ck21 FIND v(dout0_50) AT=110.025n

* CHECK dout0_51 Vdout0_51ck21 = 0.9 time = 110
.meas tran vdout0_51ck21 FIND v(dout0_51) AT=110.025n

* CHECK dout0_52 Vdout0_52ck21 = 0.9 time = 110
.meas tran vdout0_52ck21 FIND v(dout0_52) AT=110.025n

* CHECK dout0_53 Vdout0_53ck21 = 0.9 time = 110
.meas tran vdout0_53ck21 FIND v(dout0_53) AT=110.025n

* CHECK dout0_54 Vdout0_54ck21 = 0 time = 110
.meas tran vdout0_54ck21 FIND v(dout0_54) AT=110.025n

* CHECK dout0_55 Vdout0_55ck21 = 0 time = 110
.meas tran vdout0_55ck21 FIND v(dout0_55) AT=110.025n

* CHECK dout0_56 Vdout0_56ck21 = 0.9 time = 110
.meas tran vdout0_56ck21 FIND v(dout0_56) AT=110.025n

* CHECK dout0_57 Vdout0_57ck21 = 0.9 time = 110
.meas tran vdout0_57ck21 FIND v(dout0_57) AT=110.025n

* CHECK dout0_58 Vdout0_58ck21 = 0.9 time = 110
.meas tran vdout0_58ck21 FIND v(dout0_58) AT=110.025n

* CHECK dout0_59 Vdout0_59ck21 = 0.9 time = 110
.meas tran vdout0_59ck21 FIND v(dout0_59) AT=110.025n

* CHECK dout0_60 Vdout0_60ck21 = 0 time = 110
.meas tran vdout0_60ck21 FIND v(dout0_60) AT=110.025n

* CHECK dout0_61 Vdout0_61ck21 = 0 time = 110
.meas tran vdout0_61ck21 FIND v(dout0_61) AT=110.025n

* CHECK dout0_62 Vdout0_62ck21 = 0 time = 110
.meas tran vdout0_62ck21 FIND v(dout0_62) AT=110.025n

* CHECK dout0_63 Vdout0_63ck21 = 0 time = 110
.meas tran vdout0_63ck21 FIND v(dout0_63) AT=110.025n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 125
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=125.025n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 125
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=125.025n

* CHECK dout0_2 Vdout0_2ck24 = 0.9 time = 125
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=125.025n

* CHECK dout0_3 Vdout0_3ck24 = 0.9 time = 125
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=125.025n

* CHECK dout0_4 Vdout0_4ck24 = 0.9 time = 125
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=125.025n

* CHECK dout0_5 Vdout0_5ck24 = 0.9 time = 125
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=125.025n

* CHECK dout0_6 Vdout0_6ck24 = 0.9 time = 125
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=125.025n

* CHECK dout0_7 Vdout0_7ck24 = 0.9 time = 125
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=125.025n

* CHECK dout0_8 Vdout0_8ck24 = 0 time = 125
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=125.025n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 125
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=125.025n

* CHECK dout0_10 Vdout0_10ck24 = 0.9 time = 125
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=125.025n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 125
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=125.025n

* CHECK dout0_12 Vdout0_12ck24 = 0 time = 125
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=125.025n

* CHECK dout0_13 Vdout0_13ck24 = 0.9 time = 125
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=125.025n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 125
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=125.025n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 125
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=125.025n

* CHECK dout0_16 Vdout0_16ck24 = 0 time = 125
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=125.025n

* CHECK dout0_17 Vdout0_17ck24 = 0 time = 125
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=125.025n

* CHECK dout0_18 Vdout0_18ck24 = 0 time = 125
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=125.025n

* CHECK dout0_19 Vdout0_19ck24 = 0 time = 125
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=125.025n

* CHECK dout0_20 Vdout0_20ck24 = 0 time = 125
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=125.025n

* CHECK dout0_21 Vdout0_21ck24 = 0 time = 125
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=125.025n

* CHECK dout0_22 Vdout0_22ck24 = 0 time = 125
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=125.025n

* CHECK dout0_23 Vdout0_23ck24 = 0 time = 125
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=125.025n

* CHECK dout0_24 Vdout0_24ck24 = 0 time = 125
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=125.025n

* CHECK dout0_25 Vdout0_25ck24 = 0 time = 125
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=125.025n

* CHECK dout0_26 Vdout0_26ck24 = 0.9 time = 125
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=125.025n

* CHECK dout0_27 Vdout0_27ck24 = 0.9 time = 125
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=125.025n

* CHECK dout0_28 Vdout0_28ck24 = 0.9 time = 125
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=125.025n

* CHECK dout0_29 Vdout0_29ck24 = 0 time = 125
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=125.025n

* CHECK dout0_30 Vdout0_30ck24 = 0.9 time = 125
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=125.025n

* CHECK dout0_31 Vdout0_31ck24 = 0 time = 125
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=125.025n

* CHECK dout0_32 Vdout0_32ck24 = 0 time = 125
.meas tran vdout0_32ck24 FIND v(dout0_32) AT=125.025n

* CHECK dout0_33 Vdout0_33ck24 = 0.9 time = 125
.meas tran vdout0_33ck24 FIND v(dout0_33) AT=125.025n

* CHECK dout0_34 Vdout0_34ck24 = 0 time = 125
.meas tran vdout0_34ck24 FIND v(dout0_34) AT=125.025n

* CHECK dout0_35 Vdout0_35ck24 = 0 time = 125
.meas tran vdout0_35ck24 FIND v(dout0_35) AT=125.025n

* CHECK dout0_36 Vdout0_36ck24 = 0.9 time = 125
.meas tran vdout0_36ck24 FIND v(dout0_36) AT=125.025n

* CHECK dout0_37 Vdout0_37ck24 = 0 time = 125
.meas tran vdout0_37ck24 FIND v(dout0_37) AT=125.025n

* CHECK dout0_38 Vdout0_38ck24 = 0.9 time = 125
.meas tran vdout0_38ck24 FIND v(dout0_38) AT=125.025n

* CHECK dout0_39 Vdout0_39ck24 = 0.9 time = 125
.meas tran vdout0_39ck24 FIND v(dout0_39) AT=125.025n

* CHECK dout0_40 Vdout0_40ck24 = 0 time = 125
.meas tran vdout0_40ck24 FIND v(dout0_40) AT=125.025n

* CHECK dout0_41 Vdout0_41ck24 = 0 time = 125
.meas tran vdout0_41ck24 FIND v(dout0_41) AT=125.025n

* CHECK dout0_42 Vdout0_42ck24 = 0 time = 125
.meas tran vdout0_42ck24 FIND v(dout0_42) AT=125.025n

* CHECK dout0_43 Vdout0_43ck24 = 0.9 time = 125
.meas tran vdout0_43ck24 FIND v(dout0_43) AT=125.025n

* CHECK dout0_44 Vdout0_44ck24 = 0.9 time = 125
.meas tran vdout0_44ck24 FIND v(dout0_44) AT=125.025n

* CHECK dout0_45 Vdout0_45ck24 = 0 time = 125
.meas tran vdout0_45ck24 FIND v(dout0_45) AT=125.025n

* CHECK dout0_46 Vdout0_46ck24 = 0.9 time = 125
.meas tran vdout0_46ck24 FIND v(dout0_46) AT=125.025n

* CHECK dout0_47 Vdout0_47ck24 = 0.9 time = 125
.meas tran vdout0_47ck24 FIND v(dout0_47) AT=125.025n

* CHECK dout0_48 Vdout0_48ck24 = 0 time = 125
.meas tran vdout0_48ck24 FIND v(dout0_48) AT=125.025n

* CHECK dout0_49 Vdout0_49ck24 = 0.9 time = 125
.meas tran vdout0_49ck24 FIND v(dout0_49) AT=125.025n

* CHECK dout0_50 Vdout0_50ck24 = 0.9 time = 125
.meas tran vdout0_50ck24 FIND v(dout0_50) AT=125.025n

* CHECK dout0_51 Vdout0_51ck24 = 0 time = 125
.meas tran vdout0_51ck24 FIND v(dout0_51) AT=125.025n

* CHECK dout0_52 Vdout0_52ck24 = 0 time = 125
.meas tran vdout0_52ck24 FIND v(dout0_52) AT=125.025n

* CHECK dout0_53 Vdout0_53ck24 = 0 time = 125
.meas tran vdout0_53ck24 FIND v(dout0_53) AT=125.025n

* CHECK dout0_54 Vdout0_54ck24 = 0.9 time = 125
.meas tran vdout0_54ck24 FIND v(dout0_54) AT=125.025n

* CHECK dout0_55 Vdout0_55ck24 = 0.9 time = 125
.meas tran vdout0_55ck24 FIND v(dout0_55) AT=125.025n

* CHECK dout0_56 Vdout0_56ck24 = 0.9 time = 125
.meas tran vdout0_56ck24 FIND v(dout0_56) AT=125.025n

* CHECK dout0_57 Vdout0_57ck24 = 0.9 time = 125
.meas tran vdout0_57ck24 FIND v(dout0_57) AT=125.025n

* CHECK dout0_58 Vdout0_58ck24 = 0 time = 125
.meas tran vdout0_58ck24 FIND v(dout0_58) AT=125.025n

* CHECK dout0_59 Vdout0_59ck24 = 0.9 time = 125
.meas tran vdout0_59ck24 FIND v(dout0_59) AT=125.025n

* CHECK dout0_60 Vdout0_60ck24 = 0 time = 125
.meas tran vdout0_60ck24 FIND v(dout0_60) AT=125.025n

* CHECK dout0_61 Vdout0_61ck24 = 0 time = 125
.meas tran vdout0_61ck24 FIND v(dout0_61) AT=125.025n

* CHECK dout0_62 Vdout0_62ck24 = 0.9 time = 125
.meas tran vdout0_62ck24 FIND v(dout0_62) AT=125.025n

* CHECK dout0_63 Vdout0_63ck24 = 0.9 time = 125
.meas tran vdout0_63ck24 FIND v(dout0_63) AT=125.025n

* CHECK dout0_0 Vdout0_0ck25 = 0 time = 130
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=130.025n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 130
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=130.025n

* CHECK dout0_2 Vdout0_2ck25 = 0.9 time = 130
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=130.025n

* CHECK dout0_3 Vdout0_3ck25 = 0.9 time = 130
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=130.025n

* CHECK dout0_4 Vdout0_4ck25 = 0.9 time = 130
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=130.025n

* CHECK dout0_5 Vdout0_5ck25 = 0.9 time = 130
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=130.025n

* CHECK dout0_6 Vdout0_6ck25 = 0.9 time = 130
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=130.025n

* CHECK dout0_7 Vdout0_7ck25 = 0.9 time = 130
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=130.025n

* CHECK dout0_8 Vdout0_8ck25 = 0 time = 130
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=130.025n

* CHECK dout0_9 Vdout0_9ck25 = 0 time = 130
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=130.025n

* CHECK dout0_10 Vdout0_10ck25 = 0.9 time = 130
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=130.025n

* CHECK dout0_11 Vdout0_11ck25 = 0 time = 130
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=130.025n

* CHECK dout0_12 Vdout0_12ck25 = 0 time = 130
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=130.025n

* CHECK dout0_13 Vdout0_13ck25 = 0.9 time = 130
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=130.025n

* CHECK dout0_14 Vdout0_14ck25 = 0 time = 130
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=130.025n

* CHECK dout0_15 Vdout0_15ck25 = 0 time = 130
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=130.025n

* CHECK dout0_16 Vdout0_16ck25 = 0 time = 130
.meas tran vdout0_16ck25 FIND v(dout0_16) AT=130.025n

* CHECK dout0_17 Vdout0_17ck25 = 0 time = 130
.meas tran vdout0_17ck25 FIND v(dout0_17) AT=130.025n

* CHECK dout0_18 Vdout0_18ck25 = 0 time = 130
.meas tran vdout0_18ck25 FIND v(dout0_18) AT=130.025n

* CHECK dout0_19 Vdout0_19ck25 = 0 time = 130
.meas tran vdout0_19ck25 FIND v(dout0_19) AT=130.025n

* CHECK dout0_20 Vdout0_20ck25 = 0 time = 130
.meas tran vdout0_20ck25 FIND v(dout0_20) AT=130.025n

* CHECK dout0_21 Vdout0_21ck25 = 0 time = 130
.meas tran vdout0_21ck25 FIND v(dout0_21) AT=130.025n

* CHECK dout0_22 Vdout0_22ck25 = 0 time = 130
.meas tran vdout0_22ck25 FIND v(dout0_22) AT=130.025n

* CHECK dout0_23 Vdout0_23ck25 = 0 time = 130
.meas tran vdout0_23ck25 FIND v(dout0_23) AT=130.025n

* CHECK dout0_24 Vdout0_24ck25 = 0 time = 130
.meas tran vdout0_24ck25 FIND v(dout0_24) AT=130.025n

* CHECK dout0_25 Vdout0_25ck25 = 0 time = 130
.meas tran vdout0_25ck25 FIND v(dout0_25) AT=130.025n

* CHECK dout0_26 Vdout0_26ck25 = 0.9 time = 130
.meas tran vdout0_26ck25 FIND v(dout0_26) AT=130.025n

* CHECK dout0_27 Vdout0_27ck25 = 0.9 time = 130
.meas tran vdout0_27ck25 FIND v(dout0_27) AT=130.025n

* CHECK dout0_28 Vdout0_28ck25 = 0.9 time = 130
.meas tran vdout0_28ck25 FIND v(dout0_28) AT=130.025n

* CHECK dout0_29 Vdout0_29ck25 = 0 time = 130
.meas tran vdout0_29ck25 FIND v(dout0_29) AT=130.025n

* CHECK dout0_30 Vdout0_30ck25 = 0.9 time = 130
.meas tran vdout0_30ck25 FIND v(dout0_30) AT=130.025n

* CHECK dout0_31 Vdout0_31ck25 = 0 time = 130
.meas tran vdout0_31ck25 FIND v(dout0_31) AT=130.025n

* CHECK dout0_32 Vdout0_32ck25 = 0 time = 130
.meas tran vdout0_32ck25 FIND v(dout0_32) AT=130.025n

* CHECK dout0_33 Vdout0_33ck25 = 0.9 time = 130
.meas tran vdout0_33ck25 FIND v(dout0_33) AT=130.025n

* CHECK dout0_34 Vdout0_34ck25 = 0 time = 130
.meas tran vdout0_34ck25 FIND v(dout0_34) AT=130.025n

* CHECK dout0_35 Vdout0_35ck25 = 0 time = 130
.meas tran vdout0_35ck25 FIND v(dout0_35) AT=130.025n

* CHECK dout0_36 Vdout0_36ck25 = 0.9 time = 130
.meas tran vdout0_36ck25 FIND v(dout0_36) AT=130.025n

* CHECK dout0_37 Vdout0_37ck25 = 0 time = 130
.meas tran vdout0_37ck25 FIND v(dout0_37) AT=130.025n

* CHECK dout0_38 Vdout0_38ck25 = 0.9 time = 130
.meas tran vdout0_38ck25 FIND v(dout0_38) AT=130.025n

* CHECK dout0_39 Vdout0_39ck25 = 0.9 time = 130
.meas tran vdout0_39ck25 FIND v(dout0_39) AT=130.025n

* CHECK dout0_40 Vdout0_40ck25 = 0 time = 130
.meas tran vdout0_40ck25 FIND v(dout0_40) AT=130.025n

* CHECK dout0_41 Vdout0_41ck25 = 0 time = 130
.meas tran vdout0_41ck25 FIND v(dout0_41) AT=130.025n

* CHECK dout0_42 Vdout0_42ck25 = 0 time = 130
.meas tran vdout0_42ck25 FIND v(dout0_42) AT=130.025n

* CHECK dout0_43 Vdout0_43ck25 = 0.9 time = 130
.meas tran vdout0_43ck25 FIND v(dout0_43) AT=130.025n

* CHECK dout0_44 Vdout0_44ck25 = 0.9 time = 130
.meas tran vdout0_44ck25 FIND v(dout0_44) AT=130.025n

* CHECK dout0_45 Vdout0_45ck25 = 0 time = 130
.meas tran vdout0_45ck25 FIND v(dout0_45) AT=130.025n

* CHECK dout0_46 Vdout0_46ck25 = 0.9 time = 130
.meas tran vdout0_46ck25 FIND v(dout0_46) AT=130.025n

* CHECK dout0_47 Vdout0_47ck25 = 0.9 time = 130
.meas tran vdout0_47ck25 FIND v(dout0_47) AT=130.025n

* CHECK dout0_48 Vdout0_48ck25 = 0 time = 130
.meas tran vdout0_48ck25 FIND v(dout0_48) AT=130.025n

* CHECK dout0_49 Vdout0_49ck25 = 0.9 time = 130
.meas tran vdout0_49ck25 FIND v(dout0_49) AT=130.025n

* CHECK dout0_50 Vdout0_50ck25 = 0.9 time = 130
.meas tran vdout0_50ck25 FIND v(dout0_50) AT=130.025n

* CHECK dout0_51 Vdout0_51ck25 = 0 time = 130
.meas tran vdout0_51ck25 FIND v(dout0_51) AT=130.025n

* CHECK dout0_52 Vdout0_52ck25 = 0 time = 130
.meas tran vdout0_52ck25 FIND v(dout0_52) AT=130.025n

* CHECK dout0_53 Vdout0_53ck25 = 0 time = 130
.meas tran vdout0_53ck25 FIND v(dout0_53) AT=130.025n

* CHECK dout0_54 Vdout0_54ck25 = 0.9 time = 130
.meas tran vdout0_54ck25 FIND v(dout0_54) AT=130.025n

* CHECK dout0_55 Vdout0_55ck25 = 0.9 time = 130
.meas tran vdout0_55ck25 FIND v(dout0_55) AT=130.025n

* CHECK dout0_56 Vdout0_56ck25 = 0.9 time = 130
.meas tran vdout0_56ck25 FIND v(dout0_56) AT=130.025n

* CHECK dout0_57 Vdout0_57ck25 = 0.9 time = 130
.meas tran vdout0_57ck25 FIND v(dout0_57) AT=130.025n

* CHECK dout0_58 Vdout0_58ck25 = 0 time = 130
.meas tran vdout0_58ck25 FIND v(dout0_58) AT=130.025n

* CHECK dout0_59 Vdout0_59ck25 = 0.9 time = 130
.meas tran vdout0_59ck25 FIND v(dout0_59) AT=130.025n

* CHECK dout0_60 Vdout0_60ck25 = 0 time = 130
.meas tran vdout0_60ck25 FIND v(dout0_60) AT=130.025n

* CHECK dout0_61 Vdout0_61ck25 = 0 time = 130
.meas tran vdout0_61ck25 FIND v(dout0_61) AT=130.025n

* CHECK dout0_62 Vdout0_62ck25 = 0.9 time = 130
.meas tran vdout0_62ck25 FIND v(dout0_62) AT=130.025n

* CHECK dout0_63 Vdout0_63ck25 = 0.9 time = 130
.meas tran vdout0_63ck25 FIND v(dout0_63) AT=130.025n

* CHECK dout0_0 Vdout0_0ck36 = 0 time = 185
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=185.025n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 185
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=185.025n

* CHECK dout0_2 Vdout0_2ck36 = 0.9 time = 185
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=185.025n

* CHECK dout0_3 Vdout0_3ck36 = 0.9 time = 185
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=185.025n

* CHECK dout0_4 Vdout0_4ck36 = 0 time = 185
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=185.025n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 185
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=185.025n

* CHECK dout0_6 Vdout0_6ck36 = 0.9 time = 185
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=185.025n

* CHECK dout0_7 Vdout0_7ck36 = 0.9 time = 185
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=185.025n

* CHECK dout0_8 Vdout0_8ck36 = 0.9 time = 185
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=185.025n

* CHECK dout0_9 Vdout0_9ck36 = 0 time = 185
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=185.025n

* CHECK dout0_10 Vdout0_10ck36 = 0.9 time = 185
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=185.025n

* CHECK dout0_11 Vdout0_11ck36 = 0.9 time = 185
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=185.025n

* CHECK dout0_12 Vdout0_12ck36 = 0 time = 185
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=185.025n

* CHECK dout0_13 Vdout0_13ck36 = 0 time = 185
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=185.025n

* CHECK dout0_14 Vdout0_14ck36 = 0 time = 185
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=185.025n

* CHECK dout0_15 Vdout0_15ck36 = 0.9 time = 185
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=185.025n

* CHECK dout0_16 Vdout0_16ck36 = 0.9 time = 185
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=185.025n

* CHECK dout0_17 Vdout0_17ck36 = 0.9 time = 185
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=185.025n

* CHECK dout0_18 Vdout0_18ck36 = 0.9 time = 185
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=185.025n

* CHECK dout0_19 Vdout0_19ck36 = 0 time = 185
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=185.025n

* CHECK dout0_20 Vdout0_20ck36 = 0 time = 185
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=185.025n

* CHECK dout0_21 Vdout0_21ck36 = 0 time = 185
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=185.025n

* CHECK dout0_22 Vdout0_22ck36 = 0.9 time = 185
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=185.025n

* CHECK dout0_23 Vdout0_23ck36 = 0 time = 185
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=185.025n

* CHECK dout0_24 Vdout0_24ck36 = 0 time = 185
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=185.025n

* CHECK dout0_25 Vdout0_25ck36 = 0 time = 185
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=185.025n

* CHECK dout0_26 Vdout0_26ck36 = 0.9 time = 185
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=185.025n

* CHECK dout0_27 Vdout0_27ck36 = 0.9 time = 185
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=185.025n

* CHECK dout0_28 Vdout0_28ck36 = 0 time = 185
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=185.025n

* CHECK dout0_29 Vdout0_29ck36 = 0.9 time = 185
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=185.025n

* CHECK dout0_30 Vdout0_30ck36 = 0 time = 185
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=185.025n

* CHECK dout0_31 Vdout0_31ck36 = 0 time = 185
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=185.025n

* CHECK dout0_32 Vdout0_32ck36 = 0 time = 185
.meas tran vdout0_32ck36 FIND v(dout0_32) AT=185.025n

* CHECK dout0_33 Vdout0_33ck36 = 0 time = 185
.meas tran vdout0_33ck36 FIND v(dout0_33) AT=185.025n

* CHECK dout0_34 Vdout0_34ck36 = 0.9 time = 185
.meas tran vdout0_34ck36 FIND v(dout0_34) AT=185.025n

* CHECK dout0_35 Vdout0_35ck36 = 0 time = 185
.meas tran vdout0_35ck36 FIND v(dout0_35) AT=185.025n

* CHECK dout0_36 Vdout0_36ck36 = 0 time = 185
.meas tran vdout0_36ck36 FIND v(dout0_36) AT=185.025n

* CHECK dout0_37 Vdout0_37ck36 = 0.9 time = 185
.meas tran vdout0_37ck36 FIND v(dout0_37) AT=185.025n

* CHECK dout0_38 Vdout0_38ck36 = 0 time = 185
.meas tran vdout0_38ck36 FIND v(dout0_38) AT=185.025n

* CHECK dout0_39 Vdout0_39ck36 = 0.9 time = 185
.meas tran vdout0_39ck36 FIND v(dout0_39) AT=185.025n

* CHECK dout0_40 Vdout0_40ck36 = 0.9 time = 185
.meas tran vdout0_40ck36 FIND v(dout0_40) AT=185.025n

* CHECK dout0_41 Vdout0_41ck36 = 0.9 time = 185
.meas tran vdout0_41ck36 FIND v(dout0_41) AT=185.025n

* CHECK dout0_42 Vdout0_42ck36 = 0.9 time = 185
.meas tran vdout0_42ck36 FIND v(dout0_42) AT=185.025n

* CHECK dout0_43 Vdout0_43ck36 = 0 time = 185
.meas tran vdout0_43ck36 FIND v(dout0_43) AT=185.025n

* CHECK dout0_44 Vdout0_44ck36 = 0 time = 185
.meas tran vdout0_44ck36 FIND v(dout0_44) AT=185.025n

* CHECK dout0_45 Vdout0_45ck36 = 0.9 time = 185
.meas tran vdout0_45ck36 FIND v(dout0_45) AT=185.025n

* CHECK dout0_46 Vdout0_46ck36 = 0.9 time = 185
.meas tran vdout0_46ck36 FIND v(dout0_46) AT=185.025n

* CHECK dout0_47 Vdout0_47ck36 = 0.9 time = 185
.meas tran vdout0_47ck36 FIND v(dout0_47) AT=185.025n

* CHECK dout0_48 Vdout0_48ck36 = 0.9 time = 185
.meas tran vdout0_48ck36 FIND v(dout0_48) AT=185.025n

* CHECK dout0_49 Vdout0_49ck36 = 0 time = 185
.meas tran vdout0_49ck36 FIND v(dout0_49) AT=185.025n

* CHECK dout0_50 Vdout0_50ck36 = 0 time = 185
.meas tran vdout0_50ck36 FIND v(dout0_50) AT=185.025n

* CHECK dout0_51 Vdout0_51ck36 = 0 time = 185
.meas tran vdout0_51ck36 FIND v(dout0_51) AT=185.025n

* CHECK dout0_52 Vdout0_52ck36 = 0.9 time = 185
.meas tran vdout0_52ck36 FIND v(dout0_52) AT=185.025n

* CHECK dout0_53 Vdout0_53ck36 = 0 time = 185
.meas tran vdout0_53ck36 FIND v(dout0_53) AT=185.025n

* CHECK dout0_54 Vdout0_54ck36 = 0.9 time = 185
.meas tran vdout0_54ck36 FIND v(dout0_54) AT=185.025n

* CHECK dout0_55 Vdout0_55ck36 = 0 time = 185
.meas tran vdout0_55ck36 FIND v(dout0_55) AT=185.025n

* CHECK dout0_56 Vdout0_56ck36 = 0 time = 185
.meas tran vdout0_56ck36 FIND v(dout0_56) AT=185.025n

* CHECK dout0_57 Vdout0_57ck36 = 0 time = 185
.meas tran vdout0_57ck36 FIND v(dout0_57) AT=185.025n

* CHECK dout0_58 Vdout0_58ck36 = 0.9 time = 185
.meas tran vdout0_58ck36 FIND v(dout0_58) AT=185.025n

* CHECK dout0_59 Vdout0_59ck36 = 0.9 time = 185
.meas tran vdout0_59ck36 FIND v(dout0_59) AT=185.025n

* CHECK dout0_60 Vdout0_60ck36 = 0.9 time = 185
.meas tran vdout0_60ck36 FIND v(dout0_60) AT=185.025n

* CHECK dout0_61 Vdout0_61ck36 = 0 time = 185
.meas tran vdout0_61ck36 FIND v(dout0_61) AT=185.025n

* CHECK dout0_62 Vdout0_62ck36 = 0 time = 185
.meas tran vdout0_62ck36 FIND v(dout0_62) AT=185.025n

* CHECK dout0_63 Vdout0_63ck36 = 0.9 time = 185
.meas tran vdout0_63ck36 FIND v(dout0_63) AT=185.025n

* CHECK dout0_0 Vdout0_0ck37 = 0 time = 190
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=190.025n

* CHECK dout0_1 Vdout0_1ck37 = 0 time = 190
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=190.025n

* CHECK dout0_2 Vdout0_2ck37 = 0.9 time = 190
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=190.025n

* CHECK dout0_3 Vdout0_3ck37 = 0.9 time = 190
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=190.025n

* CHECK dout0_4 Vdout0_4ck37 = 0 time = 190
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=190.025n

* CHECK dout0_5 Vdout0_5ck37 = 0 time = 190
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=190.025n

* CHECK dout0_6 Vdout0_6ck37 = 0.9 time = 190
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=190.025n

* CHECK dout0_7 Vdout0_7ck37 = 0.9 time = 190
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=190.025n

* CHECK dout0_8 Vdout0_8ck37 = 0.9 time = 190
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=190.025n

* CHECK dout0_9 Vdout0_9ck37 = 0 time = 190
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=190.025n

* CHECK dout0_10 Vdout0_10ck37 = 0.9 time = 190
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=190.025n

* CHECK dout0_11 Vdout0_11ck37 = 0.9 time = 190
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=190.025n

* CHECK dout0_12 Vdout0_12ck37 = 0 time = 190
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=190.025n

* CHECK dout0_13 Vdout0_13ck37 = 0 time = 190
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=190.025n

* CHECK dout0_14 Vdout0_14ck37 = 0 time = 190
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=190.025n

* CHECK dout0_15 Vdout0_15ck37 = 0.9 time = 190
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=190.025n

* CHECK dout0_16 Vdout0_16ck37 = 0.9 time = 190
.meas tran vdout0_16ck37 FIND v(dout0_16) AT=190.025n

* CHECK dout0_17 Vdout0_17ck37 = 0.9 time = 190
.meas tran vdout0_17ck37 FIND v(dout0_17) AT=190.025n

* CHECK dout0_18 Vdout0_18ck37 = 0.9 time = 190
.meas tran vdout0_18ck37 FIND v(dout0_18) AT=190.025n

* CHECK dout0_19 Vdout0_19ck37 = 0 time = 190
.meas tran vdout0_19ck37 FIND v(dout0_19) AT=190.025n

* CHECK dout0_20 Vdout0_20ck37 = 0 time = 190
.meas tran vdout0_20ck37 FIND v(dout0_20) AT=190.025n

* CHECK dout0_21 Vdout0_21ck37 = 0 time = 190
.meas tran vdout0_21ck37 FIND v(dout0_21) AT=190.025n

* CHECK dout0_22 Vdout0_22ck37 = 0.9 time = 190
.meas tran vdout0_22ck37 FIND v(dout0_22) AT=190.025n

* CHECK dout0_23 Vdout0_23ck37 = 0 time = 190
.meas tran vdout0_23ck37 FIND v(dout0_23) AT=190.025n

* CHECK dout0_24 Vdout0_24ck37 = 0 time = 190
.meas tran vdout0_24ck37 FIND v(dout0_24) AT=190.025n

* CHECK dout0_25 Vdout0_25ck37 = 0 time = 190
.meas tran vdout0_25ck37 FIND v(dout0_25) AT=190.025n

* CHECK dout0_26 Vdout0_26ck37 = 0.9 time = 190
.meas tran vdout0_26ck37 FIND v(dout0_26) AT=190.025n

* CHECK dout0_27 Vdout0_27ck37 = 0.9 time = 190
.meas tran vdout0_27ck37 FIND v(dout0_27) AT=190.025n

* CHECK dout0_28 Vdout0_28ck37 = 0 time = 190
.meas tran vdout0_28ck37 FIND v(dout0_28) AT=190.025n

* CHECK dout0_29 Vdout0_29ck37 = 0.9 time = 190
.meas tran vdout0_29ck37 FIND v(dout0_29) AT=190.025n

* CHECK dout0_30 Vdout0_30ck37 = 0 time = 190
.meas tran vdout0_30ck37 FIND v(dout0_30) AT=190.025n

* CHECK dout0_31 Vdout0_31ck37 = 0 time = 190
.meas tran vdout0_31ck37 FIND v(dout0_31) AT=190.025n

* CHECK dout0_32 Vdout0_32ck37 = 0 time = 190
.meas tran vdout0_32ck37 FIND v(dout0_32) AT=190.025n

* CHECK dout0_33 Vdout0_33ck37 = 0 time = 190
.meas tran vdout0_33ck37 FIND v(dout0_33) AT=190.025n

* CHECK dout0_34 Vdout0_34ck37 = 0.9 time = 190
.meas tran vdout0_34ck37 FIND v(dout0_34) AT=190.025n

* CHECK dout0_35 Vdout0_35ck37 = 0 time = 190
.meas tran vdout0_35ck37 FIND v(dout0_35) AT=190.025n

* CHECK dout0_36 Vdout0_36ck37 = 0 time = 190
.meas tran vdout0_36ck37 FIND v(dout0_36) AT=190.025n

* CHECK dout0_37 Vdout0_37ck37 = 0.9 time = 190
.meas tran vdout0_37ck37 FIND v(dout0_37) AT=190.025n

* CHECK dout0_38 Vdout0_38ck37 = 0 time = 190
.meas tran vdout0_38ck37 FIND v(dout0_38) AT=190.025n

* CHECK dout0_39 Vdout0_39ck37 = 0.9 time = 190
.meas tran vdout0_39ck37 FIND v(dout0_39) AT=190.025n

* CHECK dout0_40 Vdout0_40ck37 = 0.9 time = 190
.meas tran vdout0_40ck37 FIND v(dout0_40) AT=190.025n

* CHECK dout0_41 Vdout0_41ck37 = 0.9 time = 190
.meas tran vdout0_41ck37 FIND v(dout0_41) AT=190.025n

* CHECK dout0_42 Vdout0_42ck37 = 0.9 time = 190
.meas tran vdout0_42ck37 FIND v(dout0_42) AT=190.025n

* CHECK dout0_43 Vdout0_43ck37 = 0 time = 190
.meas tran vdout0_43ck37 FIND v(dout0_43) AT=190.025n

* CHECK dout0_44 Vdout0_44ck37 = 0 time = 190
.meas tran vdout0_44ck37 FIND v(dout0_44) AT=190.025n

* CHECK dout0_45 Vdout0_45ck37 = 0.9 time = 190
.meas tran vdout0_45ck37 FIND v(dout0_45) AT=190.025n

* CHECK dout0_46 Vdout0_46ck37 = 0.9 time = 190
.meas tran vdout0_46ck37 FIND v(dout0_46) AT=190.025n

* CHECK dout0_47 Vdout0_47ck37 = 0.9 time = 190
.meas tran vdout0_47ck37 FIND v(dout0_47) AT=190.025n

* CHECK dout0_48 Vdout0_48ck37 = 0.9 time = 190
.meas tran vdout0_48ck37 FIND v(dout0_48) AT=190.025n

* CHECK dout0_49 Vdout0_49ck37 = 0 time = 190
.meas tran vdout0_49ck37 FIND v(dout0_49) AT=190.025n

* CHECK dout0_50 Vdout0_50ck37 = 0 time = 190
.meas tran vdout0_50ck37 FIND v(dout0_50) AT=190.025n

* CHECK dout0_51 Vdout0_51ck37 = 0 time = 190
.meas tran vdout0_51ck37 FIND v(dout0_51) AT=190.025n

* CHECK dout0_52 Vdout0_52ck37 = 0.9 time = 190
.meas tran vdout0_52ck37 FIND v(dout0_52) AT=190.025n

* CHECK dout0_53 Vdout0_53ck37 = 0 time = 190
.meas tran vdout0_53ck37 FIND v(dout0_53) AT=190.025n

* CHECK dout0_54 Vdout0_54ck37 = 0.9 time = 190
.meas tran vdout0_54ck37 FIND v(dout0_54) AT=190.025n

* CHECK dout0_55 Vdout0_55ck37 = 0 time = 190
.meas tran vdout0_55ck37 FIND v(dout0_55) AT=190.025n

* CHECK dout0_56 Vdout0_56ck37 = 0 time = 190
.meas tran vdout0_56ck37 FIND v(dout0_56) AT=190.025n

* CHECK dout0_57 Vdout0_57ck37 = 0 time = 190
.meas tran vdout0_57ck37 FIND v(dout0_57) AT=190.025n

* CHECK dout0_58 Vdout0_58ck37 = 0.9 time = 190
.meas tran vdout0_58ck37 FIND v(dout0_58) AT=190.025n

* CHECK dout0_59 Vdout0_59ck37 = 0.9 time = 190
.meas tran vdout0_59ck37 FIND v(dout0_59) AT=190.025n

* CHECK dout0_60 Vdout0_60ck37 = 0.9 time = 190
.meas tran vdout0_60ck37 FIND v(dout0_60) AT=190.025n

* CHECK dout0_61 Vdout0_61ck37 = 0 time = 190
.meas tran vdout0_61ck37 FIND v(dout0_61) AT=190.025n

* CHECK dout0_62 Vdout0_62ck37 = 0 time = 190
.meas tran vdout0_62ck37 FIND v(dout0_62) AT=190.025n

* CHECK dout0_63 Vdout0_63ck37 = 0.9 time = 190
.meas tran vdout0_63ck37 FIND v(dout0_63) AT=190.025n

* CHECK dout0_0 Vdout0_0ck39 = 0.9 time = 200
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=200.025n

* CHECK dout0_1 Vdout0_1ck39 = 0.9 time = 200
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=200.025n

* CHECK dout0_2 Vdout0_2ck39 = 0 time = 200
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=200.025n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 200
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=200.025n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 200
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=200.025n

* CHECK dout0_5 Vdout0_5ck39 = 0.9 time = 200
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=200.025n

* CHECK dout0_6 Vdout0_6ck39 = 0.9 time = 200
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=200.025n

* CHECK dout0_7 Vdout0_7ck39 = 0 time = 200
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=200.025n

* CHECK dout0_8 Vdout0_8ck39 = 0 time = 200
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=200.025n

* CHECK dout0_9 Vdout0_9ck39 = 0 time = 200
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=200.025n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 200
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=200.025n

* CHECK dout0_11 Vdout0_11ck39 = 0.9 time = 200
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=200.025n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 200
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=200.025n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 200
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=200.025n

* CHECK dout0_14 Vdout0_14ck39 = 0 time = 200
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=200.025n

* CHECK dout0_15 Vdout0_15ck39 = 0 time = 200
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=200.025n

* CHECK dout0_16 Vdout0_16ck39 = 0 time = 200
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=200.025n

* CHECK dout0_17 Vdout0_17ck39 = 0.9 time = 200
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=200.025n

* CHECK dout0_18 Vdout0_18ck39 = 0.9 time = 200
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=200.025n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 200
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=200.025n

* CHECK dout0_20 Vdout0_20ck39 = 0 time = 200
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=200.025n

* CHECK dout0_21 Vdout0_21ck39 = 0.9 time = 200
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=200.025n

* CHECK dout0_22 Vdout0_22ck39 = 0.9 time = 200
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=200.025n

* CHECK dout0_23 Vdout0_23ck39 = 0 time = 200
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=200.025n

* CHECK dout0_24 Vdout0_24ck39 = 0.9 time = 200
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=200.025n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 200
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=200.025n

* CHECK dout0_26 Vdout0_26ck39 = 0 time = 200
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=200.025n

* CHECK dout0_27 Vdout0_27ck39 = 0.9 time = 200
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=200.025n

* CHECK dout0_28 Vdout0_28ck39 = 0.9 time = 200
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=200.025n

* CHECK dout0_29 Vdout0_29ck39 = 0 time = 200
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=200.025n

* CHECK dout0_30 Vdout0_30ck39 = 0.9 time = 200
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=200.025n

* CHECK dout0_31 Vdout0_31ck39 = 0.9 time = 200
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=200.025n

* CHECK dout0_32 Vdout0_32ck39 = 0.9 time = 200
.meas tran vdout0_32ck39 FIND v(dout0_32) AT=200.025n

* CHECK dout0_33 Vdout0_33ck39 = 0 time = 200
.meas tran vdout0_33ck39 FIND v(dout0_33) AT=200.025n

* CHECK dout0_34 Vdout0_34ck39 = 0.9 time = 200
.meas tran vdout0_34ck39 FIND v(dout0_34) AT=200.025n

* CHECK dout0_35 Vdout0_35ck39 = 0.9 time = 200
.meas tran vdout0_35ck39 FIND v(dout0_35) AT=200.025n

* CHECK dout0_36 Vdout0_36ck39 = 0.9 time = 200
.meas tran vdout0_36ck39 FIND v(dout0_36) AT=200.025n

* CHECK dout0_37 Vdout0_37ck39 = 0.9 time = 200
.meas tran vdout0_37ck39 FIND v(dout0_37) AT=200.025n

* CHECK dout0_38 Vdout0_38ck39 = 0.9 time = 200
.meas tran vdout0_38ck39 FIND v(dout0_38) AT=200.025n

* CHECK dout0_39 Vdout0_39ck39 = 0.9 time = 200
.meas tran vdout0_39ck39 FIND v(dout0_39) AT=200.025n

* CHECK dout0_40 Vdout0_40ck39 = 0 time = 200
.meas tran vdout0_40ck39 FIND v(dout0_40) AT=200.025n

* CHECK dout0_41 Vdout0_41ck39 = 0 time = 200
.meas tran vdout0_41ck39 FIND v(dout0_41) AT=200.025n

* CHECK dout0_42 Vdout0_42ck39 = 0 time = 200
.meas tran vdout0_42ck39 FIND v(dout0_42) AT=200.025n

* CHECK dout0_43 Vdout0_43ck39 = 0.9 time = 200
.meas tran vdout0_43ck39 FIND v(dout0_43) AT=200.025n

* CHECK dout0_44 Vdout0_44ck39 = 0.9 time = 200
.meas tran vdout0_44ck39 FIND v(dout0_44) AT=200.025n

* CHECK dout0_45 Vdout0_45ck39 = 0 time = 200
.meas tran vdout0_45ck39 FIND v(dout0_45) AT=200.025n

* CHECK dout0_46 Vdout0_46ck39 = 0 time = 200
.meas tran vdout0_46ck39 FIND v(dout0_46) AT=200.025n

* CHECK dout0_47 Vdout0_47ck39 = 0 time = 200
.meas tran vdout0_47ck39 FIND v(dout0_47) AT=200.025n

* CHECK dout0_48 Vdout0_48ck39 = 0.9 time = 200
.meas tran vdout0_48ck39 FIND v(dout0_48) AT=200.025n

* CHECK dout0_49 Vdout0_49ck39 = 0.9 time = 200
.meas tran vdout0_49ck39 FIND v(dout0_49) AT=200.025n

* CHECK dout0_50 Vdout0_50ck39 = 0.9 time = 200
.meas tran vdout0_50ck39 FIND v(dout0_50) AT=200.025n

* CHECK dout0_51 Vdout0_51ck39 = 0.9 time = 200
.meas tran vdout0_51ck39 FIND v(dout0_51) AT=200.025n

* CHECK dout0_52 Vdout0_52ck39 = 0 time = 200
.meas tran vdout0_52ck39 FIND v(dout0_52) AT=200.025n

* CHECK dout0_53 Vdout0_53ck39 = 0.9 time = 200
.meas tran vdout0_53ck39 FIND v(dout0_53) AT=200.025n

* CHECK dout0_54 Vdout0_54ck39 = 0 time = 200
.meas tran vdout0_54ck39 FIND v(dout0_54) AT=200.025n

* CHECK dout0_55 Vdout0_55ck39 = 0 time = 200
.meas tran vdout0_55ck39 FIND v(dout0_55) AT=200.025n

* CHECK dout0_56 Vdout0_56ck39 = 0 time = 200
.meas tran vdout0_56ck39 FIND v(dout0_56) AT=200.025n

* CHECK dout0_57 Vdout0_57ck39 = 0.9 time = 200
.meas tran vdout0_57ck39 FIND v(dout0_57) AT=200.025n

* CHECK dout0_58 Vdout0_58ck39 = 0 time = 200
.meas tran vdout0_58ck39 FIND v(dout0_58) AT=200.025n

* CHECK dout0_59 Vdout0_59ck39 = 0 time = 200
.meas tran vdout0_59ck39 FIND v(dout0_59) AT=200.025n

* CHECK dout0_60 Vdout0_60ck39 = 0 time = 200
.meas tran vdout0_60ck39 FIND v(dout0_60) AT=200.025n

* CHECK dout0_61 Vdout0_61ck39 = 0 time = 200
.meas tran vdout0_61ck39 FIND v(dout0_61) AT=200.025n

* CHECK dout0_62 Vdout0_62ck39 = 0 time = 200
.meas tran vdout0_62ck39 FIND v(dout0_62) AT=200.025n

* CHECK dout0_63 Vdout0_63ck39 = 0.9 time = 200
.meas tran vdout0_63ck39 FIND v(dout0_63) AT=200.025n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 210
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=210.025n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 210
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=210.025n

* CHECK dout0_2 Vdout0_2ck41 = 0.9 time = 210
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=210.025n

* CHECK dout0_3 Vdout0_3ck41 = 0.9 time = 210
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=210.025n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 210
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=210.025n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 210
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=210.025n

* CHECK dout0_6 Vdout0_6ck41 = 0.9 time = 210
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=210.025n

* CHECK dout0_7 Vdout0_7ck41 = 0.9 time = 210
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=210.025n

* CHECK dout0_8 Vdout0_8ck41 = 0.9 time = 210
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=210.025n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 210
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=210.025n

* CHECK dout0_10 Vdout0_10ck41 = 0.9 time = 210
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=210.025n

* CHECK dout0_11 Vdout0_11ck41 = 0.9 time = 210
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=210.025n

* CHECK dout0_12 Vdout0_12ck41 = 0 time = 210
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=210.025n

* CHECK dout0_13 Vdout0_13ck41 = 0 time = 210
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=210.025n

* CHECK dout0_14 Vdout0_14ck41 = 0 time = 210
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=210.025n

* CHECK dout0_15 Vdout0_15ck41 = 0.9 time = 210
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=210.025n

* CHECK dout0_16 Vdout0_16ck41 = 0.9 time = 210
.meas tran vdout0_16ck41 FIND v(dout0_16) AT=210.025n

* CHECK dout0_17 Vdout0_17ck41 = 0.9 time = 210
.meas tran vdout0_17ck41 FIND v(dout0_17) AT=210.025n

* CHECK dout0_18 Vdout0_18ck41 = 0.9 time = 210
.meas tran vdout0_18ck41 FIND v(dout0_18) AT=210.025n

* CHECK dout0_19 Vdout0_19ck41 = 0 time = 210
.meas tran vdout0_19ck41 FIND v(dout0_19) AT=210.025n

* CHECK dout0_20 Vdout0_20ck41 = 0 time = 210
.meas tran vdout0_20ck41 FIND v(dout0_20) AT=210.025n

* CHECK dout0_21 Vdout0_21ck41 = 0 time = 210
.meas tran vdout0_21ck41 FIND v(dout0_21) AT=210.025n

* CHECK dout0_22 Vdout0_22ck41 = 0.9 time = 210
.meas tran vdout0_22ck41 FIND v(dout0_22) AT=210.025n

* CHECK dout0_23 Vdout0_23ck41 = 0 time = 210
.meas tran vdout0_23ck41 FIND v(dout0_23) AT=210.025n

* CHECK dout0_24 Vdout0_24ck41 = 0 time = 210
.meas tran vdout0_24ck41 FIND v(dout0_24) AT=210.025n

* CHECK dout0_25 Vdout0_25ck41 = 0 time = 210
.meas tran vdout0_25ck41 FIND v(dout0_25) AT=210.025n

* CHECK dout0_26 Vdout0_26ck41 = 0.9 time = 210
.meas tran vdout0_26ck41 FIND v(dout0_26) AT=210.025n

* CHECK dout0_27 Vdout0_27ck41 = 0.9 time = 210
.meas tran vdout0_27ck41 FIND v(dout0_27) AT=210.025n

* CHECK dout0_28 Vdout0_28ck41 = 0 time = 210
.meas tran vdout0_28ck41 FIND v(dout0_28) AT=210.025n

* CHECK dout0_29 Vdout0_29ck41 = 0.9 time = 210
.meas tran vdout0_29ck41 FIND v(dout0_29) AT=210.025n

* CHECK dout0_30 Vdout0_30ck41 = 0 time = 210
.meas tran vdout0_30ck41 FIND v(dout0_30) AT=210.025n

* CHECK dout0_31 Vdout0_31ck41 = 0 time = 210
.meas tran vdout0_31ck41 FIND v(dout0_31) AT=210.025n

* CHECK dout0_32 Vdout0_32ck41 = 0 time = 210
.meas tran vdout0_32ck41 FIND v(dout0_32) AT=210.025n

* CHECK dout0_33 Vdout0_33ck41 = 0 time = 210
.meas tran vdout0_33ck41 FIND v(dout0_33) AT=210.025n

* CHECK dout0_34 Vdout0_34ck41 = 0.9 time = 210
.meas tran vdout0_34ck41 FIND v(dout0_34) AT=210.025n

* CHECK dout0_35 Vdout0_35ck41 = 0 time = 210
.meas tran vdout0_35ck41 FIND v(dout0_35) AT=210.025n

* CHECK dout0_36 Vdout0_36ck41 = 0 time = 210
.meas tran vdout0_36ck41 FIND v(dout0_36) AT=210.025n

* CHECK dout0_37 Vdout0_37ck41 = 0.9 time = 210
.meas tran vdout0_37ck41 FIND v(dout0_37) AT=210.025n

* CHECK dout0_38 Vdout0_38ck41 = 0 time = 210
.meas tran vdout0_38ck41 FIND v(dout0_38) AT=210.025n

* CHECK dout0_39 Vdout0_39ck41 = 0.9 time = 210
.meas tran vdout0_39ck41 FIND v(dout0_39) AT=210.025n

* CHECK dout0_40 Vdout0_40ck41 = 0.9 time = 210
.meas tran vdout0_40ck41 FIND v(dout0_40) AT=210.025n

* CHECK dout0_41 Vdout0_41ck41 = 0.9 time = 210
.meas tran vdout0_41ck41 FIND v(dout0_41) AT=210.025n

* CHECK dout0_42 Vdout0_42ck41 = 0.9 time = 210
.meas tran vdout0_42ck41 FIND v(dout0_42) AT=210.025n

* CHECK dout0_43 Vdout0_43ck41 = 0 time = 210
.meas tran vdout0_43ck41 FIND v(dout0_43) AT=210.025n

* CHECK dout0_44 Vdout0_44ck41 = 0 time = 210
.meas tran vdout0_44ck41 FIND v(dout0_44) AT=210.025n

* CHECK dout0_45 Vdout0_45ck41 = 0.9 time = 210
.meas tran vdout0_45ck41 FIND v(dout0_45) AT=210.025n

* CHECK dout0_46 Vdout0_46ck41 = 0.9 time = 210
.meas tran vdout0_46ck41 FIND v(dout0_46) AT=210.025n

* CHECK dout0_47 Vdout0_47ck41 = 0.9 time = 210
.meas tran vdout0_47ck41 FIND v(dout0_47) AT=210.025n

* CHECK dout0_48 Vdout0_48ck41 = 0.9 time = 210
.meas tran vdout0_48ck41 FIND v(dout0_48) AT=210.025n

* CHECK dout0_49 Vdout0_49ck41 = 0 time = 210
.meas tran vdout0_49ck41 FIND v(dout0_49) AT=210.025n

* CHECK dout0_50 Vdout0_50ck41 = 0 time = 210
.meas tran vdout0_50ck41 FIND v(dout0_50) AT=210.025n

* CHECK dout0_51 Vdout0_51ck41 = 0 time = 210
.meas tran vdout0_51ck41 FIND v(dout0_51) AT=210.025n

* CHECK dout0_52 Vdout0_52ck41 = 0.9 time = 210
.meas tran vdout0_52ck41 FIND v(dout0_52) AT=210.025n

* CHECK dout0_53 Vdout0_53ck41 = 0 time = 210
.meas tran vdout0_53ck41 FIND v(dout0_53) AT=210.025n

* CHECK dout0_54 Vdout0_54ck41 = 0.9 time = 210
.meas tran vdout0_54ck41 FIND v(dout0_54) AT=210.025n

* CHECK dout0_55 Vdout0_55ck41 = 0 time = 210
.meas tran vdout0_55ck41 FIND v(dout0_55) AT=210.025n

* CHECK dout0_56 Vdout0_56ck41 = 0 time = 210
.meas tran vdout0_56ck41 FIND v(dout0_56) AT=210.025n

* CHECK dout0_57 Vdout0_57ck41 = 0 time = 210
.meas tran vdout0_57ck41 FIND v(dout0_57) AT=210.025n

* CHECK dout0_58 Vdout0_58ck41 = 0.9 time = 210
.meas tran vdout0_58ck41 FIND v(dout0_58) AT=210.025n

* CHECK dout0_59 Vdout0_59ck41 = 0.9 time = 210
.meas tran vdout0_59ck41 FIND v(dout0_59) AT=210.025n

* CHECK dout0_60 Vdout0_60ck41 = 0.9 time = 210
.meas tran vdout0_60ck41 FIND v(dout0_60) AT=210.025n

* CHECK dout0_61 Vdout0_61ck41 = 0 time = 210
.meas tran vdout0_61ck41 FIND v(dout0_61) AT=210.025n

* CHECK dout0_62 Vdout0_62ck41 = 0 time = 210
.meas tran vdout0_62ck41 FIND v(dout0_62) AT=210.025n

* CHECK dout0_63 Vdout0_63ck41 = 0.9 time = 210
.meas tran vdout0_63ck41 FIND v(dout0_63) AT=210.025n

* CHECK dout0_0 Vdout0_0ck42 = 0.9 time = 215
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=215.025n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 215
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=215.025n

* CHECK dout0_2 Vdout0_2ck42 = 0.9 time = 215
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=215.025n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 215
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=215.025n

* CHECK dout0_4 Vdout0_4ck42 = 0.9 time = 215
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=215.025n

* CHECK dout0_5 Vdout0_5ck42 = 0 time = 215
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=215.025n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 215
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=215.025n

* CHECK dout0_7 Vdout0_7ck42 = 0.9 time = 215
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=215.025n

* CHECK dout0_8 Vdout0_8ck42 = 0.9 time = 215
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=215.025n

* CHECK dout0_9 Vdout0_9ck42 = 0.9 time = 215
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=215.025n

* CHECK dout0_10 Vdout0_10ck42 = 0.9 time = 215
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=215.025n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 215
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=215.025n

* CHECK dout0_12 Vdout0_12ck42 = 0 time = 215
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=215.025n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 215
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=215.025n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 215
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=215.025n

* CHECK dout0_15 Vdout0_15ck42 = 0 time = 215
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=215.025n

* CHECK dout0_16 Vdout0_16ck42 = 0 time = 215
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=215.025n

* CHECK dout0_17 Vdout0_17ck42 = 0 time = 215
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=215.025n

* CHECK dout0_18 Vdout0_18ck42 = 0 time = 215
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=215.025n

* CHECK dout0_19 Vdout0_19ck42 = 0 time = 215
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=215.025n

* CHECK dout0_20 Vdout0_20ck42 = 0 time = 215
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=215.025n

* CHECK dout0_21 Vdout0_21ck42 = 0.9 time = 215
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=215.025n

* CHECK dout0_22 Vdout0_22ck42 = 0 time = 215
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=215.025n

* CHECK dout0_23 Vdout0_23ck42 = 0.9 time = 215
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=215.025n

* CHECK dout0_24 Vdout0_24ck42 = 0.9 time = 215
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=215.025n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 215
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=215.025n

* CHECK dout0_26 Vdout0_26ck42 = 0 time = 215
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=215.025n

* CHECK dout0_27 Vdout0_27ck42 = 0.9 time = 215
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=215.025n

* CHECK dout0_28 Vdout0_28ck42 = 0 time = 215
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=215.025n

* CHECK dout0_29 Vdout0_29ck42 = 0 time = 215
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=215.025n

* CHECK dout0_30 Vdout0_30ck42 = 0.9 time = 215
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=215.025n

* CHECK dout0_31 Vdout0_31ck42 = 0 time = 215
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=215.025n

* CHECK dout0_32 Vdout0_32ck42 = 0 time = 215
.meas tran vdout0_32ck42 FIND v(dout0_32) AT=215.025n

* CHECK dout0_33 Vdout0_33ck42 = 0.9 time = 215
.meas tran vdout0_33ck42 FIND v(dout0_33) AT=215.025n

* CHECK dout0_34 Vdout0_34ck42 = 0.9 time = 215
.meas tran vdout0_34ck42 FIND v(dout0_34) AT=215.025n

* CHECK dout0_35 Vdout0_35ck42 = 0.9 time = 215
.meas tran vdout0_35ck42 FIND v(dout0_35) AT=215.025n

* CHECK dout0_36 Vdout0_36ck42 = 0.9 time = 215
.meas tran vdout0_36ck42 FIND v(dout0_36) AT=215.025n

* CHECK dout0_37 Vdout0_37ck42 = 0.9 time = 215
.meas tran vdout0_37ck42 FIND v(dout0_37) AT=215.025n

* CHECK dout0_38 Vdout0_38ck42 = 0 time = 215
.meas tran vdout0_38ck42 FIND v(dout0_38) AT=215.025n

* CHECK dout0_39 Vdout0_39ck42 = 0.9 time = 215
.meas tran vdout0_39ck42 FIND v(dout0_39) AT=215.025n

* CHECK dout0_40 Vdout0_40ck42 = 0.9 time = 215
.meas tran vdout0_40ck42 FIND v(dout0_40) AT=215.025n

* CHECK dout0_41 Vdout0_41ck42 = 0 time = 215
.meas tran vdout0_41ck42 FIND v(dout0_41) AT=215.025n

* CHECK dout0_42 Vdout0_42ck42 = 0 time = 215
.meas tran vdout0_42ck42 FIND v(dout0_42) AT=215.025n

* CHECK dout0_43 Vdout0_43ck42 = 0 time = 215
.meas tran vdout0_43ck42 FIND v(dout0_43) AT=215.025n

* CHECK dout0_44 Vdout0_44ck42 = 0 time = 215
.meas tran vdout0_44ck42 FIND v(dout0_44) AT=215.025n

* CHECK dout0_45 Vdout0_45ck42 = 0.9 time = 215
.meas tran vdout0_45ck42 FIND v(dout0_45) AT=215.025n

* CHECK dout0_46 Vdout0_46ck42 = 0.9 time = 215
.meas tran vdout0_46ck42 FIND v(dout0_46) AT=215.025n

* CHECK dout0_47 Vdout0_47ck42 = 0 time = 215
.meas tran vdout0_47ck42 FIND v(dout0_47) AT=215.025n

* CHECK dout0_48 Vdout0_48ck42 = 0 time = 215
.meas tran vdout0_48ck42 FIND v(dout0_48) AT=215.025n

* CHECK dout0_49 Vdout0_49ck42 = 0.9 time = 215
.meas tran vdout0_49ck42 FIND v(dout0_49) AT=215.025n

* CHECK dout0_50 Vdout0_50ck42 = 0.9 time = 215
.meas tran vdout0_50ck42 FIND v(dout0_50) AT=215.025n

* CHECK dout0_51 Vdout0_51ck42 = 0 time = 215
.meas tran vdout0_51ck42 FIND v(dout0_51) AT=215.025n

* CHECK dout0_52 Vdout0_52ck42 = 0.9 time = 215
.meas tran vdout0_52ck42 FIND v(dout0_52) AT=215.025n

* CHECK dout0_53 Vdout0_53ck42 = 0.9 time = 215
.meas tran vdout0_53ck42 FIND v(dout0_53) AT=215.025n

* CHECK dout0_54 Vdout0_54ck42 = 0 time = 215
.meas tran vdout0_54ck42 FIND v(dout0_54) AT=215.025n

* CHECK dout0_55 Vdout0_55ck42 = 0.9 time = 215
.meas tran vdout0_55ck42 FIND v(dout0_55) AT=215.025n

* CHECK dout0_56 Vdout0_56ck42 = 0.9 time = 215
.meas tran vdout0_56ck42 FIND v(dout0_56) AT=215.025n

* CHECK dout0_57 Vdout0_57ck42 = 0 time = 215
.meas tran vdout0_57ck42 FIND v(dout0_57) AT=215.025n

* CHECK dout0_58 Vdout0_58ck42 = 0 time = 215
.meas tran vdout0_58ck42 FIND v(dout0_58) AT=215.025n

* CHECK dout0_59 Vdout0_59ck42 = 0.9 time = 215
.meas tran vdout0_59ck42 FIND v(dout0_59) AT=215.025n

* CHECK dout0_60 Vdout0_60ck42 = 0.9 time = 215
.meas tran vdout0_60ck42 FIND v(dout0_60) AT=215.025n

* CHECK dout0_61 Vdout0_61ck42 = 0.9 time = 215
.meas tran vdout0_61ck42 FIND v(dout0_61) AT=215.025n

* CHECK dout0_62 Vdout0_62ck42 = 0 time = 215
.meas tran vdout0_62ck42 FIND v(dout0_62) AT=215.025n

* CHECK dout0_63 Vdout0_63ck42 = 0 time = 215
.meas tran vdout0_63ck42 FIND v(dout0_63) AT=215.025n

* CHECK dout0_0 Vdout0_0ck43 = 0 time = 220
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=220.025n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 220
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=220.025n

* CHECK dout0_2 Vdout0_2ck43 = 0.9 time = 220
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=220.025n

* CHECK dout0_3 Vdout0_3ck43 = 0.9 time = 220
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=220.025n

* CHECK dout0_4 Vdout0_4ck43 = 0 time = 220
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=220.025n

* CHECK dout0_5 Vdout0_5ck43 = 0 time = 220
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=220.025n

* CHECK dout0_6 Vdout0_6ck43 = 0.9 time = 220
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=220.025n

* CHECK dout0_7 Vdout0_7ck43 = 0.9 time = 220
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=220.025n

* CHECK dout0_8 Vdout0_8ck43 = 0.9 time = 220
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=220.025n

* CHECK dout0_9 Vdout0_9ck43 = 0 time = 220
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=220.025n

* CHECK dout0_10 Vdout0_10ck43 = 0.9 time = 220
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=220.025n

* CHECK dout0_11 Vdout0_11ck43 = 0.9 time = 220
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=220.025n

* CHECK dout0_12 Vdout0_12ck43 = 0 time = 220
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=220.025n

* CHECK dout0_13 Vdout0_13ck43 = 0 time = 220
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=220.025n

* CHECK dout0_14 Vdout0_14ck43 = 0 time = 220
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=220.025n

* CHECK dout0_15 Vdout0_15ck43 = 0.9 time = 220
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=220.025n

* CHECK dout0_16 Vdout0_16ck43 = 0.9 time = 220
.meas tran vdout0_16ck43 FIND v(dout0_16) AT=220.025n

* CHECK dout0_17 Vdout0_17ck43 = 0.9 time = 220
.meas tran vdout0_17ck43 FIND v(dout0_17) AT=220.025n

* CHECK dout0_18 Vdout0_18ck43 = 0.9 time = 220
.meas tran vdout0_18ck43 FIND v(dout0_18) AT=220.025n

* CHECK dout0_19 Vdout0_19ck43 = 0 time = 220
.meas tran vdout0_19ck43 FIND v(dout0_19) AT=220.025n

* CHECK dout0_20 Vdout0_20ck43 = 0 time = 220
.meas tran vdout0_20ck43 FIND v(dout0_20) AT=220.025n

* CHECK dout0_21 Vdout0_21ck43 = 0 time = 220
.meas tran vdout0_21ck43 FIND v(dout0_21) AT=220.025n

* CHECK dout0_22 Vdout0_22ck43 = 0.9 time = 220
.meas tran vdout0_22ck43 FIND v(dout0_22) AT=220.025n

* CHECK dout0_23 Vdout0_23ck43 = 0 time = 220
.meas tran vdout0_23ck43 FIND v(dout0_23) AT=220.025n

* CHECK dout0_24 Vdout0_24ck43 = 0 time = 220
.meas tran vdout0_24ck43 FIND v(dout0_24) AT=220.025n

* CHECK dout0_25 Vdout0_25ck43 = 0 time = 220
.meas tran vdout0_25ck43 FIND v(dout0_25) AT=220.025n

* CHECK dout0_26 Vdout0_26ck43 = 0.9 time = 220
.meas tran vdout0_26ck43 FIND v(dout0_26) AT=220.025n

* CHECK dout0_27 Vdout0_27ck43 = 0.9 time = 220
.meas tran vdout0_27ck43 FIND v(dout0_27) AT=220.025n

* CHECK dout0_28 Vdout0_28ck43 = 0 time = 220
.meas tran vdout0_28ck43 FIND v(dout0_28) AT=220.025n

* CHECK dout0_29 Vdout0_29ck43 = 0.9 time = 220
.meas tran vdout0_29ck43 FIND v(dout0_29) AT=220.025n

* CHECK dout0_30 Vdout0_30ck43 = 0 time = 220
.meas tran vdout0_30ck43 FIND v(dout0_30) AT=220.025n

* CHECK dout0_31 Vdout0_31ck43 = 0 time = 220
.meas tran vdout0_31ck43 FIND v(dout0_31) AT=220.025n

* CHECK dout0_32 Vdout0_32ck43 = 0 time = 220
.meas tran vdout0_32ck43 FIND v(dout0_32) AT=220.025n

* CHECK dout0_33 Vdout0_33ck43 = 0 time = 220
.meas tran vdout0_33ck43 FIND v(dout0_33) AT=220.025n

* CHECK dout0_34 Vdout0_34ck43 = 0.9 time = 220
.meas tran vdout0_34ck43 FIND v(dout0_34) AT=220.025n

* CHECK dout0_35 Vdout0_35ck43 = 0 time = 220
.meas tran vdout0_35ck43 FIND v(dout0_35) AT=220.025n

* CHECK dout0_36 Vdout0_36ck43 = 0 time = 220
.meas tran vdout0_36ck43 FIND v(dout0_36) AT=220.025n

* CHECK dout0_37 Vdout0_37ck43 = 0.9 time = 220
.meas tran vdout0_37ck43 FIND v(dout0_37) AT=220.025n

* CHECK dout0_38 Vdout0_38ck43 = 0 time = 220
.meas tran vdout0_38ck43 FIND v(dout0_38) AT=220.025n

* CHECK dout0_39 Vdout0_39ck43 = 0.9 time = 220
.meas tran vdout0_39ck43 FIND v(dout0_39) AT=220.025n

* CHECK dout0_40 Vdout0_40ck43 = 0.9 time = 220
.meas tran vdout0_40ck43 FIND v(dout0_40) AT=220.025n

* CHECK dout0_41 Vdout0_41ck43 = 0.9 time = 220
.meas tran vdout0_41ck43 FIND v(dout0_41) AT=220.025n

* CHECK dout0_42 Vdout0_42ck43 = 0.9 time = 220
.meas tran vdout0_42ck43 FIND v(dout0_42) AT=220.025n

* CHECK dout0_43 Vdout0_43ck43 = 0 time = 220
.meas tran vdout0_43ck43 FIND v(dout0_43) AT=220.025n

* CHECK dout0_44 Vdout0_44ck43 = 0 time = 220
.meas tran vdout0_44ck43 FIND v(dout0_44) AT=220.025n

* CHECK dout0_45 Vdout0_45ck43 = 0.9 time = 220
.meas tran vdout0_45ck43 FIND v(dout0_45) AT=220.025n

* CHECK dout0_46 Vdout0_46ck43 = 0.9 time = 220
.meas tran vdout0_46ck43 FIND v(dout0_46) AT=220.025n

* CHECK dout0_47 Vdout0_47ck43 = 0.9 time = 220
.meas tran vdout0_47ck43 FIND v(dout0_47) AT=220.025n

* CHECK dout0_48 Vdout0_48ck43 = 0.9 time = 220
.meas tran vdout0_48ck43 FIND v(dout0_48) AT=220.025n

* CHECK dout0_49 Vdout0_49ck43 = 0 time = 220
.meas tran vdout0_49ck43 FIND v(dout0_49) AT=220.025n

* CHECK dout0_50 Vdout0_50ck43 = 0 time = 220
.meas tran vdout0_50ck43 FIND v(dout0_50) AT=220.025n

* CHECK dout0_51 Vdout0_51ck43 = 0 time = 220
.meas tran vdout0_51ck43 FIND v(dout0_51) AT=220.025n

* CHECK dout0_52 Vdout0_52ck43 = 0.9 time = 220
.meas tran vdout0_52ck43 FIND v(dout0_52) AT=220.025n

* CHECK dout0_53 Vdout0_53ck43 = 0 time = 220
.meas tran vdout0_53ck43 FIND v(dout0_53) AT=220.025n

* CHECK dout0_54 Vdout0_54ck43 = 0.9 time = 220
.meas tran vdout0_54ck43 FIND v(dout0_54) AT=220.025n

* CHECK dout0_55 Vdout0_55ck43 = 0 time = 220
.meas tran vdout0_55ck43 FIND v(dout0_55) AT=220.025n

* CHECK dout0_56 Vdout0_56ck43 = 0 time = 220
.meas tran vdout0_56ck43 FIND v(dout0_56) AT=220.025n

* CHECK dout0_57 Vdout0_57ck43 = 0 time = 220
.meas tran vdout0_57ck43 FIND v(dout0_57) AT=220.025n

* CHECK dout0_58 Vdout0_58ck43 = 0.9 time = 220
.meas tran vdout0_58ck43 FIND v(dout0_58) AT=220.025n

* CHECK dout0_59 Vdout0_59ck43 = 0.9 time = 220
.meas tran vdout0_59ck43 FIND v(dout0_59) AT=220.025n

* CHECK dout0_60 Vdout0_60ck43 = 0.9 time = 220
.meas tran vdout0_60ck43 FIND v(dout0_60) AT=220.025n

* CHECK dout0_61 Vdout0_61ck43 = 0 time = 220
.meas tran vdout0_61ck43 FIND v(dout0_61) AT=220.025n

* CHECK dout0_62 Vdout0_62ck43 = 0 time = 220
.meas tran vdout0_62ck43 FIND v(dout0_62) AT=220.025n

* CHECK dout0_63 Vdout0_63ck43 = 0.9 time = 220
.meas tran vdout0_63ck43 FIND v(dout0_63) AT=220.025n

* CHECK dout0_0 Vdout0_0ck47 = 0.9 time = 240
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=240.025n

* CHECK dout0_1 Vdout0_1ck47 = 0.9 time = 240
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=240.025n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 240
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=240.025n

* CHECK dout0_3 Vdout0_3ck47 = 0.9 time = 240
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=240.025n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 240
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=240.025n

* CHECK dout0_5 Vdout0_5ck47 = 0.9 time = 240
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=240.025n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 240
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=240.025n

* CHECK dout0_7 Vdout0_7ck47 = 0.9 time = 240
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=240.025n

* CHECK dout0_8 Vdout0_8ck47 = 0.9 time = 240
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=240.025n

* CHECK dout0_9 Vdout0_9ck47 = 0.9 time = 240
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=240.025n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 240
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=240.025n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 240
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=240.025n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 240
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=240.025n

* CHECK dout0_13 Vdout0_13ck47 = 0.9 time = 240
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=240.025n

* CHECK dout0_14 Vdout0_14ck47 = 0.9 time = 240
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=240.025n

* CHECK dout0_15 Vdout0_15ck47 = 0 time = 240
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=240.025n

* CHECK dout0_16 Vdout0_16ck47 = 0 time = 240
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=240.025n

* CHECK dout0_17 Vdout0_17ck47 = 0 time = 240
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=240.025n

* CHECK dout0_18 Vdout0_18ck47 = 0 time = 240
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=240.025n

* CHECK dout0_19 Vdout0_19ck47 = 0.9 time = 240
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=240.025n

* CHECK dout0_20 Vdout0_20ck47 = 0.9 time = 240
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=240.025n

* CHECK dout0_21 Vdout0_21ck47 = 0 time = 240
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=240.025n

* CHECK dout0_22 Vdout0_22ck47 = 0 time = 240
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=240.025n

* CHECK dout0_23 Vdout0_23ck47 = 0 time = 240
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=240.025n

* CHECK dout0_24 Vdout0_24ck47 = 0 time = 240
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=240.025n

* CHECK dout0_25 Vdout0_25ck47 = 0.9 time = 240
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=240.025n

* CHECK dout0_26 Vdout0_26ck47 = 0.9 time = 240
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=240.025n

* CHECK dout0_27 Vdout0_27ck47 = 0.9 time = 240
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=240.025n

* CHECK dout0_28 Vdout0_28ck47 = 0 time = 240
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=240.025n

* CHECK dout0_29 Vdout0_29ck47 = 0.9 time = 240
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=240.025n

* CHECK dout0_30 Vdout0_30ck47 = 0.9 time = 240
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=240.025n

* CHECK dout0_31 Vdout0_31ck47 = 0.9 time = 240
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=240.025n

* CHECK dout0_32 Vdout0_32ck47 = 0 time = 240
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=240.025n

* CHECK dout0_33 Vdout0_33ck47 = 0 time = 240
.meas tran vdout0_33ck47 FIND v(dout0_33) AT=240.025n

* CHECK dout0_34 Vdout0_34ck47 = 0.9 time = 240
.meas tran vdout0_34ck47 FIND v(dout0_34) AT=240.025n

* CHECK dout0_35 Vdout0_35ck47 = 0 time = 240
.meas tran vdout0_35ck47 FIND v(dout0_35) AT=240.025n

* CHECK dout0_36 Vdout0_36ck47 = 0.9 time = 240
.meas tran vdout0_36ck47 FIND v(dout0_36) AT=240.025n

* CHECK dout0_37 Vdout0_37ck47 = 0.9 time = 240
.meas tran vdout0_37ck47 FIND v(dout0_37) AT=240.025n

* CHECK dout0_38 Vdout0_38ck47 = 0.9 time = 240
.meas tran vdout0_38ck47 FIND v(dout0_38) AT=240.025n

* CHECK dout0_39 Vdout0_39ck47 = 0 time = 240
.meas tran vdout0_39ck47 FIND v(dout0_39) AT=240.025n

* CHECK dout0_40 Vdout0_40ck47 = 0.9 time = 240
.meas tran vdout0_40ck47 FIND v(dout0_40) AT=240.025n

* CHECK dout0_41 Vdout0_41ck47 = 0 time = 240
.meas tran vdout0_41ck47 FIND v(dout0_41) AT=240.025n

* CHECK dout0_42 Vdout0_42ck47 = 0 time = 240
.meas tran vdout0_42ck47 FIND v(dout0_42) AT=240.025n

* CHECK dout0_43 Vdout0_43ck47 = 0.9 time = 240
.meas tran vdout0_43ck47 FIND v(dout0_43) AT=240.025n

* CHECK dout0_44 Vdout0_44ck47 = 0 time = 240
.meas tran vdout0_44ck47 FIND v(dout0_44) AT=240.025n

* CHECK dout0_45 Vdout0_45ck47 = 0.9 time = 240
.meas tran vdout0_45ck47 FIND v(dout0_45) AT=240.025n

* CHECK dout0_46 Vdout0_46ck47 = 0 time = 240
.meas tran vdout0_46ck47 FIND v(dout0_46) AT=240.025n

* CHECK dout0_47 Vdout0_47ck47 = 0 time = 240
.meas tran vdout0_47ck47 FIND v(dout0_47) AT=240.025n

* CHECK dout0_48 Vdout0_48ck47 = 0.9 time = 240
.meas tran vdout0_48ck47 FIND v(dout0_48) AT=240.025n

* CHECK dout0_49 Vdout0_49ck47 = 0 time = 240
.meas tran vdout0_49ck47 FIND v(dout0_49) AT=240.025n

* CHECK dout0_50 Vdout0_50ck47 = 0.9 time = 240
.meas tran vdout0_50ck47 FIND v(dout0_50) AT=240.025n

* CHECK dout0_51 Vdout0_51ck47 = 0.9 time = 240
.meas tran vdout0_51ck47 FIND v(dout0_51) AT=240.025n

* CHECK dout0_52 Vdout0_52ck47 = 0.9 time = 240
.meas tran vdout0_52ck47 FIND v(dout0_52) AT=240.025n

* CHECK dout0_53 Vdout0_53ck47 = 0 time = 240
.meas tran vdout0_53ck47 FIND v(dout0_53) AT=240.025n

* CHECK dout0_54 Vdout0_54ck47 = 0 time = 240
.meas tran vdout0_54ck47 FIND v(dout0_54) AT=240.025n

* CHECK dout0_55 Vdout0_55ck47 = 0 time = 240
.meas tran vdout0_55ck47 FIND v(dout0_55) AT=240.025n

* CHECK dout0_56 Vdout0_56ck47 = 0 time = 240
.meas tran vdout0_56ck47 FIND v(dout0_56) AT=240.025n

* CHECK dout0_57 Vdout0_57ck47 = 0 time = 240
.meas tran vdout0_57ck47 FIND v(dout0_57) AT=240.025n

* CHECK dout0_58 Vdout0_58ck47 = 0.9 time = 240
.meas tran vdout0_58ck47 FIND v(dout0_58) AT=240.025n

* CHECK dout0_59 Vdout0_59ck47 = 0 time = 240
.meas tran vdout0_59ck47 FIND v(dout0_59) AT=240.025n

* CHECK dout0_60 Vdout0_60ck47 = 0 time = 240
.meas tran vdout0_60ck47 FIND v(dout0_60) AT=240.025n

* CHECK dout0_61 Vdout0_61ck47 = 0.9 time = 240
.meas tran vdout0_61ck47 FIND v(dout0_61) AT=240.025n

* CHECK dout0_62 Vdout0_62ck47 = 0.9 time = 240
.meas tran vdout0_62ck47 FIND v(dout0_62) AT=240.025n

* CHECK dout0_63 Vdout0_63ck47 = 0 time = 240
.meas tran vdout0_63ck47 FIND v(dout0_63) AT=240.025n

* CHECK dout0_0 Vdout0_0ck49 = 0.9 time = 250
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=250.025n

* CHECK dout0_1 Vdout0_1ck49 = 0 time = 250
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=250.025n

* CHECK dout0_2 Vdout0_2ck49 = 0.9 time = 250
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=250.025n

* CHECK dout0_3 Vdout0_3ck49 = 0 time = 250
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=250.025n

* CHECK dout0_4 Vdout0_4ck49 = 0.9 time = 250
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=250.025n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 250
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=250.025n

* CHECK dout0_6 Vdout0_6ck49 = 0 time = 250
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=250.025n

* CHECK dout0_7 Vdout0_7ck49 = 0.9 time = 250
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=250.025n

* CHECK dout0_8 Vdout0_8ck49 = 0.9 time = 250
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=250.025n

* CHECK dout0_9 Vdout0_9ck49 = 0.9 time = 250
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=250.025n

* CHECK dout0_10 Vdout0_10ck49 = 0.9 time = 250
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=250.025n

* CHECK dout0_11 Vdout0_11ck49 = 0 time = 250
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=250.025n

* CHECK dout0_12 Vdout0_12ck49 = 0 time = 250
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=250.025n

* CHECK dout0_13 Vdout0_13ck49 = 0 time = 250
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=250.025n

* CHECK dout0_14 Vdout0_14ck49 = 0 time = 250
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=250.025n

* CHECK dout0_15 Vdout0_15ck49 = 0 time = 250
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=250.025n

* CHECK dout0_16 Vdout0_16ck49 = 0 time = 250
.meas tran vdout0_16ck49 FIND v(dout0_16) AT=250.025n

* CHECK dout0_17 Vdout0_17ck49 = 0 time = 250
.meas tran vdout0_17ck49 FIND v(dout0_17) AT=250.025n

* CHECK dout0_18 Vdout0_18ck49 = 0 time = 250
.meas tran vdout0_18ck49 FIND v(dout0_18) AT=250.025n

* CHECK dout0_19 Vdout0_19ck49 = 0 time = 250
.meas tran vdout0_19ck49 FIND v(dout0_19) AT=250.025n

* CHECK dout0_20 Vdout0_20ck49 = 0 time = 250
.meas tran vdout0_20ck49 FIND v(dout0_20) AT=250.025n

* CHECK dout0_21 Vdout0_21ck49 = 0.9 time = 250
.meas tran vdout0_21ck49 FIND v(dout0_21) AT=250.025n

* CHECK dout0_22 Vdout0_22ck49 = 0 time = 250
.meas tran vdout0_22ck49 FIND v(dout0_22) AT=250.025n

* CHECK dout0_23 Vdout0_23ck49 = 0.9 time = 250
.meas tran vdout0_23ck49 FIND v(dout0_23) AT=250.025n

* CHECK dout0_24 Vdout0_24ck49 = 0.9 time = 250
.meas tran vdout0_24ck49 FIND v(dout0_24) AT=250.025n

* CHECK dout0_25 Vdout0_25ck49 = 0 time = 250
.meas tran vdout0_25ck49 FIND v(dout0_25) AT=250.025n

* CHECK dout0_26 Vdout0_26ck49 = 0 time = 250
.meas tran vdout0_26ck49 FIND v(dout0_26) AT=250.025n

* CHECK dout0_27 Vdout0_27ck49 = 0.9 time = 250
.meas tran vdout0_27ck49 FIND v(dout0_27) AT=250.025n

* CHECK dout0_28 Vdout0_28ck49 = 0 time = 250
.meas tran vdout0_28ck49 FIND v(dout0_28) AT=250.025n

* CHECK dout0_29 Vdout0_29ck49 = 0 time = 250
.meas tran vdout0_29ck49 FIND v(dout0_29) AT=250.025n

* CHECK dout0_30 Vdout0_30ck49 = 0.9 time = 250
.meas tran vdout0_30ck49 FIND v(dout0_30) AT=250.025n

* CHECK dout0_31 Vdout0_31ck49 = 0 time = 250
.meas tran vdout0_31ck49 FIND v(dout0_31) AT=250.025n

* CHECK dout0_32 Vdout0_32ck49 = 0 time = 250
.meas tran vdout0_32ck49 FIND v(dout0_32) AT=250.025n

* CHECK dout0_33 Vdout0_33ck49 = 0.9 time = 250
.meas tran vdout0_33ck49 FIND v(dout0_33) AT=250.025n

* CHECK dout0_34 Vdout0_34ck49 = 0.9 time = 250
.meas tran vdout0_34ck49 FIND v(dout0_34) AT=250.025n

* CHECK dout0_35 Vdout0_35ck49 = 0.9 time = 250
.meas tran vdout0_35ck49 FIND v(dout0_35) AT=250.025n

* CHECK dout0_36 Vdout0_36ck49 = 0.9 time = 250
.meas tran vdout0_36ck49 FIND v(dout0_36) AT=250.025n

* CHECK dout0_37 Vdout0_37ck49 = 0.9 time = 250
.meas tran vdout0_37ck49 FIND v(dout0_37) AT=250.025n

* CHECK dout0_38 Vdout0_38ck49 = 0 time = 250
.meas tran vdout0_38ck49 FIND v(dout0_38) AT=250.025n

* CHECK dout0_39 Vdout0_39ck49 = 0.9 time = 250
.meas tran vdout0_39ck49 FIND v(dout0_39) AT=250.025n

* CHECK dout0_40 Vdout0_40ck49 = 0.9 time = 250
.meas tran vdout0_40ck49 FIND v(dout0_40) AT=250.025n

* CHECK dout0_41 Vdout0_41ck49 = 0 time = 250
.meas tran vdout0_41ck49 FIND v(dout0_41) AT=250.025n

* CHECK dout0_42 Vdout0_42ck49 = 0 time = 250
.meas tran vdout0_42ck49 FIND v(dout0_42) AT=250.025n

* CHECK dout0_43 Vdout0_43ck49 = 0 time = 250
.meas tran vdout0_43ck49 FIND v(dout0_43) AT=250.025n

* CHECK dout0_44 Vdout0_44ck49 = 0 time = 250
.meas tran vdout0_44ck49 FIND v(dout0_44) AT=250.025n

* CHECK dout0_45 Vdout0_45ck49 = 0.9 time = 250
.meas tran vdout0_45ck49 FIND v(dout0_45) AT=250.025n

* CHECK dout0_46 Vdout0_46ck49 = 0.9 time = 250
.meas tran vdout0_46ck49 FIND v(dout0_46) AT=250.025n

* CHECK dout0_47 Vdout0_47ck49 = 0 time = 250
.meas tran vdout0_47ck49 FIND v(dout0_47) AT=250.025n

* CHECK dout0_48 Vdout0_48ck49 = 0 time = 250
.meas tran vdout0_48ck49 FIND v(dout0_48) AT=250.025n

* CHECK dout0_49 Vdout0_49ck49 = 0.9 time = 250
.meas tran vdout0_49ck49 FIND v(dout0_49) AT=250.025n

* CHECK dout0_50 Vdout0_50ck49 = 0.9 time = 250
.meas tran vdout0_50ck49 FIND v(dout0_50) AT=250.025n

* CHECK dout0_51 Vdout0_51ck49 = 0 time = 250
.meas tran vdout0_51ck49 FIND v(dout0_51) AT=250.025n

* CHECK dout0_52 Vdout0_52ck49 = 0.9 time = 250
.meas tran vdout0_52ck49 FIND v(dout0_52) AT=250.025n

* CHECK dout0_53 Vdout0_53ck49 = 0.9 time = 250
.meas tran vdout0_53ck49 FIND v(dout0_53) AT=250.025n

* CHECK dout0_54 Vdout0_54ck49 = 0 time = 250
.meas tran vdout0_54ck49 FIND v(dout0_54) AT=250.025n

* CHECK dout0_55 Vdout0_55ck49 = 0.9 time = 250
.meas tran vdout0_55ck49 FIND v(dout0_55) AT=250.025n

* CHECK dout0_56 Vdout0_56ck49 = 0.9 time = 250
.meas tran vdout0_56ck49 FIND v(dout0_56) AT=250.025n

* CHECK dout0_57 Vdout0_57ck49 = 0 time = 250
.meas tran vdout0_57ck49 FIND v(dout0_57) AT=250.025n

* CHECK dout0_58 Vdout0_58ck49 = 0 time = 250
.meas tran vdout0_58ck49 FIND v(dout0_58) AT=250.025n

* CHECK dout0_59 Vdout0_59ck49 = 0.9 time = 250
.meas tran vdout0_59ck49 FIND v(dout0_59) AT=250.025n

* CHECK dout0_60 Vdout0_60ck49 = 0.9 time = 250
.meas tran vdout0_60ck49 FIND v(dout0_60) AT=250.025n

* CHECK dout0_61 Vdout0_61ck49 = 0.9 time = 250
.meas tran vdout0_61ck49 FIND v(dout0_61) AT=250.025n

* CHECK dout0_62 Vdout0_62ck49 = 0 time = 250
.meas tran vdout0_62ck49 FIND v(dout0_62) AT=250.025n

* CHECK dout0_63 Vdout0_63ck49 = 0 time = 250
.meas tran vdout0_63ck49 FIND v(dout0_63) AT=250.025n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 270
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=270.025n

* CHECK dout0_1 Vdout0_1ck53 = 0.9 time = 270
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=270.025n

* CHECK dout0_2 Vdout0_2ck53 = 0.9 time = 270
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=270.025n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 270
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=270.025n

* CHECK dout0_4 Vdout0_4ck53 = 0.9 time = 270
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=270.025n

* CHECK dout0_5 Vdout0_5ck53 = 0.9 time = 270
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=270.025n

* CHECK dout0_6 Vdout0_6ck53 = 0.9 time = 270
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=270.025n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 270
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=270.025n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 270
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=270.025n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 270
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=270.025n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 270
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=270.025n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 270
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=270.025n

* CHECK dout0_12 Vdout0_12ck53 = 0.9 time = 270
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=270.025n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 270
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=270.025n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 270
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=270.025n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 270
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=270.025n

* CHECK dout0_16 Vdout0_16ck53 = 0 time = 270
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=270.025n

* CHECK dout0_17 Vdout0_17ck53 = 0.9 time = 270
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=270.025n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 270
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=270.025n

* CHECK dout0_19 Vdout0_19ck53 = 0 time = 270
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=270.025n

* CHECK dout0_20 Vdout0_20ck53 = 0 time = 270
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=270.025n

* CHECK dout0_21 Vdout0_21ck53 = 0 time = 270
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=270.025n

* CHECK dout0_22 Vdout0_22ck53 = 0.9 time = 270
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=270.025n

* CHECK dout0_23 Vdout0_23ck53 = 0 time = 270
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=270.025n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 270
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=270.025n

* CHECK dout0_25 Vdout0_25ck53 = 0.9 time = 270
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=270.025n

* CHECK dout0_26 Vdout0_26ck53 = 0.9 time = 270
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=270.025n

* CHECK dout0_27 Vdout0_27ck53 = 0 time = 270
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=270.025n

* CHECK dout0_28 Vdout0_28ck53 = 0 time = 270
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=270.025n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 270
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=270.025n

* CHECK dout0_30 Vdout0_30ck53 = 0 time = 270
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=270.025n

* CHECK dout0_31 Vdout0_31ck53 = 0.9 time = 270
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=270.025n

* CHECK dout0_32 Vdout0_32ck53 = 0 time = 270
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=270.025n

* CHECK dout0_33 Vdout0_33ck53 = 0 time = 270
.meas tran vdout0_33ck53 FIND v(dout0_33) AT=270.025n

* CHECK dout0_34 Vdout0_34ck53 = 0.9 time = 270
.meas tran vdout0_34ck53 FIND v(dout0_34) AT=270.025n

* CHECK dout0_35 Vdout0_35ck53 = 0 time = 270
.meas tran vdout0_35ck53 FIND v(dout0_35) AT=270.025n

* CHECK dout0_36 Vdout0_36ck53 = 0 time = 270
.meas tran vdout0_36ck53 FIND v(dout0_36) AT=270.025n

* CHECK dout0_37 Vdout0_37ck53 = 0.9 time = 270
.meas tran vdout0_37ck53 FIND v(dout0_37) AT=270.025n

* CHECK dout0_38 Vdout0_38ck53 = 0 time = 270
.meas tran vdout0_38ck53 FIND v(dout0_38) AT=270.025n

* CHECK dout0_39 Vdout0_39ck53 = 0.9 time = 270
.meas tran vdout0_39ck53 FIND v(dout0_39) AT=270.025n

* CHECK dout0_40 Vdout0_40ck53 = 0.9 time = 270
.meas tran vdout0_40ck53 FIND v(dout0_40) AT=270.025n

* CHECK dout0_41 Vdout0_41ck53 = 0.9 time = 270
.meas tran vdout0_41ck53 FIND v(dout0_41) AT=270.025n

* CHECK dout0_42 Vdout0_42ck53 = 0.9 time = 270
.meas tran vdout0_42ck53 FIND v(dout0_42) AT=270.025n

* CHECK dout0_43 Vdout0_43ck53 = 0 time = 270
.meas tran vdout0_43ck53 FIND v(dout0_43) AT=270.025n

* CHECK dout0_44 Vdout0_44ck53 = 0.9 time = 270
.meas tran vdout0_44ck53 FIND v(dout0_44) AT=270.025n

* CHECK dout0_45 Vdout0_45ck53 = 0 time = 270
.meas tran vdout0_45ck53 FIND v(dout0_45) AT=270.025n

* CHECK dout0_46 Vdout0_46ck53 = 0.9 time = 270
.meas tran vdout0_46ck53 FIND v(dout0_46) AT=270.025n

* CHECK dout0_47 Vdout0_47ck53 = 0 time = 270
.meas tran vdout0_47ck53 FIND v(dout0_47) AT=270.025n

* CHECK dout0_48 Vdout0_48ck53 = 0.9 time = 270
.meas tran vdout0_48ck53 FIND v(dout0_48) AT=270.025n

* CHECK dout0_49 Vdout0_49ck53 = 0 time = 270
.meas tran vdout0_49ck53 FIND v(dout0_49) AT=270.025n

* CHECK dout0_50 Vdout0_50ck53 = 0 time = 270
.meas tran vdout0_50ck53 FIND v(dout0_50) AT=270.025n

* CHECK dout0_51 Vdout0_51ck53 = 0 time = 270
.meas tran vdout0_51ck53 FIND v(dout0_51) AT=270.025n

* CHECK dout0_52 Vdout0_52ck53 = 0 time = 270
.meas tran vdout0_52ck53 FIND v(dout0_52) AT=270.025n

* CHECK dout0_53 Vdout0_53ck53 = 0.9 time = 270
.meas tran vdout0_53ck53 FIND v(dout0_53) AT=270.025n

* CHECK dout0_54 Vdout0_54ck53 = 0.9 time = 270
.meas tran vdout0_54ck53 FIND v(dout0_54) AT=270.025n

* CHECK dout0_55 Vdout0_55ck53 = 0.9 time = 270
.meas tran vdout0_55ck53 FIND v(dout0_55) AT=270.025n

* CHECK dout0_56 Vdout0_56ck53 = 0.9 time = 270
.meas tran vdout0_56ck53 FIND v(dout0_56) AT=270.025n

* CHECK dout0_57 Vdout0_57ck53 = 0.9 time = 270
.meas tran vdout0_57ck53 FIND v(dout0_57) AT=270.025n

* CHECK dout0_58 Vdout0_58ck53 = 0.9 time = 270
.meas tran vdout0_58ck53 FIND v(dout0_58) AT=270.025n

* CHECK dout0_59 Vdout0_59ck53 = 0.9 time = 270
.meas tran vdout0_59ck53 FIND v(dout0_59) AT=270.025n

* CHECK dout0_60 Vdout0_60ck53 = 0.9 time = 270
.meas tran vdout0_60ck53 FIND v(dout0_60) AT=270.025n

* CHECK dout0_61 Vdout0_61ck53 = 0 time = 270
.meas tran vdout0_61ck53 FIND v(dout0_61) AT=270.025n

* CHECK dout0_62 Vdout0_62ck53 = 0.9 time = 270
.meas tran vdout0_62ck53 FIND v(dout0_62) AT=270.025n

* CHECK dout0_63 Vdout0_63ck53 = 0 time = 270
.meas tran vdout0_63ck53 FIND v(dout0_63) AT=270.025n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 275
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=275.025n

* CHECK dout0_1 Vdout0_1ck54 = 0.9 time = 275
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=275.025n

* CHECK dout0_2 Vdout0_2ck54 = 0.9 time = 275
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=275.025n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 275
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=275.025n

* CHECK dout0_4 Vdout0_4ck54 = 0.9 time = 275
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=275.025n

* CHECK dout0_5 Vdout0_5ck54 = 0.9 time = 275
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=275.025n

* CHECK dout0_6 Vdout0_6ck54 = 0.9 time = 275
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=275.025n

* CHECK dout0_7 Vdout0_7ck54 = 0 time = 275
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=275.025n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 275
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=275.025n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 275
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=275.025n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 275
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=275.025n

* CHECK dout0_11 Vdout0_11ck54 = 0 time = 275
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=275.025n

* CHECK dout0_12 Vdout0_12ck54 = 0.9 time = 275
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=275.025n

* CHECK dout0_13 Vdout0_13ck54 = 0 time = 275
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=275.025n

* CHECK dout0_14 Vdout0_14ck54 = 0 time = 275
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=275.025n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 275
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=275.025n

* CHECK dout0_16 Vdout0_16ck54 = 0 time = 275
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=275.025n

* CHECK dout0_17 Vdout0_17ck54 = 0.9 time = 275
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=275.025n

* CHECK dout0_18 Vdout0_18ck54 = 0 time = 275
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=275.025n

* CHECK dout0_19 Vdout0_19ck54 = 0 time = 275
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=275.025n

* CHECK dout0_20 Vdout0_20ck54 = 0 time = 275
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=275.025n

* CHECK dout0_21 Vdout0_21ck54 = 0 time = 275
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=275.025n

* CHECK dout0_22 Vdout0_22ck54 = 0.9 time = 275
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=275.025n

* CHECK dout0_23 Vdout0_23ck54 = 0 time = 275
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=275.025n

* CHECK dout0_24 Vdout0_24ck54 = 0 time = 275
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=275.025n

* CHECK dout0_25 Vdout0_25ck54 = 0.9 time = 275
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=275.025n

* CHECK dout0_26 Vdout0_26ck54 = 0.9 time = 275
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=275.025n

* CHECK dout0_27 Vdout0_27ck54 = 0 time = 275
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=275.025n

* CHECK dout0_28 Vdout0_28ck54 = 0 time = 275
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=275.025n

* CHECK dout0_29 Vdout0_29ck54 = 0 time = 275
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=275.025n

* CHECK dout0_30 Vdout0_30ck54 = 0 time = 275
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=275.025n

* CHECK dout0_31 Vdout0_31ck54 = 0.9 time = 275
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=275.025n

* CHECK dout0_32 Vdout0_32ck54 = 0 time = 275
.meas tran vdout0_32ck54 FIND v(dout0_32) AT=275.025n

* CHECK dout0_33 Vdout0_33ck54 = 0 time = 275
.meas tran vdout0_33ck54 FIND v(dout0_33) AT=275.025n

* CHECK dout0_34 Vdout0_34ck54 = 0.9 time = 275
.meas tran vdout0_34ck54 FIND v(dout0_34) AT=275.025n

* CHECK dout0_35 Vdout0_35ck54 = 0 time = 275
.meas tran vdout0_35ck54 FIND v(dout0_35) AT=275.025n

* CHECK dout0_36 Vdout0_36ck54 = 0 time = 275
.meas tran vdout0_36ck54 FIND v(dout0_36) AT=275.025n

* CHECK dout0_37 Vdout0_37ck54 = 0.9 time = 275
.meas tran vdout0_37ck54 FIND v(dout0_37) AT=275.025n

* CHECK dout0_38 Vdout0_38ck54 = 0 time = 275
.meas tran vdout0_38ck54 FIND v(dout0_38) AT=275.025n

* CHECK dout0_39 Vdout0_39ck54 = 0.9 time = 275
.meas tran vdout0_39ck54 FIND v(dout0_39) AT=275.025n

* CHECK dout0_40 Vdout0_40ck54 = 0.9 time = 275
.meas tran vdout0_40ck54 FIND v(dout0_40) AT=275.025n

* CHECK dout0_41 Vdout0_41ck54 = 0.9 time = 275
.meas tran vdout0_41ck54 FIND v(dout0_41) AT=275.025n

* CHECK dout0_42 Vdout0_42ck54 = 0.9 time = 275
.meas tran vdout0_42ck54 FIND v(dout0_42) AT=275.025n

* CHECK dout0_43 Vdout0_43ck54 = 0 time = 275
.meas tran vdout0_43ck54 FIND v(dout0_43) AT=275.025n

* CHECK dout0_44 Vdout0_44ck54 = 0.9 time = 275
.meas tran vdout0_44ck54 FIND v(dout0_44) AT=275.025n

* CHECK dout0_45 Vdout0_45ck54 = 0 time = 275
.meas tran vdout0_45ck54 FIND v(dout0_45) AT=275.025n

* CHECK dout0_46 Vdout0_46ck54 = 0.9 time = 275
.meas tran vdout0_46ck54 FIND v(dout0_46) AT=275.025n

* CHECK dout0_47 Vdout0_47ck54 = 0 time = 275
.meas tran vdout0_47ck54 FIND v(dout0_47) AT=275.025n

* CHECK dout0_48 Vdout0_48ck54 = 0.9 time = 275
.meas tran vdout0_48ck54 FIND v(dout0_48) AT=275.025n

* CHECK dout0_49 Vdout0_49ck54 = 0 time = 275
.meas tran vdout0_49ck54 FIND v(dout0_49) AT=275.025n

* CHECK dout0_50 Vdout0_50ck54 = 0 time = 275
.meas tran vdout0_50ck54 FIND v(dout0_50) AT=275.025n

* CHECK dout0_51 Vdout0_51ck54 = 0 time = 275
.meas tran vdout0_51ck54 FIND v(dout0_51) AT=275.025n

* CHECK dout0_52 Vdout0_52ck54 = 0 time = 275
.meas tran vdout0_52ck54 FIND v(dout0_52) AT=275.025n

* CHECK dout0_53 Vdout0_53ck54 = 0.9 time = 275
.meas tran vdout0_53ck54 FIND v(dout0_53) AT=275.025n

* CHECK dout0_54 Vdout0_54ck54 = 0.9 time = 275
.meas tran vdout0_54ck54 FIND v(dout0_54) AT=275.025n

* CHECK dout0_55 Vdout0_55ck54 = 0.9 time = 275
.meas tran vdout0_55ck54 FIND v(dout0_55) AT=275.025n

* CHECK dout0_56 Vdout0_56ck54 = 0.9 time = 275
.meas tran vdout0_56ck54 FIND v(dout0_56) AT=275.025n

* CHECK dout0_57 Vdout0_57ck54 = 0.9 time = 275
.meas tran vdout0_57ck54 FIND v(dout0_57) AT=275.025n

* CHECK dout0_58 Vdout0_58ck54 = 0.9 time = 275
.meas tran vdout0_58ck54 FIND v(dout0_58) AT=275.025n

* CHECK dout0_59 Vdout0_59ck54 = 0.9 time = 275
.meas tran vdout0_59ck54 FIND v(dout0_59) AT=275.025n

* CHECK dout0_60 Vdout0_60ck54 = 0.9 time = 275
.meas tran vdout0_60ck54 FIND v(dout0_60) AT=275.025n

* CHECK dout0_61 Vdout0_61ck54 = 0 time = 275
.meas tran vdout0_61ck54 FIND v(dout0_61) AT=275.025n

* CHECK dout0_62 Vdout0_62ck54 = 0.9 time = 275
.meas tran vdout0_62ck54 FIND v(dout0_62) AT=275.025n

* CHECK dout0_63 Vdout0_63ck54 = 0 time = 275
.meas tran vdout0_63ck54 FIND v(dout0_63) AT=275.025n

* CHECK dout0_0 Vdout0_0ck56 = 0.9 time = 285
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=285.025n

* CHECK dout0_1 Vdout0_1ck56 = 0.9 time = 285
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=285.025n

* CHECK dout0_2 Vdout0_2ck56 = 0.9 time = 285
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=285.025n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 285
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=285.025n

* CHECK dout0_4 Vdout0_4ck56 = 0 time = 285
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=285.025n

* CHECK dout0_5 Vdout0_5ck56 = 0.9 time = 285
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=285.025n

* CHECK dout0_6 Vdout0_6ck56 = 0.9 time = 285
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=285.025n

* CHECK dout0_7 Vdout0_7ck56 = 0.9 time = 285
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=285.025n

* CHECK dout0_8 Vdout0_8ck56 = 0.9 time = 285
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=285.025n

* CHECK dout0_9 Vdout0_9ck56 = 0.9 time = 285
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=285.025n

* CHECK dout0_10 Vdout0_10ck56 = 0.9 time = 285
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=285.025n

* CHECK dout0_11 Vdout0_11ck56 = 0.9 time = 285
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=285.025n

* CHECK dout0_12 Vdout0_12ck56 = 0 time = 285
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=285.025n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 285
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=285.025n

* CHECK dout0_14 Vdout0_14ck56 = 0.9 time = 285
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=285.025n

* CHECK dout0_15 Vdout0_15ck56 = 0.9 time = 285
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=285.025n

* CHECK dout0_16 Vdout0_16ck56 = 0 time = 285
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=285.025n

* CHECK dout0_17 Vdout0_17ck56 = 0.9 time = 285
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=285.025n

* CHECK dout0_18 Vdout0_18ck56 = 0 time = 285
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=285.025n

* CHECK dout0_19 Vdout0_19ck56 = 0 time = 285
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=285.025n

* CHECK dout0_20 Vdout0_20ck56 = 0 time = 285
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=285.025n

* CHECK dout0_21 Vdout0_21ck56 = 0 time = 285
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=285.025n

* CHECK dout0_22 Vdout0_22ck56 = 0 time = 285
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=285.025n

* CHECK dout0_23 Vdout0_23ck56 = 0 time = 285
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=285.025n

* CHECK dout0_24 Vdout0_24ck56 = 0 time = 285
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=285.025n

* CHECK dout0_25 Vdout0_25ck56 = 0.9 time = 285
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=285.025n

* CHECK dout0_26 Vdout0_26ck56 = 0 time = 285
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=285.025n

* CHECK dout0_27 Vdout0_27ck56 = 0 time = 285
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=285.025n

* CHECK dout0_28 Vdout0_28ck56 = 0.9 time = 285
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=285.025n

* CHECK dout0_29 Vdout0_29ck56 = 0 time = 285
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=285.025n

* CHECK dout0_30 Vdout0_30ck56 = 0.9 time = 285
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=285.025n

* CHECK dout0_31 Vdout0_31ck56 = 0 time = 285
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=285.025n

* CHECK dout0_32 Vdout0_32ck56 = 0 time = 285
.meas tran vdout0_32ck56 FIND v(dout0_32) AT=285.025n

* CHECK dout0_33 Vdout0_33ck56 = 0 time = 285
.meas tran vdout0_33ck56 FIND v(dout0_33) AT=285.025n

* CHECK dout0_34 Vdout0_34ck56 = 0 time = 285
.meas tran vdout0_34ck56 FIND v(dout0_34) AT=285.025n

* CHECK dout0_35 Vdout0_35ck56 = 0.9 time = 285
.meas tran vdout0_35ck56 FIND v(dout0_35) AT=285.025n

* CHECK dout0_36 Vdout0_36ck56 = 0.9 time = 285
.meas tran vdout0_36ck56 FIND v(dout0_36) AT=285.025n

* CHECK dout0_37 Vdout0_37ck56 = 0 time = 285
.meas tran vdout0_37ck56 FIND v(dout0_37) AT=285.025n

* CHECK dout0_38 Vdout0_38ck56 = 0 time = 285
.meas tran vdout0_38ck56 FIND v(dout0_38) AT=285.025n

* CHECK dout0_39 Vdout0_39ck56 = 0.9 time = 285
.meas tran vdout0_39ck56 FIND v(dout0_39) AT=285.025n

* CHECK dout0_40 Vdout0_40ck56 = 0.9 time = 285
.meas tran vdout0_40ck56 FIND v(dout0_40) AT=285.025n

* CHECK dout0_41 Vdout0_41ck56 = 0.9 time = 285
.meas tran vdout0_41ck56 FIND v(dout0_41) AT=285.025n

* CHECK dout0_42 Vdout0_42ck56 = 0.9 time = 285
.meas tran vdout0_42ck56 FIND v(dout0_42) AT=285.025n

* CHECK dout0_43 Vdout0_43ck56 = 0.9 time = 285
.meas tran vdout0_43ck56 FIND v(dout0_43) AT=285.025n

* CHECK dout0_44 Vdout0_44ck56 = 0.9 time = 285
.meas tran vdout0_44ck56 FIND v(dout0_44) AT=285.025n

* CHECK dout0_45 Vdout0_45ck56 = 0.9 time = 285
.meas tran vdout0_45ck56 FIND v(dout0_45) AT=285.025n

* CHECK dout0_46 Vdout0_46ck56 = 0.9 time = 285
.meas tran vdout0_46ck56 FIND v(dout0_46) AT=285.025n

* CHECK dout0_47 Vdout0_47ck56 = 0 time = 285
.meas tran vdout0_47ck56 FIND v(dout0_47) AT=285.025n

* CHECK dout0_48 Vdout0_48ck56 = 0 time = 285
.meas tran vdout0_48ck56 FIND v(dout0_48) AT=285.025n

* CHECK dout0_49 Vdout0_49ck56 = 0 time = 285
.meas tran vdout0_49ck56 FIND v(dout0_49) AT=285.025n

* CHECK dout0_50 Vdout0_50ck56 = 0.9 time = 285
.meas tran vdout0_50ck56 FIND v(dout0_50) AT=285.025n

* CHECK dout0_51 Vdout0_51ck56 = 0 time = 285
.meas tran vdout0_51ck56 FIND v(dout0_51) AT=285.025n

* CHECK dout0_52 Vdout0_52ck56 = 0 time = 285
.meas tran vdout0_52ck56 FIND v(dout0_52) AT=285.025n

* CHECK dout0_53 Vdout0_53ck56 = 0 time = 285
.meas tran vdout0_53ck56 FIND v(dout0_53) AT=285.025n

* CHECK dout0_54 Vdout0_54ck56 = 0.9 time = 285
.meas tran vdout0_54ck56 FIND v(dout0_54) AT=285.025n

* CHECK dout0_55 Vdout0_55ck56 = 0 time = 285
.meas tran vdout0_55ck56 FIND v(dout0_55) AT=285.025n

* CHECK dout0_56 Vdout0_56ck56 = 0.9 time = 285
.meas tran vdout0_56ck56 FIND v(dout0_56) AT=285.025n

* CHECK dout0_57 Vdout0_57ck56 = 0.9 time = 285
.meas tran vdout0_57ck56 FIND v(dout0_57) AT=285.025n

* CHECK dout0_58 Vdout0_58ck56 = 0 time = 285
.meas tran vdout0_58ck56 FIND v(dout0_58) AT=285.025n

* CHECK dout0_59 Vdout0_59ck56 = 0 time = 285
.meas tran vdout0_59ck56 FIND v(dout0_59) AT=285.025n

* CHECK dout0_60 Vdout0_60ck56 = 0 time = 285
.meas tran vdout0_60ck56 FIND v(dout0_60) AT=285.025n

* CHECK dout0_61 Vdout0_61ck56 = 0.9 time = 285
.meas tran vdout0_61ck56 FIND v(dout0_61) AT=285.025n

* CHECK dout0_62 Vdout0_62ck56 = 0.9 time = 285
.meas tran vdout0_62ck56 FIND v(dout0_62) AT=285.025n

* CHECK dout0_63 Vdout0_63ck56 = 0 time = 285
.meas tran vdout0_63ck56 FIND v(dout0_63) AT=285.025n

* CHECK dout0_0 Vdout0_0ck58 = 0.9 time = 295
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=295.025n

* CHECK dout0_1 Vdout0_1ck58 = 0.9 time = 295
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=295.025n

* CHECK dout0_2 Vdout0_2ck58 = 0.9 time = 295
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=295.025n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 295
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=295.025n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 295
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=295.025n

* CHECK dout0_5 Vdout0_5ck58 = 0.9 time = 295
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=295.025n

* CHECK dout0_6 Vdout0_6ck58 = 0.9 time = 295
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=295.025n

* CHECK dout0_7 Vdout0_7ck58 = 0.9 time = 295
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=295.025n

* CHECK dout0_8 Vdout0_8ck58 = 0.9 time = 295
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=295.025n

* CHECK dout0_9 Vdout0_9ck58 = 0.9 time = 295
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=295.025n

* CHECK dout0_10 Vdout0_10ck58 = 0.9 time = 295
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=295.025n

* CHECK dout0_11 Vdout0_11ck58 = 0.9 time = 295
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=295.025n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 295
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=295.025n

* CHECK dout0_13 Vdout0_13ck58 = 0 time = 295
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=295.025n

* CHECK dout0_14 Vdout0_14ck58 = 0.9 time = 295
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=295.025n

* CHECK dout0_15 Vdout0_15ck58 = 0.9 time = 295
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=295.025n

* CHECK dout0_16 Vdout0_16ck58 = 0 time = 295
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=295.025n

* CHECK dout0_17 Vdout0_17ck58 = 0.9 time = 295
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=295.025n

* CHECK dout0_18 Vdout0_18ck58 = 0 time = 295
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=295.025n

* CHECK dout0_19 Vdout0_19ck58 = 0 time = 295
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=295.025n

* CHECK dout0_20 Vdout0_20ck58 = 0 time = 295
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=295.025n

* CHECK dout0_21 Vdout0_21ck58 = 0 time = 295
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=295.025n

* CHECK dout0_22 Vdout0_22ck58 = 0 time = 295
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=295.025n

* CHECK dout0_23 Vdout0_23ck58 = 0 time = 295
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=295.025n

* CHECK dout0_24 Vdout0_24ck58 = 0 time = 295
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=295.025n

* CHECK dout0_25 Vdout0_25ck58 = 0.9 time = 295
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=295.025n

* CHECK dout0_26 Vdout0_26ck58 = 0 time = 295
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=295.025n

* CHECK dout0_27 Vdout0_27ck58 = 0 time = 295
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=295.025n

* CHECK dout0_28 Vdout0_28ck58 = 0.9 time = 295
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=295.025n

* CHECK dout0_29 Vdout0_29ck58 = 0 time = 295
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=295.025n

* CHECK dout0_30 Vdout0_30ck58 = 0.9 time = 295
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=295.025n

* CHECK dout0_31 Vdout0_31ck58 = 0 time = 295
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=295.025n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 295
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=295.025n

* CHECK dout0_33 Vdout0_33ck58 = 0 time = 295
.meas tran vdout0_33ck58 FIND v(dout0_33) AT=295.025n

* CHECK dout0_34 Vdout0_34ck58 = 0 time = 295
.meas tran vdout0_34ck58 FIND v(dout0_34) AT=295.025n

* CHECK dout0_35 Vdout0_35ck58 = 0.9 time = 295
.meas tran vdout0_35ck58 FIND v(dout0_35) AT=295.025n

* CHECK dout0_36 Vdout0_36ck58 = 0.9 time = 295
.meas tran vdout0_36ck58 FIND v(dout0_36) AT=295.025n

* CHECK dout0_37 Vdout0_37ck58 = 0 time = 295
.meas tran vdout0_37ck58 FIND v(dout0_37) AT=295.025n

* CHECK dout0_38 Vdout0_38ck58 = 0 time = 295
.meas tran vdout0_38ck58 FIND v(dout0_38) AT=295.025n

* CHECK dout0_39 Vdout0_39ck58 = 0.9 time = 295
.meas tran vdout0_39ck58 FIND v(dout0_39) AT=295.025n

* CHECK dout0_40 Vdout0_40ck58 = 0.9 time = 295
.meas tran vdout0_40ck58 FIND v(dout0_40) AT=295.025n

* CHECK dout0_41 Vdout0_41ck58 = 0.9 time = 295
.meas tran vdout0_41ck58 FIND v(dout0_41) AT=295.025n

* CHECK dout0_42 Vdout0_42ck58 = 0.9 time = 295
.meas tran vdout0_42ck58 FIND v(dout0_42) AT=295.025n

* CHECK dout0_43 Vdout0_43ck58 = 0.9 time = 295
.meas tran vdout0_43ck58 FIND v(dout0_43) AT=295.025n

* CHECK dout0_44 Vdout0_44ck58 = 0.9 time = 295
.meas tran vdout0_44ck58 FIND v(dout0_44) AT=295.025n

* CHECK dout0_45 Vdout0_45ck58 = 0.9 time = 295
.meas tran vdout0_45ck58 FIND v(dout0_45) AT=295.025n

* CHECK dout0_46 Vdout0_46ck58 = 0.9 time = 295
.meas tran vdout0_46ck58 FIND v(dout0_46) AT=295.025n

* CHECK dout0_47 Vdout0_47ck58 = 0 time = 295
.meas tran vdout0_47ck58 FIND v(dout0_47) AT=295.025n

* CHECK dout0_48 Vdout0_48ck58 = 0 time = 295
.meas tran vdout0_48ck58 FIND v(dout0_48) AT=295.025n

* CHECK dout0_49 Vdout0_49ck58 = 0 time = 295
.meas tran vdout0_49ck58 FIND v(dout0_49) AT=295.025n

* CHECK dout0_50 Vdout0_50ck58 = 0.9 time = 295
.meas tran vdout0_50ck58 FIND v(dout0_50) AT=295.025n

* CHECK dout0_51 Vdout0_51ck58 = 0 time = 295
.meas tran vdout0_51ck58 FIND v(dout0_51) AT=295.025n

* CHECK dout0_52 Vdout0_52ck58 = 0 time = 295
.meas tran vdout0_52ck58 FIND v(dout0_52) AT=295.025n

* CHECK dout0_53 Vdout0_53ck58 = 0 time = 295
.meas tran vdout0_53ck58 FIND v(dout0_53) AT=295.025n

* CHECK dout0_54 Vdout0_54ck58 = 0.9 time = 295
.meas tran vdout0_54ck58 FIND v(dout0_54) AT=295.025n

* CHECK dout0_55 Vdout0_55ck58 = 0 time = 295
.meas tran vdout0_55ck58 FIND v(dout0_55) AT=295.025n

* CHECK dout0_56 Vdout0_56ck58 = 0.9 time = 295
.meas tran vdout0_56ck58 FIND v(dout0_56) AT=295.025n

* CHECK dout0_57 Vdout0_57ck58 = 0.9 time = 295
.meas tran vdout0_57ck58 FIND v(dout0_57) AT=295.025n

* CHECK dout0_58 Vdout0_58ck58 = 0 time = 295
.meas tran vdout0_58ck58 FIND v(dout0_58) AT=295.025n

* CHECK dout0_59 Vdout0_59ck58 = 0 time = 295
.meas tran vdout0_59ck58 FIND v(dout0_59) AT=295.025n

* CHECK dout0_60 Vdout0_60ck58 = 0 time = 295
.meas tran vdout0_60ck58 FIND v(dout0_60) AT=295.025n

* CHECK dout0_61 Vdout0_61ck58 = 0.9 time = 295
.meas tran vdout0_61ck58 FIND v(dout0_61) AT=295.025n

* CHECK dout0_62 Vdout0_62ck58 = 0.9 time = 295
.meas tran vdout0_62ck58 FIND v(dout0_62) AT=295.025n

* CHECK dout0_63 Vdout0_63ck58 = 0 time = 295
.meas tran vdout0_63ck58 FIND v(dout0_63) AT=295.025n

* CHECK dout0_0 Vdout0_0ck59 = 0.9 time = 300
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=300.025n

* CHECK dout0_1 Vdout0_1ck59 = 0.9 time = 300
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=300.025n

* CHECK dout0_2 Vdout0_2ck59 = 0 time = 300
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=300.025n

* CHECK dout0_3 Vdout0_3ck59 = 0.9 time = 300
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=300.025n

* CHECK dout0_4 Vdout0_4ck59 = 0 time = 300
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=300.025n

* CHECK dout0_5 Vdout0_5ck59 = 0.9 time = 300
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=300.025n

* CHECK dout0_6 Vdout0_6ck59 = 0.9 time = 300
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=300.025n

* CHECK dout0_7 Vdout0_7ck59 = 0.9 time = 300
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=300.025n

* CHECK dout0_8 Vdout0_8ck59 = 0.9 time = 300
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=300.025n

* CHECK dout0_9 Vdout0_9ck59 = 0.9 time = 300
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=300.025n

* CHECK dout0_10 Vdout0_10ck59 = 0 time = 300
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=300.025n

* CHECK dout0_11 Vdout0_11ck59 = 0 time = 300
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=300.025n

* CHECK dout0_12 Vdout0_12ck59 = 0.9 time = 300
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=300.025n

* CHECK dout0_13 Vdout0_13ck59 = 0 time = 300
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=300.025n

* CHECK dout0_14 Vdout0_14ck59 = 0.9 time = 300
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=300.025n

* CHECK dout0_15 Vdout0_15ck59 = 0 time = 300
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=300.025n

* CHECK dout0_16 Vdout0_16ck59 = 0 time = 300
.meas tran vdout0_16ck59 FIND v(dout0_16) AT=300.025n

* CHECK dout0_17 Vdout0_17ck59 = 0.9 time = 300
.meas tran vdout0_17ck59 FIND v(dout0_17) AT=300.025n

* CHECK dout0_18 Vdout0_18ck59 = 0.9 time = 300
.meas tran vdout0_18ck59 FIND v(dout0_18) AT=300.025n

* CHECK dout0_19 Vdout0_19ck59 = 0.9 time = 300
.meas tran vdout0_19ck59 FIND v(dout0_19) AT=300.025n

* CHECK dout0_20 Vdout0_20ck59 = 0.9 time = 300
.meas tran vdout0_20ck59 FIND v(dout0_20) AT=300.025n

* CHECK dout0_21 Vdout0_21ck59 = 0.9 time = 300
.meas tran vdout0_21ck59 FIND v(dout0_21) AT=300.025n

* CHECK dout0_22 Vdout0_22ck59 = 0 time = 300
.meas tran vdout0_22ck59 FIND v(dout0_22) AT=300.025n

* CHECK dout0_23 Vdout0_23ck59 = 0 time = 300
.meas tran vdout0_23ck59 FIND v(dout0_23) AT=300.025n

* CHECK dout0_24 Vdout0_24ck59 = 0 time = 300
.meas tran vdout0_24ck59 FIND v(dout0_24) AT=300.025n

* CHECK dout0_25 Vdout0_25ck59 = 0 time = 300
.meas tran vdout0_25ck59 FIND v(dout0_25) AT=300.025n

* CHECK dout0_26 Vdout0_26ck59 = 0 time = 300
.meas tran vdout0_26ck59 FIND v(dout0_26) AT=300.025n

* CHECK dout0_27 Vdout0_27ck59 = 0 time = 300
.meas tran vdout0_27ck59 FIND v(dout0_27) AT=300.025n

* CHECK dout0_28 Vdout0_28ck59 = 0.9 time = 300
.meas tran vdout0_28ck59 FIND v(dout0_28) AT=300.025n

* CHECK dout0_29 Vdout0_29ck59 = 0 time = 300
.meas tran vdout0_29ck59 FIND v(dout0_29) AT=300.025n

* CHECK dout0_30 Vdout0_30ck59 = 0 time = 300
.meas tran vdout0_30ck59 FIND v(dout0_30) AT=300.025n

* CHECK dout0_31 Vdout0_31ck59 = 0 time = 300
.meas tran vdout0_31ck59 FIND v(dout0_31) AT=300.025n

* CHECK dout0_32 Vdout0_32ck59 = 0 time = 300
.meas tran vdout0_32ck59 FIND v(dout0_32) AT=300.025n

* CHECK dout0_33 Vdout0_33ck59 = 0 time = 300
.meas tran vdout0_33ck59 FIND v(dout0_33) AT=300.025n

* CHECK dout0_34 Vdout0_34ck59 = 0 time = 300
.meas tran vdout0_34ck59 FIND v(dout0_34) AT=300.025n

* CHECK dout0_35 Vdout0_35ck59 = 0.9 time = 300
.meas tran vdout0_35ck59 FIND v(dout0_35) AT=300.025n

* CHECK dout0_36 Vdout0_36ck59 = 0 time = 300
.meas tran vdout0_36ck59 FIND v(dout0_36) AT=300.025n

* CHECK dout0_37 Vdout0_37ck59 = 0 time = 300
.meas tran vdout0_37ck59 FIND v(dout0_37) AT=300.025n

* CHECK dout0_38 Vdout0_38ck59 = 0.9 time = 300
.meas tran vdout0_38ck59 FIND v(dout0_38) AT=300.025n

* CHECK dout0_39 Vdout0_39ck59 = 0.9 time = 300
.meas tran vdout0_39ck59 FIND v(dout0_39) AT=300.025n

* CHECK dout0_40 Vdout0_40ck59 = 0.9 time = 300
.meas tran vdout0_40ck59 FIND v(dout0_40) AT=300.025n

* CHECK dout0_41 Vdout0_41ck59 = 0 time = 300
.meas tran vdout0_41ck59 FIND v(dout0_41) AT=300.025n

* CHECK dout0_42 Vdout0_42ck59 = 0 time = 300
.meas tran vdout0_42ck59 FIND v(dout0_42) AT=300.025n

* CHECK dout0_43 Vdout0_43ck59 = 0.9 time = 300
.meas tran vdout0_43ck59 FIND v(dout0_43) AT=300.025n

* CHECK dout0_44 Vdout0_44ck59 = 0 time = 300
.meas tran vdout0_44ck59 FIND v(dout0_44) AT=300.025n

* CHECK dout0_45 Vdout0_45ck59 = 0 time = 300
.meas tran vdout0_45ck59 FIND v(dout0_45) AT=300.025n

* CHECK dout0_46 Vdout0_46ck59 = 0.9 time = 300
.meas tran vdout0_46ck59 FIND v(dout0_46) AT=300.025n

* CHECK dout0_47 Vdout0_47ck59 = 0.9 time = 300
.meas tran vdout0_47ck59 FIND v(dout0_47) AT=300.025n

* CHECK dout0_48 Vdout0_48ck59 = 0.9 time = 300
.meas tran vdout0_48ck59 FIND v(dout0_48) AT=300.025n

* CHECK dout0_49 Vdout0_49ck59 = 0.9 time = 300
.meas tran vdout0_49ck59 FIND v(dout0_49) AT=300.025n

* CHECK dout0_50 Vdout0_50ck59 = 0 time = 300
.meas tran vdout0_50ck59 FIND v(dout0_50) AT=300.025n

* CHECK dout0_51 Vdout0_51ck59 = 0.9 time = 300
.meas tran vdout0_51ck59 FIND v(dout0_51) AT=300.025n

* CHECK dout0_52 Vdout0_52ck59 = 0.9 time = 300
.meas tran vdout0_52ck59 FIND v(dout0_52) AT=300.025n

* CHECK dout0_53 Vdout0_53ck59 = 0.9 time = 300
.meas tran vdout0_53ck59 FIND v(dout0_53) AT=300.025n

* CHECK dout0_54 Vdout0_54ck59 = 0.9 time = 300
.meas tran vdout0_54ck59 FIND v(dout0_54) AT=300.025n

* CHECK dout0_55 Vdout0_55ck59 = 0.9 time = 300
.meas tran vdout0_55ck59 FIND v(dout0_55) AT=300.025n

* CHECK dout0_56 Vdout0_56ck59 = 0 time = 300
.meas tran vdout0_56ck59 FIND v(dout0_56) AT=300.025n

* CHECK dout0_57 Vdout0_57ck59 = 0.9 time = 300
.meas tran vdout0_57ck59 FIND v(dout0_57) AT=300.025n

* CHECK dout0_58 Vdout0_58ck59 = 0.9 time = 300
.meas tran vdout0_58ck59 FIND v(dout0_58) AT=300.025n

* CHECK dout0_59 Vdout0_59ck59 = 0.9 time = 300
.meas tran vdout0_59ck59 FIND v(dout0_59) AT=300.025n

* CHECK dout0_60 Vdout0_60ck59 = 0.9 time = 300
.meas tran vdout0_60ck59 FIND v(dout0_60) AT=300.025n

* CHECK dout0_61 Vdout0_61ck59 = 0.9 time = 300
.meas tran vdout0_61ck59 FIND v(dout0_61) AT=300.025n

* CHECK dout0_62 Vdout0_62ck59 = 0.9 time = 300
.meas tran vdout0_62ck59 FIND v(dout0_62) AT=300.025n

* CHECK dout0_63 Vdout0_63ck59 = 0.9 time = 300
.meas tran vdout0_63ck59 FIND v(dout0_63) AT=300.025n

* CHECK dout0_0 Vdout0_0ck60 = 0.9 time = 305
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=305.025n

* CHECK dout0_1 Vdout0_1ck60 = 0.9 time = 305
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=305.025n

* CHECK dout0_2 Vdout0_2ck60 = 0.9 time = 305
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=305.025n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 305
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=305.025n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 305
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=305.025n

* CHECK dout0_5 Vdout0_5ck60 = 0.9 time = 305
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=305.025n

* CHECK dout0_6 Vdout0_6ck60 = 0.9 time = 305
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=305.025n

* CHECK dout0_7 Vdout0_7ck60 = 0.9 time = 305
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=305.025n

* CHECK dout0_8 Vdout0_8ck60 = 0.9 time = 305
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=305.025n

* CHECK dout0_9 Vdout0_9ck60 = 0.9 time = 305
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=305.025n

* CHECK dout0_10 Vdout0_10ck60 = 0.9 time = 305
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=305.025n

* CHECK dout0_11 Vdout0_11ck60 = 0.9 time = 305
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=305.025n

* CHECK dout0_12 Vdout0_12ck60 = 0 time = 305
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=305.025n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 305
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=305.025n

* CHECK dout0_14 Vdout0_14ck60 = 0.9 time = 305
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=305.025n

* CHECK dout0_15 Vdout0_15ck60 = 0.9 time = 305
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=305.025n

* CHECK dout0_16 Vdout0_16ck60 = 0 time = 305
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=305.025n

* CHECK dout0_17 Vdout0_17ck60 = 0.9 time = 305
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=305.025n

* CHECK dout0_18 Vdout0_18ck60 = 0 time = 305
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=305.025n

* CHECK dout0_19 Vdout0_19ck60 = 0 time = 305
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=305.025n

* CHECK dout0_20 Vdout0_20ck60 = 0 time = 305
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=305.025n

* CHECK dout0_21 Vdout0_21ck60 = 0 time = 305
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=305.025n

* CHECK dout0_22 Vdout0_22ck60 = 0 time = 305
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=305.025n

* CHECK dout0_23 Vdout0_23ck60 = 0 time = 305
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=305.025n

* CHECK dout0_24 Vdout0_24ck60 = 0 time = 305
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=305.025n

* CHECK dout0_25 Vdout0_25ck60 = 0.9 time = 305
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=305.025n

* CHECK dout0_26 Vdout0_26ck60 = 0 time = 305
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=305.025n

* CHECK dout0_27 Vdout0_27ck60 = 0 time = 305
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=305.025n

* CHECK dout0_28 Vdout0_28ck60 = 0.9 time = 305
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=305.025n

* CHECK dout0_29 Vdout0_29ck60 = 0 time = 305
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=305.025n

* CHECK dout0_30 Vdout0_30ck60 = 0.9 time = 305
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=305.025n

* CHECK dout0_31 Vdout0_31ck60 = 0 time = 305
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=305.025n

* CHECK dout0_32 Vdout0_32ck60 = 0 time = 305
.meas tran vdout0_32ck60 FIND v(dout0_32) AT=305.025n

* CHECK dout0_33 Vdout0_33ck60 = 0 time = 305
.meas tran vdout0_33ck60 FIND v(dout0_33) AT=305.025n

* CHECK dout0_34 Vdout0_34ck60 = 0 time = 305
.meas tran vdout0_34ck60 FIND v(dout0_34) AT=305.025n

* CHECK dout0_35 Vdout0_35ck60 = 0.9 time = 305
.meas tran vdout0_35ck60 FIND v(dout0_35) AT=305.025n

* CHECK dout0_36 Vdout0_36ck60 = 0.9 time = 305
.meas tran vdout0_36ck60 FIND v(dout0_36) AT=305.025n

* CHECK dout0_37 Vdout0_37ck60 = 0 time = 305
.meas tran vdout0_37ck60 FIND v(dout0_37) AT=305.025n

* CHECK dout0_38 Vdout0_38ck60 = 0 time = 305
.meas tran vdout0_38ck60 FIND v(dout0_38) AT=305.025n

* CHECK dout0_39 Vdout0_39ck60 = 0.9 time = 305
.meas tran vdout0_39ck60 FIND v(dout0_39) AT=305.025n

* CHECK dout0_40 Vdout0_40ck60 = 0.9 time = 305
.meas tran vdout0_40ck60 FIND v(dout0_40) AT=305.025n

* CHECK dout0_41 Vdout0_41ck60 = 0.9 time = 305
.meas tran vdout0_41ck60 FIND v(dout0_41) AT=305.025n

* CHECK dout0_42 Vdout0_42ck60 = 0.9 time = 305
.meas tran vdout0_42ck60 FIND v(dout0_42) AT=305.025n

* CHECK dout0_43 Vdout0_43ck60 = 0.9 time = 305
.meas tran vdout0_43ck60 FIND v(dout0_43) AT=305.025n

* CHECK dout0_44 Vdout0_44ck60 = 0.9 time = 305
.meas tran vdout0_44ck60 FIND v(dout0_44) AT=305.025n

* CHECK dout0_45 Vdout0_45ck60 = 0.9 time = 305
.meas tran vdout0_45ck60 FIND v(dout0_45) AT=305.025n

* CHECK dout0_46 Vdout0_46ck60 = 0.9 time = 305
.meas tran vdout0_46ck60 FIND v(dout0_46) AT=305.025n

* CHECK dout0_47 Vdout0_47ck60 = 0 time = 305
.meas tran vdout0_47ck60 FIND v(dout0_47) AT=305.025n

* CHECK dout0_48 Vdout0_48ck60 = 0 time = 305
.meas tran vdout0_48ck60 FIND v(dout0_48) AT=305.025n

* CHECK dout0_49 Vdout0_49ck60 = 0 time = 305
.meas tran vdout0_49ck60 FIND v(dout0_49) AT=305.025n

* CHECK dout0_50 Vdout0_50ck60 = 0.9 time = 305
.meas tran vdout0_50ck60 FIND v(dout0_50) AT=305.025n

* CHECK dout0_51 Vdout0_51ck60 = 0 time = 305
.meas tran vdout0_51ck60 FIND v(dout0_51) AT=305.025n

* CHECK dout0_52 Vdout0_52ck60 = 0 time = 305
.meas tran vdout0_52ck60 FIND v(dout0_52) AT=305.025n

* CHECK dout0_53 Vdout0_53ck60 = 0 time = 305
.meas tran vdout0_53ck60 FIND v(dout0_53) AT=305.025n

* CHECK dout0_54 Vdout0_54ck60 = 0.9 time = 305
.meas tran vdout0_54ck60 FIND v(dout0_54) AT=305.025n

* CHECK dout0_55 Vdout0_55ck60 = 0 time = 305
.meas tran vdout0_55ck60 FIND v(dout0_55) AT=305.025n

* CHECK dout0_56 Vdout0_56ck60 = 0.9 time = 305
.meas tran vdout0_56ck60 FIND v(dout0_56) AT=305.025n

* CHECK dout0_57 Vdout0_57ck60 = 0.9 time = 305
.meas tran vdout0_57ck60 FIND v(dout0_57) AT=305.025n

* CHECK dout0_58 Vdout0_58ck60 = 0 time = 305
.meas tran vdout0_58ck60 FIND v(dout0_58) AT=305.025n

* CHECK dout0_59 Vdout0_59ck60 = 0 time = 305
.meas tran vdout0_59ck60 FIND v(dout0_59) AT=305.025n

* CHECK dout0_60 Vdout0_60ck60 = 0 time = 305
.meas tran vdout0_60ck60 FIND v(dout0_60) AT=305.025n

* CHECK dout0_61 Vdout0_61ck60 = 0.9 time = 305
.meas tran vdout0_61ck60 FIND v(dout0_61) AT=305.025n

* CHECK dout0_62 Vdout0_62ck60 = 0.9 time = 305
.meas tran vdout0_62ck60 FIND v(dout0_62) AT=305.025n

* CHECK dout0_63 Vdout0_63ck60 = 0 time = 305
.meas tran vdout0_63ck60 FIND v(dout0_63) AT=305.025n

* CHECK dout0_0 Vdout0_0ck63 = 0.9 time = 320
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=320.025n

* CHECK dout0_1 Vdout0_1ck63 = 0.9 time = 320
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=320.025n

* CHECK dout0_2 Vdout0_2ck63 = 0.9 time = 320
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=320.025n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 320
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=320.025n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 320
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=320.025n

* CHECK dout0_5 Vdout0_5ck63 = 0.9 time = 320
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=320.025n

* CHECK dout0_6 Vdout0_6ck63 = 0.9 time = 320
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=320.025n

* CHECK dout0_7 Vdout0_7ck63 = 0.9 time = 320
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=320.025n

* CHECK dout0_8 Vdout0_8ck63 = 0.9 time = 320
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=320.025n

* CHECK dout0_9 Vdout0_9ck63 = 0.9 time = 320
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=320.025n

* CHECK dout0_10 Vdout0_10ck63 = 0.9 time = 320
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=320.025n

* CHECK dout0_11 Vdout0_11ck63 = 0.9 time = 320
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=320.025n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 320
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=320.025n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 320
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=320.025n

* CHECK dout0_14 Vdout0_14ck63 = 0.9 time = 320
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=320.025n

* CHECK dout0_15 Vdout0_15ck63 = 0.9 time = 320
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=320.025n

* CHECK dout0_16 Vdout0_16ck63 = 0 time = 320
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=320.025n

* CHECK dout0_17 Vdout0_17ck63 = 0.9 time = 320
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=320.025n

* CHECK dout0_18 Vdout0_18ck63 = 0 time = 320
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=320.025n

* CHECK dout0_19 Vdout0_19ck63 = 0 time = 320
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=320.025n

* CHECK dout0_20 Vdout0_20ck63 = 0 time = 320
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=320.025n

* CHECK dout0_21 Vdout0_21ck63 = 0 time = 320
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=320.025n

* CHECK dout0_22 Vdout0_22ck63 = 0 time = 320
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=320.025n

* CHECK dout0_23 Vdout0_23ck63 = 0 time = 320
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=320.025n

* CHECK dout0_24 Vdout0_24ck63 = 0 time = 320
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=320.025n

* CHECK dout0_25 Vdout0_25ck63 = 0.9 time = 320
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=320.025n

* CHECK dout0_26 Vdout0_26ck63 = 0 time = 320
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=320.025n

* CHECK dout0_27 Vdout0_27ck63 = 0 time = 320
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=320.025n

* CHECK dout0_28 Vdout0_28ck63 = 0.9 time = 320
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=320.025n

* CHECK dout0_29 Vdout0_29ck63 = 0 time = 320
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=320.025n

* CHECK dout0_30 Vdout0_30ck63 = 0.9 time = 320
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=320.025n

* CHECK dout0_31 Vdout0_31ck63 = 0 time = 320
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=320.025n

* CHECK dout0_32 Vdout0_32ck63 = 0 time = 320
.meas tran vdout0_32ck63 FIND v(dout0_32) AT=320.025n

* CHECK dout0_33 Vdout0_33ck63 = 0 time = 320
.meas tran vdout0_33ck63 FIND v(dout0_33) AT=320.025n

* CHECK dout0_34 Vdout0_34ck63 = 0 time = 320
.meas tran vdout0_34ck63 FIND v(dout0_34) AT=320.025n

* CHECK dout0_35 Vdout0_35ck63 = 0.9 time = 320
.meas tran vdout0_35ck63 FIND v(dout0_35) AT=320.025n

* CHECK dout0_36 Vdout0_36ck63 = 0.9 time = 320
.meas tran vdout0_36ck63 FIND v(dout0_36) AT=320.025n

* CHECK dout0_37 Vdout0_37ck63 = 0 time = 320
.meas tran vdout0_37ck63 FIND v(dout0_37) AT=320.025n

* CHECK dout0_38 Vdout0_38ck63 = 0 time = 320
.meas tran vdout0_38ck63 FIND v(dout0_38) AT=320.025n

* CHECK dout0_39 Vdout0_39ck63 = 0.9 time = 320
.meas tran vdout0_39ck63 FIND v(dout0_39) AT=320.025n

* CHECK dout0_40 Vdout0_40ck63 = 0.9 time = 320
.meas tran vdout0_40ck63 FIND v(dout0_40) AT=320.025n

* CHECK dout0_41 Vdout0_41ck63 = 0.9 time = 320
.meas tran vdout0_41ck63 FIND v(dout0_41) AT=320.025n

* CHECK dout0_42 Vdout0_42ck63 = 0.9 time = 320
.meas tran vdout0_42ck63 FIND v(dout0_42) AT=320.025n

* CHECK dout0_43 Vdout0_43ck63 = 0.9 time = 320
.meas tran vdout0_43ck63 FIND v(dout0_43) AT=320.025n

* CHECK dout0_44 Vdout0_44ck63 = 0.9 time = 320
.meas tran vdout0_44ck63 FIND v(dout0_44) AT=320.025n

* CHECK dout0_45 Vdout0_45ck63 = 0.9 time = 320
.meas tran vdout0_45ck63 FIND v(dout0_45) AT=320.025n

* CHECK dout0_46 Vdout0_46ck63 = 0.9 time = 320
.meas tran vdout0_46ck63 FIND v(dout0_46) AT=320.025n

* CHECK dout0_47 Vdout0_47ck63 = 0 time = 320
.meas tran vdout0_47ck63 FIND v(dout0_47) AT=320.025n

* CHECK dout0_48 Vdout0_48ck63 = 0 time = 320
.meas tran vdout0_48ck63 FIND v(dout0_48) AT=320.025n

* CHECK dout0_49 Vdout0_49ck63 = 0 time = 320
.meas tran vdout0_49ck63 FIND v(dout0_49) AT=320.025n

* CHECK dout0_50 Vdout0_50ck63 = 0.9 time = 320
.meas tran vdout0_50ck63 FIND v(dout0_50) AT=320.025n

* CHECK dout0_51 Vdout0_51ck63 = 0 time = 320
.meas tran vdout0_51ck63 FIND v(dout0_51) AT=320.025n

* CHECK dout0_52 Vdout0_52ck63 = 0 time = 320
.meas tran vdout0_52ck63 FIND v(dout0_52) AT=320.025n

* CHECK dout0_53 Vdout0_53ck63 = 0 time = 320
.meas tran vdout0_53ck63 FIND v(dout0_53) AT=320.025n

* CHECK dout0_54 Vdout0_54ck63 = 0.9 time = 320
.meas tran vdout0_54ck63 FIND v(dout0_54) AT=320.025n

* CHECK dout0_55 Vdout0_55ck63 = 0 time = 320
.meas tran vdout0_55ck63 FIND v(dout0_55) AT=320.025n

* CHECK dout0_56 Vdout0_56ck63 = 0.9 time = 320
.meas tran vdout0_56ck63 FIND v(dout0_56) AT=320.025n

* CHECK dout0_57 Vdout0_57ck63 = 0.9 time = 320
.meas tran vdout0_57ck63 FIND v(dout0_57) AT=320.025n

* CHECK dout0_58 Vdout0_58ck63 = 0 time = 320
.meas tran vdout0_58ck63 FIND v(dout0_58) AT=320.025n

* CHECK dout0_59 Vdout0_59ck63 = 0 time = 320
.meas tran vdout0_59ck63 FIND v(dout0_59) AT=320.025n

* CHECK dout0_60 Vdout0_60ck63 = 0 time = 320
.meas tran vdout0_60ck63 FIND v(dout0_60) AT=320.025n

* CHECK dout0_61 Vdout0_61ck63 = 0.9 time = 320
.meas tran vdout0_61ck63 FIND v(dout0_61) AT=320.025n

* CHECK dout0_62 Vdout0_62ck63 = 0.9 time = 320
.meas tran vdout0_62ck63 FIND v(dout0_62) AT=320.025n

* CHECK dout0_63 Vdout0_63ck63 = 0 time = 320
.meas tran vdout0_63ck63 FIND v(dout0_63) AT=320.025n

* CHECK dout0_0 Vdout0_0ck67 = 0.9 time = 340
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=340.025n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 340
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=340.025n

* CHECK dout0_2 Vdout0_2ck67 = 0.9 time = 340
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=340.025n

* CHECK dout0_3 Vdout0_3ck67 = 0 time = 340
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=340.025n

* CHECK dout0_4 Vdout0_4ck67 = 0.9 time = 340
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=340.025n

* CHECK dout0_5 Vdout0_5ck67 = 0.9 time = 340
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=340.025n

* CHECK dout0_6 Vdout0_6ck67 = 0.9 time = 340
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=340.025n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 340
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=340.025n

* CHECK dout0_8 Vdout0_8ck67 = 0.9 time = 340
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=340.025n

* CHECK dout0_9 Vdout0_9ck67 = 0.9 time = 340
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=340.025n

* CHECK dout0_10 Vdout0_10ck67 = 0.9 time = 340
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=340.025n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 340
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=340.025n

* CHECK dout0_12 Vdout0_12ck67 = 0.9 time = 340
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=340.025n

* CHECK dout0_13 Vdout0_13ck67 = 0 time = 340
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=340.025n

* CHECK dout0_14 Vdout0_14ck67 = 0 time = 340
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=340.025n

* CHECK dout0_15 Vdout0_15ck67 = 0.9 time = 340
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=340.025n

* CHECK dout0_16 Vdout0_16ck67 = 0.9 time = 340
.meas tran vdout0_16ck67 FIND v(dout0_16) AT=340.025n

* CHECK dout0_17 Vdout0_17ck67 = 0.9 time = 340
.meas tran vdout0_17ck67 FIND v(dout0_17) AT=340.025n

* CHECK dout0_18 Vdout0_18ck67 = 0.9 time = 340
.meas tran vdout0_18ck67 FIND v(dout0_18) AT=340.025n

* CHECK dout0_19 Vdout0_19ck67 = 0 time = 340
.meas tran vdout0_19ck67 FIND v(dout0_19) AT=340.025n

* CHECK dout0_20 Vdout0_20ck67 = 0 time = 340
.meas tran vdout0_20ck67 FIND v(dout0_20) AT=340.025n

* CHECK dout0_21 Vdout0_21ck67 = 0.9 time = 340
.meas tran vdout0_21ck67 FIND v(dout0_21) AT=340.025n

* CHECK dout0_22 Vdout0_22ck67 = 0 time = 340
.meas tran vdout0_22ck67 FIND v(dout0_22) AT=340.025n

* CHECK dout0_23 Vdout0_23ck67 = 0 time = 340
.meas tran vdout0_23ck67 FIND v(dout0_23) AT=340.025n

* CHECK dout0_24 Vdout0_24ck67 = 0 time = 340
.meas tran vdout0_24ck67 FIND v(dout0_24) AT=340.025n

* CHECK dout0_25 Vdout0_25ck67 = 0 time = 340
.meas tran vdout0_25ck67 FIND v(dout0_25) AT=340.025n

* CHECK dout0_26 Vdout0_26ck67 = 0.9 time = 340
.meas tran vdout0_26ck67 FIND v(dout0_26) AT=340.025n

* CHECK dout0_27 Vdout0_27ck67 = 0 time = 340
.meas tran vdout0_27ck67 FIND v(dout0_27) AT=340.025n

* CHECK dout0_28 Vdout0_28ck67 = 0.9 time = 340
.meas tran vdout0_28ck67 FIND v(dout0_28) AT=340.025n

* CHECK dout0_29 Vdout0_29ck67 = 0.9 time = 340
.meas tran vdout0_29ck67 FIND v(dout0_29) AT=340.025n

* CHECK dout0_30 Vdout0_30ck67 = 0.9 time = 340
.meas tran vdout0_30ck67 FIND v(dout0_30) AT=340.025n

* CHECK dout0_31 Vdout0_31ck67 = 0.9 time = 340
.meas tran vdout0_31ck67 FIND v(dout0_31) AT=340.025n

* CHECK dout0_32 Vdout0_32ck67 = 0 time = 340
.meas tran vdout0_32ck67 FIND v(dout0_32) AT=340.025n

* CHECK dout0_33 Vdout0_33ck67 = 0.9 time = 340
.meas tran vdout0_33ck67 FIND v(dout0_33) AT=340.025n

* CHECK dout0_34 Vdout0_34ck67 = 0.9 time = 340
.meas tran vdout0_34ck67 FIND v(dout0_34) AT=340.025n

* CHECK dout0_35 Vdout0_35ck67 = 0 time = 340
.meas tran vdout0_35ck67 FIND v(dout0_35) AT=340.025n

* CHECK dout0_36 Vdout0_36ck67 = 0.9 time = 340
.meas tran vdout0_36ck67 FIND v(dout0_36) AT=340.025n

* CHECK dout0_37 Vdout0_37ck67 = 0 time = 340
.meas tran vdout0_37ck67 FIND v(dout0_37) AT=340.025n

* CHECK dout0_38 Vdout0_38ck67 = 0.9 time = 340
.meas tran vdout0_38ck67 FIND v(dout0_38) AT=340.025n

* CHECK dout0_39 Vdout0_39ck67 = 0 time = 340
.meas tran vdout0_39ck67 FIND v(dout0_39) AT=340.025n

* CHECK dout0_40 Vdout0_40ck67 = 0 time = 340
.meas tran vdout0_40ck67 FIND v(dout0_40) AT=340.025n

* CHECK dout0_41 Vdout0_41ck67 = 0.9 time = 340
.meas tran vdout0_41ck67 FIND v(dout0_41) AT=340.025n

* CHECK dout0_42 Vdout0_42ck67 = 0 time = 340
.meas tran vdout0_42ck67 FIND v(dout0_42) AT=340.025n

* CHECK dout0_43 Vdout0_43ck67 = 0 time = 340
.meas tran vdout0_43ck67 FIND v(dout0_43) AT=340.025n

* CHECK dout0_44 Vdout0_44ck67 = 0 time = 340
.meas tran vdout0_44ck67 FIND v(dout0_44) AT=340.025n

* CHECK dout0_45 Vdout0_45ck67 = 0.9 time = 340
.meas tran vdout0_45ck67 FIND v(dout0_45) AT=340.025n

* CHECK dout0_46 Vdout0_46ck67 = 0.9 time = 340
.meas tran vdout0_46ck67 FIND v(dout0_46) AT=340.025n

* CHECK dout0_47 Vdout0_47ck67 = 0.9 time = 340
.meas tran vdout0_47ck67 FIND v(dout0_47) AT=340.025n

* CHECK dout0_48 Vdout0_48ck67 = 0 time = 340
.meas tran vdout0_48ck67 FIND v(dout0_48) AT=340.025n

* CHECK dout0_49 Vdout0_49ck67 = 0.9 time = 340
.meas tran vdout0_49ck67 FIND v(dout0_49) AT=340.025n

* CHECK dout0_50 Vdout0_50ck67 = 0 time = 340
.meas tran vdout0_50ck67 FIND v(dout0_50) AT=340.025n

* CHECK dout0_51 Vdout0_51ck67 = 0 time = 340
.meas tran vdout0_51ck67 FIND v(dout0_51) AT=340.025n

* CHECK dout0_52 Vdout0_52ck67 = 0.9 time = 340
.meas tran vdout0_52ck67 FIND v(dout0_52) AT=340.025n

* CHECK dout0_53 Vdout0_53ck67 = 0.9 time = 340
.meas tran vdout0_53ck67 FIND v(dout0_53) AT=340.025n

* CHECK dout0_54 Vdout0_54ck67 = 0 time = 340
.meas tran vdout0_54ck67 FIND v(dout0_54) AT=340.025n

* CHECK dout0_55 Vdout0_55ck67 = 0.9 time = 340
.meas tran vdout0_55ck67 FIND v(dout0_55) AT=340.025n

* CHECK dout0_56 Vdout0_56ck67 = 0 time = 340
.meas tran vdout0_56ck67 FIND v(dout0_56) AT=340.025n

* CHECK dout0_57 Vdout0_57ck67 = 0.9 time = 340
.meas tran vdout0_57ck67 FIND v(dout0_57) AT=340.025n

* CHECK dout0_58 Vdout0_58ck67 = 0 time = 340
.meas tran vdout0_58ck67 FIND v(dout0_58) AT=340.025n

* CHECK dout0_59 Vdout0_59ck67 = 0 time = 340
.meas tran vdout0_59ck67 FIND v(dout0_59) AT=340.025n

* CHECK dout0_60 Vdout0_60ck67 = 0.9 time = 340
.meas tran vdout0_60ck67 FIND v(dout0_60) AT=340.025n

* CHECK dout0_61 Vdout0_61ck67 = 0 time = 340
.meas tran vdout0_61ck67 FIND v(dout0_61) AT=340.025n

* CHECK dout0_62 Vdout0_62ck67 = 0.9 time = 340
.meas tran vdout0_62ck67 FIND v(dout0_62) AT=340.025n

* CHECK dout0_63 Vdout0_63ck67 = 0 time = 340
.meas tran vdout0_63ck67 FIND v(dout0_63) AT=340.025n

* CHECK dout0_0 Vdout0_0ck68 = 0.9 time = 345
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=345.025n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 345
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=345.025n

* CHECK dout0_2 Vdout0_2ck68 = 0.9 time = 345
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=345.025n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 345
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=345.025n

* CHECK dout0_4 Vdout0_4ck68 = 0.9 time = 345
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=345.025n

* CHECK dout0_5 Vdout0_5ck68 = 0.9 time = 345
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=345.025n

* CHECK dout0_6 Vdout0_6ck68 = 0.9 time = 345
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=345.025n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 345
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=345.025n

* CHECK dout0_8 Vdout0_8ck68 = 0.9 time = 345
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=345.025n

* CHECK dout0_9 Vdout0_9ck68 = 0.9 time = 345
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=345.025n

* CHECK dout0_10 Vdout0_10ck68 = 0.9 time = 345
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=345.025n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 345
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=345.025n

* CHECK dout0_12 Vdout0_12ck68 = 0.9 time = 345
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=345.025n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 345
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=345.025n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 345
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=345.025n

* CHECK dout0_15 Vdout0_15ck68 = 0.9 time = 345
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=345.025n

* CHECK dout0_16 Vdout0_16ck68 = 0.9 time = 345
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=345.025n

* CHECK dout0_17 Vdout0_17ck68 = 0.9 time = 345
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=345.025n

* CHECK dout0_18 Vdout0_18ck68 = 0.9 time = 345
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=345.025n

* CHECK dout0_19 Vdout0_19ck68 = 0 time = 345
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=345.025n

* CHECK dout0_20 Vdout0_20ck68 = 0 time = 345
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=345.025n

* CHECK dout0_21 Vdout0_21ck68 = 0.9 time = 345
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=345.025n

* CHECK dout0_22 Vdout0_22ck68 = 0 time = 345
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=345.025n

* CHECK dout0_23 Vdout0_23ck68 = 0 time = 345
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=345.025n

* CHECK dout0_24 Vdout0_24ck68 = 0 time = 345
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=345.025n

* CHECK dout0_25 Vdout0_25ck68 = 0 time = 345
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=345.025n

* CHECK dout0_26 Vdout0_26ck68 = 0.9 time = 345
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=345.025n

* CHECK dout0_27 Vdout0_27ck68 = 0 time = 345
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=345.025n

* CHECK dout0_28 Vdout0_28ck68 = 0.9 time = 345
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=345.025n

* CHECK dout0_29 Vdout0_29ck68 = 0.9 time = 345
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=345.025n

* CHECK dout0_30 Vdout0_30ck68 = 0.9 time = 345
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=345.025n

* CHECK dout0_31 Vdout0_31ck68 = 0.9 time = 345
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=345.025n

* CHECK dout0_32 Vdout0_32ck68 = 0 time = 345
.meas tran vdout0_32ck68 FIND v(dout0_32) AT=345.025n

* CHECK dout0_33 Vdout0_33ck68 = 0.9 time = 345
.meas tran vdout0_33ck68 FIND v(dout0_33) AT=345.025n

* CHECK dout0_34 Vdout0_34ck68 = 0.9 time = 345
.meas tran vdout0_34ck68 FIND v(dout0_34) AT=345.025n

* CHECK dout0_35 Vdout0_35ck68 = 0 time = 345
.meas tran vdout0_35ck68 FIND v(dout0_35) AT=345.025n

* CHECK dout0_36 Vdout0_36ck68 = 0.9 time = 345
.meas tran vdout0_36ck68 FIND v(dout0_36) AT=345.025n

* CHECK dout0_37 Vdout0_37ck68 = 0 time = 345
.meas tran vdout0_37ck68 FIND v(dout0_37) AT=345.025n

* CHECK dout0_38 Vdout0_38ck68 = 0.9 time = 345
.meas tran vdout0_38ck68 FIND v(dout0_38) AT=345.025n

* CHECK dout0_39 Vdout0_39ck68 = 0 time = 345
.meas tran vdout0_39ck68 FIND v(dout0_39) AT=345.025n

* CHECK dout0_40 Vdout0_40ck68 = 0 time = 345
.meas tran vdout0_40ck68 FIND v(dout0_40) AT=345.025n

* CHECK dout0_41 Vdout0_41ck68 = 0.9 time = 345
.meas tran vdout0_41ck68 FIND v(dout0_41) AT=345.025n

* CHECK dout0_42 Vdout0_42ck68 = 0 time = 345
.meas tran vdout0_42ck68 FIND v(dout0_42) AT=345.025n

* CHECK dout0_43 Vdout0_43ck68 = 0 time = 345
.meas tran vdout0_43ck68 FIND v(dout0_43) AT=345.025n

* CHECK dout0_44 Vdout0_44ck68 = 0 time = 345
.meas tran vdout0_44ck68 FIND v(dout0_44) AT=345.025n

* CHECK dout0_45 Vdout0_45ck68 = 0.9 time = 345
.meas tran vdout0_45ck68 FIND v(dout0_45) AT=345.025n

* CHECK dout0_46 Vdout0_46ck68 = 0.9 time = 345
.meas tran vdout0_46ck68 FIND v(dout0_46) AT=345.025n

* CHECK dout0_47 Vdout0_47ck68 = 0.9 time = 345
.meas tran vdout0_47ck68 FIND v(dout0_47) AT=345.025n

* CHECK dout0_48 Vdout0_48ck68 = 0 time = 345
.meas tran vdout0_48ck68 FIND v(dout0_48) AT=345.025n

* CHECK dout0_49 Vdout0_49ck68 = 0.9 time = 345
.meas tran vdout0_49ck68 FIND v(dout0_49) AT=345.025n

* CHECK dout0_50 Vdout0_50ck68 = 0 time = 345
.meas tran vdout0_50ck68 FIND v(dout0_50) AT=345.025n

* CHECK dout0_51 Vdout0_51ck68 = 0 time = 345
.meas tran vdout0_51ck68 FIND v(dout0_51) AT=345.025n

* CHECK dout0_52 Vdout0_52ck68 = 0.9 time = 345
.meas tran vdout0_52ck68 FIND v(dout0_52) AT=345.025n

* CHECK dout0_53 Vdout0_53ck68 = 0.9 time = 345
.meas tran vdout0_53ck68 FIND v(dout0_53) AT=345.025n

* CHECK dout0_54 Vdout0_54ck68 = 0 time = 345
.meas tran vdout0_54ck68 FIND v(dout0_54) AT=345.025n

* CHECK dout0_55 Vdout0_55ck68 = 0.9 time = 345
.meas tran vdout0_55ck68 FIND v(dout0_55) AT=345.025n

* CHECK dout0_56 Vdout0_56ck68 = 0 time = 345
.meas tran vdout0_56ck68 FIND v(dout0_56) AT=345.025n

* CHECK dout0_57 Vdout0_57ck68 = 0.9 time = 345
.meas tran vdout0_57ck68 FIND v(dout0_57) AT=345.025n

* CHECK dout0_58 Vdout0_58ck68 = 0 time = 345
.meas tran vdout0_58ck68 FIND v(dout0_58) AT=345.025n

* CHECK dout0_59 Vdout0_59ck68 = 0 time = 345
.meas tran vdout0_59ck68 FIND v(dout0_59) AT=345.025n

* CHECK dout0_60 Vdout0_60ck68 = 0.9 time = 345
.meas tran vdout0_60ck68 FIND v(dout0_60) AT=345.025n

* CHECK dout0_61 Vdout0_61ck68 = 0 time = 345
.meas tran vdout0_61ck68 FIND v(dout0_61) AT=345.025n

* CHECK dout0_62 Vdout0_62ck68 = 0.9 time = 345
.meas tran vdout0_62ck68 FIND v(dout0_62) AT=345.025n

* CHECK dout0_63 Vdout0_63ck68 = 0 time = 345
.meas tran vdout0_63ck68 FIND v(dout0_63) AT=345.025n

* CHECK dout0_0 Vdout0_0ck69 = 0.9 time = 350
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=350.025n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 350
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=350.025n

* CHECK dout0_2 Vdout0_2ck69 = 0.9 time = 350
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=350.025n

* CHECK dout0_3 Vdout0_3ck69 = 0 time = 350
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=350.025n

* CHECK dout0_4 Vdout0_4ck69 = 0.9 time = 350
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=350.025n

* CHECK dout0_5 Vdout0_5ck69 = 0.9 time = 350
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=350.025n

* CHECK dout0_6 Vdout0_6ck69 = 0.9 time = 350
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=350.025n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 350
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=350.025n

* CHECK dout0_8 Vdout0_8ck69 = 0.9 time = 350
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=350.025n

* CHECK dout0_9 Vdout0_9ck69 = 0.9 time = 350
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=350.025n

* CHECK dout0_10 Vdout0_10ck69 = 0.9 time = 350
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=350.025n

* CHECK dout0_11 Vdout0_11ck69 = 0 time = 350
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=350.025n

* CHECK dout0_12 Vdout0_12ck69 = 0.9 time = 350
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=350.025n

* CHECK dout0_13 Vdout0_13ck69 = 0 time = 350
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=350.025n

* CHECK dout0_14 Vdout0_14ck69 = 0 time = 350
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=350.025n

* CHECK dout0_15 Vdout0_15ck69 = 0.9 time = 350
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=350.025n

* CHECK dout0_16 Vdout0_16ck69 = 0.9 time = 350
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=350.025n

* CHECK dout0_17 Vdout0_17ck69 = 0.9 time = 350
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=350.025n

* CHECK dout0_18 Vdout0_18ck69 = 0.9 time = 350
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=350.025n

* CHECK dout0_19 Vdout0_19ck69 = 0 time = 350
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=350.025n

* CHECK dout0_20 Vdout0_20ck69 = 0 time = 350
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=350.025n

* CHECK dout0_21 Vdout0_21ck69 = 0.9 time = 350
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=350.025n

* CHECK dout0_22 Vdout0_22ck69 = 0 time = 350
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=350.025n

* CHECK dout0_23 Vdout0_23ck69 = 0 time = 350
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=350.025n

* CHECK dout0_24 Vdout0_24ck69 = 0 time = 350
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=350.025n

* CHECK dout0_25 Vdout0_25ck69 = 0 time = 350
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=350.025n

* CHECK dout0_26 Vdout0_26ck69 = 0.9 time = 350
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=350.025n

* CHECK dout0_27 Vdout0_27ck69 = 0 time = 350
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=350.025n

* CHECK dout0_28 Vdout0_28ck69 = 0.9 time = 350
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=350.025n

* CHECK dout0_29 Vdout0_29ck69 = 0.9 time = 350
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=350.025n

* CHECK dout0_30 Vdout0_30ck69 = 0.9 time = 350
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=350.025n

* CHECK dout0_31 Vdout0_31ck69 = 0.9 time = 350
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=350.025n

* CHECK dout0_32 Vdout0_32ck69 = 0 time = 350
.meas tran vdout0_32ck69 FIND v(dout0_32) AT=350.025n

* CHECK dout0_33 Vdout0_33ck69 = 0.9 time = 350
.meas tran vdout0_33ck69 FIND v(dout0_33) AT=350.025n

* CHECK dout0_34 Vdout0_34ck69 = 0.9 time = 350
.meas tran vdout0_34ck69 FIND v(dout0_34) AT=350.025n

* CHECK dout0_35 Vdout0_35ck69 = 0 time = 350
.meas tran vdout0_35ck69 FIND v(dout0_35) AT=350.025n

* CHECK dout0_36 Vdout0_36ck69 = 0.9 time = 350
.meas tran vdout0_36ck69 FIND v(dout0_36) AT=350.025n

* CHECK dout0_37 Vdout0_37ck69 = 0 time = 350
.meas tran vdout0_37ck69 FIND v(dout0_37) AT=350.025n

* CHECK dout0_38 Vdout0_38ck69 = 0.9 time = 350
.meas tran vdout0_38ck69 FIND v(dout0_38) AT=350.025n

* CHECK dout0_39 Vdout0_39ck69 = 0 time = 350
.meas tran vdout0_39ck69 FIND v(dout0_39) AT=350.025n

* CHECK dout0_40 Vdout0_40ck69 = 0 time = 350
.meas tran vdout0_40ck69 FIND v(dout0_40) AT=350.025n

* CHECK dout0_41 Vdout0_41ck69 = 0.9 time = 350
.meas tran vdout0_41ck69 FIND v(dout0_41) AT=350.025n

* CHECK dout0_42 Vdout0_42ck69 = 0 time = 350
.meas tran vdout0_42ck69 FIND v(dout0_42) AT=350.025n

* CHECK dout0_43 Vdout0_43ck69 = 0 time = 350
.meas tran vdout0_43ck69 FIND v(dout0_43) AT=350.025n

* CHECK dout0_44 Vdout0_44ck69 = 0 time = 350
.meas tran vdout0_44ck69 FIND v(dout0_44) AT=350.025n

* CHECK dout0_45 Vdout0_45ck69 = 0.9 time = 350
.meas tran vdout0_45ck69 FIND v(dout0_45) AT=350.025n

* CHECK dout0_46 Vdout0_46ck69 = 0.9 time = 350
.meas tran vdout0_46ck69 FIND v(dout0_46) AT=350.025n

* CHECK dout0_47 Vdout0_47ck69 = 0.9 time = 350
.meas tran vdout0_47ck69 FIND v(dout0_47) AT=350.025n

* CHECK dout0_48 Vdout0_48ck69 = 0 time = 350
.meas tran vdout0_48ck69 FIND v(dout0_48) AT=350.025n

* CHECK dout0_49 Vdout0_49ck69 = 0.9 time = 350
.meas tran vdout0_49ck69 FIND v(dout0_49) AT=350.025n

* CHECK dout0_50 Vdout0_50ck69 = 0 time = 350
.meas tran vdout0_50ck69 FIND v(dout0_50) AT=350.025n

* CHECK dout0_51 Vdout0_51ck69 = 0 time = 350
.meas tran vdout0_51ck69 FIND v(dout0_51) AT=350.025n

* CHECK dout0_52 Vdout0_52ck69 = 0.9 time = 350
.meas tran vdout0_52ck69 FIND v(dout0_52) AT=350.025n

* CHECK dout0_53 Vdout0_53ck69 = 0.9 time = 350
.meas tran vdout0_53ck69 FIND v(dout0_53) AT=350.025n

* CHECK dout0_54 Vdout0_54ck69 = 0 time = 350
.meas tran vdout0_54ck69 FIND v(dout0_54) AT=350.025n

* CHECK dout0_55 Vdout0_55ck69 = 0.9 time = 350
.meas tran vdout0_55ck69 FIND v(dout0_55) AT=350.025n

* CHECK dout0_56 Vdout0_56ck69 = 0 time = 350
.meas tran vdout0_56ck69 FIND v(dout0_56) AT=350.025n

* CHECK dout0_57 Vdout0_57ck69 = 0.9 time = 350
.meas tran vdout0_57ck69 FIND v(dout0_57) AT=350.025n

* CHECK dout0_58 Vdout0_58ck69 = 0 time = 350
.meas tran vdout0_58ck69 FIND v(dout0_58) AT=350.025n

* CHECK dout0_59 Vdout0_59ck69 = 0 time = 350
.meas tran vdout0_59ck69 FIND v(dout0_59) AT=350.025n

* CHECK dout0_60 Vdout0_60ck69 = 0.9 time = 350
.meas tran vdout0_60ck69 FIND v(dout0_60) AT=350.025n

* CHECK dout0_61 Vdout0_61ck69 = 0 time = 350
.meas tran vdout0_61ck69 FIND v(dout0_61) AT=350.025n

* CHECK dout0_62 Vdout0_62ck69 = 0.9 time = 350
.meas tran vdout0_62ck69 FIND v(dout0_62) AT=350.025n

* CHECK dout0_63 Vdout0_63ck69 = 0 time = 350
.meas tran vdout0_63ck69 FIND v(dout0_63) AT=350.025n

* CHECK dout0_0 Vdout0_0ck71 = 0.9 time = 360
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=360.025n

* CHECK dout0_1 Vdout0_1ck71 = 0.9 time = 360
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=360.025n

* CHECK dout0_2 Vdout0_2ck71 = 0.9 time = 360
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=360.025n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 360
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=360.025n

* CHECK dout0_4 Vdout0_4ck71 = 0 time = 360
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=360.025n

* CHECK dout0_5 Vdout0_5ck71 = 0.9 time = 360
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=360.025n

* CHECK dout0_6 Vdout0_6ck71 = 0.9 time = 360
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=360.025n

* CHECK dout0_7 Vdout0_7ck71 = 0.9 time = 360
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=360.025n

* CHECK dout0_8 Vdout0_8ck71 = 0.9 time = 360
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=360.025n

* CHECK dout0_9 Vdout0_9ck71 = 0.9 time = 360
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=360.025n

* CHECK dout0_10 Vdout0_10ck71 = 0.9 time = 360
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=360.025n

* CHECK dout0_11 Vdout0_11ck71 = 0.9 time = 360
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=360.025n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 360
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=360.025n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 360
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=360.025n

* CHECK dout0_14 Vdout0_14ck71 = 0.9 time = 360
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=360.025n

* CHECK dout0_15 Vdout0_15ck71 = 0.9 time = 360
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=360.025n

* CHECK dout0_16 Vdout0_16ck71 = 0 time = 360
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=360.025n

* CHECK dout0_17 Vdout0_17ck71 = 0.9 time = 360
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=360.025n

* CHECK dout0_18 Vdout0_18ck71 = 0 time = 360
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=360.025n

* CHECK dout0_19 Vdout0_19ck71 = 0 time = 360
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=360.025n

* CHECK dout0_20 Vdout0_20ck71 = 0 time = 360
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=360.025n

* CHECK dout0_21 Vdout0_21ck71 = 0 time = 360
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=360.025n

* CHECK dout0_22 Vdout0_22ck71 = 0 time = 360
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=360.025n

* CHECK dout0_23 Vdout0_23ck71 = 0 time = 360
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=360.025n

* CHECK dout0_24 Vdout0_24ck71 = 0 time = 360
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=360.025n

* CHECK dout0_25 Vdout0_25ck71 = 0.9 time = 360
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=360.025n

* CHECK dout0_26 Vdout0_26ck71 = 0 time = 360
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=360.025n

* CHECK dout0_27 Vdout0_27ck71 = 0 time = 360
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=360.025n

* CHECK dout0_28 Vdout0_28ck71 = 0.9 time = 360
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=360.025n

* CHECK dout0_29 Vdout0_29ck71 = 0 time = 360
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=360.025n

* CHECK dout0_30 Vdout0_30ck71 = 0.9 time = 360
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=360.025n

* CHECK dout0_31 Vdout0_31ck71 = 0 time = 360
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=360.025n

* CHECK dout0_32 Vdout0_32ck71 = 0 time = 360
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=360.025n

* CHECK dout0_33 Vdout0_33ck71 = 0 time = 360
.meas tran vdout0_33ck71 FIND v(dout0_33) AT=360.025n

* CHECK dout0_34 Vdout0_34ck71 = 0 time = 360
.meas tran vdout0_34ck71 FIND v(dout0_34) AT=360.025n

* CHECK dout0_35 Vdout0_35ck71 = 0.9 time = 360
.meas tran vdout0_35ck71 FIND v(dout0_35) AT=360.025n

* CHECK dout0_36 Vdout0_36ck71 = 0.9 time = 360
.meas tran vdout0_36ck71 FIND v(dout0_36) AT=360.025n

* CHECK dout0_37 Vdout0_37ck71 = 0 time = 360
.meas tran vdout0_37ck71 FIND v(dout0_37) AT=360.025n

* CHECK dout0_38 Vdout0_38ck71 = 0 time = 360
.meas tran vdout0_38ck71 FIND v(dout0_38) AT=360.025n

* CHECK dout0_39 Vdout0_39ck71 = 0.9 time = 360
.meas tran vdout0_39ck71 FIND v(dout0_39) AT=360.025n

* CHECK dout0_40 Vdout0_40ck71 = 0.9 time = 360
.meas tran vdout0_40ck71 FIND v(dout0_40) AT=360.025n

* CHECK dout0_41 Vdout0_41ck71 = 0.9 time = 360
.meas tran vdout0_41ck71 FIND v(dout0_41) AT=360.025n

* CHECK dout0_42 Vdout0_42ck71 = 0.9 time = 360
.meas tran vdout0_42ck71 FIND v(dout0_42) AT=360.025n

* CHECK dout0_43 Vdout0_43ck71 = 0.9 time = 360
.meas tran vdout0_43ck71 FIND v(dout0_43) AT=360.025n

* CHECK dout0_44 Vdout0_44ck71 = 0.9 time = 360
.meas tran vdout0_44ck71 FIND v(dout0_44) AT=360.025n

* CHECK dout0_45 Vdout0_45ck71 = 0.9 time = 360
.meas tran vdout0_45ck71 FIND v(dout0_45) AT=360.025n

* CHECK dout0_46 Vdout0_46ck71 = 0.9 time = 360
.meas tran vdout0_46ck71 FIND v(dout0_46) AT=360.025n

* CHECK dout0_47 Vdout0_47ck71 = 0 time = 360
.meas tran vdout0_47ck71 FIND v(dout0_47) AT=360.025n

* CHECK dout0_48 Vdout0_48ck71 = 0 time = 360
.meas tran vdout0_48ck71 FIND v(dout0_48) AT=360.025n

* CHECK dout0_49 Vdout0_49ck71 = 0 time = 360
.meas tran vdout0_49ck71 FIND v(dout0_49) AT=360.025n

* CHECK dout0_50 Vdout0_50ck71 = 0.9 time = 360
.meas tran vdout0_50ck71 FIND v(dout0_50) AT=360.025n

* CHECK dout0_51 Vdout0_51ck71 = 0 time = 360
.meas tran vdout0_51ck71 FIND v(dout0_51) AT=360.025n

* CHECK dout0_52 Vdout0_52ck71 = 0 time = 360
.meas tran vdout0_52ck71 FIND v(dout0_52) AT=360.025n

* CHECK dout0_53 Vdout0_53ck71 = 0 time = 360
.meas tran vdout0_53ck71 FIND v(dout0_53) AT=360.025n

* CHECK dout0_54 Vdout0_54ck71 = 0.9 time = 360
.meas tran vdout0_54ck71 FIND v(dout0_54) AT=360.025n

* CHECK dout0_55 Vdout0_55ck71 = 0 time = 360
.meas tran vdout0_55ck71 FIND v(dout0_55) AT=360.025n

* CHECK dout0_56 Vdout0_56ck71 = 0.9 time = 360
.meas tran vdout0_56ck71 FIND v(dout0_56) AT=360.025n

* CHECK dout0_57 Vdout0_57ck71 = 0.9 time = 360
.meas tran vdout0_57ck71 FIND v(dout0_57) AT=360.025n

* CHECK dout0_58 Vdout0_58ck71 = 0 time = 360
.meas tran vdout0_58ck71 FIND v(dout0_58) AT=360.025n

* CHECK dout0_59 Vdout0_59ck71 = 0 time = 360
.meas tran vdout0_59ck71 FIND v(dout0_59) AT=360.025n

* CHECK dout0_60 Vdout0_60ck71 = 0 time = 360
.meas tran vdout0_60ck71 FIND v(dout0_60) AT=360.025n

* CHECK dout0_61 Vdout0_61ck71 = 0.9 time = 360
.meas tran vdout0_61ck71 FIND v(dout0_61) AT=360.025n

* CHECK dout0_62 Vdout0_62ck71 = 0.9 time = 360
.meas tran vdout0_62ck71 FIND v(dout0_62) AT=360.025n

* CHECK dout0_63 Vdout0_63ck71 = 0 time = 360
.meas tran vdout0_63ck71 FIND v(dout0_63) AT=360.025n

* CHECK dout0_0 Vdout0_0ck76 = 0.9 time = 385
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=385.025n

* CHECK dout0_1 Vdout0_1ck76 = 0.9 time = 385
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=385.025n

* CHECK dout0_2 Vdout0_2ck76 = 0.9 time = 385
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=385.025n

* CHECK dout0_3 Vdout0_3ck76 = 0.9 time = 385
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=385.025n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 385
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=385.025n

* CHECK dout0_5 Vdout0_5ck76 = 0.9 time = 385
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=385.025n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 385
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=385.025n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 385
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=385.025n

* CHECK dout0_8 Vdout0_8ck76 = 0.9 time = 385
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=385.025n

* CHECK dout0_9 Vdout0_9ck76 = 0 time = 385
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=385.025n

* CHECK dout0_10 Vdout0_10ck76 = 0.9 time = 385
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=385.025n

* CHECK dout0_11 Vdout0_11ck76 = 0.9 time = 385
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=385.025n

* CHECK dout0_12 Vdout0_12ck76 = 0.9 time = 385
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=385.025n

* CHECK dout0_13 Vdout0_13ck76 = 0.9 time = 385
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=385.025n

* CHECK dout0_14 Vdout0_14ck76 = 0 time = 385
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=385.025n

* CHECK dout0_15 Vdout0_15ck76 = 0 time = 385
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=385.025n

* CHECK dout0_16 Vdout0_16ck76 = 0.9 time = 385
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=385.025n

* CHECK dout0_17 Vdout0_17ck76 = 0 time = 385
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=385.025n

* CHECK dout0_18 Vdout0_18ck76 = 0 time = 385
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=385.025n

* CHECK dout0_19 Vdout0_19ck76 = 0.9 time = 385
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=385.025n

* CHECK dout0_20 Vdout0_20ck76 = 0.9 time = 385
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=385.025n

* CHECK dout0_21 Vdout0_21ck76 = 0.9 time = 385
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=385.025n

* CHECK dout0_22 Vdout0_22ck76 = 0 time = 385
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=385.025n

* CHECK dout0_23 Vdout0_23ck76 = 0.9 time = 385
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=385.025n

* CHECK dout0_24 Vdout0_24ck76 = 0.9 time = 385
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=385.025n

* CHECK dout0_25 Vdout0_25ck76 = 0.9 time = 385
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=385.025n

* CHECK dout0_26 Vdout0_26ck76 = 0.9 time = 385
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=385.025n

* CHECK dout0_27 Vdout0_27ck76 = 0.9 time = 385
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=385.025n

* CHECK dout0_28 Vdout0_28ck76 = 0 time = 385
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=385.025n

* CHECK dout0_29 Vdout0_29ck76 = 0 time = 385
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=385.025n

* CHECK dout0_30 Vdout0_30ck76 = 0 time = 385
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=385.025n

* CHECK dout0_31 Vdout0_31ck76 = 0.9 time = 385
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=385.025n

* CHECK dout0_32 Vdout0_32ck76 = 0.9 time = 385
.meas tran vdout0_32ck76 FIND v(dout0_32) AT=385.025n

* CHECK dout0_33 Vdout0_33ck76 = 0.9 time = 385
.meas tran vdout0_33ck76 FIND v(dout0_33) AT=385.025n

* CHECK dout0_34 Vdout0_34ck76 = 0 time = 385
.meas tran vdout0_34ck76 FIND v(dout0_34) AT=385.025n

* CHECK dout0_35 Vdout0_35ck76 = 0 time = 385
.meas tran vdout0_35ck76 FIND v(dout0_35) AT=385.025n

* CHECK dout0_36 Vdout0_36ck76 = 0 time = 385
.meas tran vdout0_36ck76 FIND v(dout0_36) AT=385.025n

* CHECK dout0_37 Vdout0_37ck76 = 0.9 time = 385
.meas tran vdout0_37ck76 FIND v(dout0_37) AT=385.025n

* CHECK dout0_38 Vdout0_38ck76 = 0 time = 385
.meas tran vdout0_38ck76 FIND v(dout0_38) AT=385.025n

* CHECK dout0_39 Vdout0_39ck76 = 0.9 time = 385
.meas tran vdout0_39ck76 FIND v(dout0_39) AT=385.025n

* CHECK dout0_40 Vdout0_40ck76 = 0.9 time = 385
.meas tran vdout0_40ck76 FIND v(dout0_40) AT=385.025n

* CHECK dout0_41 Vdout0_41ck76 = 0 time = 385
.meas tran vdout0_41ck76 FIND v(dout0_41) AT=385.025n

* CHECK dout0_42 Vdout0_42ck76 = 0 time = 385
.meas tran vdout0_42ck76 FIND v(dout0_42) AT=385.025n

* CHECK dout0_43 Vdout0_43ck76 = 0 time = 385
.meas tran vdout0_43ck76 FIND v(dout0_43) AT=385.025n

* CHECK dout0_44 Vdout0_44ck76 = 0 time = 385
.meas tran vdout0_44ck76 FIND v(dout0_44) AT=385.025n

* CHECK dout0_45 Vdout0_45ck76 = 0.9 time = 385
.meas tran vdout0_45ck76 FIND v(dout0_45) AT=385.025n

* CHECK dout0_46 Vdout0_46ck76 = 0.9 time = 385
.meas tran vdout0_46ck76 FIND v(dout0_46) AT=385.025n

* CHECK dout0_47 Vdout0_47ck76 = 0.9 time = 385
.meas tran vdout0_47ck76 FIND v(dout0_47) AT=385.025n

* CHECK dout0_48 Vdout0_48ck76 = 0 time = 385
.meas tran vdout0_48ck76 FIND v(dout0_48) AT=385.025n

* CHECK dout0_49 Vdout0_49ck76 = 0 time = 385
.meas tran vdout0_49ck76 FIND v(dout0_49) AT=385.025n

* CHECK dout0_50 Vdout0_50ck76 = 0 time = 385
.meas tran vdout0_50ck76 FIND v(dout0_50) AT=385.025n

* CHECK dout0_51 Vdout0_51ck76 = 0 time = 385
.meas tran vdout0_51ck76 FIND v(dout0_51) AT=385.025n

* CHECK dout0_52 Vdout0_52ck76 = 0.9 time = 385
.meas tran vdout0_52ck76 FIND v(dout0_52) AT=385.025n

* CHECK dout0_53 Vdout0_53ck76 = 0.9 time = 385
.meas tran vdout0_53ck76 FIND v(dout0_53) AT=385.025n

* CHECK dout0_54 Vdout0_54ck76 = 0 time = 385
.meas tran vdout0_54ck76 FIND v(dout0_54) AT=385.025n

* CHECK dout0_55 Vdout0_55ck76 = 0 time = 385
.meas tran vdout0_55ck76 FIND v(dout0_55) AT=385.025n

* CHECK dout0_56 Vdout0_56ck76 = 0.9 time = 385
.meas tran vdout0_56ck76 FIND v(dout0_56) AT=385.025n

* CHECK dout0_57 Vdout0_57ck76 = 0.9 time = 385
.meas tran vdout0_57ck76 FIND v(dout0_57) AT=385.025n

* CHECK dout0_58 Vdout0_58ck76 = 0.9 time = 385
.meas tran vdout0_58ck76 FIND v(dout0_58) AT=385.025n

* CHECK dout0_59 Vdout0_59ck76 = 0 time = 385
.meas tran vdout0_59ck76 FIND v(dout0_59) AT=385.025n

* CHECK dout0_60 Vdout0_60ck76 = 0.9 time = 385
.meas tran vdout0_60ck76 FIND v(dout0_60) AT=385.025n

* CHECK dout0_61 Vdout0_61ck76 = 0.9 time = 385
.meas tran vdout0_61ck76 FIND v(dout0_61) AT=385.025n

* CHECK dout0_62 Vdout0_62ck76 = 0 time = 385
.meas tran vdout0_62ck76 FIND v(dout0_62) AT=385.025n

* CHECK dout0_63 Vdout0_63ck76 = 0 time = 385
.meas tran vdout0_63ck76 FIND v(dout0_63) AT=385.025n

* CHECK dout0_0 Vdout0_0ck78 = 0.9 time = 395
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=395.025n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 395
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=395.025n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 395
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=395.025n

* CHECK dout0_3 Vdout0_3ck78 = 0 time = 395
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=395.025n

* CHECK dout0_4 Vdout0_4ck78 = 0.9 time = 395
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=395.025n

* CHECK dout0_5 Vdout0_5ck78 = 0 time = 395
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=395.025n

* CHECK dout0_6 Vdout0_6ck78 = 0.9 time = 395
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=395.025n

* CHECK dout0_7 Vdout0_7ck78 = 0.9 time = 395
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=395.025n

* CHECK dout0_8 Vdout0_8ck78 = 0.9 time = 395
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=395.025n

* CHECK dout0_9 Vdout0_9ck78 = 0.9 time = 395
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=395.025n

* CHECK dout0_10 Vdout0_10ck78 = 0.9 time = 395
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=395.025n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 395
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=395.025n

* CHECK dout0_12 Vdout0_12ck78 = 0.9 time = 395
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=395.025n

* CHECK dout0_13 Vdout0_13ck78 = 0.9 time = 395
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=395.025n

* CHECK dout0_14 Vdout0_14ck78 = 0.9 time = 395
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=395.025n

* CHECK dout0_15 Vdout0_15ck78 = 0 time = 395
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=395.025n

* CHECK dout0_16 Vdout0_16ck78 = 0.9 time = 395
.meas tran vdout0_16ck78 FIND v(dout0_16) AT=395.025n

* CHECK dout0_17 Vdout0_17ck78 = 0.9 time = 395
.meas tran vdout0_17ck78 FIND v(dout0_17) AT=395.025n

* CHECK dout0_18 Vdout0_18ck78 = 0 time = 395
.meas tran vdout0_18ck78 FIND v(dout0_18) AT=395.025n

* CHECK dout0_19 Vdout0_19ck78 = 0.9 time = 395
.meas tran vdout0_19ck78 FIND v(dout0_19) AT=395.025n

* CHECK dout0_20 Vdout0_20ck78 = 0.9 time = 395
.meas tran vdout0_20ck78 FIND v(dout0_20) AT=395.025n

* CHECK dout0_21 Vdout0_21ck78 = 0.9 time = 395
.meas tran vdout0_21ck78 FIND v(dout0_21) AT=395.025n

* CHECK dout0_22 Vdout0_22ck78 = 0 time = 395
.meas tran vdout0_22ck78 FIND v(dout0_22) AT=395.025n

* CHECK dout0_23 Vdout0_23ck78 = 0.9 time = 395
.meas tran vdout0_23ck78 FIND v(dout0_23) AT=395.025n

* CHECK dout0_24 Vdout0_24ck78 = 0 time = 395
.meas tran vdout0_24ck78 FIND v(dout0_24) AT=395.025n

* CHECK dout0_25 Vdout0_25ck78 = 0 time = 395
.meas tran vdout0_25ck78 FIND v(dout0_25) AT=395.025n

* CHECK dout0_26 Vdout0_26ck78 = 0 time = 395
.meas tran vdout0_26ck78 FIND v(dout0_26) AT=395.025n

* CHECK dout0_27 Vdout0_27ck78 = 0 time = 395
.meas tran vdout0_27ck78 FIND v(dout0_27) AT=395.025n

* CHECK dout0_28 Vdout0_28ck78 = 0 time = 395
.meas tran vdout0_28ck78 FIND v(dout0_28) AT=395.025n

* CHECK dout0_29 Vdout0_29ck78 = 0 time = 395
.meas tran vdout0_29ck78 FIND v(dout0_29) AT=395.025n

* CHECK dout0_30 Vdout0_30ck78 = 0 time = 395
.meas tran vdout0_30ck78 FIND v(dout0_30) AT=395.025n

* CHECK dout0_31 Vdout0_31ck78 = 0 time = 395
.meas tran vdout0_31ck78 FIND v(dout0_31) AT=395.025n

* CHECK dout0_32 Vdout0_32ck78 = 0.9 time = 395
.meas tran vdout0_32ck78 FIND v(dout0_32) AT=395.025n

* CHECK dout0_33 Vdout0_33ck78 = 0.9 time = 395
.meas tran vdout0_33ck78 FIND v(dout0_33) AT=395.025n

* CHECK dout0_34 Vdout0_34ck78 = 0 time = 395
.meas tran vdout0_34ck78 FIND v(dout0_34) AT=395.025n

* CHECK dout0_35 Vdout0_35ck78 = 0.9 time = 395
.meas tran vdout0_35ck78 FIND v(dout0_35) AT=395.025n

* CHECK dout0_36 Vdout0_36ck78 = 0 time = 395
.meas tran vdout0_36ck78 FIND v(dout0_36) AT=395.025n

* CHECK dout0_37 Vdout0_37ck78 = 0.9 time = 395
.meas tran vdout0_37ck78 FIND v(dout0_37) AT=395.025n

* CHECK dout0_38 Vdout0_38ck78 = 0 time = 395
.meas tran vdout0_38ck78 FIND v(dout0_38) AT=395.025n

* CHECK dout0_39 Vdout0_39ck78 = 0 time = 395
.meas tran vdout0_39ck78 FIND v(dout0_39) AT=395.025n

* CHECK dout0_40 Vdout0_40ck78 = 0 time = 395
.meas tran vdout0_40ck78 FIND v(dout0_40) AT=395.025n

* CHECK dout0_41 Vdout0_41ck78 = 0 time = 395
.meas tran vdout0_41ck78 FIND v(dout0_41) AT=395.025n

* CHECK dout0_42 Vdout0_42ck78 = 0 time = 395
.meas tran vdout0_42ck78 FIND v(dout0_42) AT=395.025n

* CHECK dout0_43 Vdout0_43ck78 = 0.9 time = 395
.meas tran vdout0_43ck78 FIND v(dout0_43) AT=395.025n

* CHECK dout0_44 Vdout0_44ck78 = 0.9 time = 395
.meas tran vdout0_44ck78 FIND v(dout0_44) AT=395.025n

* CHECK dout0_45 Vdout0_45ck78 = 0.9 time = 395
.meas tran vdout0_45ck78 FIND v(dout0_45) AT=395.025n

* CHECK dout0_46 Vdout0_46ck78 = 0 time = 395
.meas tran vdout0_46ck78 FIND v(dout0_46) AT=395.025n

* CHECK dout0_47 Vdout0_47ck78 = 0.9 time = 395
.meas tran vdout0_47ck78 FIND v(dout0_47) AT=395.025n

* CHECK dout0_48 Vdout0_48ck78 = 0.9 time = 395
.meas tran vdout0_48ck78 FIND v(dout0_48) AT=395.025n

* CHECK dout0_49 Vdout0_49ck78 = 0.9 time = 395
.meas tran vdout0_49ck78 FIND v(dout0_49) AT=395.025n

* CHECK dout0_50 Vdout0_50ck78 = 0.9 time = 395
.meas tran vdout0_50ck78 FIND v(dout0_50) AT=395.025n

* CHECK dout0_51 Vdout0_51ck78 = 0 time = 395
.meas tran vdout0_51ck78 FIND v(dout0_51) AT=395.025n

* CHECK dout0_52 Vdout0_52ck78 = 0.9 time = 395
.meas tran vdout0_52ck78 FIND v(dout0_52) AT=395.025n

* CHECK dout0_53 Vdout0_53ck78 = 0 time = 395
.meas tran vdout0_53ck78 FIND v(dout0_53) AT=395.025n

* CHECK dout0_54 Vdout0_54ck78 = 0 time = 395
.meas tran vdout0_54ck78 FIND v(dout0_54) AT=395.025n

* CHECK dout0_55 Vdout0_55ck78 = 0 time = 395
.meas tran vdout0_55ck78 FIND v(dout0_55) AT=395.025n

* CHECK dout0_56 Vdout0_56ck78 = 0 time = 395
.meas tran vdout0_56ck78 FIND v(dout0_56) AT=395.025n

* CHECK dout0_57 Vdout0_57ck78 = 0 time = 395
.meas tran vdout0_57ck78 FIND v(dout0_57) AT=395.025n

* CHECK dout0_58 Vdout0_58ck78 = 0.9 time = 395
.meas tran vdout0_58ck78 FIND v(dout0_58) AT=395.025n

* CHECK dout0_59 Vdout0_59ck78 = 0 time = 395
.meas tran vdout0_59ck78 FIND v(dout0_59) AT=395.025n

* CHECK dout0_60 Vdout0_60ck78 = 0.9 time = 395
.meas tran vdout0_60ck78 FIND v(dout0_60) AT=395.025n

* CHECK dout0_61 Vdout0_61ck78 = 0 time = 395
.meas tran vdout0_61ck78 FIND v(dout0_61) AT=395.025n

* CHECK dout0_62 Vdout0_62ck78 = 0 time = 395
.meas tran vdout0_62ck78 FIND v(dout0_62) AT=395.025n

* CHECK dout0_63 Vdout0_63ck78 = 0 time = 395
.meas tran vdout0_63ck78 FIND v(dout0_63) AT=395.025n

* CHECK dout0_0 Vdout0_0ck81 = 0.9 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 0.9 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 0.9 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 0.9 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 0.9 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 0 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 0.9 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 0.9 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 0.9 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 0.9 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0.9 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0.9 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 0 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 0 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 0.9 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 0.9 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 0.9 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 0 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 0.9 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0.9 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 0.9 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 0.9 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 0.9 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 0 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0.9 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_32 Vdout0_32ck81 = 0.9 time = 410
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=410.025n

* CHECK dout0_33 Vdout0_33ck81 = 0.9 time = 410
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=410.025n

* CHECK dout0_34 Vdout0_34ck81 = 0 time = 410
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=410.025n

* CHECK dout0_35 Vdout0_35ck81 = 0 time = 410
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=410.025n

* CHECK dout0_36 Vdout0_36ck81 = 0 time = 410
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=410.025n

* CHECK dout0_37 Vdout0_37ck81 = 0.9 time = 410
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=410.025n

* CHECK dout0_38 Vdout0_38ck81 = 0 time = 410
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=410.025n

* CHECK dout0_39 Vdout0_39ck81 = 0.9 time = 410
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=410.025n

* CHECK dout0_40 Vdout0_40ck81 = 0.9 time = 410
.meas tran vdout0_40ck81 FIND v(dout0_40) AT=410.025n

* CHECK dout0_41 Vdout0_41ck81 = 0 time = 410
.meas tran vdout0_41ck81 FIND v(dout0_41) AT=410.025n

* CHECK dout0_42 Vdout0_42ck81 = 0 time = 410
.meas tran vdout0_42ck81 FIND v(dout0_42) AT=410.025n

* CHECK dout0_43 Vdout0_43ck81 = 0 time = 410
.meas tran vdout0_43ck81 FIND v(dout0_43) AT=410.025n

* CHECK dout0_44 Vdout0_44ck81 = 0 time = 410
.meas tran vdout0_44ck81 FIND v(dout0_44) AT=410.025n

* CHECK dout0_45 Vdout0_45ck81 = 0.9 time = 410
.meas tran vdout0_45ck81 FIND v(dout0_45) AT=410.025n

* CHECK dout0_46 Vdout0_46ck81 = 0.9 time = 410
.meas tran vdout0_46ck81 FIND v(dout0_46) AT=410.025n

* CHECK dout0_47 Vdout0_47ck81 = 0.9 time = 410
.meas tran vdout0_47ck81 FIND v(dout0_47) AT=410.025n

* CHECK dout0_48 Vdout0_48ck81 = 0 time = 410
.meas tran vdout0_48ck81 FIND v(dout0_48) AT=410.025n

* CHECK dout0_49 Vdout0_49ck81 = 0 time = 410
.meas tran vdout0_49ck81 FIND v(dout0_49) AT=410.025n

* CHECK dout0_50 Vdout0_50ck81 = 0 time = 410
.meas tran vdout0_50ck81 FIND v(dout0_50) AT=410.025n

* CHECK dout0_51 Vdout0_51ck81 = 0 time = 410
.meas tran vdout0_51ck81 FIND v(dout0_51) AT=410.025n

* CHECK dout0_52 Vdout0_52ck81 = 0.9 time = 410
.meas tran vdout0_52ck81 FIND v(dout0_52) AT=410.025n

* CHECK dout0_53 Vdout0_53ck81 = 0.9 time = 410
.meas tran vdout0_53ck81 FIND v(dout0_53) AT=410.025n

* CHECK dout0_54 Vdout0_54ck81 = 0 time = 410
.meas tran vdout0_54ck81 FIND v(dout0_54) AT=410.025n

* CHECK dout0_55 Vdout0_55ck81 = 0 time = 410
.meas tran vdout0_55ck81 FIND v(dout0_55) AT=410.025n

* CHECK dout0_56 Vdout0_56ck81 = 0.9 time = 410
.meas tran vdout0_56ck81 FIND v(dout0_56) AT=410.025n

* CHECK dout0_57 Vdout0_57ck81 = 0.9 time = 410
.meas tran vdout0_57ck81 FIND v(dout0_57) AT=410.025n

* CHECK dout0_58 Vdout0_58ck81 = 0.9 time = 410
.meas tran vdout0_58ck81 FIND v(dout0_58) AT=410.025n

* CHECK dout0_59 Vdout0_59ck81 = 0 time = 410
.meas tran vdout0_59ck81 FIND v(dout0_59) AT=410.025n

* CHECK dout0_60 Vdout0_60ck81 = 0.9 time = 410
.meas tran vdout0_60ck81 FIND v(dout0_60) AT=410.025n

* CHECK dout0_61 Vdout0_61ck81 = 0.9 time = 410
.meas tran vdout0_61ck81 FIND v(dout0_61) AT=410.025n

* CHECK dout0_62 Vdout0_62ck81 = 0 time = 410
.meas tran vdout0_62ck81 FIND v(dout0_62) AT=410.025n

* CHECK dout0_63 Vdout0_63ck81 = 0 time = 410
.meas tran vdout0_63ck81 FIND v(dout0_63) AT=410.025n

* CHECK dout0_0 Vdout0_0ck88 = 0.9 time = 445
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=445.025n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 445
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=445.025n

* CHECK dout0_2 Vdout0_2ck88 = 0 time = 445
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=445.025n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 445
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=445.025n

* CHECK dout0_4 Vdout0_4ck88 = 0.9 time = 445
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=445.025n

* CHECK dout0_5 Vdout0_5ck88 = 0.9 time = 445
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=445.025n

* CHECK dout0_6 Vdout0_6ck88 = 0.9 time = 445
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=445.025n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 445
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=445.025n

* CHECK dout0_8 Vdout0_8ck88 = 0.9 time = 445
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=445.025n

* CHECK dout0_9 Vdout0_9ck88 = 0.9 time = 445
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=445.025n

* CHECK dout0_10 Vdout0_10ck88 = 0 time = 445
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=445.025n

* CHECK dout0_11 Vdout0_11ck88 = 0.9 time = 445
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=445.025n

* CHECK dout0_12 Vdout0_12ck88 = 0.9 time = 445
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=445.025n

* CHECK dout0_13 Vdout0_13ck88 = 0.9 time = 445
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=445.025n

* CHECK dout0_14 Vdout0_14ck88 = 0.9 time = 445
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=445.025n

* CHECK dout0_15 Vdout0_15ck88 = 0.9 time = 445
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=445.025n

* CHECK dout0_16 Vdout0_16ck88 = 0 time = 445
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=445.025n

* CHECK dout0_17 Vdout0_17ck88 = 0 time = 445
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=445.025n

* CHECK dout0_18 Vdout0_18ck88 = 0.9 time = 445
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=445.025n

* CHECK dout0_19 Vdout0_19ck88 = 0 time = 445
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=445.025n

* CHECK dout0_20 Vdout0_20ck88 = 0 time = 445
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=445.025n

* CHECK dout0_21 Vdout0_21ck88 = 0 time = 445
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=445.025n

* CHECK dout0_22 Vdout0_22ck88 = 0.9 time = 445
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=445.025n

* CHECK dout0_23 Vdout0_23ck88 = 0 time = 445
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=445.025n

* CHECK dout0_24 Vdout0_24ck88 = 0.9 time = 445
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=445.025n

* CHECK dout0_25 Vdout0_25ck88 = 0.9 time = 445
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=445.025n

* CHECK dout0_26 Vdout0_26ck88 = 0.9 time = 445
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=445.025n

* CHECK dout0_27 Vdout0_27ck88 = 0.9 time = 445
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=445.025n

* CHECK dout0_28 Vdout0_28ck88 = 0.9 time = 445
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=445.025n

* CHECK dout0_29 Vdout0_29ck88 = 0.9 time = 445
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=445.025n

* CHECK dout0_30 Vdout0_30ck88 = 0 time = 445
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=445.025n

* CHECK dout0_31 Vdout0_31ck88 = 0.9 time = 445
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=445.025n

* CHECK dout0_32 Vdout0_32ck88 = 0 time = 445
.meas tran vdout0_32ck88 FIND v(dout0_32) AT=445.025n

* CHECK dout0_33 Vdout0_33ck88 = 0.9 time = 445
.meas tran vdout0_33ck88 FIND v(dout0_33) AT=445.025n

* CHECK dout0_34 Vdout0_34ck88 = 0 time = 445
.meas tran vdout0_34ck88 FIND v(dout0_34) AT=445.025n

* CHECK dout0_35 Vdout0_35ck88 = 0.9 time = 445
.meas tran vdout0_35ck88 FIND v(dout0_35) AT=445.025n

* CHECK dout0_36 Vdout0_36ck88 = 0 time = 445
.meas tran vdout0_36ck88 FIND v(dout0_36) AT=445.025n

* CHECK dout0_37 Vdout0_37ck88 = 0 time = 445
.meas tran vdout0_37ck88 FIND v(dout0_37) AT=445.025n

* CHECK dout0_38 Vdout0_38ck88 = 0.9 time = 445
.meas tran vdout0_38ck88 FIND v(dout0_38) AT=445.025n

* CHECK dout0_39 Vdout0_39ck88 = 0 time = 445
.meas tran vdout0_39ck88 FIND v(dout0_39) AT=445.025n

* CHECK dout0_40 Vdout0_40ck88 = 0 time = 445
.meas tran vdout0_40ck88 FIND v(dout0_40) AT=445.025n

* CHECK dout0_41 Vdout0_41ck88 = 0 time = 445
.meas tran vdout0_41ck88 FIND v(dout0_41) AT=445.025n

* CHECK dout0_42 Vdout0_42ck88 = 0.9 time = 445
.meas tran vdout0_42ck88 FIND v(dout0_42) AT=445.025n

* CHECK dout0_43 Vdout0_43ck88 = 0.9 time = 445
.meas tran vdout0_43ck88 FIND v(dout0_43) AT=445.025n

* CHECK dout0_44 Vdout0_44ck88 = 0.9 time = 445
.meas tran vdout0_44ck88 FIND v(dout0_44) AT=445.025n

* CHECK dout0_45 Vdout0_45ck88 = 0.9 time = 445
.meas tran vdout0_45ck88 FIND v(dout0_45) AT=445.025n

* CHECK dout0_46 Vdout0_46ck88 = 0 time = 445
.meas tran vdout0_46ck88 FIND v(dout0_46) AT=445.025n

* CHECK dout0_47 Vdout0_47ck88 = 0.9 time = 445
.meas tran vdout0_47ck88 FIND v(dout0_47) AT=445.025n

* CHECK dout0_48 Vdout0_48ck88 = 0 time = 445
.meas tran vdout0_48ck88 FIND v(dout0_48) AT=445.025n

* CHECK dout0_49 Vdout0_49ck88 = 0 time = 445
.meas tran vdout0_49ck88 FIND v(dout0_49) AT=445.025n

* CHECK dout0_50 Vdout0_50ck88 = 0 time = 445
.meas tran vdout0_50ck88 FIND v(dout0_50) AT=445.025n

* CHECK dout0_51 Vdout0_51ck88 = 0.9 time = 445
.meas tran vdout0_51ck88 FIND v(dout0_51) AT=445.025n

* CHECK dout0_52 Vdout0_52ck88 = 0.9 time = 445
.meas tran vdout0_52ck88 FIND v(dout0_52) AT=445.025n

* CHECK dout0_53 Vdout0_53ck88 = 0.9 time = 445
.meas tran vdout0_53ck88 FIND v(dout0_53) AT=445.025n

* CHECK dout0_54 Vdout0_54ck88 = 0.9 time = 445
.meas tran vdout0_54ck88 FIND v(dout0_54) AT=445.025n

* CHECK dout0_55 Vdout0_55ck88 = 0.9 time = 445
.meas tran vdout0_55ck88 FIND v(dout0_55) AT=445.025n

* CHECK dout0_56 Vdout0_56ck88 = 0.9 time = 445
.meas tran vdout0_56ck88 FIND v(dout0_56) AT=445.025n

* CHECK dout0_57 Vdout0_57ck88 = 0 time = 445
.meas tran vdout0_57ck88 FIND v(dout0_57) AT=445.025n

* CHECK dout0_58 Vdout0_58ck88 = 0.9 time = 445
.meas tran vdout0_58ck88 FIND v(dout0_58) AT=445.025n

* CHECK dout0_59 Vdout0_59ck88 = 0.9 time = 445
.meas tran vdout0_59ck88 FIND v(dout0_59) AT=445.025n

* CHECK dout0_60 Vdout0_60ck88 = 0.9 time = 445
.meas tran vdout0_60ck88 FIND v(dout0_60) AT=445.025n

* CHECK dout0_61 Vdout0_61ck88 = 0 time = 445
.meas tran vdout0_61ck88 FIND v(dout0_61) AT=445.025n

* CHECK dout0_62 Vdout0_62ck88 = 0 time = 445
.meas tran vdout0_62ck88 FIND v(dout0_62) AT=445.025n

* CHECK dout0_63 Vdout0_63ck88 = 0.9 time = 445
.meas tran vdout0_63ck88 FIND v(dout0_63) AT=445.025n

* CHECK dout0_0 Vdout0_0ck89 = 0.9 time = 450
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=450.025n

* CHECK dout0_1 Vdout0_1ck89 = 0 time = 450
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=450.025n

* CHECK dout0_2 Vdout0_2ck89 = 0 time = 450
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=450.025n

* CHECK dout0_3 Vdout0_3ck89 = 0 time = 450
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=450.025n

* CHECK dout0_4 Vdout0_4ck89 = 0.9 time = 450
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=450.025n

* CHECK dout0_5 Vdout0_5ck89 = 0.9 time = 450
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=450.025n

* CHECK dout0_6 Vdout0_6ck89 = 0.9 time = 450
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=450.025n

* CHECK dout0_7 Vdout0_7ck89 = 0 time = 450
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=450.025n

* CHECK dout0_8 Vdout0_8ck89 = 0.9 time = 450
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=450.025n

* CHECK dout0_9 Vdout0_9ck89 = 0.9 time = 450
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=450.025n

* CHECK dout0_10 Vdout0_10ck89 = 0 time = 450
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=450.025n

* CHECK dout0_11 Vdout0_11ck89 = 0.9 time = 450
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=450.025n

* CHECK dout0_12 Vdout0_12ck89 = 0.9 time = 450
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=450.025n

* CHECK dout0_13 Vdout0_13ck89 = 0.9 time = 450
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=450.025n

* CHECK dout0_14 Vdout0_14ck89 = 0.9 time = 450
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=450.025n

* CHECK dout0_15 Vdout0_15ck89 = 0.9 time = 450
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=450.025n

* CHECK dout0_16 Vdout0_16ck89 = 0 time = 450
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=450.025n

* CHECK dout0_17 Vdout0_17ck89 = 0 time = 450
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=450.025n

* CHECK dout0_18 Vdout0_18ck89 = 0.9 time = 450
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=450.025n

* CHECK dout0_19 Vdout0_19ck89 = 0 time = 450
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=450.025n

* CHECK dout0_20 Vdout0_20ck89 = 0 time = 450
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=450.025n

* CHECK dout0_21 Vdout0_21ck89 = 0 time = 450
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=450.025n

* CHECK dout0_22 Vdout0_22ck89 = 0.9 time = 450
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=450.025n

* CHECK dout0_23 Vdout0_23ck89 = 0 time = 450
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=450.025n

* CHECK dout0_24 Vdout0_24ck89 = 0.9 time = 450
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=450.025n

* CHECK dout0_25 Vdout0_25ck89 = 0.9 time = 450
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=450.025n

* CHECK dout0_26 Vdout0_26ck89 = 0.9 time = 450
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=450.025n

* CHECK dout0_27 Vdout0_27ck89 = 0.9 time = 450
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=450.025n

* CHECK dout0_28 Vdout0_28ck89 = 0.9 time = 450
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=450.025n

* CHECK dout0_29 Vdout0_29ck89 = 0.9 time = 450
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=450.025n

* CHECK dout0_30 Vdout0_30ck89 = 0 time = 450
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=450.025n

* CHECK dout0_31 Vdout0_31ck89 = 0.9 time = 450
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=450.025n

* CHECK dout0_32 Vdout0_32ck89 = 0 time = 450
.meas tran vdout0_32ck89 FIND v(dout0_32) AT=450.025n

* CHECK dout0_33 Vdout0_33ck89 = 0.9 time = 450
.meas tran vdout0_33ck89 FIND v(dout0_33) AT=450.025n

* CHECK dout0_34 Vdout0_34ck89 = 0 time = 450
.meas tran vdout0_34ck89 FIND v(dout0_34) AT=450.025n

* CHECK dout0_35 Vdout0_35ck89 = 0.9 time = 450
.meas tran vdout0_35ck89 FIND v(dout0_35) AT=450.025n

* CHECK dout0_36 Vdout0_36ck89 = 0 time = 450
.meas tran vdout0_36ck89 FIND v(dout0_36) AT=450.025n

* CHECK dout0_37 Vdout0_37ck89 = 0 time = 450
.meas tran vdout0_37ck89 FIND v(dout0_37) AT=450.025n

* CHECK dout0_38 Vdout0_38ck89 = 0.9 time = 450
.meas tran vdout0_38ck89 FIND v(dout0_38) AT=450.025n

* CHECK dout0_39 Vdout0_39ck89 = 0 time = 450
.meas tran vdout0_39ck89 FIND v(dout0_39) AT=450.025n

* CHECK dout0_40 Vdout0_40ck89 = 0 time = 450
.meas tran vdout0_40ck89 FIND v(dout0_40) AT=450.025n

* CHECK dout0_41 Vdout0_41ck89 = 0 time = 450
.meas tran vdout0_41ck89 FIND v(dout0_41) AT=450.025n

* CHECK dout0_42 Vdout0_42ck89 = 0.9 time = 450
.meas tran vdout0_42ck89 FIND v(dout0_42) AT=450.025n

* CHECK dout0_43 Vdout0_43ck89 = 0.9 time = 450
.meas tran vdout0_43ck89 FIND v(dout0_43) AT=450.025n

* CHECK dout0_44 Vdout0_44ck89 = 0.9 time = 450
.meas tran vdout0_44ck89 FIND v(dout0_44) AT=450.025n

* CHECK dout0_45 Vdout0_45ck89 = 0.9 time = 450
.meas tran vdout0_45ck89 FIND v(dout0_45) AT=450.025n

* CHECK dout0_46 Vdout0_46ck89 = 0 time = 450
.meas tran vdout0_46ck89 FIND v(dout0_46) AT=450.025n

* CHECK dout0_47 Vdout0_47ck89 = 0.9 time = 450
.meas tran vdout0_47ck89 FIND v(dout0_47) AT=450.025n

* CHECK dout0_48 Vdout0_48ck89 = 0 time = 450
.meas tran vdout0_48ck89 FIND v(dout0_48) AT=450.025n

* CHECK dout0_49 Vdout0_49ck89 = 0 time = 450
.meas tran vdout0_49ck89 FIND v(dout0_49) AT=450.025n

* CHECK dout0_50 Vdout0_50ck89 = 0 time = 450
.meas tran vdout0_50ck89 FIND v(dout0_50) AT=450.025n

* CHECK dout0_51 Vdout0_51ck89 = 0.9 time = 450
.meas tran vdout0_51ck89 FIND v(dout0_51) AT=450.025n

* CHECK dout0_52 Vdout0_52ck89 = 0.9 time = 450
.meas tran vdout0_52ck89 FIND v(dout0_52) AT=450.025n

* CHECK dout0_53 Vdout0_53ck89 = 0.9 time = 450
.meas tran vdout0_53ck89 FIND v(dout0_53) AT=450.025n

* CHECK dout0_54 Vdout0_54ck89 = 0.9 time = 450
.meas tran vdout0_54ck89 FIND v(dout0_54) AT=450.025n

* CHECK dout0_55 Vdout0_55ck89 = 0.9 time = 450
.meas tran vdout0_55ck89 FIND v(dout0_55) AT=450.025n

* CHECK dout0_56 Vdout0_56ck89 = 0.9 time = 450
.meas tran vdout0_56ck89 FIND v(dout0_56) AT=450.025n

* CHECK dout0_57 Vdout0_57ck89 = 0 time = 450
.meas tran vdout0_57ck89 FIND v(dout0_57) AT=450.025n

* CHECK dout0_58 Vdout0_58ck89 = 0.9 time = 450
.meas tran vdout0_58ck89 FIND v(dout0_58) AT=450.025n

* CHECK dout0_59 Vdout0_59ck89 = 0.9 time = 450
.meas tran vdout0_59ck89 FIND v(dout0_59) AT=450.025n

* CHECK dout0_60 Vdout0_60ck89 = 0.9 time = 450
.meas tran vdout0_60ck89 FIND v(dout0_60) AT=450.025n

* CHECK dout0_61 Vdout0_61ck89 = 0 time = 450
.meas tran vdout0_61ck89 FIND v(dout0_61) AT=450.025n

* CHECK dout0_62 Vdout0_62ck89 = 0 time = 450
.meas tran vdout0_62ck89 FIND v(dout0_62) AT=450.025n

* CHECK dout0_63 Vdout0_63ck89 = 0.9 time = 450
.meas tran vdout0_63ck89 FIND v(dout0_63) AT=450.025n

* CHECK dout0_0 Vdout0_0ck90 = 0.9 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 0.9 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 0.9 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 0.9 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 0.9 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 0.9 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 0.9 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 0.9 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0.9 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0.9 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 0.9 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 0 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 0 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 0.9 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 0 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 0.9 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 0.9 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 0.9 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 0.9 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 0.9 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 0.9 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0.9 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 0.9 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_32 Vdout0_32ck90 = 0 time = 455
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=455.025n

* CHECK dout0_33 Vdout0_33ck90 = 0.9 time = 455
.meas tran vdout0_33ck90 FIND v(dout0_33) AT=455.025n

* CHECK dout0_34 Vdout0_34ck90 = 0 time = 455
.meas tran vdout0_34ck90 FIND v(dout0_34) AT=455.025n

* CHECK dout0_35 Vdout0_35ck90 = 0.9 time = 455
.meas tran vdout0_35ck90 FIND v(dout0_35) AT=455.025n

* CHECK dout0_36 Vdout0_36ck90 = 0 time = 455
.meas tran vdout0_36ck90 FIND v(dout0_36) AT=455.025n

* CHECK dout0_37 Vdout0_37ck90 = 0 time = 455
.meas tran vdout0_37ck90 FIND v(dout0_37) AT=455.025n

* CHECK dout0_38 Vdout0_38ck90 = 0.9 time = 455
.meas tran vdout0_38ck90 FIND v(dout0_38) AT=455.025n

* CHECK dout0_39 Vdout0_39ck90 = 0 time = 455
.meas tran vdout0_39ck90 FIND v(dout0_39) AT=455.025n

* CHECK dout0_40 Vdout0_40ck90 = 0 time = 455
.meas tran vdout0_40ck90 FIND v(dout0_40) AT=455.025n

* CHECK dout0_41 Vdout0_41ck90 = 0 time = 455
.meas tran vdout0_41ck90 FIND v(dout0_41) AT=455.025n

* CHECK dout0_42 Vdout0_42ck90 = 0.9 time = 455
.meas tran vdout0_42ck90 FIND v(dout0_42) AT=455.025n

* CHECK dout0_43 Vdout0_43ck90 = 0.9 time = 455
.meas tran vdout0_43ck90 FIND v(dout0_43) AT=455.025n

* CHECK dout0_44 Vdout0_44ck90 = 0.9 time = 455
.meas tran vdout0_44ck90 FIND v(dout0_44) AT=455.025n

* CHECK dout0_45 Vdout0_45ck90 = 0.9 time = 455
.meas tran vdout0_45ck90 FIND v(dout0_45) AT=455.025n

* CHECK dout0_46 Vdout0_46ck90 = 0 time = 455
.meas tran vdout0_46ck90 FIND v(dout0_46) AT=455.025n

* CHECK dout0_47 Vdout0_47ck90 = 0.9 time = 455
.meas tran vdout0_47ck90 FIND v(dout0_47) AT=455.025n

* CHECK dout0_48 Vdout0_48ck90 = 0 time = 455
.meas tran vdout0_48ck90 FIND v(dout0_48) AT=455.025n

* CHECK dout0_49 Vdout0_49ck90 = 0 time = 455
.meas tran vdout0_49ck90 FIND v(dout0_49) AT=455.025n

* CHECK dout0_50 Vdout0_50ck90 = 0 time = 455
.meas tran vdout0_50ck90 FIND v(dout0_50) AT=455.025n

* CHECK dout0_51 Vdout0_51ck90 = 0.9 time = 455
.meas tran vdout0_51ck90 FIND v(dout0_51) AT=455.025n

* CHECK dout0_52 Vdout0_52ck90 = 0.9 time = 455
.meas tran vdout0_52ck90 FIND v(dout0_52) AT=455.025n

* CHECK dout0_53 Vdout0_53ck90 = 0.9 time = 455
.meas tran vdout0_53ck90 FIND v(dout0_53) AT=455.025n

* CHECK dout0_54 Vdout0_54ck90 = 0.9 time = 455
.meas tran vdout0_54ck90 FIND v(dout0_54) AT=455.025n

* CHECK dout0_55 Vdout0_55ck90 = 0.9 time = 455
.meas tran vdout0_55ck90 FIND v(dout0_55) AT=455.025n

* CHECK dout0_56 Vdout0_56ck90 = 0.9 time = 455
.meas tran vdout0_56ck90 FIND v(dout0_56) AT=455.025n

* CHECK dout0_57 Vdout0_57ck90 = 0 time = 455
.meas tran vdout0_57ck90 FIND v(dout0_57) AT=455.025n

* CHECK dout0_58 Vdout0_58ck90 = 0.9 time = 455
.meas tran vdout0_58ck90 FIND v(dout0_58) AT=455.025n

* CHECK dout0_59 Vdout0_59ck90 = 0.9 time = 455
.meas tran vdout0_59ck90 FIND v(dout0_59) AT=455.025n

* CHECK dout0_60 Vdout0_60ck90 = 0.9 time = 455
.meas tran vdout0_60ck90 FIND v(dout0_60) AT=455.025n

* CHECK dout0_61 Vdout0_61ck90 = 0 time = 455
.meas tran vdout0_61ck90 FIND v(dout0_61) AT=455.025n

* CHECK dout0_62 Vdout0_62ck90 = 0 time = 455
.meas tran vdout0_62ck90 FIND v(dout0_62) AT=455.025n

* CHECK dout0_63 Vdout0_63ck90 = 0.9 time = 455
.meas tran vdout0_63ck90 FIND v(dout0_63) AT=455.025n

* CHECK dout0_0 Vdout0_0ck91 = 0.9 time = 460
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=460.025n

* CHECK dout0_1 Vdout0_1ck91 = 0.9 time = 460
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=460.025n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 460
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=460.025n

* CHECK dout0_3 Vdout0_3ck91 = 0.9 time = 460
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=460.025n

* CHECK dout0_4 Vdout0_4ck91 = 0.9 time = 460
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=460.025n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 460
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=460.025n

* CHECK dout0_6 Vdout0_6ck91 = 0.9 time = 460
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=460.025n

* CHECK dout0_7 Vdout0_7ck91 = 0.9 time = 460
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=460.025n

* CHECK dout0_8 Vdout0_8ck91 = 0.9 time = 460
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=460.025n

* CHECK dout0_9 Vdout0_9ck91 = 0.9 time = 460
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=460.025n

* CHECK dout0_10 Vdout0_10ck91 = 0.9 time = 460
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=460.025n

* CHECK dout0_11 Vdout0_11ck91 = 0.9 time = 460
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=460.025n

* CHECK dout0_12 Vdout0_12ck91 = 0.9 time = 460
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=460.025n

* CHECK dout0_13 Vdout0_13ck91 = 0.9 time = 460
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=460.025n

* CHECK dout0_14 Vdout0_14ck91 = 0.9 time = 460
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=460.025n

* CHECK dout0_15 Vdout0_15ck91 = 0.9 time = 460
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=460.025n

* CHECK dout0_16 Vdout0_16ck91 = 0 time = 460
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=460.025n

* CHECK dout0_17 Vdout0_17ck91 = 0.9 time = 460
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=460.025n

* CHECK dout0_18 Vdout0_18ck91 = 0.9 time = 460
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=460.025n

* CHECK dout0_19 Vdout0_19ck91 = 0 time = 460
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=460.025n

* CHECK dout0_20 Vdout0_20ck91 = 0 time = 460
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=460.025n

* CHECK dout0_21 Vdout0_21ck91 = 0 time = 460
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=460.025n

* CHECK dout0_22 Vdout0_22ck91 = 0 time = 460
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=460.025n

* CHECK dout0_23 Vdout0_23ck91 = 0 time = 460
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=460.025n

* CHECK dout0_24 Vdout0_24ck91 = 0.9 time = 460
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=460.025n

* CHECK dout0_25 Vdout0_25ck91 = 0.9 time = 460
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=460.025n

* CHECK dout0_26 Vdout0_26ck91 = 0 time = 460
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=460.025n

* CHECK dout0_27 Vdout0_27ck91 = 0 time = 460
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=460.025n

* CHECK dout0_28 Vdout0_28ck91 = 0.9 time = 460
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=460.025n

* CHECK dout0_29 Vdout0_29ck91 = 0 time = 460
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=460.025n

* CHECK dout0_30 Vdout0_30ck91 = 0.9 time = 460
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=460.025n

* CHECK dout0_31 Vdout0_31ck91 = 0 time = 460
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=460.025n

* CHECK dout0_32 Vdout0_32ck91 = 0 time = 460
.meas tran vdout0_32ck91 FIND v(dout0_32) AT=460.025n

* CHECK dout0_33 Vdout0_33ck91 = 0.9 time = 460
.meas tran vdout0_33ck91 FIND v(dout0_33) AT=460.025n

* CHECK dout0_34 Vdout0_34ck91 = 0 time = 460
.meas tran vdout0_34ck91 FIND v(dout0_34) AT=460.025n

* CHECK dout0_35 Vdout0_35ck91 = 0.9 time = 460
.meas tran vdout0_35ck91 FIND v(dout0_35) AT=460.025n

* CHECK dout0_36 Vdout0_36ck91 = 0 time = 460
.meas tran vdout0_36ck91 FIND v(dout0_36) AT=460.025n

* CHECK dout0_37 Vdout0_37ck91 = 0 time = 460
.meas tran vdout0_37ck91 FIND v(dout0_37) AT=460.025n

* CHECK dout0_38 Vdout0_38ck91 = 0.9 time = 460
.meas tran vdout0_38ck91 FIND v(dout0_38) AT=460.025n

* CHECK dout0_39 Vdout0_39ck91 = 0 time = 460
.meas tran vdout0_39ck91 FIND v(dout0_39) AT=460.025n

* CHECK dout0_40 Vdout0_40ck91 = 0.9 time = 460
.meas tran vdout0_40ck91 FIND v(dout0_40) AT=460.025n

* CHECK dout0_41 Vdout0_41ck91 = 0.9 time = 460
.meas tran vdout0_41ck91 FIND v(dout0_41) AT=460.025n

* CHECK dout0_42 Vdout0_42ck91 = 0.9 time = 460
.meas tran vdout0_42ck91 FIND v(dout0_42) AT=460.025n

* CHECK dout0_43 Vdout0_43ck91 = 0.9 time = 460
.meas tran vdout0_43ck91 FIND v(dout0_43) AT=460.025n

* CHECK dout0_44 Vdout0_44ck91 = 0.9 time = 460
.meas tran vdout0_44ck91 FIND v(dout0_44) AT=460.025n

* CHECK dout0_45 Vdout0_45ck91 = 0 time = 460
.meas tran vdout0_45ck91 FIND v(dout0_45) AT=460.025n

* CHECK dout0_46 Vdout0_46ck91 = 0 time = 460
.meas tran vdout0_46ck91 FIND v(dout0_46) AT=460.025n

* CHECK dout0_47 Vdout0_47ck91 = 0 time = 460
.meas tran vdout0_47ck91 FIND v(dout0_47) AT=460.025n

* CHECK dout0_48 Vdout0_48ck91 = 0.9 time = 460
.meas tran vdout0_48ck91 FIND v(dout0_48) AT=460.025n

* CHECK dout0_49 Vdout0_49ck91 = 0 time = 460
.meas tran vdout0_49ck91 FIND v(dout0_49) AT=460.025n

* CHECK dout0_50 Vdout0_50ck91 = 0 time = 460
.meas tran vdout0_50ck91 FIND v(dout0_50) AT=460.025n

* CHECK dout0_51 Vdout0_51ck91 = 0 time = 460
.meas tran vdout0_51ck91 FIND v(dout0_51) AT=460.025n

* CHECK dout0_52 Vdout0_52ck91 = 0 time = 460
.meas tran vdout0_52ck91 FIND v(dout0_52) AT=460.025n

* CHECK dout0_53 Vdout0_53ck91 = 0.9 time = 460
.meas tran vdout0_53ck91 FIND v(dout0_53) AT=460.025n

* CHECK dout0_54 Vdout0_54ck91 = 0 time = 460
.meas tran vdout0_54ck91 FIND v(dout0_54) AT=460.025n

* CHECK dout0_55 Vdout0_55ck91 = 0 time = 460
.meas tran vdout0_55ck91 FIND v(dout0_55) AT=460.025n

* CHECK dout0_56 Vdout0_56ck91 = 0.9 time = 460
.meas tran vdout0_56ck91 FIND v(dout0_56) AT=460.025n

* CHECK dout0_57 Vdout0_57ck91 = 0.9 time = 460
.meas tran vdout0_57ck91 FIND v(dout0_57) AT=460.025n

* CHECK dout0_58 Vdout0_58ck91 = 0.9 time = 460
.meas tran vdout0_58ck91 FIND v(dout0_58) AT=460.025n

* CHECK dout0_59 Vdout0_59ck91 = 0.9 time = 460
.meas tran vdout0_59ck91 FIND v(dout0_59) AT=460.025n

* CHECK dout0_60 Vdout0_60ck91 = 0 time = 460
.meas tran vdout0_60ck91 FIND v(dout0_60) AT=460.025n

* CHECK dout0_61 Vdout0_61ck91 = 0 time = 460
.meas tran vdout0_61ck91 FIND v(dout0_61) AT=460.025n

* CHECK dout0_62 Vdout0_62ck91 = 0 time = 460
.meas tran vdout0_62ck91 FIND v(dout0_62) AT=460.025n

* CHECK dout0_63 Vdout0_63ck91 = 0 time = 460
.meas tran vdout0_63ck91 FIND v(dout0_63) AT=460.025n

* CHECK dout0_0 Vdout0_0ck92 = 0.9 time = 465
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=465.025n

* CHECK dout0_1 Vdout0_1ck92 = 0.9 time = 465
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=465.025n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 465
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=465.025n

* CHECK dout0_3 Vdout0_3ck92 = 0.9 time = 465
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=465.025n

* CHECK dout0_4 Vdout0_4ck92 = 0.9 time = 465
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=465.025n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 465
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=465.025n

* CHECK dout0_6 Vdout0_6ck92 = 0.9 time = 465
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=465.025n

* CHECK dout0_7 Vdout0_7ck92 = 0.9 time = 465
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=465.025n

* CHECK dout0_8 Vdout0_8ck92 = 0.9 time = 465
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=465.025n

* CHECK dout0_9 Vdout0_9ck92 = 0.9 time = 465
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=465.025n

* CHECK dout0_10 Vdout0_10ck92 = 0.9 time = 465
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=465.025n

* CHECK dout0_11 Vdout0_11ck92 = 0.9 time = 465
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=465.025n

* CHECK dout0_12 Vdout0_12ck92 = 0.9 time = 465
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=465.025n

* CHECK dout0_13 Vdout0_13ck92 = 0.9 time = 465
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=465.025n

* CHECK dout0_14 Vdout0_14ck92 = 0.9 time = 465
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=465.025n

* CHECK dout0_15 Vdout0_15ck92 = 0.9 time = 465
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=465.025n

* CHECK dout0_16 Vdout0_16ck92 = 0 time = 465
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=465.025n

* CHECK dout0_17 Vdout0_17ck92 = 0.9 time = 465
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=465.025n

* CHECK dout0_18 Vdout0_18ck92 = 0.9 time = 465
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=465.025n

* CHECK dout0_19 Vdout0_19ck92 = 0 time = 465
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=465.025n

* CHECK dout0_20 Vdout0_20ck92 = 0 time = 465
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=465.025n

* CHECK dout0_21 Vdout0_21ck92 = 0 time = 465
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=465.025n

* CHECK dout0_22 Vdout0_22ck92 = 0 time = 465
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=465.025n

* CHECK dout0_23 Vdout0_23ck92 = 0 time = 465
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=465.025n

* CHECK dout0_24 Vdout0_24ck92 = 0.9 time = 465
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=465.025n

* CHECK dout0_25 Vdout0_25ck92 = 0.9 time = 465
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=465.025n

* CHECK dout0_26 Vdout0_26ck92 = 0 time = 465
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=465.025n

* CHECK dout0_27 Vdout0_27ck92 = 0 time = 465
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=465.025n

* CHECK dout0_28 Vdout0_28ck92 = 0.9 time = 465
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=465.025n

* CHECK dout0_29 Vdout0_29ck92 = 0 time = 465
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=465.025n

* CHECK dout0_30 Vdout0_30ck92 = 0.9 time = 465
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=465.025n

* CHECK dout0_31 Vdout0_31ck92 = 0 time = 465
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=465.025n

* CHECK dout0_32 Vdout0_32ck92 = 0 time = 465
.meas tran vdout0_32ck92 FIND v(dout0_32) AT=465.025n

* CHECK dout0_33 Vdout0_33ck92 = 0.9 time = 465
.meas tran vdout0_33ck92 FIND v(dout0_33) AT=465.025n

* CHECK dout0_34 Vdout0_34ck92 = 0 time = 465
.meas tran vdout0_34ck92 FIND v(dout0_34) AT=465.025n

* CHECK dout0_35 Vdout0_35ck92 = 0.9 time = 465
.meas tran vdout0_35ck92 FIND v(dout0_35) AT=465.025n

* CHECK dout0_36 Vdout0_36ck92 = 0 time = 465
.meas tran vdout0_36ck92 FIND v(dout0_36) AT=465.025n

* CHECK dout0_37 Vdout0_37ck92 = 0 time = 465
.meas tran vdout0_37ck92 FIND v(dout0_37) AT=465.025n

* CHECK dout0_38 Vdout0_38ck92 = 0.9 time = 465
.meas tran vdout0_38ck92 FIND v(dout0_38) AT=465.025n

* CHECK dout0_39 Vdout0_39ck92 = 0 time = 465
.meas tran vdout0_39ck92 FIND v(dout0_39) AT=465.025n

* CHECK dout0_40 Vdout0_40ck92 = 0.9 time = 465
.meas tran vdout0_40ck92 FIND v(dout0_40) AT=465.025n

* CHECK dout0_41 Vdout0_41ck92 = 0.9 time = 465
.meas tran vdout0_41ck92 FIND v(dout0_41) AT=465.025n

* CHECK dout0_42 Vdout0_42ck92 = 0.9 time = 465
.meas tran vdout0_42ck92 FIND v(dout0_42) AT=465.025n

* CHECK dout0_43 Vdout0_43ck92 = 0.9 time = 465
.meas tran vdout0_43ck92 FIND v(dout0_43) AT=465.025n

* CHECK dout0_44 Vdout0_44ck92 = 0.9 time = 465
.meas tran vdout0_44ck92 FIND v(dout0_44) AT=465.025n

* CHECK dout0_45 Vdout0_45ck92 = 0 time = 465
.meas tran vdout0_45ck92 FIND v(dout0_45) AT=465.025n

* CHECK dout0_46 Vdout0_46ck92 = 0 time = 465
.meas tran vdout0_46ck92 FIND v(dout0_46) AT=465.025n

* CHECK dout0_47 Vdout0_47ck92 = 0 time = 465
.meas tran vdout0_47ck92 FIND v(dout0_47) AT=465.025n

* CHECK dout0_48 Vdout0_48ck92 = 0.9 time = 465
.meas tran vdout0_48ck92 FIND v(dout0_48) AT=465.025n

* CHECK dout0_49 Vdout0_49ck92 = 0 time = 465
.meas tran vdout0_49ck92 FIND v(dout0_49) AT=465.025n

* CHECK dout0_50 Vdout0_50ck92 = 0 time = 465
.meas tran vdout0_50ck92 FIND v(dout0_50) AT=465.025n

* CHECK dout0_51 Vdout0_51ck92 = 0 time = 465
.meas tran vdout0_51ck92 FIND v(dout0_51) AT=465.025n

* CHECK dout0_52 Vdout0_52ck92 = 0 time = 465
.meas tran vdout0_52ck92 FIND v(dout0_52) AT=465.025n

* CHECK dout0_53 Vdout0_53ck92 = 0.9 time = 465
.meas tran vdout0_53ck92 FIND v(dout0_53) AT=465.025n

* CHECK dout0_54 Vdout0_54ck92 = 0 time = 465
.meas tran vdout0_54ck92 FIND v(dout0_54) AT=465.025n

* CHECK dout0_55 Vdout0_55ck92 = 0 time = 465
.meas tran vdout0_55ck92 FIND v(dout0_55) AT=465.025n

* CHECK dout0_56 Vdout0_56ck92 = 0.9 time = 465
.meas tran vdout0_56ck92 FIND v(dout0_56) AT=465.025n

* CHECK dout0_57 Vdout0_57ck92 = 0.9 time = 465
.meas tran vdout0_57ck92 FIND v(dout0_57) AT=465.025n

* CHECK dout0_58 Vdout0_58ck92 = 0.9 time = 465
.meas tran vdout0_58ck92 FIND v(dout0_58) AT=465.025n

* CHECK dout0_59 Vdout0_59ck92 = 0.9 time = 465
.meas tran vdout0_59ck92 FIND v(dout0_59) AT=465.025n

* CHECK dout0_60 Vdout0_60ck92 = 0 time = 465
.meas tran vdout0_60ck92 FIND v(dout0_60) AT=465.025n

* CHECK dout0_61 Vdout0_61ck92 = 0 time = 465
.meas tran vdout0_61ck92 FIND v(dout0_61) AT=465.025n

* CHECK dout0_62 Vdout0_62ck92 = 0 time = 465
.meas tran vdout0_62ck92 FIND v(dout0_62) AT=465.025n

* CHECK dout0_63 Vdout0_63ck92 = 0 time = 465
.meas tran vdout0_63ck92 FIND v(dout0_63) AT=465.025n

* CHECK dout0_0 Vdout0_0ck93 = 0.9 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 0 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 0.9 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 0.9 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 0.9 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 0.9 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 0.9 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 0.9 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 0.9 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 0.9 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 0.9 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 0.9 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 0 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 0 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 0.9 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 0 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 0 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 0 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 0.9 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 0.9 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 0.9 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 0.9 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 0.9 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 0.9 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 0.9 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 0 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 0.9 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 470
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=470.025n

* CHECK dout0_33 Vdout0_33ck93 = 0.9 time = 470
.meas tran vdout0_33ck93 FIND v(dout0_33) AT=470.025n

* CHECK dout0_34 Vdout0_34ck93 = 0 time = 470
.meas tran vdout0_34ck93 FIND v(dout0_34) AT=470.025n

* CHECK dout0_35 Vdout0_35ck93 = 0.9 time = 470
.meas tran vdout0_35ck93 FIND v(dout0_35) AT=470.025n

* CHECK dout0_36 Vdout0_36ck93 = 0 time = 470
.meas tran vdout0_36ck93 FIND v(dout0_36) AT=470.025n

* CHECK dout0_37 Vdout0_37ck93 = 0 time = 470
.meas tran vdout0_37ck93 FIND v(dout0_37) AT=470.025n

* CHECK dout0_38 Vdout0_38ck93 = 0.9 time = 470
.meas tran vdout0_38ck93 FIND v(dout0_38) AT=470.025n

* CHECK dout0_39 Vdout0_39ck93 = 0 time = 470
.meas tran vdout0_39ck93 FIND v(dout0_39) AT=470.025n

* CHECK dout0_40 Vdout0_40ck93 = 0 time = 470
.meas tran vdout0_40ck93 FIND v(dout0_40) AT=470.025n

* CHECK dout0_41 Vdout0_41ck93 = 0 time = 470
.meas tran vdout0_41ck93 FIND v(dout0_41) AT=470.025n

* CHECK dout0_42 Vdout0_42ck93 = 0.9 time = 470
.meas tran vdout0_42ck93 FIND v(dout0_42) AT=470.025n

* CHECK dout0_43 Vdout0_43ck93 = 0.9 time = 470
.meas tran vdout0_43ck93 FIND v(dout0_43) AT=470.025n

* CHECK dout0_44 Vdout0_44ck93 = 0.9 time = 470
.meas tran vdout0_44ck93 FIND v(dout0_44) AT=470.025n

* CHECK dout0_45 Vdout0_45ck93 = 0.9 time = 470
.meas tran vdout0_45ck93 FIND v(dout0_45) AT=470.025n

* CHECK dout0_46 Vdout0_46ck93 = 0 time = 470
.meas tran vdout0_46ck93 FIND v(dout0_46) AT=470.025n

* CHECK dout0_47 Vdout0_47ck93 = 0.9 time = 470
.meas tran vdout0_47ck93 FIND v(dout0_47) AT=470.025n

* CHECK dout0_48 Vdout0_48ck93 = 0 time = 470
.meas tran vdout0_48ck93 FIND v(dout0_48) AT=470.025n

* CHECK dout0_49 Vdout0_49ck93 = 0 time = 470
.meas tran vdout0_49ck93 FIND v(dout0_49) AT=470.025n

* CHECK dout0_50 Vdout0_50ck93 = 0 time = 470
.meas tran vdout0_50ck93 FIND v(dout0_50) AT=470.025n

* CHECK dout0_51 Vdout0_51ck93 = 0.9 time = 470
.meas tran vdout0_51ck93 FIND v(dout0_51) AT=470.025n

* CHECK dout0_52 Vdout0_52ck93 = 0.9 time = 470
.meas tran vdout0_52ck93 FIND v(dout0_52) AT=470.025n

* CHECK dout0_53 Vdout0_53ck93 = 0.9 time = 470
.meas tran vdout0_53ck93 FIND v(dout0_53) AT=470.025n

* CHECK dout0_54 Vdout0_54ck93 = 0.9 time = 470
.meas tran vdout0_54ck93 FIND v(dout0_54) AT=470.025n

* CHECK dout0_55 Vdout0_55ck93 = 0.9 time = 470
.meas tran vdout0_55ck93 FIND v(dout0_55) AT=470.025n

* CHECK dout0_56 Vdout0_56ck93 = 0.9 time = 470
.meas tran vdout0_56ck93 FIND v(dout0_56) AT=470.025n

* CHECK dout0_57 Vdout0_57ck93 = 0 time = 470
.meas tran vdout0_57ck93 FIND v(dout0_57) AT=470.025n

* CHECK dout0_58 Vdout0_58ck93 = 0.9 time = 470
.meas tran vdout0_58ck93 FIND v(dout0_58) AT=470.025n

* CHECK dout0_59 Vdout0_59ck93 = 0.9 time = 470
.meas tran vdout0_59ck93 FIND v(dout0_59) AT=470.025n

* CHECK dout0_60 Vdout0_60ck93 = 0.9 time = 470
.meas tran vdout0_60ck93 FIND v(dout0_60) AT=470.025n

* CHECK dout0_61 Vdout0_61ck93 = 0 time = 470
.meas tran vdout0_61ck93 FIND v(dout0_61) AT=470.025n

* CHECK dout0_62 Vdout0_62ck93 = 0 time = 470
.meas tran vdout0_62ck93 FIND v(dout0_62) AT=470.025n

* CHECK dout0_63 Vdout0_63ck93 = 0.9 time = 470
.meas tran vdout0_63ck93 FIND v(dout0_63) AT=470.025n

* CHECK dout0_0 Vdout0_0ck94 = 0.9 time = 475
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=475.025n

* CHECK dout0_1 Vdout0_1ck94 = 0.9 time = 475
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=475.025n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 475
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=475.025n

* CHECK dout0_3 Vdout0_3ck94 = 0.9 time = 475
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=475.025n

* CHECK dout0_4 Vdout0_4ck94 = 0.9 time = 475
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=475.025n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 475
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=475.025n

* CHECK dout0_6 Vdout0_6ck94 = 0.9 time = 475
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=475.025n

* CHECK dout0_7 Vdout0_7ck94 = 0.9 time = 475
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=475.025n

* CHECK dout0_8 Vdout0_8ck94 = 0.9 time = 475
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=475.025n

* CHECK dout0_9 Vdout0_9ck94 = 0.9 time = 475
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=475.025n

* CHECK dout0_10 Vdout0_10ck94 = 0.9 time = 475
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=475.025n

* CHECK dout0_11 Vdout0_11ck94 = 0.9 time = 475
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=475.025n

* CHECK dout0_12 Vdout0_12ck94 = 0.9 time = 475
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=475.025n

* CHECK dout0_13 Vdout0_13ck94 = 0.9 time = 475
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=475.025n

* CHECK dout0_14 Vdout0_14ck94 = 0.9 time = 475
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=475.025n

* CHECK dout0_15 Vdout0_15ck94 = 0.9 time = 475
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=475.025n

* CHECK dout0_16 Vdout0_16ck94 = 0 time = 475
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=475.025n

* CHECK dout0_17 Vdout0_17ck94 = 0.9 time = 475
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=475.025n

* CHECK dout0_18 Vdout0_18ck94 = 0.9 time = 475
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=475.025n

* CHECK dout0_19 Vdout0_19ck94 = 0 time = 475
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=475.025n

* CHECK dout0_20 Vdout0_20ck94 = 0 time = 475
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=475.025n

* CHECK dout0_21 Vdout0_21ck94 = 0 time = 475
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=475.025n

* CHECK dout0_22 Vdout0_22ck94 = 0 time = 475
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=475.025n

* CHECK dout0_23 Vdout0_23ck94 = 0 time = 475
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=475.025n

* CHECK dout0_24 Vdout0_24ck94 = 0.9 time = 475
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=475.025n

* CHECK dout0_25 Vdout0_25ck94 = 0.9 time = 475
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=475.025n

* CHECK dout0_26 Vdout0_26ck94 = 0 time = 475
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=475.025n

* CHECK dout0_27 Vdout0_27ck94 = 0 time = 475
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=475.025n

* CHECK dout0_28 Vdout0_28ck94 = 0.9 time = 475
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=475.025n

* CHECK dout0_29 Vdout0_29ck94 = 0 time = 475
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=475.025n

* CHECK dout0_30 Vdout0_30ck94 = 0.9 time = 475
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=475.025n

* CHECK dout0_31 Vdout0_31ck94 = 0 time = 475
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=475.025n

* CHECK dout0_32 Vdout0_32ck94 = 0 time = 475
.meas tran vdout0_32ck94 FIND v(dout0_32) AT=475.025n

* CHECK dout0_33 Vdout0_33ck94 = 0.9 time = 475
.meas tran vdout0_33ck94 FIND v(dout0_33) AT=475.025n

* CHECK dout0_34 Vdout0_34ck94 = 0 time = 475
.meas tran vdout0_34ck94 FIND v(dout0_34) AT=475.025n

* CHECK dout0_35 Vdout0_35ck94 = 0.9 time = 475
.meas tran vdout0_35ck94 FIND v(dout0_35) AT=475.025n

* CHECK dout0_36 Vdout0_36ck94 = 0 time = 475
.meas tran vdout0_36ck94 FIND v(dout0_36) AT=475.025n

* CHECK dout0_37 Vdout0_37ck94 = 0 time = 475
.meas tran vdout0_37ck94 FIND v(dout0_37) AT=475.025n

* CHECK dout0_38 Vdout0_38ck94 = 0.9 time = 475
.meas tran vdout0_38ck94 FIND v(dout0_38) AT=475.025n

* CHECK dout0_39 Vdout0_39ck94 = 0 time = 475
.meas tran vdout0_39ck94 FIND v(dout0_39) AT=475.025n

* CHECK dout0_40 Vdout0_40ck94 = 0.9 time = 475
.meas tran vdout0_40ck94 FIND v(dout0_40) AT=475.025n

* CHECK dout0_41 Vdout0_41ck94 = 0.9 time = 475
.meas tran vdout0_41ck94 FIND v(dout0_41) AT=475.025n

* CHECK dout0_42 Vdout0_42ck94 = 0.9 time = 475
.meas tran vdout0_42ck94 FIND v(dout0_42) AT=475.025n

* CHECK dout0_43 Vdout0_43ck94 = 0.9 time = 475
.meas tran vdout0_43ck94 FIND v(dout0_43) AT=475.025n

* CHECK dout0_44 Vdout0_44ck94 = 0.9 time = 475
.meas tran vdout0_44ck94 FIND v(dout0_44) AT=475.025n

* CHECK dout0_45 Vdout0_45ck94 = 0 time = 475
.meas tran vdout0_45ck94 FIND v(dout0_45) AT=475.025n

* CHECK dout0_46 Vdout0_46ck94 = 0 time = 475
.meas tran vdout0_46ck94 FIND v(dout0_46) AT=475.025n

* CHECK dout0_47 Vdout0_47ck94 = 0 time = 475
.meas tran vdout0_47ck94 FIND v(dout0_47) AT=475.025n

* CHECK dout0_48 Vdout0_48ck94 = 0.9 time = 475
.meas tran vdout0_48ck94 FIND v(dout0_48) AT=475.025n

* CHECK dout0_49 Vdout0_49ck94 = 0 time = 475
.meas tran vdout0_49ck94 FIND v(dout0_49) AT=475.025n

* CHECK dout0_50 Vdout0_50ck94 = 0 time = 475
.meas tran vdout0_50ck94 FIND v(dout0_50) AT=475.025n

* CHECK dout0_51 Vdout0_51ck94 = 0 time = 475
.meas tran vdout0_51ck94 FIND v(dout0_51) AT=475.025n

* CHECK dout0_52 Vdout0_52ck94 = 0 time = 475
.meas tran vdout0_52ck94 FIND v(dout0_52) AT=475.025n

* CHECK dout0_53 Vdout0_53ck94 = 0.9 time = 475
.meas tran vdout0_53ck94 FIND v(dout0_53) AT=475.025n

* CHECK dout0_54 Vdout0_54ck94 = 0 time = 475
.meas tran vdout0_54ck94 FIND v(dout0_54) AT=475.025n

* CHECK dout0_55 Vdout0_55ck94 = 0 time = 475
.meas tran vdout0_55ck94 FIND v(dout0_55) AT=475.025n

* CHECK dout0_56 Vdout0_56ck94 = 0.9 time = 475
.meas tran vdout0_56ck94 FIND v(dout0_56) AT=475.025n

* CHECK dout0_57 Vdout0_57ck94 = 0.9 time = 475
.meas tran vdout0_57ck94 FIND v(dout0_57) AT=475.025n

* CHECK dout0_58 Vdout0_58ck94 = 0.9 time = 475
.meas tran vdout0_58ck94 FIND v(dout0_58) AT=475.025n

* CHECK dout0_59 Vdout0_59ck94 = 0.9 time = 475
.meas tran vdout0_59ck94 FIND v(dout0_59) AT=475.025n

* CHECK dout0_60 Vdout0_60ck94 = 0 time = 475
.meas tran vdout0_60ck94 FIND v(dout0_60) AT=475.025n

* CHECK dout0_61 Vdout0_61ck94 = 0 time = 475
.meas tran vdout0_61ck94 FIND v(dout0_61) AT=475.025n

* CHECK dout0_62 Vdout0_62ck94 = 0 time = 475
.meas tran vdout0_62ck94 FIND v(dout0_62) AT=475.025n

* CHECK dout0_63 Vdout0_63ck94 = 0 time = 475
.meas tran vdout0_63ck94 FIND v(dout0_63) AT=475.025n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 0.9 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0.9 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 0.9 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0.9 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 0.9 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 0.9 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 0 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 0.9 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 0.9 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 0.9 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 0.9 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0.9 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0.9 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 0 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 0.9 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 0 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_32 Vdout0_32ck96 = 0.9 time = 485
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=485.025n

* CHECK dout0_33 Vdout0_33ck96 = 0 time = 485
.meas tran vdout0_33ck96 FIND v(dout0_33) AT=485.025n

* CHECK dout0_34 Vdout0_34ck96 = 0.9 time = 485
.meas tran vdout0_34ck96 FIND v(dout0_34) AT=485.025n

* CHECK dout0_35 Vdout0_35ck96 = 0 time = 485
.meas tran vdout0_35ck96 FIND v(dout0_35) AT=485.025n

* CHECK dout0_36 Vdout0_36ck96 = 0 time = 485
.meas tran vdout0_36ck96 FIND v(dout0_36) AT=485.025n

* CHECK dout0_37 Vdout0_37ck96 = 0.9 time = 485
.meas tran vdout0_37ck96 FIND v(dout0_37) AT=485.025n

* CHECK dout0_38 Vdout0_38ck96 = 0 time = 485
.meas tran vdout0_38ck96 FIND v(dout0_38) AT=485.025n

* CHECK dout0_39 Vdout0_39ck96 = 0 time = 485
.meas tran vdout0_39ck96 FIND v(dout0_39) AT=485.025n

* CHECK dout0_40 Vdout0_40ck96 = 0.9 time = 485
.meas tran vdout0_40ck96 FIND v(dout0_40) AT=485.025n

* CHECK dout0_41 Vdout0_41ck96 = 0.9 time = 485
.meas tran vdout0_41ck96 FIND v(dout0_41) AT=485.025n

* CHECK dout0_42 Vdout0_42ck96 = 0 time = 485
.meas tran vdout0_42ck96 FIND v(dout0_42) AT=485.025n

* CHECK dout0_43 Vdout0_43ck96 = 0.9 time = 485
.meas tran vdout0_43ck96 FIND v(dout0_43) AT=485.025n

* CHECK dout0_44 Vdout0_44ck96 = 0 time = 485
.meas tran vdout0_44ck96 FIND v(dout0_44) AT=485.025n

* CHECK dout0_45 Vdout0_45ck96 = 0 time = 485
.meas tran vdout0_45ck96 FIND v(dout0_45) AT=485.025n

* CHECK dout0_46 Vdout0_46ck96 = 0.9 time = 485
.meas tran vdout0_46ck96 FIND v(dout0_46) AT=485.025n

* CHECK dout0_47 Vdout0_47ck96 = 0.9 time = 485
.meas tran vdout0_47ck96 FIND v(dout0_47) AT=485.025n

* CHECK dout0_48 Vdout0_48ck96 = 0.9 time = 485
.meas tran vdout0_48ck96 FIND v(dout0_48) AT=485.025n

* CHECK dout0_49 Vdout0_49ck96 = 0.9 time = 485
.meas tran vdout0_49ck96 FIND v(dout0_49) AT=485.025n

* CHECK dout0_50 Vdout0_50ck96 = 0.9 time = 485
.meas tran vdout0_50ck96 FIND v(dout0_50) AT=485.025n

* CHECK dout0_51 Vdout0_51ck96 = 0 time = 485
.meas tran vdout0_51ck96 FIND v(dout0_51) AT=485.025n

* CHECK dout0_52 Vdout0_52ck96 = 0.9 time = 485
.meas tran vdout0_52ck96 FIND v(dout0_52) AT=485.025n

* CHECK dout0_53 Vdout0_53ck96 = 0.9 time = 485
.meas tran vdout0_53ck96 FIND v(dout0_53) AT=485.025n

* CHECK dout0_54 Vdout0_54ck96 = 0.9 time = 485
.meas tran vdout0_54ck96 FIND v(dout0_54) AT=485.025n

* CHECK dout0_55 Vdout0_55ck96 = 0 time = 485
.meas tran vdout0_55ck96 FIND v(dout0_55) AT=485.025n

* CHECK dout0_56 Vdout0_56ck96 = 0 time = 485
.meas tran vdout0_56ck96 FIND v(dout0_56) AT=485.025n

* CHECK dout0_57 Vdout0_57ck96 = 0 time = 485
.meas tran vdout0_57ck96 FIND v(dout0_57) AT=485.025n

* CHECK dout0_58 Vdout0_58ck96 = 0 time = 485
.meas tran vdout0_58ck96 FIND v(dout0_58) AT=485.025n

* CHECK dout0_59 Vdout0_59ck96 = 0 time = 485
.meas tran vdout0_59ck96 FIND v(dout0_59) AT=485.025n

* CHECK dout0_60 Vdout0_60ck96 = 0.9 time = 485
.meas tran vdout0_60ck96 FIND v(dout0_60) AT=485.025n

* CHECK dout0_61 Vdout0_61ck96 = 0 time = 485
.meas tran vdout0_61ck96 FIND v(dout0_61) AT=485.025n

* CHECK dout0_62 Vdout0_62ck96 = 0 time = 485
.meas tran vdout0_62ck96 FIND v(dout0_62) AT=485.025n

* CHECK dout0_63 Vdout0_63ck96 = 0.9 time = 485
.meas tran vdout0_63ck96 FIND v(dout0_63) AT=485.025n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 505
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=505.025n

* CHECK dout0_1 Vdout0_1ck100 = 0.9 time = 505
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=505.025n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 505
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=505.025n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 505
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=505.025n

* CHECK dout0_4 Vdout0_4ck100 = 0 time = 505
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=505.025n

* CHECK dout0_5 Vdout0_5ck100 = 0.9 time = 505
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=505.025n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 505
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=505.025n

* CHECK dout0_7 Vdout0_7ck100 = 0.9 time = 505
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=505.025n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 505
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=505.025n

* CHECK dout0_9 Vdout0_9ck100 = 0.9 time = 505
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=505.025n

* CHECK dout0_10 Vdout0_10ck100 = 0 time = 505
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=505.025n

* CHECK dout0_11 Vdout0_11ck100 = 0.9 time = 505
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=505.025n

* CHECK dout0_12 Vdout0_12ck100 = 0 time = 505
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=505.025n

* CHECK dout0_13 Vdout0_13ck100 = 0 time = 505
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=505.025n

* CHECK dout0_14 Vdout0_14ck100 = 0 time = 505
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=505.025n

* CHECK dout0_15 Vdout0_15ck100 = 0 time = 505
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=505.025n

* CHECK dout0_16 Vdout0_16ck100 = 0.9 time = 505
.meas tran vdout0_16ck100 FIND v(dout0_16) AT=505.025n

* CHECK dout0_17 Vdout0_17ck100 = 0 time = 505
.meas tran vdout0_17ck100 FIND v(dout0_17) AT=505.025n

* CHECK dout0_18 Vdout0_18ck100 = 0 time = 505
.meas tran vdout0_18ck100 FIND v(dout0_18) AT=505.025n

* CHECK dout0_19 Vdout0_19ck100 = 0 time = 505
.meas tran vdout0_19ck100 FIND v(dout0_19) AT=505.025n

* CHECK dout0_20 Vdout0_20ck100 = 0.9 time = 505
.meas tran vdout0_20ck100 FIND v(dout0_20) AT=505.025n

* CHECK dout0_21 Vdout0_21ck100 = 0.9 time = 505
.meas tran vdout0_21ck100 FIND v(dout0_21) AT=505.025n

* CHECK dout0_22 Vdout0_22ck100 = 0 time = 505
.meas tran vdout0_22ck100 FIND v(dout0_22) AT=505.025n

* CHECK dout0_23 Vdout0_23ck100 = 0.9 time = 505
.meas tran vdout0_23ck100 FIND v(dout0_23) AT=505.025n

* CHECK dout0_24 Vdout0_24ck100 = 0 time = 505
.meas tran vdout0_24ck100 FIND v(dout0_24) AT=505.025n

* CHECK dout0_25 Vdout0_25ck100 = 0.9 time = 505
.meas tran vdout0_25ck100 FIND v(dout0_25) AT=505.025n

* CHECK dout0_26 Vdout0_26ck100 = 0.9 time = 505
.meas tran vdout0_26ck100 FIND v(dout0_26) AT=505.025n

* CHECK dout0_27 Vdout0_27ck100 = 0.9 time = 505
.meas tran vdout0_27ck100 FIND v(dout0_27) AT=505.025n

* CHECK dout0_28 Vdout0_28ck100 = 0 time = 505
.meas tran vdout0_28ck100 FIND v(dout0_28) AT=505.025n

* CHECK dout0_29 Vdout0_29ck100 = 0.9 time = 505
.meas tran vdout0_29ck100 FIND v(dout0_29) AT=505.025n

* CHECK dout0_30 Vdout0_30ck100 = 0 time = 505
.meas tran vdout0_30ck100 FIND v(dout0_30) AT=505.025n

* CHECK dout0_31 Vdout0_31ck100 = 0 time = 505
.meas tran vdout0_31ck100 FIND v(dout0_31) AT=505.025n

* CHECK dout0_32 Vdout0_32ck100 = 0.9 time = 505
.meas tran vdout0_32ck100 FIND v(dout0_32) AT=505.025n

* CHECK dout0_33 Vdout0_33ck100 = 0 time = 505
.meas tran vdout0_33ck100 FIND v(dout0_33) AT=505.025n

* CHECK dout0_34 Vdout0_34ck100 = 0.9 time = 505
.meas tran vdout0_34ck100 FIND v(dout0_34) AT=505.025n

* CHECK dout0_35 Vdout0_35ck100 = 0 time = 505
.meas tran vdout0_35ck100 FIND v(dout0_35) AT=505.025n

* CHECK dout0_36 Vdout0_36ck100 = 0 time = 505
.meas tran vdout0_36ck100 FIND v(dout0_36) AT=505.025n

* CHECK dout0_37 Vdout0_37ck100 = 0.9 time = 505
.meas tran vdout0_37ck100 FIND v(dout0_37) AT=505.025n

* CHECK dout0_38 Vdout0_38ck100 = 0 time = 505
.meas tran vdout0_38ck100 FIND v(dout0_38) AT=505.025n

* CHECK dout0_39 Vdout0_39ck100 = 0 time = 505
.meas tran vdout0_39ck100 FIND v(dout0_39) AT=505.025n

* CHECK dout0_40 Vdout0_40ck100 = 0.9 time = 505
.meas tran vdout0_40ck100 FIND v(dout0_40) AT=505.025n

* CHECK dout0_41 Vdout0_41ck100 = 0.9 time = 505
.meas tran vdout0_41ck100 FIND v(dout0_41) AT=505.025n

* CHECK dout0_42 Vdout0_42ck100 = 0 time = 505
.meas tran vdout0_42ck100 FIND v(dout0_42) AT=505.025n

* CHECK dout0_43 Vdout0_43ck100 = 0.9 time = 505
.meas tran vdout0_43ck100 FIND v(dout0_43) AT=505.025n

* CHECK dout0_44 Vdout0_44ck100 = 0 time = 505
.meas tran vdout0_44ck100 FIND v(dout0_44) AT=505.025n

* CHECK dout0_45 Vdout0_45ck100 = 0 time = 505
.meas tran vdout0_45ck100 FIND v(dout0_45) AT=505.025n

* CHECK dout0_46 Vdout0_46ck100 = 0.9 time = 505
.meas tran vdout0_46ck100 FIND v(dout0_46) AT=505.025n

* CHECK dout0_47 Vdout0_47ck100 = 0.9 time = 505
.meas tran vdout0_47ck100 FIND v(dout0_47) AT=505.025n

* CHECK dout0_48 Vdout0_48ck100 = 0.9 time = 505
.meas tran vdout0_48ck100 FIND v(dout0_48) AT=505.025n

* CHECK dout0_49 Vdout0_49ck100 = 0.9 time = 505
.meas tran vdout0_49ck100 FIND v(dout0_49) AT=505.025n

* CHECK dout0_50 Vdout0_50ck100 = 0.9 time = 505
.meas tran vdout0_50ck100 FIND v(dout0_50) AT=505.025n

* CHECK dout0_51 Vdout0_51ck100 = 0 time = 505
.meas tran vdout0_51ck100 FIND v(dout0_51) AT=505.025n

* CHECK dout0_52 Vdout0_52ck100 = 0.9 time = 505
.meas tran vdout0_52ck100 FIND v(dout0_52) AT=505.025n

* CHECK dout0_53 Vdout0_53ck100 = 0.9 time = 505
.meas tran vdout0_53ck100 FIND v(dout0_53) AT=505.025n

* CHECK dout0_54 Vdout0_54ck100 = 0.9 time = 505
.meas tran vdout0_54ck100 FIND v(dout0_54) AT=505.025n

* CHECK dout0_55 Vdout0_55ck100 = 0 time = 505
.meas tran vdout0_55ck100 FIND v(dout0_55) AT=505.025n

* CHECK dout0_56 Vdout0_56ck100 = 0 time = 505
.meas tran vdout0_56ck100 FIND v(dout0_56) AT=505.025n

* CHECK dout0_57 Vdout0_57ck100 = 0 time = 505
.meas tran vdout0_57ck100 FIND v(dout0_57) AT=505.025n

* CHECK dout0_58 Vdout0_58ck100 = 0 time = 505
.meas tran vdout0_58ck100 FIND v(dout0_58) AT=505.025n

* CHECK dout0_59 Vdout0_59ck100 = 0 time = 505
.meas tran vdout0_59ck100 FIND v(dout0_59) AT=505.025n

* CHECK dout0_60 Vdout0_60ck100 = 0.9 time = 505
.meas tran vdout0_60ck100 FIND v(dout0_60) AT=505.025n

* CHECK dout0_61 Vdout0_61ck100 = 0 time = 505
.meas tran vdout0_61ck100 FIND v(dout0_61) AT=505.025n

* CHECK dout0_62 Vdout0_62ck100 = 0 time = 505
.meas tran vdout0_62ck100 FIND v(dout0_62) AT=505.025n

* CHECK dout0_63 Vdout0_63ck100 = 0.9 time = 505
.meas tran vdout0_63ck100 FIND v(dout0_63) AT=505.025n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0.9 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0.9 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0.9 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0.9 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0.9 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 0 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 0.9 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0.9 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0.9 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0.9 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0.9 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 0.9 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0.9 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 0.9 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_32 Vdout0_32ck102 = 0.9 time = 515
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=515.025n

* CHECK dout0_33 Vdout0_33ck102 = 0 time = 515
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=515.025n

* CHECK dout0_34 Vdout0_34ck102 = 0.9 time = 515
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=515.025n

* CHECK dout0_35 Vdout0_35ck102 = 0 time = 515
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=515.025n

* CHECK dout0_36 Vdout0_36ck102 = 0 time = 515
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=515.025n

* CHECK dout0_37 Vdout0_37ck102 = 0.9 time = 515
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=515.025n

* CHECK dout0_38 Vdout0_38ck102 = 0 time = 515
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=515.025n

* CHECK dout0_39 Vdout0_39ck102 = 0 time = 515
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=515.025n

* CHECK dout0_40 Vdout0_40ck102 = 0.9 time = 515
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=515.025n

* CHECK dout0_41 Vdout0_41ck102 = 0.9 time = 515
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=515.025n

* CHECK dout0_42 Vdout0_42ck102 = 0 time = 515
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=515.025n

* CHECK dout0_43 Vdout0_43ck102 = 0.9 time = 515
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=515.025n

* CHECK dout0_44 Vdout0_44ck102 = 0 time = 515
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=515.025n

* CHECK dout0_45 Vdout0_45ck102 = 0 time = 515
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=515.025n

* CHECK dout0_46 Vdout0_46ck102 = 0.9 time = 515
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=515.025n

* CHECK dout0_47 Vdout0_47ck102 = 0.9 time = 515
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=515.025n

* CHECK dout0_48 Vdout0_48ck102 = 0.9 time = 515
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=515.025n

* CHECK dout0_49 Vdout0_49ck102 = 0.9 time = 515
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=515.025n

* CHECK dout0_50 Vdout0_50ck102 = 0.9 time = 515
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=515.025n

* CHECK dout0_51 Vdout0_51ck102 = 0 time = 515
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=515.025n

* CHECK dout0_52 Vdout0_52ck102 = 0.9 time = 515
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=515.025n

* CHECK dout0_53 Vdout0_53ck102 = 0.9 time = 515
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=515.025n

* CHECK dout0_54 Vdout0_54ck102 = 0.9 time = 515
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=515.025n

* CHECK dout0_55 Vdout0_55ck102 = 0 time = 515
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=515.025n

* CHECK dout0_56 Vdout0_56ck102 = 0 time = 515
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=515.025n

* CHECK dout0_57 Vdout0_57ck102 = 0 time = 515
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=515.025n

* CHECK dout0_58 Vdout0_58ck102 = 0 time = 515
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=515.025n

* CHECK dout0_59 Vdout0_59ck102 = 0 time = 515
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=515.025n

* CHECK dout0_60 Vdout0_60ck102 = 0.9 time = 515
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=515.025n

* CHECK dout0_61 Vdout0_61ck102 = 0 time = 515
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=515.025n

* CHECK dout0_62 Vdout0_62ck102 = 0 time = 515
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=515.025n

* CHECK dout0_63 Vdout0_63ck102 = 0.9 time = 515
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=515.025n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 520
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=520.025n

* CHECK dout0_1 Vdout0_1ck103 = 0.9 time = 520
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=520.025n

* CHECK dout0_2 Vdout0_2ck103 = 0 time = 520
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=520.025n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 520
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=520.025n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 520
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=520.025n

* CHECK dout0_5 Vdout0_5ck103 = 0.9 time = 520
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=520.025n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 520
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=520.025n

* CHECK dout0_7 Vdout0_7ck103 = 0.9 time = 520
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=520.025n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 520
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=520.025n

* CHECK dout0_9 Vdout0_9ck103 = 0.9 time = 520
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=520.025n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 520
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=520.025n

* CHECK dout0_11 Vdout0_11ck103 = 0.9 time = 520
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=520.025n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 520
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=520.025n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 520
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=520.025n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 520
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=520.025n

* CHECK dout0_15 Vdout0_15ck103 = 0 time = 520
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=520.025n

* CHECK dout0_16 Vdout0_16ck103 = 0.9 time = 520
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=520.025n

* CHECK dout0_17 Vdout0_17ck103 = 0 time = 520
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=520.025n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 520
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=520.025n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 520
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=520.025n

* CHECK dout0_20 Vdout0_20ck103 = 0.9 time = 520
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=520.025n

* CHECK dout0_21 Vdout0_21ck103 = 0.9 time = 520
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=520.025n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 520
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=520.025n

* CHECK dout0_23 Vdout0_23ck103 = 0.9 time = 520
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=520.025n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 520
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=520.025n

* CHECK dout0_25 Vdout0_25ck103 = 0.9 time = 520
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=520.025n

* CHECK dout0_26 Vdout0_26ck103 = 0.9 time = 520
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=520.025n

* CHECK dout0_27 Vdout0_27ck103 = 0.9 time = 520
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=520.025n

* CHECK dout0_28 Vdout0_28ck103 = 0 time = 520
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=520.025n

* CHECK dout0_29 Vdout0_29ck103 = 0.9 time = 520
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=520.025n

* CHECK dout0_30 Vdout0_30ck103 = 0 time = 520
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=520.025n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 520
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=520.025n

* CHECK dout0_32 Vdout0_32ck103 = 0.9 time = 520
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=520.025n

* CHECK dout0_33 Vdout0_33ck103 = 0 time = 520
.meas tran vdout0_33ck103 FIND v(dout0_33) AT=520.025n

* CHECK dout0_34 Vdout0_34ck103 = 0.9 time = 520
.meas tran vdout0_34ck103 FIND v(dout0_34) AT=520.025n

* CHECK dout0_35 Vdout0_35ck103 = 0 time = 520
.meas tran vdout0_35ck103 FIND v(dout0_35) AT=520.025n

* CHECK dout0_36 Vdout0_36ck103 = 0 time = 520
.meas tran vdout0_36ck103 FIND v(dout0_36) AT=520.025n

* CHECK dout0_37 Vdout0_37ck103 = 0.9 time = 520
.meas tran vdout0_37ck103 FIND v(dout0_37) AT=520.025n

* CHECK dout0_38 Vdout0_38ck103 = 0 time = 520
.meas tran vdout0_38ck103 FIND v(dout0_38) AT=520.025n

* CHECK dout0_39 Vdout0_39ck103 = 0 time = 520
.meas tran vdout0_39ck103 FIND v(dout0_39) AT=520.025n

* CHECK dout0_40 Vdout0_40ck103 = 0.9 time = 520
.meas tran vdout0_40ck103 FIND v(dout0_40) AT=520.025n

* CHECK dout0_41 Vdout0_41ck103 = 0.9 time = 520
.meas tran vdout0_41ck103 FIND v(dout0_41) AT=520.025n

* CHECK dout0_42 Vdout0_42ck103 = 0 time = 520
.meas tran vdout0_42ck103 FIND v(dout0_42) AT=520.025n

* CHECK dout0_43 Vdout0_43ck103 = 0.9 time = 520
.meas tran vdout0_43ck103 FIND v(dout0_43) AT=520.025n

* CHECK dout0_44 Vdout0_44ck103 = 0 time = 520
.meas tran vdout0_44ck103 FIND v(dout0_44) AT=520.025n

* CHECK dout0_45 Vdout0_45ck103 = 0 time = 520
.meas tran vdout0_45ck103 FIND v(dout0_45) AT=520.025n

* CHECK dout0_46 Vdout0_46ck103 = 0.9 time = 520
.meas tran vdout0_46ck103 FIND v(dout0_46) AT=520.025n

* CHECK dout0_47 Vdout0_47ck103 = 0.9 time = 520
.meas tran vdout0_47ck103 FIND v(dout0_47) AT=520.025n

* CHECK dout0_48 Vdout0_48ck103 = 0.9 time = 520
.meas tran vdout0_48ck103 FIND v(dout0_48) AT=520.025n

* CHECK dout0_49 Vdout0_49ck103 = 0.9 time = 520
.meas tran vdout0_49ck103 FIND v(dout0_49) AT=520.025n

* CHECK dout0_50 Vdout0_50ck103 = 0.9 time = 520
.meas tran vdout0_50ck103 FIND v(dout0_50) AT=520.025n

* CHECK dout0_51 Vdout0_51ck103 = 0 time = 520
.meas tran vdout0_51ck103 FIND v(dout0_51) AT=520.025n

* CHECK dout0_52 Vdout0_52ck103 = 0.9 time = 520
.meas tran vdout0_52ck103 FIND v(dout0_52) AT=520.025n

* CHECK dout0_53 Vdout0_53ck103 = 0.9 time = 520
.meas tran vdout0_53ck103 FIND v(dout0_53) AT=520.025n

* CHECK dout0_54 Vdout0_54ck103 = 0.9 time = 520
.meas tran vdout0_54ck103 FIND v(dout0_54) AT=520.025n

* CHECK dout0_55 Vdout0_55ck103 = 0 time = 520
.meas tran vdout0_55ck103 FIND v(dout0_55) AT=520.025n

* CHECK dout0_56 Vdout0_56ck103 = 0 time = 520
.meas tran vdout0_56ck103 FIND v(dout0_56) AT=520.025n

* CHECK dout0_57 Vdout0_57ck103 = 0 time = 520
.meas tran vdout0_57ck103 FIND v(dout0_57) AT=520.025n

* CHECK dout0_58 Vdout0_58ck103 = 0 time = 520
.meas tran vdout0_58ck103 FIND v(dout0_58) AT=520.025n

* CHECK dout0_59 Vdout0_59ck103 = 0 time = 520
.meas tran vdout0_59ck103 FIND v(dout0_59) AT=520.025n

* CHECK dout0_60 Vdout0_60ck103 = 0.9 time = 520
.meas tran vdout0_60ck103 FIND v(dout0_60) AT=520.025n

* CHECK dout0_61 Vdout0_61ck103 = 0 time = 520
.meas tran vdout0_61ck103 FIND v(dout0_61) AT=520.025n

* CHECK dout0_62 Vdout0_62ck103 = 0 time = 520
.meas tran vdout0_62ck103 FIND v(dout0_62) AT=520.025n

* CHECK dout0_63 Vdout0_63ck103 = 0.9 time = 520
.meas tran vdout0_63ck103 FIND v(dout0_63) AT=520.025n

* CHECK dout0_0 Vdout0_0ck104 = 0 time = 525
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=525.025n

* CHECK dout0_1 Vdout0_1ck104 = 0 time = 525
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=525.025n

* CHECK dout0_2 Vdout0_2ck104 = 0 time = 525
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=525.025n

* CHECK dout0_3 Vdout0_3ck104 = 0 time = 525
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=525.025n

* CHECK dout0_4 Vdout0_4ck104 = 0.9 time = 525
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=525.025n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 525
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=525.025n

* CHECK dout0_6 Vdout0_6ck104 = 0 time = 525
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=525.025n

* CHECK dout0_7 Vdout0_7ck104 = 0 time = 525
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=525.025n

* CHECK dout0_8 Vdout0_8ck104 = 0.9 time = 525
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=525.025n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 525
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=525.025n

* CHECK dout0_10 Vdout0_10ck104 = 0.9 time = 525
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=525.025n

* CHECK dout0_11 Vdout0_11ck104 = 0.9 time = 525
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=525.025n

* CHECK dout0_12 Vdout0_12ck104 = 0.9 time = 525
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=525.025n

* CHECK dout0_13 Vdout0_13ck104 = 0 time = 525
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=525.025n

* CHECK dout0_14 Vdout0_14ck104 = 0.9 time = 525
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=525.025n

* CHECK dout0_15 Vdout0_15ck104 = 0.9 time = 525
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=525.025n

* CHECK dout0_16 Vdout0_16ck104 = 0.9 time = 525
.meas tran vdout0_16ck104 FIND v(dout0_16) AT=525.025n

* CHECK dout0_17 Vdout0_17ck104 = 0 time = 525
.meas tran vdout0_17ck104 FIND v(dout0_17) AT=525.025n

* CHECK dout0_18 Vdout0_18ck104 = 0 time = 525
.meas tran vdout0_18ck104 FIND v(dout0_18) AT=525.025n

* CHECK dout0_19 Vdout0_19ck104 = 0 time = 525
.meas tran vdout0_19ck104 FIND v(dout0_19) AT=525.025n

* CHECK dout0_20 Vdout0_20ck104 = 0.9 time = 525
.meas tran vdout0_20ck104 FIND v(dout0_20) AT=525.025n

* CHECK dout0_21 Vdout0_21ck104 = 0.9 time = 525
.meas tran vdout0_21ck104 FIND v(dout0_21) AT=525.025n

* CHECK dout0_22 Vdout0_22ck104 = 0.9 time = 525
.meas tran vdout0_22ck104 FIND v(dout0_22) AT=525.025n

* CHECK dout0_23 Vdout0_23ck104 = 0 time = 525
.meas tran vdout0_23ck104 FIND v(dout0_23) AT=525.025n

* CHECK dout0_24 Vdout0_24ck104 = 0 time = 525
.meas tran vdout0_24ck104 FIND v(dout0_24) AT=525.025n

* CHECK dout0_25 Vdout0_25ck104 = 0.9 time = 525
.meas tran vdout0_25ck104 FIND v(dout0_25) AT=525.025n

* CHECK dout0_26 Vdout0_26ck104 = 0.9 time = 525
.meas tran vdout0_26ck104 FIND v(dout0_26) AT=525.025n

* CHECK dout0_27 Vdout0_27ck104 = 0.9 time = 525
.meas tran vdout0_27ck104 FIND v(dout0_27) AT=525.025n

* CHECK dout0_28 Vdout0_28ck104 = 0 time = 525
.meas tran vdout0_28ck104 FIND v(dout0_28) AT=525.025n

* CHECK dout0_29 Vdout0_29ck104 = 0 time = 525
.meas tran vdout0_29ck104 FIND v(dout0_29) AT=525.025n

* CHECK dout0_30 Vdout0_30ck104 = 0.9 time = 525
.meas tran vdout0_30ck104 FIND v(dout0_30) AT=525.025n

* CHECK dout0_31 Vdout0_31ck104 = 0 time = 525
.meas tran vdout0_31ck104 FIND v(dout0_31) AT=525.025n

* CHECK dout0_32 Vdout0_32ck104 = 0.9 time = 525
.meas tran vdout0_32ck104 FIND v(dout0_32) AT=525.025n

* CHECK dout0_33 Vdout0_33ck104 = 0 time = 525
.meas tran vdout0_33ck104 FIND v(dout0_33) AT=525.025n

* CHECK dout0_34 Vdout0_34ck104 = 0 time = 525
.meas tran vdout0_34ck104 FIND v(dout0_34) AT=525.025n

* CHECK dout0_35 Vdout0_35ck104 = 0 time = 525
.meas tran vdout0_35ck104 FIND v(dout0_35) AT=525.025n

* CHECK dout0_36 Vdout0_36ck104 = 0 time = 525
.meas tran vdout0_36ck104 FIND v(dout0_36) AT=525.025n

* CHECK dout0_37 Vdout0_37ck104 = 0 time = 525
.meas tran vdout0_37ck104 FIND v(dout0_37) AT=525.025n

* CHECK dout0_38 Vdout0_38ck104 = 0 time = 525
.meas tran vdout0_38ck104 FIND v(dout0_38) AT=525.025n

* CHECK dout0_39 Vdout0_39ck104 = 0 time = 525
.meas tran vdout0_39ck104 FIND v(dout0_39) AT=525.025n

* CHECK dout0_40 Vdout0_40ck104 = 0 time = 525
.meas tran vdout0_40ck104 FIND v(dout0_40) AT=525.025n

* CHECK dout0_41 Vdout0_41ck104 = 0 time = 525
.meas tran vdout0_41ck104 FIND v(dout0_41) AT=525.025n

* CHECK dout0_42 Vdout0_42ck104 = 0 time = 525
.meas tran vdout0_42ck104 FIND v(dout0_42) AT=525.025n

* CHECK dout0_43 Vdout0_43ck104 = 0.9 time = 525
.meas tran vdout0_43ck104 FIND v(dout0_43) AT=525.025n

* CHECK dout0_44 Vdout0_44ck104 = 0 time = 525
.meas tran vdout0_44ck104 FIND v(dout0_44) AT=525.025n

* CHECK dout0_45 Vdout0_45ck104 = 0 time = 525
.meas tran vdout0_45ck104 FIND v(dout0_45) AT=525.025n

* CHECK dout0_46 Vdout0_46ck104 = 0 time = 525
.meas tran vdout0_46ck104 FIND v(dout0_46) AT=525.025n

* CHECK dout0_47 Vdout0_47ck104 = 0 time = 525
.meas tran vdout0_47ck104 FIND v(dout0_47) AT=525.025n

* CHECK dout0_48 Vdout0_48ck104 = 0.9 time = 525
.meas tran vdout0_48ck104 FIND v(dout0_48) AT=525.025n

* CHECK dout0_49 Vdout0_49ck104 = 0 time = 525
.meas tran vdout0_49ck104 FIND v(dout0_49) AT=525.025n

* CHECK dout0_50 Vdout0_50ck104 = 0 time = 525
.meas tran vdout0_50ck104 FIND v(dout0_50) AT=525.025n

* CHECK dout0_51 Vdout0_51ck104 = 0 time = 525
.meas tran vdout0_51ck104 FIND v(dout0_51) AT=525.025n

* CHECK dout0_52 Vdout0_52ck104 = 0.9 time = 525
.meas tran vdout0_52ck104 FIND v(dout0_52) AT=525.025n

* CHECK dout0_53 Vdout0_53ck104 = 0 time = 525
.meas tran vdout0_53ck104 FIND v(dout0_53) AT=525.025n

* CHECK dout0_54 Vdout0_54ck104 = 0 time = 525
.meas tran vdout0_54ck104 FIND v(dout0_54) AT=525.025n

* CHECK dout0_55 Vdout0_55ck104 = 0 time = 525
.meas tran vdout0_55ck104 FIND v(dout0_55) AT=525.025n

* CHECK dout0_56 Vdout0_56ck104 = 0 time = 525
.meas tran vdout0_56ck104 FIND v(dout0_56) AT=525.025n

* CHECK dout0_57 Vdout0_57ck104 = 0.9 time = 525
.meas tran vdout0_57ck104 FIND v(dout0_57) AT=525.025n

* CHECK dout0_58 Vdout0_58ck104 = 0.9 time = 525
.meas tran vdout0_58ck104 FIND v(dout0_58) AT=525.025n

* CHECK dout0_59 Vdout0_59ck104 = 0 time = 525
.meas tran vdout0_59ck104 FIND v(dout0_59) AT=525.025n

* CHECK dout0_60 Vdout0_60ck104 = 0.9 time = 525
.meas tran vdout0_60ck104 FIND v(dout0_60) AT=525.025n

* CHECK dout0_61 Vdout0_61ck104 = 0.9 time = 525
.meas tran vdout0_61ck104 FIND v(dout0_61) AT=525.025n

* CHECK dout0_62 Vdout0_62ck104 = 0 time = 525
.meas tran vdout0_62ck104 FIND v(dout0_62) AT=525.025n

* CHECK dout0_63 Vdout0_63ck104 = 0 time = 525
.meas tran vdout0_63ck104 FIND v(dout0_63) AT=525.025n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 530
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=530.025n

* CHECK dout0_1 Vdout0_1ck105 = 0.9 time = 530
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=530.025n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 530
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=530.025n

* CHECK dout0_3 Vdout0_3ck105 = 0 time = 530
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=530.025n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 530
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=530.025n

* CHECK dout0_5 Vdout0_5ck105 = 0.9 time = 530
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=530.025n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 530
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=530.025n

* CHECK dout0_7 Vdout0_7ck105 = 0.9 time = 530
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=530.025n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 530
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=530.025n

* CHECK dout0_9 Vdout0_9ck105 = 0.9 time = 530
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=530.025n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 530
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=530.025n

* CHECK dout0_11 Vdout0_11ck105 = 0.9 time = 530
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=530.025n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 530
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=530.025n

* CHECK dout0_13 Vdout0_13ck105 = 0 time = 530
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=530.025n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 530
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=530.025n

* CHECK dout0_15 Vdout0_15ck105 = 0 time = 530
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=530.025n

* CHECK dout0_16 Vdout0_16ck105 = 0.9 time = 530
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=530.025n

* CHECK dout0_17 Vdout0_17ck105 = 0 time = 530
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=530.025n

* CHECK dout0_18 Vdout0_18ck105 = 0 time = 530
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=530.025n

* CHECK dout0_19 Vdout0_19ck105 = 0 time = 530
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=530.025n

* CHECK dout0_20 Vdout0_20ck105 = 0.9 time = 530
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=530.025n

* CHECK dout0_21 Vdout0_21ck105 = 0.9 time = 530
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=530.025n

* CHECK dout0_22 Vdout0_22ck105 = 0 time = 530
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=530.025n

* CHECK dout0_23 Vdout0_23ck105 = 0.9 time = 530
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=530.025n

* CHECK dout0_24 Vdout0_24ck105 = 0 time = 530
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=530.025n

* CHECK dout0_25 Vdout0_25ck105 = 0.9 time = 530
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=530.025n

* CHECK dout0_26 Vdout0_26ck105 = 0.9 time = 530
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=530.025n

* CHECK dout0_27 Vdout0_27ck105 = 0.9 time = 530
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=530.025n

* CHECK dout0_28 Vdout0_28ck105 = 0 time = 530
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=530.025n

* CHECK dout0_29 Vdout0_29ck105 = 0.9 time = 530
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=530.025n

* CHECK dout0_30 Vdout0_30ck105 = 0 time = 530
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=530.025n

* CHECK dout0_31 Vdout0_31ck105 = 0 time = 530
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=530.025n

* CHECK dout0_32 Vdout0_32ck105 = 0.9 time = 530
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=530.025n

* CHECK dout0_33 Vdout0_33ck105 = 0 time = 530
.meas tran vdout0_33ck105 FIND v(dout0_33) AT=530.025n

* CHECK dout0_34 Vdout0_34ck105 = 0.9 time = 530
.meas tran vdout0_34ck105 FIND v(dout0_34) AT=530.025n

* CHECK dout0_35 Vdout0_35ck105 = 0 time = 530
.meas tran vdout0_35ck105 FIND v(dout0_35) AT=530.025n

* CHECK dout0_36 Vdout0_36ck105 = 0 time = 530
.meas tran vdout0_36ck105 FIND v(dout0_36) AT=530.025n

* CHECK dout0_37 Vdout0_37ck105 = 0.9 time = 530
.meas tran vdout0_37ck105 FIND v(dout0_37) AT=530.025n

* CHECK dout0_38 Vdout0_38ck105 = 0 time = 530
.meas tran vdout0_38ck105 FIND v(dout0_38) AT=530.025n

* CHECK dout0_39 Vdout0_39ck105 = 0 time = 530
.meas tran vdout0_39ck105 FIND v(dout0_39) AT=530.025n

* CHECK dout0_40 Vdout0_40ck105 = 0.9 time = 530
.meas tran vdout0_40ck105 FIND v(dout0_40) AT=530.025n

* CHECK dout0_41 Vdout0_41ck105 = 0.9 time = 530
.meas tran vdout0_41ck105 FIND v(dout0_41) AT=530.025n

* CHECK dout0_42 Vdout0_42ck105 = 0 time = 530
.meas tran vdout0_42ck105 FIND v(dout0_42) AT=530.025n

* CHECK dout0_43 Vdout0_43ck105 = 0.9 time = 530
.meas tran vdout0_43ck105 FIND v(dout0_43) AT=530.025n

* CHECK dout0_44 Vdout0_44ck105 = 0 time = 530
.meas tran vdout0_44ck105 FIND v(dout0_44) AT=530.025n

* CHECK dout0_45 Vdout0_45ck105 = 0 time = 530
.meas tran vdout0_45ck105 FIND v(dout0_45) AT=530.025n

* CHECK dout0_46 Vdout0_46ck105 = 0.9 time = 530
.meas tran vdout0_46ck105 FIND v(dout0_46) AT=530.025n

* CHECK dout0_47 Vdout0_47ck105 = 0.9 time = 530
.meas tran vdout0_47ck105 FIND v(dout0_47) AT=530.025n

* CHECK dout0_48 Vdout0_48ck105 = 0.9 time = 530
.meas tran vdout0_48ck105 FIND v(dout0_48) AT=530.025n

* CHECK dout0_49 Vdout0_49ck105 = 0.9 time = 530
.meas tran vdout0_49ck105 FIND v(dout0_49) AT=530.025n

* CHECK dout0_50 Vdout0_50ck105 = 0.9 time = 530
.meas tran vdout0_50ck105 FIND v(dout0_50) AT=530.025n

* CHECK dout0_51 Vdout0_51ck105 = 0 time = 530
.meas tran vdout0_51ck105 FIND v(dout0_51) AT=530.025n

* CHECK dout0_52 Vdout0_52ck105 = 0.9 time = 530
.meas tran vdout0_52ck105 FIND v(dout0_52) AT=530.025n

* CHECK dout0_53 Vdout0_53ck105 = 0.9 time = 530
.meas tran vdout0_53ck105 FIND v(dout0_53) AT=530.025n

* CHECK dout0_54 Vdout0_54ck105 = 0.9 time = 530
.meas tran vdout0_54ck105 FIND v(dout0_54) AT=530.025n

* CHECK dout0_55 Vdout0_55ck105 = 0 time = 530
.meas tran vdout0_55ck105 FIND v(dout0_55) AT=530.025n

* CHECK dout0_56 Vdout0_56ck105 = 0 time = 530
.meas tran vdout0_56ck105 FIND v(dout0_56) AT=530.025n

* CHECK dout0_57 Vdout0_57ck105 = 0 time = 530
.meas tran vdout0_57ck105 FIND v(dout0_57) AT=530.025n

* CHECK dout0_58 Vdout0_58ck105 = 0 time = 530
.meas tran vdout0_58ck105 FIND v(dout0_58) AT=530.025n

* CHECK dout0_59 Vdout0_59ck105 = 0 time = 530
.meas tran vdout0_59ck105 FIND v(dout0_59) AT=530.025n

* CHECK dout0_60 Vdout0_60ck105 = 0.9 time = 530
.meas tran vdout0_60ck105 FIND v(dout0_60) AT=530.025n

* CHECK dout0_61 Vdout0_61ck105 = 0 time = 530
.meas tran vdout0_61ck105 FIND v(dout0_61) AT=530.025n

* CHECK dout0_62 Vdout0_62ck105 = 0 time = 530
.meas tran vdout0_62ck105 FIND v(dout0_62) AT=530.025n

* CHECK dout0_63 Vdout0_63ck105 = 0.9 time = 530
.meas tran vdout0_63ck105 FIND v(dout0_63) AT=530.025n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0.9 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0.9 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 0.9 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0.9 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 0.9 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 0.9 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0.9 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 0.9 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 0 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0.9 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0.9 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0.9 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 0.9 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0.9 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0.9 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0.9 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_32 Vdout0_32ck106 = 0.9 time = 535
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=535.025n

* CHECK dout0_33 Vdout0_33ck106 = 0 time = 535
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=535.025n

* CHECK dout0_34 Vdout0_34ck106 = 0 time = 535
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=535.025n

* CHECK dout0_35 Vdout0_35ck106 = 0 time = 535
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=535.025n

* CHECK dout0_36 Vdout0_36ck106 = 0 time = 535
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=535.025n

* CHECK dout0_37 Vdout0_37ck106 = 0 time = 535
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=535.025n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 535
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=535.025n

* CHECK dout0_39 Vdout0_39ck106 = 0 time = 535
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=535.025n

* CHECK dout0_40 Vdout0_40ck106 = 0 time = 535
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=535.025n

* CHECK dout0_41 Vdout0_41ck106 = 0 time = 535
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=535.025n

* CHECK dout0_42 Vdout0_42ck106 = 0 time = 535
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=535.025n

* CHECK dout0_43 Vdout0_43ck106 = 0.9 time = 535
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=535.025n

* CHECK dout0_44 Vdout0_44ck106 = 0 time = 535
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=535.025n

* CHECK dout0_45 Vdout0_45ck106 = 0 time = 535
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=535.025n

* CHECK dout0_46 Vdout0_46ck106 = 0 time = 535
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=535.025n

* CHECK dout0_47 Vdout0_47ck106 = 0 time = 535
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=535.025n

* CHECK dout0_48 Vdout0_48ck106 = 0.9 time = 535
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=535.025n

* CHECK dout0_49 Vdout0_49ck106 = 0 time = 535
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=535.025n

* CHECK dout0_50 Vdout0_50ck106 = 0 time = 535
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=535.025n

* CHECK dout0_51 Vdout0_51ck106 = 0 time = 535
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=535.025n

* CHECK dout0_52 Vdout0_52ck106 = 0.9 time = 535
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=535.025n

* CHECK dout0_53 Vdout0_53ck106 = 0 time = 535
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=535.025n

* CHECK dout0_54 Vdout0_54ck106 = 0 time = 535
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=535.025n

* CHECK dout0_55 Vdout0_55ck106 = 0 time = 535
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=535.025n

* CHECK dout0_56 Vdout0_56ck106 = 0 time = 535
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=535.025n

* CHECK dout0_57 Vdout0_57ck106 = 0.9 time = 535
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=535.025n

* CHECK dout0_58 Vdout0_58ck106 = 0.9 time = 535
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=535.025n

* CHECK dout0_59 Vdout0_59ck106 = 0 time = 535
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=535.025n

* CHECK dout0_60 Vdout0_60ck106 = 0.9 time = 535
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=535.025n

* CHECK dout0_61 Vdout0_61ck106 = 0.9 time = 535
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=535.025n

* CHECK dout0_62 Vdout0_62ck106 = 0 time = 535
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=535.025n

* CHECK dout0_63 Vdout0_63ck106 = 0 time = 535
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=535.025n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 545
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=545.025n

* CHECK dout0_1 Vdout0_1ck108 = 0.9 time = 545
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=545.025n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 545
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=545.025n

* CHECK dout0_3 Vdout0_3ck108 = 0 time = 545
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=545.025n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 545
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=545.025n

* CHECK dout0_5 Vdout0_5ck108 = 0.9 time = 545
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=545.025n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 545
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=545.025n

* CHECK dout0_7 Vdout0_7ck108 = 0.9 time = 545
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=545.025n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 545
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=545.025n

* CHECK dout0_9 Vdout0_9ck108 = 0.9 time = 545
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=545.025n

* CHECK dout0_10 Vdout0_10ck108 = 0 time = 545
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=545.025n

* CHECK dout0_11 Vdout0_11ck108 = 0.9 time = 545
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=545.025n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 545
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=545.025n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 545
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=545.025n

* CHECK dout0_14 Vdout0_14ck108 = 0 time = 545
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=545.025n

* CHECK dout0_15 Vdout0_15ck108 = 0 time = 545
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=545.025n

* CHECK dout0_16 Vdout0_16ck108 = 0.9 time = 545
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=545.025n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 545
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=545.025n

* CHECK dout0_18 Vdout0_18ck108 = 0 time = 545
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=545.025n

* CHECK dout0_19 Vdout0_19ck108 = 0 time = 545
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=545.025n

* CHECK dout0_20 Vdout0_20ck108 = 0.9 time = 545
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=545.025n

* CHECK dout0_21 Vdout0_21ck108 = 0.9 time = 545
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=545.025n

* CHECK dout0_22 Vdout0_22ck108 = 0 time = 545
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=545.025n

* CHECK dout0_23 Vdout0_23ck108 = 0.9 time = 545
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=545.025n

* CHECK dout0_24 Vdout0_24ck108 = 0 time = 545
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=545.025n

* CHECK dout0_25 Vdout0_25ck108 = 0.9 time = 545
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=545.025n

* CHECK dout0_26 Vdout0_26ck108 = 0.9 time = 545
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=545.025n

* CHECK dout0_27 Vdout0_27ck108 = 0.9 time = 545
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=545.025n

* CHECK dout0_28 Vdout0_28ck108 = 0 time = 545
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=545.025n

* CHECK dout0_29 Vdout0_29ck108 = 0.9 time = 545
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=545.025n

* CHECK dout0_30 Vdout0_30ck108 = 0 time = 545
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=545.025n

* CHECK dout0_31 Vdout0_31ck108 = 0 time = 545
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=545.025n

* CHECK dout0_32 Vdout0_32ck108 = 0.9 time = 545
.meas tran vdout0_32ck108 FIND v(dout0_32) AT=545.025n

* CHECK dout0_33 Vdout0_33ck108 = 0 time = 545
.meas tran vdout0_33ck108 FIND v(dout0_33) AT=545.025n

* CHECK dout0_34 Vdout0_34ck108 = 0.9 time = 545
.meas tran vdout0_34ck108 FIND v(dout0_34) AT=545.025n

* CHECK dout0_35 Vdout0_35ck108 = 0 time = 545
.meas tran vdout0_35ck108 FIND v(dout0_35) AT=545.025n

* CHECK dout0_36 Vdout0_36ck108 = 0 time = 545
.meas tran vdout0_36ck108 FIND v(dout0_36) AT=545.025n

* CHECK dout0_37 Vdout0_37ck108 = 0.9 time = 545
.meas tran vdout0_37ck108 FIND v(dout0_37) AT=545.025n

* CHECK dout0_38 Vdout0_38ck108 = 0 time = 545
.meas tran vdout0_38ck108 FIND v(dout0_38) AT=545.025n

* CHECK dout0_39 Vdout0_39ck108 = 0 time = 545
.meas tran vdout0_39ck108 FIND v(dout0_39) AT=545.025n

* CHECK dout0_40 Vdout0_40ck108 = 0.9 time = 545
.meas tran vdout0_40ck108 FIND v(dout0_40) AT=545.025n

* CHECK dout0_41 Vdout0_41ck108 = 0.9 time = 545
.meas tran vdout0_41ck108 FIND v(dout0_41) AT=545.025n

* CHECK dout0_42 Vdout0_42ck108 = 0 time = 545
.meas tran vdout0_42ck108 FIND v(dout0_42) AT=545.025n

* CHECK dout0_43 Vdout0_43ck108 = 0.9 time = 545
.meas tran vdout0_43ck108 FIND v(dout0_43) AT=545.025n

* CHECK dout0_44 Vdout0_44ck108 = 0 time = 545
.meas tran vdout0_44ck108 FIND v(dout0_44) AT=545.025n

* CHECK dout0_45 Vdout0_45ck108 = 0 time = 545
.meas tran vdout0_45ck108 FIND v(dout0_45) AT=545.025n

* CHECK dout0_46 Vdout0_46ck108 = 0.9 time = 545
.meas tran vdout0_46ck108 FIND v(dout0_46) AT=545.025n

* CHECK dout0_47 Vdout0_47ck108 = 0.9 time = 545
.meas tran vdout0_47ck108 FIND v(dout0_47) AT=545.025n

* CHECK dout0_48 Vdout0_48ck108 = 0.9 time = 545
.meas tran vdout0_48ck108 FIND v(dout0_48) AT=545.025n

* CHECK dout0_49 Vdout0_49ck108 = 0.9 time = 545
.meas tran vdout0_49ck108 FIND v(dout0_49) AT=545.025n

* CHECK dout0_50 Vdout0_50ck108 = 0.9 time = 545
.meas tran vdout0_50ck108 FIND v(dout0_50) AT=545.025n

* CHECK dout0_51 Vdout0_51ck108 = 0 time = 545
.meas tran vdout0_51ck108 FIND v(dout0_51) AT=545.025n

* CHECK dout0_52 Vdout0_52ck108 = 0.9 time = 545
.meas tran vdout0_52ck108 FIND v(dout0_52) AT=545.025n

* CHECK dout0_53 Vdout0_53ck108 = 0.9 time = 545
.meas tran vdout0_53ck108 FIND v(dout0_53) AT=545.025n

* CHECK dout0_54 Vdout0_54ck108 = 0.9 time = 545
.meas tran vdout0_54ck108 FIND v(dout0_54) AT=545.025n

* CHECK dout0_55 Vdout0_55ck108 = 0 time = 545
.meas tran vdout0_55ck108 FIND v(dout0_55) AT=545.025n

* CHECK dout0_56 Vdout0_56ck108 = 0 time = 545
.meas tran vdout0_56ck108 FIND v(dout0_56) AT=545.025n

* CHECK dout0_57 Vdout0_57ck108 = 0 time = 545
.meas tran vdout0_57ck108 FIND v(dout0_57) AT=545.025n

* CHECK dout0_58 Vdout0_58ck108 = 0 time = 545
.meas tran vdout0_58ck108 FIND v(dout0_58) AT=545.025n

* CHECK dout0_59 Vdout0_59ck108 = 0 time = 545
.meas tran vdout0_59ck108 FIND v(dout0_59) AT=545.025n

* CHECK dout0_60 Vdout0_60ck108 = 0.9 time = 545
.meas tran vdout0_60ck108 FIND v(dout0_60) AT=545.025n

* CHECK dout0_61 Vdout0_61ck108 = 0 time = 545
.meas tran vdout0_61ck108 FIND v(dout0_61) AT=545.025n

* CHECK dout0_62 Vdout0_62ck108 = 0 time = 545
.meas tran vdout0_62ck108 FIND v(dout0_62) AT=545.025n

* CHECK dout0_63 Vdout0_63ck108 = 0.9 time = 545
.meas tran vdout0_63ck108 FIND v(dout0_63) AT=545.025n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 555
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=555.025n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 555
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=555.025n

* CHECK dout0_2 Vdout0_2ck110 = 0 time = 555
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=555.025n

* CHECK dout0_3 Vdout0_3ck110 = 0 time = 555
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=555.025n

* CHECK dout0_4 Vdout0_4ck110 = 0.9 time = 555
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=555.025n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 555
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=555.025n

* CHECK dout0_6 Vdout0_6ck110 = 0 time = 555
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=555.025n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 555
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=555.025n

* CHECK dout0_8 Vdout0_8ck110 = 0.9 time = 555
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=555.025n

* CHECK dout0_9 Vdout0_9ck110 = 0 time = 555
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=555.025n

* CHECK dout0_10 Vdout0_10ck110 = 0.9 time = 555
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=555.025n

* CHECK dout0_11 Vdout0_11ck110 = 0.9 time = 555
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=555.025n

* CHECK dout0_12 Vdout0_12ck110 = 0.9 time = 555
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=555.025n

* CHECK dout0_13 Vdout0_13ck110 = 0 time = 555
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=555.025n

* CHECK dout0_14 Vdout0_14ck110 = 0.9 time = 555
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=555.025n

* CHECK dout0_15 Vdout0_15ck110 = 0.9 time = 555
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=555.025n

* CHECK dout0_16 Vdout0_16ck110 = 0.9 time = 555
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=555.025n

* CHECK dout0_17 Vdout0_17ck110 = 0 time = 555
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=555.025n

* CHECK dout0_18 Vdout0_18ck110 = 0 time = 555
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=555.025n

* CHECK dout0_19 Vdout0_19ck110 = 0 time = 555
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=555.025n

* CHECK dout0_20 Vdout0_20ck110 = 0.9 time = 555
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=555.025n

* CHECK dout0_21 Vdout0_21ck110 = 0.9 time = 555
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=555.025n

* CHECK dout0_22 Vdout0_22ck110 = 0.9 time = 555
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=555.025n

* CHECK dout0_23 Vdout0_23ck110 = 0 time = 555
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=555.025n

* CHECK dout0_24 Vdout0_24ck110 = 0 time = 555
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=555.025n

* CHECK dout0_25 Vdout0_25ck110 = 0.9 time = 555
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=555.025n

* CHECK dout0_26 Vdout0_26ck110 = 0.9 time = 555
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=555.025n

* CHECK dout0_27 Vdout0_27ck110 = 0.9 time = 555
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=555.025n

* CHECK dout0_28 Vdout0_28ck110 = 0 time = 555
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=555.025n

* CHECK dout0_29 Vdout0_29ck110 = 0 time = 555
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=555.025n

* CHECK dout0_30 Vdout0_30ck110 = 0.9 time = 555
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=555.025n

* CHECK dout0_31 Vdout0_31ck110 = 0 time = 555
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=555.025n

* CHECK dout0_32 Vdout0_32ck110 = 0.9 time = 555
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=555.025n

* CHECK dout0_33 Vdout0_33ck110 = 0 time = 555
.meas tran vdout0_33ck110 FIND v(dout0_33) AT=555.025n

* CHECK dout0_34 Vdout0_34ck110 = 0 time = 555
.meas tran vdout0_34ck110 FIND v(dout0_34) AT=555.025n

* CHECK dout0_35 Vdout0_35ck110 = 0 time = 555
.meas tran vdout0_35ck110 FIND v(dout0_35) AT=555.025n

* CHECK dout0_36 Vdout0_36ck110 = 0 time = 555
.meas tran vdout0_36ck110 FIND v(dout0_36) AT=555.025n

* CHECK dout0_37 Vdout0_37ck110 = 0 time = 555
.meas tran vdout0_37ck110 FIND v(dout0_37) AT=555.025n

* CHECK dout0_38 Vdout0_38ck110 = 0 time = 555
.meas tran vdout0_38ck110 FIND v(dout0_38) AT=555.025n

* CHECK dout0_39 Vdout0_39ck110 = 0 time = 555
.meas tran vdout0_39ck110 FIND v(dout0_39) AT=555.025n

* CHECK dout0_40 Vdout0_40ck110 = 0 time = 555
.meas tran vdout0_40ck110 FIND v(dout0_40) AT=555.025n

* CHECK dout0_41 Vdout0_41ck110 = 0 time = 555
.meas tran vdout0_41ck110 FIND v(dout0_41) AT=555.025n

* CHECK dout0_42 Vdout0_42ck110 = 0 time = 555
.meas tran vdout0_42ck110 FIND v(dout0_42) AT=555.025n

* CHECK dout0_43 Vdout0_43ck110 = 0.9 time = 555
.meas tran vdout0_43ck110 FIND v(dout0_43) AT=555.025n

* CHECK dout0_44 Vdout0_44ck110 = 0 time = 555
.meas tran vdout0_44ck110 FIND v(dout0_44) AT=555.025n

* CHECK dout0_45 Vdout0_45ck110 = 0 time = 555
.meas tran vdout0_45ck110 FIND v(dout0_45) AT=555.025n

* CHECK dout0_46 Vdout0_46ck110 = 0 time = 555
.meas tran vdout0_46ck110 FIND v(dout0_46) AT=555.025n

* CHECK dout0_47 Vdout0_47ck110 = 0 time = 555
.meas tran vdout0_47ck110 FIND v(dout0_47) AT=555.025n

* CHECK dout0_48 Vdout0_48ck110 = 0.9 time = 555
.meas tran vdout0_48ck110 FIND v(dout0_48) AT=555.025n

* CHECK dout0_49 Vdout0_49ck110 = 0 time = 555
.meas tran vdout0_49ck110 FIND v(dout0_49) AT=555.025n

* CHECK dout0_50 Vdout0_50ck110 = 0 time = 555
.meas tran vdout0_50ck110 FIND v(dout0_50) AT=555.025n

* CHECK dout0_51 Vdout0_51ck110 = 0 time = 555
.meas tran vdout0_51ck110 FIND v(dout0_51) AT=555.025n

* CHECK dout0_52 Vdout0_52ck110 = 0.9 time = 555
.meas tran vdout0_52ck110 FIND v(dout0_52) AT=555.025n

* CHECK dout0_53 Vdout0_53ck110 = 0 time = 555
.meas tran vdout0_53ck110 FIND v(dout0_53) AT=555.025n

* CHECK dout0_54 Vdout0_54ck110 = 0 time = 555
.meas tran vdout0_54ck110 FIND v(dout0_54) AT=555.025n

* CHECK dout0_55 Vdout0_55ck110 = 0 time = 555
.meas tran vdout0_55ck110 FIND v(dout0_55) AT=555.025n

* CHECK dout0_56 Vdout0_56ck110 = 0 time = 555
.meas tran vdout0_56ck110 FIND v(dout0_56) AT=555.025n

* CHECK dout0_57 Vdout0_57ck110 = 0.9 time = 555
.meas tran vdout0_57ck110 FIND v(dout0_57) AT=555.025n

* CHECK dout0_58 Vdout0_58ck110 = 0.9 time = 555
.meas tran vdout0_58ck110 FIND v(dout0_58) AT=555.025n

* CHECK dout0_59 Vdout0_59ck110 = 0 time = 555
.meas tran vdout0_59ck110 FIND v(dout0_59) AT=555.025n

* CHECK dout0_60 Vdout0_60ck110 = 0.9 time = 555
.meas tran vdout0_60ck110 FIND v(dout0_60) AT=555.025n

* CHECK dout0_61 Vdout0_61ck110 = 0.9 time = 555
.meas tran vdout0_61ck110 FIND v(dout0_61) AT=555.025n

* CHECK dout0_62 Vdout0_62ck110 = 0 time = 555
.meas tran vdout0_62ck110 FIND v(dout0_62) AT=555.025n

* CHECK dout0_63 Vdout0_63ck110 = 0 time = 555
.meas tran vdout0_63ck110 FIND v(dout0_63) AT=555.025n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 0.9 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 0.9 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0.9 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 0.9 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 0.9 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 0.9 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 0.9 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 0 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 0.9 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 0 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 0.9 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 0 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 0.9 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0.9 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0.9 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 0.9 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 0.9 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0.9 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 0.9 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 0.9 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 0.9 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 0.9 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 0.9 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 0 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_32 Vdout0_32ck113 = 0.9 time = 570
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=570.025n

* CHECK dout0_33 Vdout0_33ck113 = 0.9 time = 570
.meas tran vdout0_33ck113 FIND v(dout0_33) AT=570.025n

* CHECK dout0_34 Vdout0_34ck113 = 0 time = 570
.meas tran vdout0_34ck113 FIND v(dout0_34) AT=570.025n

* CHECK dout0_35 Vdout0_35ck113 = 0.9 time = 570
.meas tran vdout0_35ck113 FIND v(dout0_35) AT=570.025n

* CHECK dout0_36 Vdout0_36ck113 = 0.9 time = 570
.meas tran vdout0_36ck113 FIND v(dout0_36) AT=570.025n

* CHECK dout0_37 Vdout0_37ck113 = 0.9 time = 570
.meas tran vdout0_37ck113 FIND v(dout0_37) AT=570.025n

* CHECK dout0_38 Vdout0_38ck113 = 0.9 time = 570
.meas tran vdout0_38ck113 FIND v(dout0_38) AT=570.025n

* CHECK dout0_39 Vdout0_39ck113 = 0 time = 570
.meas tran vdout0_39ck113 FIND v(dout0_39) AT=570.025n

* CHECK dout0_40 Vdout0_40ck113 = 0 time = 570
.meas tran vdout0_40ck113 FIND v(dout0_40) AT=570.025n

* CHECK dout0_41 Vdout0_41ck113 = 0 time = 570
.meas tran vdout0_41ck113 FIND v(dout0_41) AT=570.025n

* CHECK dout0_42 Vdout0_42ck113 = 0 time = 570
.meas tran vdout0_42ck113 FIND v(dout0_42) AT=570.025n

* CHECK dout0_43 Vdout0_43ck113 = 0 time = 570
.meas tran vdout0_43ck113 FIND v(dout0_43) AT=570.025n

* CHECK dout0_44 Vdout0_44ck113 = 0 time = 570
.meas tran vdout0_44ck113 FIND v(dout0_44) AT=570.025n

* CHECK dout0_45 Vdout0_45ck113 = 0 time = 570
.meas tran vdout0_45ck113 FIND v(dout0_45) AT=570.025n

* CHECK dout0_46 Vdout0_46ck113 = 0.9 time = 570
.meas tran vdout0_46ck113 FIND v(dout0_46) AT=570.025n

* CHECK dout0_47 Vdout0_47ck113 = 0 time = 570
.meas tran vdout0_47ck113 FIND v(dout0_47) AT=570.025n

* CHECK dout0_48 Vdout0_48ck113 = 0 time = 570
.meas tran vdout0_48ck113 FIND v(dout0_48) AT=570.025n

* CHECK dout0_49 Vdout0_49ck113 = 0 time = 570
.meas tran vdout0_49ck113 FIND v(dout0_49) AT=570.025n

* CHECK dout0_50 Vdout0_50ck113 = 0.9 time = 570
.meas tran vdout0_50ck113 FIND v(dout0_50) AT=570.025n

* CHECK dout0_51 Vdout0_51ck113 = 0 time = 570
.meas tran vdout0_51ck113 FIND v(dout0_51) AT=570.025n

* CHECK dout0_52 Vdout0_52ck113 = 0.9 time = 570
.meas tran vdout0_52ck113 FIND v(dout0_52) AT=570.025n

* CHECK dout0_53 Vdout0_53ck113 = 0 time = 570
.meas tran vdout0_53ck113 FIND v(dout0_53) AT=570.025n

* CHECK dout0_54 Vdout0_54ck113 = 0.9 time = 570
.meas tran vdout0_54ck113 FIND v(dout0_54) AT=570.025n

* CHECK dout0_55 Vdout0_55ck113 = 0.9 time = 570
.meas tran vdout0_55ck113 FIND v(dout0_55) AT=570.025n

* CHECK dout0_56 Vdout0_56ck113 = 0.9 time = 570
.meas tran vdout0_56ck113 FIND v(dout0_56) AT=570.025n

* CHECK dout0_57 Vdout0_57ck113 = 0.9 time = 570
.meas tran vdout0_57ck113 FIND v(dout0_57) AT=570.025n

* CHECK dout0_58 Vdout0_58ck113 = 0.9 time = 570
.meas tran vdout0_58ck113 FIND v(dout0_58) AT=570.025n

* CHECK dout0_59 Vdout0_59ck113 = 0 time = 570
.meas tran vdout0_59ck113 FIND v(dout0_59) AT=570.025n

* CHECK dout0_60 Vdout0_60ck113 = 0 time = 570
.meas tran vdout0_60ck113 FIND v(dout0_60) AT=570.025n

* CHECK dout0_61 Vdout0_61ck113 = 0 time = 570
.meas tran vdout0_61ck113 FIND v(dout0_61) AT=570.025n

* CHECK dout0_62 Vdout0_62ck113 = 0 time = 570
.meas tran vdout0_62ck113 FIND v(dout0_62) AT=570.025n

* CHECK dout0_63 Vdout0_63ck113 = 0.9 time = 570
.meas tran vdout0_63ck113 FIND v(dout0_63) AT=570.025n

* CHECK dout0_0 Vdout0_0ck116 = 0.9 time = 585
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=585.025n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 585
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=585.025n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 585
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=585.025n

* CHECK dout0_3 Vdout0_3ck116 = 0.9 time = 585
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=585.025n

* CHECK dout0_4 Vdout0_4ck116 = 0.9 time = 585
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=585.025n

* CHECK dout0_5 Vdout0_5ck116 = 0.9 time = 585
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=585.025n

* CHECK dout0_6 Vdout0_6ck116 = 0 time = 585
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=585.025n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 585
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=585.025n

* CHECK dout0_8 Vdout0_8ck116 = 0 time = 585
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=585.025n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 585
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=585.025n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 585
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=585.025n

* CHECK dout0_11 Vdout0_11ck116 = 0.9 time = 585
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=585.025n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 585
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=585.025n

* CHECK dout0_13 Vdout0_13ck116 = 0.9 time = 585
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=585.025n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 585
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=585.025n

* CHECK dout0_15 Vdout0_15ck116 = 0.9 time = 585
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=585.025n

* CHECK dout0_16 Vdout0_16ck116 = 0 time = 585
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=585.025n

* CHECK dout0_17 Vdout0_17ck116 = 0.9 time = 585
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=585.025n

* CHECK dout0_18 Vdout0_18ck116 = 0 time = 585
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=585.025n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 585
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=585.025n

* CHECK dout0_20 Vdout0_20ck116 = 0.9 time = 585
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=585.025n

* CHECK dout0_21 Vdout0_21ck116 = 0 time = 585
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=585.025n

* CHECK dout0_22 Vdout0_22ck116 = 0.9 time = 585
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=585.025n

* CHECK dout0_23 Vdout0_23ck116 = 0 time = 585
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=585.025n

* CHECK dout0_24 Vdout0_24ck116 = 0 time = 585
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=585.025n

* CHECK dout0_25 Vdout0_25ck116 = 0.9 time = 585
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=585.025n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 585
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=585.025n

* CHECK dout0_27 Vdout0_27ck116 = 0 time = 585
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=585.025n

* CHECK dout0_28 Vdout0_28ck116 = 0.9 time = 585
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=585.025n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 585
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=585.025n

* CHECK dout0_30 Vdout0_30ck116 = 0.9 time = 585
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=585.025n

* CHECK dout0_31 Vdout0_31ck116 = 0.9 time = 585
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=585.025n

* CHECK dout0_32 Vdout0_32ck116 = 0 time = 585
.meas tran vdout0_32ck116 FIND v(dout0_32) AT=585.025n

* CHECK dout0_33 Vdout0_33ck116 = 0.9 time = 585
.meas tran vdout0_33ck116 FIND v(dout0_33) AT=585.025n

* CHECK dout0_34 Vdout0_34ck116 = 0 time = 585
.meas tran vdout0_34ck116 FIND v(dout0_34) AT=585.025n

* CHECK dout0_35 Vdout0_35ck116 = 0.9 time = 585
.meas tran vdout0_35ck116 FIND v(dout0_35) AT=585.025n

* CHECK dout0_36 Vdout0_36ck116 = 0.9 time = 585
.meas tran vdout0_36ck116 FIND v(dout0_36) AT=585.025n

* CHECK dout0_37 Vdout0_37ck116 = 0 time = 585
.meas tran vdout0_37ck116 FIND v(dout0_37) AT=585.025n

* CHECK dout0_38 Vdout0_38ck116 = 0 time = 585
.meas tran vdout0_38ck116 FIND v(dout0_38) AT=585.025n

* CHECK dout0_39 Vdout0_39ck116 = 0.9 time = 585
.meas tran vdout0_39ck116 FIND v(dout0_39) AT=585.025n

* CHECK dout0_40 Vdout0_40ck116 = 0.9 time = 585
.meas tran vdout0_40ck116 FIND v(dout0_40) AT=585.025n

* CHECK dout0_41 Vdout0_41ck116 = 0 time = 585
.meas tran vdout0_41ck116 FIND v(dout0_41) AT=585.025n

* CHECK dout0_42 Vdout0_42ck116 = 0 time = 585
.meas tran vdout0_42ck116 FIND v(dout0_42) AT=585.025n

* CHECK dout0_43 Vdout0_43ck116 = 0.9 time = 585
.meas tran vdout0_43ck116 FIND v(dout0_43) AT=585.025n

* CHECK dout0_44 Vdout0_44ck116 = 0.9 time = 585
.meas tran vdout0_44ck116 FIND v(dout0_44) AT=585.025n

* CHECK dout0_45 Vdout0_45ck116 = 0 time = 585
.meas tran vdout0_45ck116 FIND v(dout0_45) AT=585.025n

* CHECK dout0_46 Vdout0_46ck116 = 0 time = 585
.meas tran vdout0_46ck116 FIND v(dout0_46) AT=585.025n

* CHECK dout0_47 Vdout0_47ck116 = 0 time = 585
.meas tran vdout0_47ck116 FIND v(dout0_47) AT=585.025n

* CHECK dout0_48 Vdout0_48ck116 = 0.9 time = 585
.meas tran vdout0_48ck116 FIND v(dout0_48) AT=585.025n

* CHECK dout0_49 Vdout0_49ck116 = 0.9 time = 585
.meas tran vdout0_49ck116 FIND v(dout0_49) AT=585.025n

* CHECK dout0_50 Vdout0_50ck116 = 0.9 time = 585
.meas tran vdout0_50ck116 FIND v(dout0_50) AT=585.025n

* CHECK dout0_51 Vdout0_51ck116 = 0 time = 585
.meas tran vdout0_51ck116 FIND v(dout0_51) AT=585.025n

* CHECK dout0_52 Vdout0_52ck116 = 0 time = 585
.meas tran vdout0_52ck116 FIND v(dout0_52) AT=585.025n

* CHECK dout0_53 Vdout0_53ck116 = 0 time = 585
.meas tran vdout0_53ck116 FIND v(dout0_53) AT=585.025n

* CHECK dout0_54 Vdout0_54ck116 = 0.9 time = 585
.meas tran vdout0_54ck116 FIND v(dout0_54) AT=585.025n

* CHECK dout0_55 Vdout0_55ck116 = 0 time = 585
.meas tran vdout0_55ck116 FIND v(dout0_55) AT=585.025n

* CHECK dout0_56 Vdout0_56ck116 = 0 time = 585
.meas tran vdout0_56ck116 FIND v(dout0_56) AT=585.025n

* CHECK dout0_57 Vdout0_57ck116 = 0.9 time = 585
.meas tran vdout0_57ck116 FIND v(dout0_57) AT=585.025n

* CHECK dout0_58 Vdout0_58ck116 = 0 time = 585
.meas tran vdout0_58ck116 FIND v(dout0_58) AT=585.025n

* CHECK dout0_59 Vdout0_59ck116 = 0 time = 585
.meas tran vdout0_59ck116 FIND v(dout0_59) AT=585.025n

* CHECK dout0_60 Vdout0_60ck116 = 0 time = 585
.meas tran vdout0_60ck116 FIND v(dout0_60) AT=585.025n

* CHECK dout0_61 Vdout0_61ck116 = 0 time = 585
.meas tran vdout0_61ck116 FIND v(dout0_61) AT=585.025n

* CHECK dout0_62 Vdout0_62ck116 = 0.9 time = 585
.meas tran vdout0_62ck116 FIND v(dout0_62) AT=585.025n

* CHECK dout0_63 Vdout0_63ck116 = 0 time = 585
.meas tran vdout0_63ck116 FIND v(dout0_63) AT=585.025n

* CHECK dout0_0 Vdout0_0ck122 = 0.9 time = 615
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=615.025n

* CHECK dout0_1 Vdout0_1ck122 = 0.9 time = 615
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=615.025n

* CHECK dout0_2 Vdout0_2ck122 = 0.9 time = 615
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=615.025n

* CHECK dout0_3 Vdout0_3ck122 = 0.9 time = 615
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=615.025n

* CHECK dout0_4 Vdout0_4ck122 = 0.9 time = 615
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=615.025n

* CHECK dout0_5 Vdout0_5ck122 = 0.9 time = 615
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=615.025n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 615
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=615.025n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 615
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=615.025n

* CHECK dout0_8 Vdout0_8ck122 = 0 time = 615
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=615.025n

* CHECK dout0_9 Vdout0_9ck122 = 0.9 time = 615
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=615.025n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 615
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=615.025n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 615
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=615.025n

* CHECK dout0_12 Vdout0_12ck122 = 0 time = 615
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=615.025n

* CHECK dout0_13 Vdout0_13ck122 = 0.9 time = 615
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=615.025n

* CHECK dout0_14 Vdout0_14ck122 = 0.9 time = 615
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=615.025n

* CHECK dout0_15 Vdout0_15ck122 = 0.9 time = 615
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=615.025n

* CHECK dout0_16 Vdout0_16ck122 = 0 time = 615
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=615.025n

* CHECK dout0_17 Vdout0_17ck122 = 0 time = 615
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=615.025n

* CHECK dout0_18 Vdout0_18ck122 = 0 time = 615
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=615.025n

* CHECK dout0_19 Vdout0_19ck122 = 0.9 time = 615
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=615.025n

* CHECK dout0_20 Vdout0_20ck122 = 0.9 time = 615
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=615.025n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 615
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=615.025n

* CHECK dout0_22 Vdout0_22ck122 = 0.9 time = 615
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=615.025n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 615
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=615.025n

* CHECK dout0_24 Vdout0_24ck122 = 0.9 time = 615
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=615.025n

* CHECK dout0_25 Vdout0_25ck122 = 0.9 time = 615
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=615.025n

* CHECK dout0_26 Vdout0_26ck122 = 0.9 time = 615
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=615.025n

* CHECK dout0_27 Vdout0_27ck122 = 0.9 time = 615
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=615.025n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 615
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=615.025n

* CHECK dout0_29 Vdout0_29ck122 = 0 time = 615
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=615.025n

* CHECK dout0_30 Vdout0_30ck122 = 0 time = 615
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=615.025n

* CHECK dout0_31 Vdout0_31ck122 = 0 time = 615
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=615.025n

* CHECK dout0_32 Vdout0_32ck122 = 0.9 time = 615
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=615.025n

* CHECK dout0_33 Vdout0_33ck122 = 0.9 time = 615
.meas tran vdout0_33ck122 FIND v(dout0_33) AT=615.025n

* CHECK dout0_34 Vdout0_34ck122 = 0.9 time = 615
.meas tran vdout0_34ck122 FIND v(dout0_34) AT=615.025n

* CHECK dout0_35 Vdout0_35ck122 = 0 time = 615
.meas tran vdout0_35ck122 FIND v(dout0_35) AT=615.025n

* CHECK dout0_36 Vdout0_36ck122 = 0 time = 615
.meas tran vdout0_36ck122 FIND v(dout0_36) AT=615.025n

* CHECK dout0_37 Vdout0_37ck122 = 0 time = 615
.meas tran vdout0_37ck122 FIND v(dout0_37) AT=615.025n

* CHECK dout0_38 Vdout0_38ck122 = 0 time = 615
.meas tran vdout0_38ck122 FIND v(dout0_38) AT=615.025n

* CHECK dout0_39 Vdout0_39ck122 = 0 time = 615
.meas tran vdout0_39ck122 FIND v(dout0_39) AT=615.025n

* CHECK dout0_40 Vdout0_40ck122 = 0 time = 615
.meas tran vdout0_40ck122 FIND v(dout0_40) AT=615.025n

* CHECK dout0_41 Vdout0_41ck122 = 0.9 time = 615
.meas tran vdout0_41ck122 FIND v(dout0_41) AT=615.025n

* CHECK dout0_42 Vdout0_42ck122 = 0.9 time = 615
.meas tran vdout0_42ck122 FIND v(dout0_42) AT=615.025n

* CHECK dout0_43 Vdout0_43ck122 = 0.9 time = 615
.meas tran vdout0_43ck122 FIND v(dout0_43) AT=615.025n

* CHECK dout0_44 Vdout0_44ck122 = 0 time = 615
.meas tran vdout0_44ck122 FIND v(dout0_44) AT=615.025n

* CHECK dout0_45 Vdout0_45ck122 = 0 time = 615
.meas tran vdout0_45ck122 FIND v(dout0_45) AT=615.025n

* CHECK dout0_46 Vdout0_46ck122 = 0 time = 615
.meas tran vdout0_46ck122 FIND v(dout0_46) AT=615.025n

* CHECK dout0_47 Vdout0_47ck122 = 0.9 time = 615
.meas tran vdout0_47ck122 FIND v(dout0_47) AT=615.025n

* CHECK dout0_48 Vdout0_48ck122 = 0.9 time = 615
.meas tran vdout0_48ck122 FIND v(dout0_48) AT=615.025n

* CHECK dout0_49 Vdout0_49ck122 = 0 time = 615
.meas tran vdout0_49ck122 FIND v(dout0_49) AT=615.025n

* CHECK dout0_50 Vdout0_50ck122 = 0.9 time = 615
.meas tran vdout0_50ck122 FIND v(dout0_50) AT=615.025n

* CHECK dout0_51 Vdout0_51ck122 = 0 time = 615
.meas tran vdout0_51ck122 FIND v(dout0_51) AT=615.025n

* CHECK dout0_52 Vdout0_52ck122 = 0 time = 615
.meas tran vdout0_52ck122 FIND v(dout0_52) AT=615.025n

* CHECK dout0_53 Vdout0_53ck122 = 0.9 time = 615
.meas tran vdout0_53ck122 FIND v(dout0_53) AT=615.025n

* CHECK dout0_54 Vdout0_54ck122 = 0.9 time = 615
.meas tran vdout0_54ck122 FIND v(dout0_54) AT=615.025n

* CHECK dout0_55 Vdout0_55ck122 = 0 time = 615
.meas tran vdout0_55ck122 FIND v(dout0_55) AT=615.025n

* CHECK dout0_56 Vdout0_56ck122 = 0 time = 615
.meas tran vdout0_56ck122 FIND v(dout0_56) AT=615.025n

* CHECK dout0_57 Vdout0_57ck122 = 0 time = 615
.meas tran vdout0_57ck122 FIND v(dout0_57) AT=615.025n

* CHECK dout0_58 Vdout0_58ck122 = 0 time = 615
.meas tran vdout0_58ck122 FIND v(dout0_58) AT=615.025n

* CHECK dout0_59 Vdout0_59ck122 = 0.9 time = 615
.meas tran vdout0_59ck122 FIND v(dout0_59) AT=615.025n

* CHECK dout0_60 Vdout0_60ck122 = 0.9 time = 615
.meas tran vdout0_60ck122 FIND v(dout0_60) AT=615.025n

* CHECK dout0_61 Vdout0_61ck122 = 0.9 time = 615
.meas tran vdout0_61ck122 FIND v(dout0_61) AT=615.025n

* CHECK dout0_62 Vdout0_62ck122 = 0.9 time = 615
.meas tran vdout0_62ck122 FIND v(dout0_62) AT=615.025n

* CHECK dout0_63 Vdout0_63ck122 = 0 time = 615
.meas tran vdout0_63ck122 FIND v(dout0_63) AT=615.025n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 0.9 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 0.9 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 0.9 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 0.9 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 0 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 0.9 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0.9 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0.9 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 0.9 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 0.9 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 0.9 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 0.9 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 0 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0.9 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0.9 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 0 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0.9 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0.9 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 0 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 0.9 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 0.9 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 0.9 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 0 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_32 Vdout0_32ck123 = 0.9 time = 620
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=620.025n

* CHECK dout0_33 Vdout0_33ck123 = 0.9 time = 620
.meas tran vdout0_33ck123 FIND v(dout0_33) AT=620.025n

* CHECK dout0_34 Vdout0_34ck123 = 0 time = 620
.meas tran vdout0_34ck123 FIND v(dout0_34) AT=620.025n

* CHECK dout0_35 Vdout0_35ck123 = 0 time = 620
.meas tran vdout0_35ck123 FIND v(dout0_35) AT=620.025n

* CHECK dout0_36 Vdout0_36ck123 = 0.9 time = 620
.meas tran vdout0_36ck123 FIND v(dout0_36) AT=620.025n

* CHECK dout0_37 Vdout0_37ck123 = 0 time = 620
.meas tran vdout0_37ck123 FIND v(dout0_37) AT=620.025n

* CHECK dout0_38 Vdout0_38ck123 = 0.9 time = 620
.meas tran vdout0_38ck123 FIND v(dout0_38) AT=620.025n

* CHECK dout0_39 Vdout0_39ck123 = 0.9 time = 620
.meas tran vdout0_39ck123 FIND v(dout0_39) AT=620.025n

* CHECK dout0_40 Vdout0_40ck123 = 0 time = 620
.meas tran vdout0_40ck123 FIND v(dout0_40) AT=620.025n

* CHECK dout0_41 Vdout0_41ck123 = 0.9 time = 620
.meas tran vdout0_41ck123 FIND v(dout0_41) AT=620.025n

* CHECK dout0_42 Vdout0_42ck123 = 0 time = 620
.meas tran vdout0_42ck123 FIND v(dout0_42) AT=620.025n

* CHECK dout0_43 Vdout0_43ck123 = 0.9 time = 620
.meas tran vdout0_43ck123 FIND v(dout0_43) AT=620.025n

* CHECK dout0_44 Vdout0_44ck123 = 0.9 time = 620
.meas tran vdout0_44ck123 FIND v(dout0_44) AT=620.025n

* CHECK dout0_45 Vdout0_45ck123 = 0 time = 620
.meas tran vdout0_45ck123 FIND v(dout0_45) AT=620.025n

* CHECK dout0_46 Vdout0_46ck123 = 0 time = 620
.meas tran vdout0_46ck123 FIND v(dout0_46) AT=620.025n

* CHECK dout0_47 Vdout0_47ck123 = 0.9 time = 620
.meas tran vdout0_47ck123 FIND v(dout0_47) AT=620.025n

* CHECK dout0_48 Vdout0_48ck123 = 0.9 time = 620
.meas tran vdout0_48ck123 FIND v(dout0_48) AT=620.025n

* CHECK dout0_49 Vdout0_49ck123 = 0.9 time = 620
.meas tran vdout0_49ck123 FIND v(dout0_49) AT=620.025n

* CHECK dout0_50 Vdout0_50ck123 = 0.9 time = 620
.meas tran vdout0_50ck123 FIND v(dout0_50) AT=620.025n

* CHECK dout0_51 Vdout0_51ck123 = 0 time = 620
.meas tran vdout0_51ck123 FIND v(dout0_51) AT=620.025n

* CHECK dout0_52 Vdout0_52ck123 = 0.9 time = 620
.meas tran vdout0_52ck123 FIND v(dout0_52) AT=620.025n

* CHECK dout0_53 Vdout0_53ck123 = 0 time = 620
.meas tran vdout0_53ck123 FIND v(dout0_53) AT=620.025n

* CHECK dout0_54 Vdout0_54ck123 = 0.9 time = 620
.meas tran vdout0_54ck123 FIND v(dout0_54) AT=620.025n

* CHECK dout0_55 Vdout0_55ck123 = 0.9 time = 620
.meas tran vdout0_55ck123 FIND v(dout0_55) AT=620.025n

* CHECK dout0_56 Vdout0_56ck123 = 0 time = 620
.meas tran vdout0_56ck123 FIND v(dout0_56) AT=620.025n

* CHECK dout0_57 Vdout0_57ck123 = 0 time = 620
.meas tran vdout0_57ck123 FIND v(dout0_57) AT=620.025n

* CHECK dout0_58 Vdout0_58ck123 = 0 time = 620
.meas tran vdout0_58ck123 FIND v(dout0_58) AT=620.025n

* CHECK dout0_59 Vdout0_59ck123 = 0.9 time = 620
.meas tran vdout0_59ck123 FIND v(dout0_59) AT=620.025n

* CHECK dout0_60 Vdout0_60ck123 = 0 time = 620
.meas tran vdout0_60ck123 FIND v(dout0_60) AT=620.025n

* CHECK dout0_61 Vdout0_61ck123 = 0.9 time = 620
.meas tran vdout0_61ck123 FIND v(dout0_61) AT=620.025n

* CHECK dout0_62 Vdout0_62ck123 = 0 time = 620
.meas tran vdout0_62ck123 FIND v(dout0_62) AT=620.025n

* CHECK dout0_63 Vdout0_63ck123 = 0 time = 620
.meas tran vdout0_63ck123 FIND v(dout0_63) AT=620.025n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 625
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=625.025n

* CHECK dout0_1 Vdout0_1ck124 = 0.9 time = 625
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=625.025n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 625
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=625.025n

* CHECK dout0_3 Vdout0_3ck124 = 0.9 time = 625
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=625.025n

* CHECK dout0_4 Vdout0_4ck124 = 0 time = 625
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=625.025n

* CHECK dout0_5 Vdout0_5ck124 = 0 time = 625
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=625.025n

* CHECK dout0_6 Vdout0_6ck124 = 0.9 time = 625
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=625.025n

* CHECK dout0_7 Vdout0_7ck124 = 0.9 time = 625
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=625.025n

* CHECK dout0_8 Vdout0_8ck124 = 0 time = 625
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=625.025n

* CHECK dout0_9 Vdout0_9ck124 = 0 time = 625
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=625.025n

* CHECK dout0_10 Vdout0_10ck124 = 0.9 time = 625
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=625.025n

* CHECK dout0_11 Vdout0_11ck124 = 0.9 time = 625
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=625.025n

* CHECK dout0_12 Vdout0_12ck124 = 0.9 time = 625
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=625.025n

* CHECK dout0_13 Vdout0_13ck124 = 0.9 time = 625
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=625.025n

* CHECK dout0_14 Vdout0_14ck124 = 0.9 time = 625
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=625.025n

* CHECK dout0_15 Vdout0_15ck124 = 0.9 time = 625
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=625.025n

* CHECK dout0_16 Vdout0_16ck124 = 0.9 time = 625
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=625.025n

* CHECK dout0_17 Vdout0_17ck124 = 0 time = 625
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=625.025n

* CHECK dout0_18 Vdout0_18ck124 = 0.9 time = 625
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=625.025n

* CHECK dout0_19 Vdout0_19ck124 = 0.9 time = 625
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=625.025n

* CHECK dout0_20 Vdout0_20ck124 = 0 time = 625
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=625.025n

* CHECK dout0_21 Vdout0_21ck124 = 0 time = 625
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=625.025n

* CHECK dout0_22 Vdout0_22ck124 = 0 time = 625
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=625.025n

* CHECK dout0_23 Vdout0_23ck124 = 0 time = 625
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=625.025n

* CHECK dout0_24 Vdout0_24ck124 = 0.9 time = 625
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=625.025n

* CHECK dout0_25 Vdout0_25ck124 = 0.9 time = 625
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=625.025n

* CHECK dout0_26 Vdout0_26ck124 = 0 time = 625
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=625.025n

* CHECK dout0_27 Vdout0_27ck124 = 0.9 time = 625
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=625.025n

* CHECK dout0_28 Vdout0_28ck124 = 0.9 time = 625
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=625.025n

* CHECK dout0_29 Vdout0_29ck124 = 0.9 time = 625
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=625.025n

* CHECK dout0_30 Vdout0_30ck124 = 0 time = 625
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=625.025n

* CHECK dout0_31 Vdout0_31ck124 = 0 time = 625
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=625.025n

* CHECK dout0_32 Vdout0_32ck124 = 0.9 time = 625
.meas tran vdout0_32ck124 FIND v(dout0_32) AT=625.025n

* CHECK dout0_33 Vdout0_33ck124 = 0.9 time = 625
.meas tran vdout0_33ck124 FIND v(dout0_33) AT=625.025n

* CHECK dout0_34 Vdout0_34ck124 = 0 time = 625
.meas tran vdout0_34ck124 FIND v(dout0_34) AT=625.025n

* CHECK dout0_35 Vdout0_35ck124 = 0 time = 625
.meas tran vdout0_35ck124 FIND v(dout0_35) AT=625.025n

* CHECK dout0_36 Vdout0_36ck124 = 0.9 time = 625
.meas tran vdout0_36ck124 FIND v(dout0_36) AT=625.025n

* CHECK dout0_37 Vdout0_37ck124 = 0 time = 625
.meas tran vdout0_37ck124 FIND v(dout0_37) AT=625.025n

* CHECK dout0_38 Vdout0_38ck124 = 0.9 time = 625
.meas tran vdout0_38ck124 FIND v(dout0_38) AT=625.025n

* CHECK dout0_39 Vdout0_39ck124 = 0.9 time = 625
.meas tran vdout0_39ck124 FIND v(dout0_39) AT=625.025n

* CHECK dout0_40 Vdout0_40ck124 = 0 time = 625
.meas tran vdout0_40ck124 FIND v(dout0_40) AT=625.025n

* CHECK dout0_41 Vdout0_41ck124 = 0.9 time = 625
.meas tran vdout0_41ck124 FIND v(dout0_41) AT=625.025n

* CHECK dout0_42 Vdout0_42ck124 = 0 time = 625
.meas tran vdout0_42ck124 FIND v(dout0_42) AT=625.025n

* CHECK dout0_43 Vdout0_43ck124 = 0.9 time = 625
.meas tran vdout0_43ck124 FIND v(dout0_43) AT=625.025n

* CHECK dout0_44 Vdout0_44ck124 = 0.9 time = 625
.meas tran vdout0_44ck124 FIND v(dout0_44) AT=625.025n

* CHECK dout0_45 Vdout0_45ck124 = 0 time = 625
.meas tran vdout0_45ck124 FIND v(dout0_45) AT=625.025n

* CHECK dout0_46 Vdout0_46ck124 = 0 time = 625
.meas tran vdout0_46ck124 FIND v(dout0_46) AT=625.025n

* CHECK dout0_47 Vdout0_47ck124 = 0.9 time = 625
.meas tran vdout0_47ck124 FIND v(dout0_47) AT=625.025n

* CHECK dout0_48 Vdout0_48ck124 = 0.9 time = 625
.meas tran vdout0_48ck124 FIND v(dout0_48) AT=625.025n

* CHECK dout0_49 Vdout0_49ck124 = 0.9 time = 625
.meas tran vdout0_49ck124 FIND v(dout0_49) AT=625.025n

* CHECK dout0_50 Vdout0_50ck124 = 0.9 time = 625
.meas tran vdout0_50ck124 FIND v(dout0_50) AT=625.025n

* CHECK dout0_51 Vdout0_51ck124 = 0 time = 625
.meas tran vdout0_51ck124 FIND v(dout0_51) AT=625.025n

* CHECK dout0_52 Vdout0_52ck124 = 0.9 time = 625
.meas tran vdout0_52ck124 FIND v(dout0_52) AT=625.025n

* CHECK dout0_53 Vdout0_53ck124 = 0 time = 625
.meas tran vdout0_53ck124 FIND v(dout0_53) AT=625.025n

* CHECK dout0_54 Vdout0_54ck124 = 0.9 time = 625
.meas tran vdout0_54ck124 FIND v(dout0_54) AT=625.025n

* CHECK dout0_55 Vdout0_55ck124 = 0.9 time = 625
.meas tran vdout0_55ck124 FIND v(dout0_55) AT=625.025n

* CHECK dout0_56 Vdout0_56ck124 = 0 time = 625
.meas tran vdout0_56ck124 FIND v(dout0_56) AT=625.025n

* CHECK dout0_57 Vdout0_57ck124 = 0 time = 625
.meas tran vdout0_57ck124 FIND v(dout0_57) AT=625.025n

* CHECK dout0_58 Vdout0_58ck124 = 0 time = 625
.meas tran vdout0_58ck124 FIND v(dout0_58) AT=625.025n

* CHECK dout0_59 Vdout0_59ck124 = 0.9 time = 625
.meas tran vdout0_59ck124 FIND v(dout0_59) AT=625.025n

* CHECK dout0_60 Vdout0_60ck124 = 0 time = 625
.meas tran vdout0_60ck124 FIND v(dout0_60) AT=625.025n

* CHECK dout0_61 Vdout0_61ck124 = 0.9 time = 625
.meas tran vdout0_61ck124 FIND v(dout0_61) AT=625.025n

* CHECK dout0_62 Vdout0_62ck124 = 0 time = 625
.meas tran vdout0_62ck124 FIND v(dout0_62) AT=625.025n

* CHECK dout0_63 Vdout0_63ck124 = 0 time = 625
.meas tran vdout0_63ck124 FIND v(dout0_63) AT=625.025n

* CHECK dout0_0 Vdout0_0ck125 = 0.9 time = 630
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=630.025n

* CHECK dout0_1 Vdout0_1ck125 = 0.9 time = 630
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=630.025n

* CHECK dout0_2 Vdout0_2ck125 = 0.9 time = 630
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=630.025n

* CHECK dout0_3 Vdout0_3ck125 = 0.9 time = 630
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=630.025n

* CHECK dout0_4 Vdout0_4ck125 = 0.9 time = 630
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=630.025n

* CHECK dout0_5 Vdout0_5ck125 = 0.9 time = 630
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=630.025n

* CHECK dout0_6 Vdout0_6ck125 = 0 time = 630
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=630.025n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 630
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=630.025n

* CHECK dout0_8 Vdout0_8ck125 = 0 time = 630
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=630.025n

* CHECK dout0_9 Vdout0_9ck125 = 0.9 time = 630
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=630.025n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 630
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=630.025n

* CHECK dout0_11 Vdout0_11ck125 = 0 time = 630
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=630.025n

* CHECK dout0_12 Vdout0_12ck125 = 0 time = 630
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=630.025n

* CHECK dout0_13 Vdout0_13ck125 = 0.9 time = 630
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=630.025n

* CHECK dout0_14 Vdout0_14ck125 = 0.9 time = 630
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=630.025n

* CHECK dout0_15 Vdout0_15ck125 = 0.9 time = 630
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=630.025n

* CHECK dout0_16 Vdout0_16ck125 = 0 time = 630
.meas tran vdout0_16ck125 FIND v(dout0_16) AT=630.025n

* CHECK dout0_17 Vdout0_17ck125 = 0 time = 630
.meas tran vdout0_17ck125 FIND v(dout0_17) AT=630.025n

* CHECK dout0_18 Vdout0_18ck125 = 0 time = 630
.meas tran vdout0_18ck125 FIND v(dout0_18) AT=630.025n

* CHECK dout0_19 Vdout0_19ck125 = 0.9 time = 630
.meas tran vdout0_19ck125 FIND v(dout0_19) AT=630.025n

* CHECK dout0_20 Vdout0_20ck125 = 0.9 time = 630
.meas tran vdout0_20ck125 FIND v(dout0_20) AT=630.025n

* CHECK dout0_21 Vdout0_21ck125 = 0 time = 630
.meas tran vdout0_21ck125 FIND v(dout0_21) AT=630.025n

* CHECK dout0_22 Vdout0_22ck125 = 0.9 time = 630
.meas tran vdout0_22ck125 FIND v(dout0_22) AT=630.025n

* CHECK dout0_23 Vdout0_23ck125 = 0 time = 630
.meas tran vdout0_23ck125 FIND v(dout0_23) AT=630.025n

* CHECK dout0_24 Vdout0_24ck125 = 0.9 time = 630
.meas tran vdout0_24ck125 FIND v(dout0_24) AT=630.025n

* CHECK dout0_25 Vdout0_25ck125 = 0.9 time = 630
.meas tran vdout0_25ck125 FIND v(dout0_25) AT=630.025n

* CHECK dout0_26 Vdout0_26ck125 = 0.9 time = 630
.meas tran vdout0_26ck125 FIND v(dout0_26) AT=630.025n

* CHECK dout0_27 Vdout0_27ck125 = 0.9 time = 630
.meas tran vdout0_27ck125 FIND v(dout0_27) AT=630.025n

* CHECK dout0_28 Vdout0_28ck125 = 0 time = 630
.meas tran vdout0_28ck125 FIND v(dout0_28) AT=630.025n

* CHECK dout0_29 Vdout0_29ck125 = 0 time = 630
.meas tran vdout0_29ck125 FIND v(dout0_29) AT=630.025n

* CHECK dout0_30 Vdout0_30ck125 = 0 time = 630
.meas tran vdout0_30ck125 FIND v(dout0_30) AT=630.025n

* CHECK dout0_31 Vdout0_31ck125 = 0 time = 630
.meas tran vdout0_31ck125 FIND v(dout0_31) AT=630.025n

* CHECK dout0_32 Vdout0_32ck125 = 0.9 time = 630
.meas tran vdout0_32ck125 FIND v(dout0_32) AT=630.025n

* CHECK dout0_33 Vdout0_33ck125 = 0.9 time = 630
.meas tran vdout0_33ck125 FIND v(dout0_33) AT=630.025n

* CHECK dout0_34 Vdout0_34ck125 = 0.9 time = 630
.meas tran vdout0_34ck125 FIND v(dout0_34) AT=630.025n

* CHECK dout0_35 Vdout0_35ck125 = 0 time = 630
.meas tran vdout0_35ck125 FIND v(dout0_35) AT=630.025n

* CHECK dout0_36 Vdout0_36ck125 = 0 time = 630
.meas tran vdout0_36ck125 FIND v(dout0_36) AT=630.025n

* CHECK dout0_37 Vdout0_37ck125 = 0 time = 630
.meas tran vdout0_37ck125 FIND v(dout0_37) AT=630.025n

* CHECK dout0_38 Vdout0_38ck125 = 0 time = 630
.meas tran vdout0_38ck125 FIND v(dout0_38) AT=630.025n

* CHECK dout0_39 Vdout0_39ck125 = 0 time = 630
.meas tran vdout0_39ck125 FIND v(dout0_39) AT=630.025n

* CHECK dout0_40 Vdout0_40ck125 = 0 time = 630
.meas tran vdout0_40ck125 FIND v(dout0_40) AT=630.025n

* CHECK dout0_41 Vdout0_41ck125 = 0.9 time = 630
.meas tran vdout0_41ck125 FIND v(dout0_41) AT=630.025n

* CHECK dout0_42 Vdout0_42ck125 = 0.9 time = 630
.meas tran vdout0_42ck125 FIND v(dout0_42) AT=630.025n

* CHECK dout0_43 Vdout0_43ck125 = 0.9 time = 630
.meas tran vdout0_43ck125 FIND v(dout0_43) AT=630.025n

* CHECK dout0_44 Vdout0_44ck125 = 0 time = 630
.meas tran vdout0_44ck125 FIND v(dout0_44) AT=630.025n

* CHECK dout0_45 Vdout0_45ck125 = 0 time = 630
.meas tran vdout0_45ck125 FIND v(dout0_45) AT=630.025n

* CHECK dout0_46 Vdout0_46ck125 = 0 time = 630
.meas tran vdout0_46ck125 FIND v(dout0_46) AT=630.025n

* CHECK dout0_47 Vdout0_47ck125 = 0.9 time = 630
.meas tran vdout0_47ck125 FIND v(dout0_47) AT=630.025n

* CHECK dout0_48 Vdout0_48ck125 = 0.9 time = 630
.meas tran vdout0_48ck125 FIND v(dout0_48) AT=630.025n

* CHECK dout0_49 Vdout0_49ck125 = 0 time = 630
.meas tran vdout0_49ck125 FIND v(dout0_49) AT=630.025n

* CHECK dout0_50 Vdout0_50ck125 = 0.9 time = 630
.meas tran vdout0_50ck125 FIND v(dout0_50) AT=630.025n

* CHECK dout0_51 Vdout0_51ck125 = 0 time = 630
.meas tran vdout0_51ck125 FIND v(dout0_51) AT=630.025n

* CHECK dout0_52 Vdout0_52ck125 = 0 time = 630
.meas tran vdout0_52ck125 FIND v(dout0_52) AT=630.025n

* CHECK dout0_53 Vdout0_53ck125 = 0.9 time = 630
.meas tran vdout0_53ck125 FIND v(dout0_53) AT=630.025n

* CHECK dout0_54 Vdout0_54ck125 = 0.9 time = 630
.meas tran vdout0_54ck125 FIND v(dout0_54) AT=630.025n

* CHECK dout0_55 Vdout0_55ck125 = 0 time = 630
.meas tran vdout0_55ck125 FIND v(dout0_55) AT=630.025n

* CHECK dout0_56 Vdout0_56ck125 = 0 time = 630
.meas tran vdout0_56ck125 FIND v(dout0_56) AT=630.025n

* CHECK dout0_57 Vdout0_57ck125 = 0 time = 630
.meas tran vdout0_57ck125 FIND v(dout0_57) AT=630.025n

* CHECK dout0_58 Vdout0_58ck125 = 0 time = 630
.meas tran vdout0_58ck125 FIND v(dout0_58) AT=630.025n

* CHECK dout0_59 Vdout0_59ck125 = 0.9 time = 630
.meas tran vdout0_59ck125 FIND v(dout0_59) AT=630.025n

* CHECK dout0_60 Vdout0_60ck125 = 0.9 time = 630
.meas tran vdout0_60ck125 FIND v(dout0_60) AT=630.025n

* CHECK dout0_61 Vdout0_61ck125 = 0.9 time = 630
.meas tran vdout0_61ck125 FIND v(dout0_61) AT=630.025n

* CHECK dout0_62 Vdout0_62ck125 = 0.9 time = 630
.meas tran vdout0_62ck125 FIND v(dout0_62) AT=630.025n

* CHECK dout0_63 Vdout0_63ck125 = 0 time = 630
.meas tran vdout0_63ck125 FIND v(dout0_63) AT=630.025n

* CHECK dout0_0 Vdout0_0ck126 = 0.9 time = 635
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=635.025n

* CHECK dout0_1 Vdout0_1ck126 = 0.9 time = 635
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=635.025n

* CHECK dout0_2 Vdout0_2ck126 = 0.9 time = 635
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=635.025n

* CHECK dout0_3 Vdout0_3ck126 = 0.9 time = 635
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=635.025n

* CHECK dout0_4 Vdout0_4ck126 = 0.9 time = 635
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=635.025n

* CHECK dout0_5 Vdout0_5ck126 = 0.9 time = 635
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=635.025n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 635
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=635.025n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 635
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=635.025n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 635
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=635.025n

* CHECK dout0_9 Vdout0_9ck126 = 0.9 time = 635
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=635.025n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 635
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=635.025n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 635
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=635.025n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 635
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=635.025n

* CHECK dout0_13 Vdout0_13ck126 = 0.9 time = 635
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=635.025n

* CHECK dout0_14 Vdout0_14ck126 = 0.9 time = 635
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=635.025n

* CHECK dout0_15 Vdout0_15ck126 = 0.9 time = 635
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=635.025n

* CHECK dout0_16 Vdout0_16ck126 = 0 time = 635
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=635.025n

* CHECK dout0_17 Vdout0_17ck126 = 0 time = 635
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=635.025n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 635
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=635.025n

* CHECK dout0_19 Vdout0_19ck126 = 0.9 time = 635
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=635.025n

* CHECK dout0_20 Vdout0_20ck126 = 0.9 time = 635
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=635.025n

* CHECK dout0_21 Vdout0_21ck126 = 0 time = 635
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=635.025n

* CHECK dout0_22 Vdout0_22ck126 = 0.9 time = 635
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=635.025n

* CHECK dout0_23 Vdout0_23ck126 = 0 time = 635
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=635.025n

* CHECK dout0_24 Vdout0_24ck126 = 0.9 time = 635
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=635.025n

* CHECK dout0_25 Vdout0_25ck126 = 0.9 time = 635
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=635.025n

* CHECK dout0_26 Vdout0_26ck126 = 0.9 time = 635
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=635.025n

* CHECK dout0_27 Vdout0_27ck126 = 0.9 time = 635
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=635.025n

* CHECK dout0_28 Vdout0_28ck126 = 0 time = 635
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=635.025n

* CHECK dout0_29 Vdout0_29ck126 = 0 time = 635
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=635.025n

* CHECK dout0_30 Vdout0_30ck126 = 0 time = 635
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=635.025n

* CHECK dout0_31 Vdout0_31ck126 = 0 time = 635
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=635.025n

* CHECK dout0_32 Vdout0_32ck126 = 0.9 time = 635
.meas tran vdout0_32ck126 FIND v(dout0_32) AT=635.025n

* CHECK dout0_33 Vdout0_33ck126 = 0.9 time = 635
.meas tran vdout0_33ck126 FIND v(dout0_33) AT=635.025n

* CHECK dout0_34 Vdout0_34ck126 = 0.9 time = 635
.meas tran vdout0_34ck126 FIND v(dout0_34) AT=635.025n

* CHECK dout0_35 Vdout0_35ck126 = 0 time = 635
.meas tran vdout0_35ck126 FIND v(dout0_35) AT=635.025n

* CHECK dout0_36 Vdout0_36ck126 = 0 time = 635
.meas tran vdout0_36ck126 FIND v(dout0_36) AT=635.025n

* CHECK dout0_37 Vdout0_37ck126 = 0 time = 635
.meas tran vdout0_37ck126 FIND v(dout0_37) AT=635.025n

* CHECK dout0_38 Vdout0_38ck126 = 0 time = 635
.meas tran vdout0_38ck126 FIND v(dout0_38) AT=635.025n

* CHECK dout0_39 Vdout0_39ck126 = 0 time = 635
.meas tran vdout0_39ck126 FIND v(dout0_39) AT=635.025n

* CHECK dout0_40 Vdout0_40ck126 = 0 time = 635
.meas tran vdout0_40ck126 FIND v(dout0_40) AT=635.025n

* CHECK dout0_41 Vdout0_41ck126 = 0.9 time = 635
.meas tran vdout0_41ck126 FIND v(dout0_41) AT=635.025n

* CHECK dout0_42 Vdout0_42ck126 = 0.9 time = 635
.meas tran vdout0_42ck126 FIND v(dout0_42) AT=635.025n

* CHECK dout0_43 Vdout0_43ck126 = 0.9 time = 635
.meas tran vdout0_43ck126 FIND v(dout0_43) AT=635.025n

* CHECK dout0_44 Vdout0_44ck126 = 0 time = 635
.meas tran vdout0_44ck126 FIND v(dout0_44) AT=635.025n

* CHECK dout0_45 Vdout0_45ck126 = 0 time = 635
.meas tran vdout0_45ck126 FIND v(dout0_45) AT=635.025n

* CHECK dout0_46 Vdout0_46ck126 = 0 time = 635
.meas tran vdout0_46ck126 FIND v(dout0_46) AT=635.025n

* CHECK dout0_47 Vdout0_47ck126 = 0.9 time = 635
.meas tran vdout0_47ck126 FIND v(dout0_47) AT=635.025n

* CHECK dout0_48 Vdout0_48ck126 = 0.9 time = 635
.meas tran vdout0_48ck126 FIND v(dout0_48) AT=635.025n

* CHECK dout0_49 Vdout0_49ck126 = 0 time = 635
.meas tran vdout0_49ck126 FIND v(dout0_49) AT=635.025n

* CHECK dout0_50 Vdout0_50ck126 = 0.9 time = 635
.meas tran vdout0_50ck126 FIND v(dout0_50) AT=635.025n

* CHECK dout0_51 Vdout0_51ck126 = 0 time = 635
.meas tran vdout0_51ck126 FIND v(dout0_51) AT=635.025n

* CHECK dout0_52 Vdout0_52ck126 = 0 time = 635
.meas tran vdout0_52ck126 FIND v(dout0_52) AT=635.025n

* CHECK dout0_53 Vdout0_53ck126 = 0.9 time = 635
.meas tran vdout0_53ck126 FIND v(dout0_53) AT=635.025n

* CHECK dout0_54 Vdout0_54ck126 = 0.9 time = 635
.meas tran vdout0_54ck126 FIND v(dout0_54) AT=635.025n

* CHECK dout0_55 Vdout0_55ck126 = 0 time = 635
.meas tran vdout0_55ck126 FIND v(dout0_55) AT=635.025n

* CHECK dout0_56 Vdout0_56ck126 = 0 time = 635
.meas tran vdout0_56ck126 FIND v(dout0_56) AT=635.025n

* CHECK dout0_57 Vdout0_57ck126 = 0 time = 635
.meas tran vdout0_57ck126 FIND v(dout0_57) AT=635.025n

* CHECK dout0_58 Vdout0_58ck126 = 0 time = 635
.meas tran vdout0_58ck126 FIND v(dout0_58) AT=635.025n

* CHECK dout0_59 Vdout0_59ck126 = 0.9 time = 635
.meas tran vdout0_59ck126 FIND v(dout0_59) AT=635.025n

* CHECK dout0_60 Vdout0_60ck126 = 0.9 time = 635
.meas tran vdout0_60ck126 FIND v(dout0_60) AT=635.025n

* CHECK dout0_61 Vdout0_61ck126 = 0.9 time = 635
.meas tran vdout0_61ck126 FIND v(dout0_61) AT=635.025n

* CHECK dout0_62 Vdout0_62ck126 = 0.9 time = 635
.meas tran vdout0_62ck126 FIND v(dout0_62) AT=635.025n

* CHECK dout0_63 Vdout0_63ck126 = 0 time = 635
.meas tran vdout0_63ck126 FIND v(dout0_63) AT=635.025n

* CHECK dout0_0 Vdout0_0ck129 = 0 time = 650
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=650.025n

* CHECK dout0_1 Vdout0_1ck129 = 0.9 time = 650
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=650.025n

* CHECK dout0_2 Vdout0_2ck129 = 0 time = 650
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=650.025n

* CHECK dout0_3 Vdout0_3ck129 = 0.9 time = 650
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=650.025n

* CHECK dout0_4 Vdout0_4ck129 = 0 time = 650
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=650.025n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 650
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=650.025n

* CHECK dout0_6 Vdout0_6ck129 = 0.9 time = 650
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=650.025n

* CHECK dout0_7 Vdout0_7ck129 = 0.9 time = 650
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=650.025n

* CHECK dout0_8 Vdout0_8ck129 = 0 time = 650
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=650.025n

* CHECK dout0_9 Vdout0_9ck129 = 0 time = 650
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=650.025n

* CHECK dout0_10 Vdout0_10ck129 = 0.9 time = 650
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=650.025n

* CHECK dout0_11 Vdout0_11ck129 = 0.9 time = 650
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=650.025n

* CHECK dout0_12 Vdout0_12ck129 = 0.9 time = 650
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=650.025n

* CHECK dout0_13 Vdout0_13ck129 = 0.9 time = 650
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=650.025n

* CHECK dout0_14 Vdout0_14ck129 = 0.9 time = 650
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=650.025n

* CHECK dout0_15 Vdout0_15ck129 = 0.9 time = 650
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=650.025n

* CHECK dout0_16 Vdout0_16ck129 = 0.9 time = 650
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=650.025n

* CHECK dout0_17 Vdout0_17ck129 = 0 time = 650
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=650.025n

* CHECK dout0_18 Vdout0_18ck129 = 0.9 time = 650
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=650.025n

* CHECK dout0_19 Vdout0_19ck129 = 0.9 time = 650
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=650.025n

* CHECK dout0_20 Vdout0_20ck129 = 0 time = 650
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=650.025n

* CHECK dout0_21 Vdout0_21ck129 = 0 time = 650
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=650.025n

* CHECK dout0_22 Vdout0_22ck129 = 0 time = 650
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=650.025n

* CHECK dout0_23 Vdout0_23ck129 = 0 time = 650
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=650.025n

* CHECK dout0_24 Vdout0_24ck129 = 0.9 time = 650
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=650.025n

* CHECK dout0_25 Vdout0_25ck129 = 0.9 time = 650
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=650.025n

* CHECK dout0_26 Vdout0_26ck129 = 0 time = 650
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=650.025n

* CHECK dout0_27 Vdout0_27ck129 = 0.9 time = 650
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=650.025n

* CHECK dout0_28 Vdout0_28ck129 = 0.9 time = 650
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=650.025n

* CHECK dout0_29 Vdout0_29ck129 = 0.9 time = 650
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=650.025n

* CHECK dout0_30 Vdout0_30ck129 = 0 time = 650
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=650.025n

* CHECK dout0_31 Vdout0_31ck129 = 0 time = 650
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=650.025n

* CHECK dout0_32 Vdout0_32ck129 = 0.9 time = 650
.meas tran vdout0_32ck129 FIND v(dout0_32) AT=650.025n

* CHECK dout0_33 Vdout0_33ck129 = 0.9 time = 650
.meas tran vdout0_33ck129 FIND v(dout0_33) AT=650.025n

* CHECK dout0_34 Vdout0_34ck129 = 0 time = 650
.meas tran vdout0_34ck129 FIND v(dout0_34) AT=650.025n

* CHECK dout0_35 Vdout0_35ck129 = 0 time = 650
.meas tran vdout0_35ck129 FIND v(dout0_35) AT=650.025n

* CHECK dout0_36 Vdout0_36ck129 = 0.9 time = 650
.meas tran vdout0_36ck129 FIND v(dout0_36) AT=650.025n

* CHECK dout0_37 Vdout0_37ck129 = 0 time = 650
.meas tran vdout0_37ck129 FIND v(dout0_37) AT=650.025n

* CHECK dout0_38 Vdout0_38ck129 = 0.9 time = 650
.meas tran vdout0_38ck129 FIND v(dout0_38) AT=650.025n

* CHECK dout0_39 Vdout0_39ck129 = 0.9 time = 650
.meas tran vdout0_39ck129 FIND v(dout0_39) AT=650.025n

* CHECK dout0_40 Vdout0_40ck129 = 0 time = 650
.meas tran vdout0_40ck129 FIND v(dout0_40) AT=650.025n

* CHECK dout0_41 Vdout0_41ck129 = 0.9 time = 650
.meas tran vdout0_41ck129 FIND v(dout0_41) AT=650.025n

* CHECK dout0_42 Vdout0_42ck129 = 0 time = 650
.meas tran vdout0_42ck129 FIND v(dout0_42) AT=650.025n

* CHECK dout0_43 Vdout0_43ck129 = 0.9 time = 650
.meas tran vdout0_43ck129 FIND v(dout0_43) AT=650.025n

* CHECK dout0_44 Vdout0_44ck129 = 0.9 time = 650
.meas tran vdout0_44ck129 FIND v(dout0_44) AT=650.025n

* CHECK dout0_45 Vdout0_45ck129 = 0 time = 650
.meas tran vdout0_45ck129 FIND v(dout0_45) AT=650.025n

* CHECK dout0_46 Vdout0_46ck129 = 0 time = 650
.meas tran vdout0_46ck129 FIND v(dout0_46) AT=650.025n

* CHECK dout0_47 Vdout0_47ck129 = 0.9 time = 650
.meas tran vdout0_47ck129 FIND v(dout0_47) AT=650.025n

* CHECK dout0_48 Vdout0_48ck129 = 0.9 time = 650
.meas tran vdout0_48ck129 FIND v(dout0_48) AT=650.025n

* CHECK dout0_49 Vdout0_49ck129 = 0.9 time = 650
.meas tran vdout0_49ck129 FIND v(dout0_49) AT=650.025n

* CHECK dout0_50 Vdout0_50ck129 = 0.9 time = 650
.meas tran vdout0_50ck129 FIND v(dout0_50) AT=650.025n

* CHECK dout0_51 Vdout0_51ck129 = 0 time = 650
.meas tran vdout0_51ck129 FIND v(dout0_51) AT=650.025n

* CHECK dout0_52 Vdout0_52ck129 = 0.9 time = 650
.meas tran vdout0_52ck129 FIND v(dout0_52) AT=650.025n

* CHECK dout0_53 Vdout0_53ck129 = 0 time = 650
.meas tran vdout0_53ck129 FIND v(dout0_53) AT=650.025n

* CHECK dout0_54 Vdout0_54ck129 = 0.9 time = 650
.meas tran vdout0_54ck129 FIND v(dout0_54) AT=650.025n

* CHECK dout0_55 Vdout0_55ck129 = 0.9 time = 650
.meas tran vdout0_55ck129 FIND v(dout0_55) AT=650.025n

* CHECK dout0_56 Vdout0_56ck129 = 0 time = 650
.meas tran vdout0_56ck129 FIND v(dout0_56) AT=650.025n

* CHECK dout0_57 Vdout0_57ck129 = 0 time = 650
.meas tran vdout0_57ck129 FIND v(dout0_57) AT=650.025n

* CHECK dout0_58 Vdout0_58ck129 = 0 time = 650
.meas tran vdout0_58ck129 FIND v(dout0_58) AT=650.025n

* CHECK dout0_59 Vdout0_59ck129 = 0.9 time = 650
.meas tran vdout0_59ck129 FIND v(dout0_59) AT=650.025n

* CHECK dout0_60 Vdout0_60ck129 = 0 time = 650
.meas tran vdout0_60ck129 FIND v(dout0_60) AT=650.025n

* CHECK dout0_61 Vdout0_61ck129 = 0.9 time = 650
.meas tran vdout0_61ck129 FIND v(dout0_61) AT=650.025n

* CHECK dout0_62 Vdout0_62ck129 = 0 time = 650
.meas tran vdout0_62ck129 FIND v(dout0_62) AT=650.025n

* CHECK dout0_63 Vdout0_63ck129 = 0 time = 650
.meas tran vdout0_63ck129 FIND v(dout0_63) AT=650.025n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 660
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=660.025n

* CHECK dout0_1 Vdout0_1ck131 = 0.9 time = 660
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=660.025n

* CHECK dout0_2 Vdout0_2ck131 = 0 time = 660
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=660.025n

* CHECK dout0_3 Vdout0_3ck131 = 0 time = 660
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=660.025n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 660
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=660.025n

* CHECK dout0_5 Vdout0_5ck131 = 0.9 time = 660
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=660.025n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 660
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=660.025n

* CHECK dout0_7 Vdout0_7ck131 = 0.9 time = 660
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=660.025n

* CHECK dout0_8 Vdout0_8ck131 = 0.9 time = 660
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=660.025n

* CHECK dout0_9 Vdout0_9ck131 = 0 time = 660
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=660.025n

* CHECK dout0_10 Vdout0_10ck131 = 0.9 time = 660
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=660.025n

* CHECK dout0_11 Vdout0_11ck131 = 0 time = 660
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=660.025n

* CHECK dout0_12 Vdout0_12ck131 = 0 time = 660
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=660.025n

* CHECK dout0_13 Vdout0_13ck131 = 0.9 time = 660
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=660.025n

* CHECK dout0_14 Vdout0_14ck131 = 0.9 time = 660
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=660.025n

* CHECK dout0_15 Vdout0_15ck131 = 0.9 time = 660
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=660.025n

* CHECK dout0_16 Vdout0_16ck131 = 0.9 time = 660
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=660.025n

* CHECK dout0_17 Vdout0_17ck131 = 0 time = 660
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=660.025n

* CHECK dout0_18 Vdout0_18ck131 = 0 time = 660
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=660.025n

* CHECK dout0_19 Vdout0_19ck131 = 0 time = 660
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=660.025n

* CHECK dout0_20 Vdout0_20ck131 = 0.9 time = 660
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=660.025n

* CHECK dout0_21 Vdout0_21ck131 = 0 time = 660
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=660.025n

* CHECK dout0_22 Vdout0_22ck131 = 0.9 time = 660
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=660.025n

* CHECK dout0_23 Vdout0_23ck131 = 0.9 time = 660
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=660.025n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 660
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=660.025n

* CHECK dout0_25 Vdout0_25ck131 = 0.9 time = 660
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=660.025n

* CHECK dout0_26 Vdout0_26ck131 = 0.9 time = 660
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=660.025n

* CHECK dout0_27 Vdout0_27ck131 = 0.9 time = 660
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=660.025n

* CHECK dout0_28 Vdout0_28ck131 = 0.9 time = 660
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=660.025n

* CHECK dout0_29 Vdout0_29ck131 = 0.9 time = 660
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=660.025n

* CHECK dout0_30 Vdout0_30ck131 = 0 time = 660
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=660.025n

* CHECK dout0_31 Vdout0_31ck131 = 0.9 time = 660
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=660.025n

* CHECK dout0_32 Vdout0_32ck131 = 0 time = 660
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=660.025n

* CHECK dout0_33 Vdout0_33ck131 = 0.9 time = 660
.meas tran vdout0_33ck131 FIND v(dout0_33) AT=660.025n

* CHECK dout0_34 Vdout0_34ck131 = 0.9 time = 660
.meas tran vdout0_34ck131 FIND v(dout0_34) AT=660.025n

* CHECK dout0_35 Vdout0_35ck131 = 0 time = 660
.meas tran vdout0_35ck131 FIND v(dout0_35) AT=660.025n

* CHECK dout0_36 Vdout0_36ck131 = 0.9 time = 660
.meas tran vdout0_36ck131 FIND v(dout0_36) AT=660.025n

* CHECK dout0_37 Vdout0_37ck131 = 0 time = 660
.meas tran vdout0_37ck131 FIND v(dout0_37) AT=660.025n

* CHECK dout0_38 Vdout0_38ck131 = 0.9 time = 660
.meas tran vdout0_38ck131 FIND v(dout0_38) AT=660.025n

* CHECK dout0_39 Vdout0_39ck131 = 0 time = 660
.meas tran vdout0_39ck131 FIND v(dout0_39) AT=660.025n

* CHECK dout0_40 Vdout0_40ck131 = 0.9 time = 660
.meas tran vdout0_40ck131 FIND v(dout0_40) AT=660.025n

* CHECK dout0_41 Vdout0_41ck131 = 0 time = 660
.meas tran vdout0_41ck131 FIND v(dout0_41) AT=660.025n

* CHECK dout0_42 Vdout0_42ck131 = 0.9 time = 660
.meas tran vdout0_42ck131 FIND v(dout0_42) AT=660.025n

* CHECK dout0_43 Vdout0_43ck131 = 0 time = 660
.meas tran vdout0_43ck131 FIND v(dout0_43) AT=660.025n

* CHECK dout0_44 Vdout0_44ck131 = 0.9 time = 660
.meas tran vdout0_44ck131 FIND v(dout0_44) AT=660.025n

* CHECK dout0_45 Vdout0_45ck131 = 0.9 time = 660
.meas tran vdout0_45ck131 FIND v(dout0_45) AT=660.025n

* CHECK dout0_46 Vdout0_46ck131 = 0.9 time = 660
.meas tran vdout0_46ck131 FIND v(dout0_46) AT=660.025n

* CHECK dout0_47 Vdout0_47ck131 = 0.9 time = 660
.meas tran vdout0_47ck131 FIND v(dout0_47) AT=660.025n

* CHECK dout0_48 Vdout0_48ck131 = 0.9 time = 660
.meas tran vdout0_48ck131 FIND v(dout0_48) AT=660.025n

* CHECK dout0_49 Vdout0_49ck131 = 0 time = 660
.meas tran vdout0_49ck131 FIND v(dout0_49) AT=660.025n

* CHECK dout0_50 Vdout0_50ck131 = 0.9 time = 660
.meas tran vdout0_50ck131 FIND v(dout0_50) AT=660.025n

* CHECK dout0_51 Vdout0_51ck131 = 0.9 time = 660
.meas tran vdout0_51ck131 FIND v(dout0_51) AT=660.025n

* CHECK dout0_52 Vdout0_52ck131 = 0.9 time = 660
.meas tran vdout0_52ck131 FIND v(dout0_52) AT=660.025n

* CHECK dout0_53 Vdout0_53ck131 = 0 time = 660
.meas tran vdout0_53ck131 FIND v(dout0_53) AT=660.025n

* CHECK dout0_54 Vdout0_54ck131 = 0.9 time = 660
.meas tran vdout0_54ck131 FIND v(dout0_54) AT=660.025n

* CHECK dout0_55 Vdout0_55ck131 = 0.9 time = 660
.meas tran vdout0_55ck131 FIND v(dout0_55) AT=660.025n

* CHECK dout0_56 Vdout0_56ck131 = 0.9 time = 660
.meas tran vdout0_56ck131 FIND v(dout0_56) AT=660.025n

* CHECK dout0_57 Vdout0_57ck131 = 0 time = 660
.meas tran vdout0_57ck131 FIND v(dout0_57) AT=660.025n

* CHECK dout0_58 Vdout0_58ck131 = 0.9 time = 660
.meas tran vdout0_58ck131 FIND v(dout0_58) AT=660.025n

* CHECK dout0_59 Vdout0_59ck131 = 0.9 time = 660
.meas tran vdout0_59ck131 FIND v(dout0_59) AT=660.025n

* CHECK dout0_60 Vdout0_60ck131 = 0.9 time = 660
.meas tran vdout0_60ck131 FIND v(dout0_60) AT=660.025n

* CHECK dout0_61 Vdout0_61ck131 = 0 time = 660
.meas tran vdout0_61ck131 FIND v(dout0_61) AT=660.025n

* CHECK dout0_62 Vdout0_62ck131 = 0 time = 660
.meas tran vdout0_62ck131 FIND v(dout0_62) AT=660.025n

* CHECK dout0_63 Vdout0_63ck131 = 0.9 time = 660
.meas tran vdout0_63ck131 FIND v(dout0_63) AT=660.025n

* CHECK dout0_0 Vdout0_0ck132 = 0 time = 665
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=665.025n

* CHECK dout0_1 Vdout0_1ck132 = 0.9 time = 665
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=665.025n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 665
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=665.025n

* CHECK dout0_3 Vdout0_3ck132 = 0.9 time = 665
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=665.025n

* CHECK dout0_4 Vdout0_4ck132 = 0 time = 665
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=665.025n

* CHECK dout0_5 Vdout0_5ck132 = 0 time = 665
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=665.025n

* CHECK dout0_6 Vdout0_6ck132 = 0.9 time = 665
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=665.025n

* CHECK dout0_7 Vdout0_7ck132 = 0.9 time = 665
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=665.025n

* CHECK dout0_8 Vdout0_8ck132 = 0 time = 665
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=665.025n

* CHECK dout0_9 Vdout0_9ck132 = 0 time = 665
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=665.025n

* CHECK dout0_10 Vdout0_10ck132 = 0.9 time = 665
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=665.025n

* CHECK dout0_11 Vdout0_11ck132 = 0.9 time = 665
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=665.025n

* CHECK dout0_12 Vdout0_12ck132 = 0.9 time = 665
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=665.025n

* CHECK dout0_13 Vdout0_13ck132 = 0.9 time = 665
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=665.025n

* CHECK dout0_14 Vdout0_14ck132 = 0.9 time = 665
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=665.025n

* CHECK dout0_15 Vdout0_15ck132 = 0.9 time = 665
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=665.025n

* CHECK dout0_16 Vdout0_16ck132 = 0.9 time = 665
.meas tran vdout0_16ck132 FIND v(dout0_16) AT=665.025n

* CHECK dout0_17 Vdout0_17ck132 = 0 time = 665
.meas tran vdout0_17ck132 FIND v(dout0_17) AT=665.025n

* CHECK dout0_18 Vdout0_18ck132 = 0.9 time = 665
.meas tran vdout0_18ck132 FIND v(dout0_18) AT=665.025n

* CHECK dout0_19 Vdout0_19ck132 = 0.9 time = 665
.meas tran vdout0_19ck132 FIND v(dout0_19) AT=665.025n

* CHECK dout0_20 Vdout0_20ck132 = 0 time = 665
.meas tran vdout0_20ck132 FIND v(dout0_20) AT=665.025n

* CHECK dout0_21 Vdout0_21ck132 = 0 time = 665
.meas tran vdout0_21ck132 FIND v(dout0_21) AT=665.025n

* CHECK dout0_22 Vdout0_22ck132 = 0 time = 665
.meas tran vdout0_22ck132 FIND v(dout0_22) AT=665.025n

* CHECK dout0_23 Vdout0_23ck132 = 0 time = 665
.meas tran vdout0_23ck132 FIND v(dout0_23) AT=665.025n

* CHECK dout0_24 Vdout0_24ck132 = 0.9 time = 665
.meas tran vdout0_24ck132 FIND v(dout0_24) AT=665.025n

* CHECK dout0_25 Vdout0_25ck132 = 0.9 time = 665
.meas tran vdout0_25ck132 FIND v(dout0_25) AT=665.025n

* CHECK dout0_26 Vdout0_26ck132 = 0 time = 665
.meas tran vdout0_26ck132 FIND v(dout0_26) AT=665.025n

* CHECK dout0_27 Vdout0_27ck132 = 0.9 time = 665
.meas tran vdout0_27ck132 FIND v(dout0_27) AT=665.025n

* CHECK dout0_28 Vdout0_28ck132 = 0.9 time = 665
.meas tran vdout0_28ck132 FIND v(dout0_28) AT=665.025n

* CHECK dout0_29 Vdout0_29ck132 = 0.9 time = 665
.meas tran vdout0_29ck132 FIND v(dout0_29) AT=665.025n

* CHECK dout0_30 Vdout0_30ck132 = 0 time = 665
.meas tran vdout0_30ck132 FIND v(dout0_30) AT=665.025n

* CHECK dout0_31 Vdout0_31ck132 = 0 time = 665
.meas tran vdout0_31ck132 FIND v(dout0_31) AT=665.025n

* CHECK dout0_32 Vdout0_32ck132 = 0.9 time = 665
.meas tran vdout0_32ck132 FIND v(dout0_32) AT=665.025n

* CHECK dout0_33 Vdout0_33ck132 = 0.9 time = 665
.meas tran vdout0_33ck132 FIND v(dout0_33) AT=665.025n

* CHECK dout0_34 Vdout0_34ck132 = 0 time = 665
.meas tran vdout0_34ck132 FIND v(dout0_34) AT=665.025n

* CHECK dout0_35 Vdout0_35ck132 = 0 time = 665
.meas tran vdout0_35ck132 FIND v(dout0_35) AT=665.025n

* CHECK dout0_36 Vdout0_36ck132 = 0.9 time = 665
.meas tran vdout0_36ck132 FIND v(dout0_36) AT=665.025n

* CHECK dout0_37 Vdout0_37ck132 = 0 time = 665
.meas tran vdout0_37ck132 FIND v(dout0_37) AT=665.025n

* CHECK dout0_38 Vdout0_38ck132 = 0.9 time = 665
.meas tran vdout0_38ck132 FIND v(dout0_38) AT=665.025n

* CHECK dout0_39 Vdout0_39ck132 = 0.9 time = 665
.meas tran vdout0_39ck132 FIND v(dout0_39) AT=665.025n

* CHECK dout0_40 Vdout0_40ck132 = 0 time = 665
.meas tran vdout0_40ck132 FIND v(dout0_40) AT=665.025n

* CHECK dout0_41 Vdout0_41ck132 = 0.9 time = 665
.meas tran vdout0_41ck132 FIND v(dout0_41) AT=665.025n

* CHECK dout0_42 Vdout0_42ck132 = 0 time = 665
.meas tran vdout0_42ck132 FIND v(dout0_42) AT=665.025n

* CHECK dout0_43 Vdout0_43ck132 = 0.9 time = 665
.meas tran vdout0_43ck132 FIND v(dout0_43) AT=665.025n

* CHECK dout0_44 Vdout0_44ck132 = 0.9 time = 665
.meas tran vdout0_44ck132 FIND v(dout0_44) AT=665.025n

* CHECK dout0_45 Vdout0_45ck132 = 0 time = 665
.meas tran vdout0_45ck132 FIND v(dout0_45) AT=665.025n

* CHECK dout0_46 Vdout0_46ck132 = 0 time = 665
.meas tran vdout0_46ck132 FIND v(dout0_46) AT=665.025n

* CHECK dout0_47 Vdout0_47ck132 = 0.9 time = 665
.meas tran vdout0_47ck132 FIND v(dout0_47) AT=665.025n

* CHECK dout0_48 Vdout0_48ck132 = 0.9 time = 665
.meas tran vdout0_48ck132 FIND v(dout0_48) AT=665.025n

* CHECK dout0_49 Vdout0_49ck132 = 0.9 time = 665
.meas tran vdout0_49ck132 FIND v(dout0_49) AT=665.025n

* CHECK dout0_50 Vdout0_50ck132 = 0.9 time = 665
.meas tran vdout0_50ck132 FIND v(dout0_50) AT=665.025n

* CHECK dout0_51 Vdout0_51ck132 = 0 time = 665
.meas tran vdout0_51ck132 FIND v(dout0_51) AT=665.025n

* CHECK dout0_52 Vdout0_52ck132 = 0.9 time = 665
.meas tran vdout0_52ck132 FIND v(dout0_52) AT=665.025n

* CHECK dout0_53 Vdout0_53ck132 = 0 time = 665
.meas tran vdout0_53ck132 FIND v(dout0_53) AT=665.025n

* CHECK dout0_54 Vdout0_54ck132 = 0.9 time = 665
.meas tran vdout0_54ck132 FIND v(dout0_54) AT=665.025n

* CHECK dout0_55 Vdout0_55ck132 = 0.9 time = 665
.meas tran vdout0_55ck132 FIND v(dout0_55) AT=665.025n

* CHECK dout0_56 Vdout0_56ck132 = 0 time = 665
.meas tran vdout0_56ck132 FIND v(dout0_56) AT=665.025n

* CHECK dout0_57 Vdout0_57ck132 = 0 time = 665
.meas tran vdout0_57ck132 FIND v(dout0_57) AT=665.025n

* CHECK dout0_58 Vdout0_58ck132 = 0 time = 665
.meas tran vdout0_58ck132 FIND v(dout0_58) AT=665.025n

* CHECK dout0_59 Vdout0_59ck132 = 0.9 time = 665
.meas tran vdout0_59ck132 FIND v(dout0_59) AT=665.025n

* CHECK dout0_60 Vdout0_60ck132 = 0 time = 665
.meas tran vdout0_60ck132 FIND v(dout0_60) AT=665.025n

* CHECK dout0_61 Vdout0_61ck132 = 0.9 time = 665
.meas tran vdout0_61ck132 FIND v(dout0_61) AT=665.025n

* CHECK dout0_62 Vdout0_62ck132 = 0 time = 665
.meas tran vdout0_62ck132 FIND v(dout0_62) AT=665.025n

* CHECK dout0_63 Vdout0_63ck132 = 0 time = 665
.meas tran vdout0_63ck132 FIND v(dout0_63) AT=665.025n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 670
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=670.025n

* CHECK dout0_1 Vdout0_1ck133 = 0.9 time = 670
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=670.025n

* CHECK dout0_2 Vdout0_2ck133 = 0 time = 670
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=670.025n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 670
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=670.025n

* CHECK dout0_4 Vdout0_4ck133 = 0 time = 670
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=670.025n

* CHECK dout0_5 Vdout0_5ck133 = 0.9 time = 670
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=670.025n

* CHECK dout0_6 Vdout0_6ck133 = 0 time = 670
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=670.025n

* CHECK dout0_7 Vdout0_7ck133 = 0.9 time = 670
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=670.025n

* CHECK dout0_8 Vdout0_8ck133 = 0.9 time = 670
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=670.025n

* CHECK dout0_9 Vdout0_9ck133 = 0 time = 670
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=670.025n

* CHECK dout0_10 Vdout0_10ck133 = 0.9 time = 670
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=670.025n

* CHECK dout0_11 Vdout0_11ck133 = 0 time = 670
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=670.025n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 670
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=670.025n

* CHECK dout0_13 Vdout0_13ck133 = 0.9 time = 670
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=670.025n

* CHECK dout0_14 Vdout0_14ck133 = 0.9 time = 670
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=670.025n

* CHECK dout0_15 Vdout0_15ck133 = 0.9 time = 670
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=670.025n

* CHECK dout0_16 Vdout0_16ck133 = 0.9 time = 670
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=670.025n

* CHECK dout0_17 Vdout0_17ck133 = 0 time = 670
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=670.025n

* CHECK dout0_18 Vdout0_18ck133 = 0 time = 670
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=670.025n

* CHECK dout0_19 Vdout0_19ck133 = 0 time = 670
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=670.025n

* CHECK dout0_20 Vdout0_20ck133 = 0.9 time = 670
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=670.025n

* CHECK dout0_21 Vdout0_21ck133 = 0 time = 670
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=670.025n

* CHECK dout0_22 Vdout0_22ck133 = 0.9 time = 670
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=670.025n

* CHECK dout0_23 Vdout0_23ck133 = 0.9 time = 670
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=670.025n

* CHECK dout0_24 Vdout0_24ck133 = 0 time = 670
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=670.025n

* CHECK dout0_25 Vdout0_25ck133 = 0.9 time = 670
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=670.025n

* CHECK dout0_26 Vdout0_26ck133 = 0.9 time = 670
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=670.025n

* CHECK dout0_27 Vdout0_27ck133 = 0.9 time = 670
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=670.025n

* CHECK dout0_28 Vdout0_28ck133 = 0.9 time = 670
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=670.025n

* CHECK dout0_29 Vdout0_29ck133 = 0.9 time = 670
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=670.025n

* CHECK dout0_30 Vdout0_30ck133 = 0 time = 670
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=670.025n

* CHECK dout0_31 Vdout0_31ck133 = 0.9 time = 670
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=670.025n

* CHECK dout0_32 Vdout0_32ck133 = 0 time = 670
.meas tran vdout0_32ck133 FIND v(dout0_32) AT=670.025n

* CHECK dout0_33 Vdout0_33ck133 = 0.9 time = 670
.meas tran vdout0_33ck133 FIND v(dout0_33) AT=670.025n

* CHECK dout0_34 Vdout0_34ck133 = 0.9 time = 670
.meas tran vdout0_34ck133 FIND v(dout0_34) AT=670.025n

* CHECK dout0_35 Vdout0_35ck133 = 0 time = 670
.meas tran vdout0_35ck133 FIND v(dout0_35) AT=670.025n

* CHECK dout0_36 Vdout0_36ck133 = 0.9 time = 670
.meas tran vdout0_36ck133 FIND v(dout0_36) AT=670.025n

* CHECK dout0_37 Vdout0_37ck133 = 0 time = 670
.meas tran vdout0_37ck133 FIND v(dout0_37) AT=670.025n

* CHECK dout0_38 Vdout0_38ck133 = 0.9 time = 670
.meas tran vdout0_38ck133 FIND v(dout0_38) AT=670.025n

* CHECK dout0_39 Vdout0_39ck133 = 0 time = 670
.meas tran vdout0_39ck133 FIND v(dout0_39) AT=670.025n

* CHECK dout0_40 Vdout0_40ck133 = 0.9 time = 670
.meas tran vdout0_40ck133 FIND v(dout0_40) AT=670.025n

* CHECK dout0_41 Vdout0_41ck133 = 0 time = 670
.meas tran vdout0_41ck133 FIND v(dout0_41) AT=670.025n

* CHECK dout0_42 Vdout0_42ck133 = 0.9 time = 670
.meas tran vdout0_42ck133 FIND v(dout0_42) AT=670.025n

* CHECK dout0_43 Vdout0_43ck133 = 0 time = 670
.meas tran vdout0_43ck133 FIND v(dout0_43) AT=670.025n

* CHECK dout0_44 Vdout0_44ck133 = 0.9 time = 670
.meas tran vdout0_44ck133 FIND v(dout0_44) AT=670.025n

* CHECK dout0_45 Vdout0_45ck133 = 0.9 time = 670
.meas tran vdout0_45ck133 FIND v(dout0_45) AT=670.025n

* CHECK dout0_46 Vdout0_46ck133 = 0.9 time = 670
.meas tran vdout0_46ck133 FIND v(dout0_46) AT=670.025n

* CHECK dout0_47 Vdout0_47ck133 = 0.9 time = 670
.meas tran vdout0_47ck133 FIND v(dout0_47) AT=670.025n

* CHECK dout0_48 Vdout0_48ck133 = 0.9 time = 670
.meas tran vdout0_48ck133 FIND v(dout0_48) AT=670.025n

* CHECK dout0_49 Vdout0_49ck133 = 0 time = 670
.meas tran vdout0_49ck133 FIND v(dout0_49) AT=670.025n

* CHECK dout0_50 Vdout0_50ck133 = 0.9 time = 670
.meas tran vdout0_50ck133 FIND v(dout0_50) AT=670.025n

* CHECK dout0_51 Vdout0_51ck133 = 0.9 time = 670
.meas tran vdout0_51ck133 FIND v(dout0_51) AT=670.025n

* CHECK dout0_52 Vdout0_52ck133 = 0.9 time = 670
.meas tran vdout0_52ck133 FIND v(dout0_52) AT=670.025n

* CHECK dout0_53 Vdout0_53ck133 = 0 time = 670
.meas tran vdout0_53ck133 FIND v(dout0_53) AT=670.025n

* CHECK dout0_54 Vdout0_54ck133 = 0.9 time = 670
.meas tran vdout0_54ck133 FIND v(dout0_54) AT=670.025n

* CHECK dout0_55 Vdout0_55ck133 = 0.9 time = 670
.meas tran vdout0_55ck133 FIND v(dout0_55) AT=670.025n

* CHECK dout0_56 Vdout0_56ck133 = 0.9 time = 670
.meas tran vdout0_56ck133 FIND v(dout0_56) AT=670.025n

* CHECK dout0_57 Vdout0_57ck133 = 0 time = 670
.meas tran vdout0_57ck133 FIND v(dout0_57) AT=670.025n

* CHECK dout0_58 Vdout0_58ck133 = 0.9 time = 670
.meas tran vdout0_58ck133 FIND v(dout0_58) AT=670.025n

* CHECK dout0_59 Vdout0_59ck133 = 0.9 time = 670
.meas tran vdout0_59ck133 FIND v(dout0_59) AT=670.025n

* CHECK dout0_60 Vdout0_60ck133 = 0.9 time = 670
.meas tran vdout0_60ck133 FIND v(dout0_60) AT=670.025n

* CHECK dout0_61 Vdout0_61ck133 = 0 time = 670
.meas tran vdout0_61ck133 FIND v(dout0_61) AT=670.025n

* CHECK dout0_62 Vdout0_62ck133 = 0 time = 670
.meas tran vdout0_62ck133 FIND v(dout0_62) AT=670.025n

* CHECK dout0_63 Vdout0_63ck133 = 0.9 time = 670
.meas tran vdout0_63ck133 FIND v(dout0_63) AT=670.025n

* CHECK dout0_0 Vdout0_0ck135 = 0 time = 680
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=680.025n

* CHECK dout0_1 Vdout0_1ck135 = 0.9 time = 680
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=680.025n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 680
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=680.025n

* CHECK dout0_3 Vdout0_3ck135 = 0 time = 680
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=680.025n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 680
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=680.025n

* CHECK dout0_5 Vdout0_5ck135 = 0.9 time = 680
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=680.025n

* CHECK dout0_6 Vdout0_6ck135 = 0 time = 680
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=680.025n

* CHECK dout0_7 Vdout0_7ck135 = 0.9 time = 680
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=680.025n

* CHECK dout0_8 Vdout0_8ck135 = 0.9 time = 680
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=680.025n

* CHECK dout0_9 Vdout0_9ck135 = 0 time = 680
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=680.025n

* CHECK dout0_10 Vdout0_10ck135 = 0.9 time = 680
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=680.025n

* CHECK dout0_11 Vdout0_11ck135 = 0 time = 680
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=680.025n

* CHECK dout0_12 Vdout0_12ck135 = 0 time = 680
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=680.025n

* CHECK dout0_13 Vdout0_13ck135 = 0.9 time = 680
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=680.025n

* CHECK dout0_14 Vdout0_14ck135 = 0.9 time = 680
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=680.025n

* CHECK dout0_15 Vdout0_15ck135 = 0.9 time = 680
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=680.025n

* CHECK dout0_16 Vdout0_16ck135 = 0.9 time = 680
.meas tran vdout0_16ck135 FIND v(dout0_16) AT=680.025n

* CHECK dout0_17 Vdout0_17ck135 = 0 time = 680
.meas tran vdout0_17ck135 FIND v(dout0_17) AT=680.025n

* CHECK dout0_18 Vdout0_18ck135 = 0 time = 680
.meas tran vdout0_18ck135 FIND v(dout0_18) AT=680.025n

* CHECK dout0_19 Vdout0_19ck135 = 0 time = 680
.meas tran vdout0_19ck135 FIND v(dout0_19) AT=680.025n

* CHECK dout0_20 Vdout0_20ck135 = 0.9 time = 680
.meas tran vdout0_20ck135 FIND v(dout0_20) AT=680.025n

* CHECK dout0_21 Vdout0_21ck135 = 0 time = 680
.meas tran vdout0_21ck135 FIND v(dout0_21) AT=680.025n

* CHECK dout0_22 Vdout0_22ck135 = 0.9 time = 680
.meas tran vdout0_22ck135 FIND v(dout0_22) AT=680.025n

* CHECK dout0_23 Vdout0_23ck135 = 0.9 time = 680
.meas tran vdout0_23ck135 FIND v(dout0_23) AT=680.025n

* CHECK dout0_24 Vdout0_24ck135 = 0 time = 680
.meas tran vdout0_24ck135 FIND v(dout0_24) AT=680.025n

* CHECK dout0_25 Vdout0_25ck135 = 0.9 time = 680
.meas tran vdout0_25ck135 FIND v(dout0_25) AT=680.025n

* CHECK dout0_26 Vdout0_26ck135 = 0.9 time = 680
.meas tran vdout0_26ck135 FIND v(dout0_26) AT=680.025n

* CHECK dout0_27 Vdout0_27ck135 = 0.9 time = 680
.meas tran vdout0_27ck135 FIND v(dout0_27) AT=680.025n

* CHECK dout0_28 Vdout0_28ck135 = 0.9 time = 680
.meas tran vdout0_28ck135 FIND v(dout0_28) AT=680.025n

* CHECK dout0_29 Vdout0_29ck135 = 0.9 time = 680
.meas tran vdout0_29ck135 FIND v(dout0_29) AT=680.025n

* CHECK dout0_30 Vdout0_30ck135 = 0 time = 680
.meas tran vdout0_30ck135 FIND v(dout0_30) AT=680.025n

* CHECK dout0_31 Vdout0_31ck135 = 0.9 time = 680
.meas tran vdout0_31ck135 FIND v(dout0_31) AT=680.025n

* CHECK dout0_32 Vdout0_32ck135 = 0 time = 680
.meas tran vdout0_32ck135 FIND v(dout0_32) AT=680.025n

* CHECK dout0_33 Vdout0_33ck135 = 0.9 time = 680
.meas tran vdout0_33ck135 FIND v(dout0_33) AT=680.025n

* CHECK dout0_34 Vdout0_34ck135 = 0.9 time = 680
.meas tran vdout0_34ck135 FIND v(dout0_34) AT=680.025n

* CHECK dout0_35 Vdout0_35ck135 = 0 time = 680
.meas tran vdout0_35ck135 FIND v(dout0_35) AT=680.025n

* CHECK dout0_36 Vdout0_36ck135 = 0.9 time = 680
.meas tran vdout0_36ck135 FIND v(dout0_36) AT=680.025n

* CHECK dout0_37 Vdout0_37ck135 = 0 time = 680
.meas tran vdout0_37ck135 FIND v(dout0_37) AT=680.025n

* CHECK dout0_38 Vdout0_38ck135 = 0.9 time = 680
.meas tran vdout0_38ck135 FIND v(dout0_38) AT=680.025n

* CHECK dout0_39 Vdout0_39ck135 = 0 time = 680
.meas tran vdout0_39ck135 FIND v(dout0_39) AT=680.025n

* CHECK dout0_40 Vdout0_40ck135 = 0.9 time = 680
.meas tran vdout0_40ck135 FIND v(dout0_40) AT=680.025n

* CHECK dout0_41 Vdout0_41ck135 = 0 time = 680
.meas tran vdout0_41ck135 FIND v(dout0_41) AT=680.025n

* CHECK dout0_42 Vdout0_42ck135 = 0.9 time = 680
.meas tran vdout0_42ck135 FIND v(dout0_42) AT=680.025n

* CHECK dout0_43 Vdout0_43ck135 = 0 time = 680
.meas tran vdout0_43ck135 FIND v(dout0_43) AT=680.025n

* CHECK dout0_44 Vdout0_44ck135 = 0.9 time = 680
.meas tran vdout0_44ck135 FIND v(dout0_44) AT=680.025n

* CHECK dout0_45 Vdout0_45ck135 = 0.9 time = 680
.meas tran vdout0_45ck135 FIND v(dout0_45) AT=680.025n

* CHECK dout0_46 Vdout0_46ck135 = 0.9 time = 680
.meas tran vdout0_46ck135 FIND v(dout0_46) AT=680.025n

* CHECK dout0_47 Vdout0_47ck135 = 0.9 time = 680
.meas tran vdout0_47ck135 FIND v(dout0_47) AT=680.025n

* CHECK dout0_48 Vdout0_48ck135 = 0.9 time = 680
.meas tran vdout0_48ck135 FIND v(dout0_48) AT=680.025n

* CHECK dout0_49 Vdout0_49ck135 = 0 time = 680
.meas tran vdout0_49ck135 FIND v(dout0_49) AT=680.025n

* CHECK dout0_50 Vdout0_50ck135 = 0.9 time = 680
.meas tran vdout0_50ck135 FIND v(dout0_50) AT=680.025n

* CHECK dout0_51 Vdout0_51ck135 = 0.9 time = 680
.meas tran vdout0_51ck135 FIND v(dout0_51) AT=680.025n

* CHECK dout0_52 Vdout0_52ck135 = 0.9 time = 680
.meas tran vdout0_52ck135 FIND v(dout0_52) AT=680.025n

* CHECK dout0_53 Vdout0_53ck135 = 0 time = 680
.meas tran vdout0_53ck135 FIND v(dout0_53) AT=680.025n

* CHECK dout0_54 Vdout0_54ck135 = 0.9 time = 680
.meas tran vdout0_54ck135 FIND v(dout0_54) AT=680.025n

* CHECK dout0_55 Vdout0_55ck135 = 0.9 time = 680
.meas tran vdout0_55ck135 FIND v(dout0_55) AT=680.025n

* CHECK dout0_56 Vdout0_56ck135 = 0.9 time = 680
.meas tran vdout0_56ck135 FIND v(dout0_56) AT=680.025n

* CHECK dout0_57 Vdout0_57ck135 = 0 time = 680
.meas tran vdout0_57ck135 FIND v(dout0_57) AT=680.025n

* CHECK dout0_58 Vdout0_58ck135 = 0.9 time = 680
.meas tran vdout0_58ck135 FIND v(dout0_58) AT=680.025n

* CHECK dout0_59 Vdout0_59ck135 = 0.9 time = 680
.meas tran vdout0_59ck135 FIND v(dout0_59) AT=680.025n

* CHECK dout0_60 Vdout0_60ck135 = 0.9 time = 680
.meas tran vdout0_60ck135 FIND v(dout0_60) AT=680.025n

* CHECK dout0_61 Vdout0_61ck135 = 0 time = 680
.meas tran vdout0_61ck135 FIND v(dout0_61) AT=680.025n

* CHECK dout0_62 Vdout0_62ck135 = 0 time = 680
.meas tran vdout0_62ck135 FIND v(dout0_62) AT=680.025n

* CHECK dout0_63 Vdout0_63ck135 = 0.9 time = 680
.meas tran vdout0_63ck135 FIND v(dout0_63) AT=680.025n

* CHECK dout0_0 Vdout0_0ck139 = 0.9 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 0.9 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0.9 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0.9 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 0 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 0 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0.9 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0.9 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 0 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 0 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0.9 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 0.9 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 0 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 0.9 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 0.9 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0.9 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0.9 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0.9 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_32 Vdout0_32ck139 = 0.9 time = 700
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=700.025n

* CHECK dout0_33 Vdout0_33ck139 = 0 time = 700
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=700.025n

* CHECK dout0_34 Vdout0_34ck139 = 0 time = 700
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=700.025n

* CHECK dout0_35 Vdout0_35ck139 = 0 time = 700
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=700.025n

* CHECK dout0_36 Vdout0_36ck139 = 0.9 time = 700
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=700.025n

* CHECK dout0_37 Vdout0_37ck139 = 0.9 time = 700
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=700.025n

* CHECK dout0_38 Vdout0_38ck139 = 0.9 time = 700
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=700.025n

* CHECK dout0_39 Vdout0_39ck139 = 0 time = 700
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=700.025n

* CHECK dout0_40 Vdout0_40ck139 = 0.9 time = 700
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=700.025n

* CHECK dout0_41 Vdout0_41ck139 = 0 time = 700
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=700.025n

* CHECK dout0_42 Vdout0_42ck139 = 0.9 time = 700
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=700.025n

* CHECK dout0_43 Vdout0_43ck139 = 0.9 time = 700
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=700.025n

* CHECK dout0_44 Vdout0_44ck139 = 0 time = 700
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=700.025n

* CHECK dout0_45 Vdout0_45ck139 = 0.9 time = 700
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=700.025n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 700
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=700.025n

* CHECK dout0_47 Vdout0_47ck139 = 0 time = 700
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=700.025n

* CHECK dout0_48 Vdout0_48ck139 = 0 time = 700
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=700.025n

* CHECK dout0_49 Vdout0_49ck139 = 0.9 time = 700
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=700.025n

* CHECK dout0_50 Vdout0_50ck139 = 0 time = 700
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=700.025n

* CHECK dout0_51 Vdout0_51ck139 = 0 time = 700
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=700.025n

* CHECK dout0_52 Vdout0_52ck139 = 0.9 time = 700
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=700.025n

* CHECK dout0_53 Vdout0_53ck139 = 0 time = 700
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=700.025n

* CHECK dout0_54 Vdout0_54ck139 = 0.9 time = 700
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=700.025n

* CHECK dout0_55 Vdout0_55ck139 = 0 time = 700
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=700.025n

* CHECK dout0_56 Vdout0_56ck139 = 0 time = 700
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=700.025n

* CHECK dout0_57 Vdout0_57ck139 = 0 time = 700
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=700.025n

* CHECK dout0_58 Vdout0_58ck139 = 0 time = 700
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=700.025n

* CHECK dout0_59 Vdout0_59ck139 = 0 time = 700
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=700.025n

* CHECK dout0_60 Vdout0_60ck139 = 0 time = 700
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=700.025n

* CHECK dout0_61 Vdout0_61ck139 = 0.9 time = 700
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=700.025n

* CHECK dout0_62 Vdout0_62ck139 = 0.9 time = 700
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=700.025n

* CHECK dout0_63 Vdout0_63ck139 = 0.9 time = 700
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=700.025n

* CHECK dout0_0 Vdout0_0ck140 = 0.9 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 0.9 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0.9 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 0 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 0 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 0.9 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 0 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 0 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 0 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 0 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 0.9 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 0.9 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0.9 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 0 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 0 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 0 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 0.9 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 0 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 0.9 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 0.9 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 0 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 0.9 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 0.9 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 0.9 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_32 Vdout0_32ck140 = 0.9 time = 705
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=705.025n

* CHECK dout0_33 Vdout0_33ck140 = 0 time = 705
.meas tran vdout0_33ck140 FIND v(dout0_33) AT=705.025n

* CHECK dout0_34 Vdout0_34ck140 = 0 time = 705
.meas tran vdout0_34ck140 FIND v(dout0_34) AT=705.025n

* CHECK dout0_35 Vdout0_35ck140 = 0 time = 705
.meas tran vdout0_35ck140 FIND v(dout0_35) AT=705.025n

* CHECK dout0_36 Vdout0_36ck140 = 0.9 time = 705
.meas tran vdout0_36ck140 FIND v(dout0_36) AT=705.025n

* CHECK dout0_37 Vdout0_37ck140 = 0.9 time = 705
.meas tran vdout0_37ck140 FIND v(dout0_37) AT=705.025n

* CHECK dout0_38 Vdout0_38ck140 = 0.9 time = 705
.meas tran vdout0_38ck140 FIND v(dout0_38) AT=705.025n

* CHECK dout0_39 Vdout0_39ck140 = 0 time = 705
.meas tran vdout0_39ck140 FIND v(dout0_39) AT=705.025n

* CHECK dout0_40 Vdout0_40ck140 = 0.9 time = 705
.meas tran vdout0_40ck140 FIND v(dout0_40) AT=705.025n

* CHECK dout0_41 Vdout0_41ck140 = 0 time = 705
.meas tran vdout0_41ck140 FIND v(dout0_41) AT=705.025n

* CHECK dout0_42 Vdout0_42ck140 = 0.9 time = 705
.meas tran vdout0_42ck140 FIND v(dout0_42) AT=705.025n

* CHECK dout0_43 Vdout0_43ck140 = 0.9 time = 705
.meas tran vdout0_43ck140 FIND v(dout0_43) AT=705.025n

* CHECK dout0_44 Vdout0_44ck140 = 0 time = 705
.meas tran vdout0_44ck140 FIND v(dout0_44) AT=705.025n

* CHECK dout0_45 Vdout0_45ck140 = 0.9 time = 705
.meas tran vdout0_45ck140 FIND v(dout0_45) AT=705.025n

* CHECK dout0_46 Vdout0_46ck140 = 0 time = 705
.meas tran vdout0_46ck140 FIND v(dout0_46) AT=705.025n

* CHECK dout0_47 Vdout0_47ck140 = 0 time = 705
.meas tran vdout0_47ck140 FIND v(dout0_47) AT=705.025n

* CHECK dout0_48 Vdout0_48ck140 = 0 time = 705
.meas tran vdout0_48ck140 FIND v(dout0_48) AT=705.025n

* CHECK dout0_49 Vdout0_49ck140 = 0.9 time = 705
.meas tran vdout0_49ck140 FIND v(dout0_49) AT=705.025n

* CHECK dout0_50 Vdout0_50ck140 = 0 time = 705
.meas tran vdout0_50ck140 FIND v(dout0_50) AT=705.025n

* CHECK dout0_51 Vdout0_51ck140 = 0 time = 705
.meas tran vdout0_51ck140 FIND v(dout0_51) AT=705.025n

* CHECK dout0_52 Vdout0_52ck140 = 0.9 time = 705
.meas tran vdout0_52ck140 FIND v(dout0_52) AT=705.025n

* CHECK dout0_53 Vdout0_53ck140 = 0 time = 705
.meas tran vdout0_53ck140 FIND v(dout0_53) AT=705.025n

* CHECK dout0_54 Vdout0_54ck140 = 0.9 time = 705
.meas tran vdout0_54ck140 FIND v(dout0_54) AT=705.025n

* CHECK dout0_55 Vdout0_55ck140 = 0 time = 705
.meas tran vdout0_55ck140 FIND v(dout0_55) AT=705.025n

* CHECK dout0_56 Vdout0_56ck140 = 0 time = 705
.meas tran vdout0_56ck140 FIND v(dout0_56) AT=705.025n

* CHECK dout0_57 Vdout0_57ck140 = 0 time = 705
.meas tran vdout0_57ck140 FIND v(dout0_57) AT=705.025n

* CHECK dout0_58 Vdout0_58ck140 = 0 time = 705
.meas tran vdout0_58ck140 FIND v(dout0_58) AT=705.025n

* CHECK dout0_59 Vdout0_59ck140 = 0 time = 705
.meas tran vdout0_59ck140 FIND v(dout0_59) AT=705.025n

* CHECK dout0_60 Vdout0_60ck140 = 0 time = 705
.meas tran vdout0_60ck140 FIND v(dout0_60) AT=705.025n

* CHECK dout0_61 Vdout0_61ck140 = 0.9 time = 705
.meas tran vdout0_61ck140 FIND v(dout0_61) AT=705.025n

* CHECK dout0_62 Vdout0_62ck140 = 0.9 time = 705
.meas tran vdout0_62ck140 FIND v(dout0_62) AT=705.025n

* CHECK dout0_63 Vdout0_63ck140 = 0.9 time = 705
.meas tran vdout0_63ck140 FIND v(dout0_63) AT=705.025n

* CHECK dout0_0 Vdout0_0ck141 = 0.9 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 0.9 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0.9 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0.9 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 0 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 0 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0.9 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 0.9 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 0 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 0 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 0 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 0.9 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 0 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 0 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 0 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 0.9 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 0 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0.9 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 0.9 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 0.9 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0.9 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 0.9 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_32 Vdout0_32ck141 = 0.9 time = 710
.meas tran vdout0_32ck141 FIND v(dout0_32) AT=710.025n

* CHECK dout0_33 Vdout0_33ck141 = 0 time = 710
.meas tran vdout0_33ck141 FIND v(dout0_33) AT=710.025n

* CHECK dout0_34 Vdout0_34ck141 = 0 time = 710
.meas tran vdout0_34ck141 FIND v(dout0_34) AT=710.025n

* CHECK dout0_35 Vdout0_35ck141 = 0 time = 710
.meas tran vdout0_35ck141 FIND v(dout0_35) AT=710.025n

* CHECK dout0_36 Vdout0_36ck141 = 0.9 time = 710
.meas tran vdout0_36ck141 FIND v(dout0_36) AT=710.025n

* CHECK dout0_37 Vdout0_37ck141 = 0.9 time = 710
.meas tran vdout0_37ck141 FIND v(dout0_37) AT=710.025n

* CHECK dout0_38 Vdout0_38ck141 = 0.9 time = 710
.meas tran vdout0_38ck141 FIND v(dout0_38) AT=710.025n

* CHECK dout0_39 Vdout0_39ck141 = 0 time = 710
.meas tran vdout0_39ck141 FIND v(dout0_39) AT=710.025n

* CHECK dout0_40 Vdout0_40ck141 = 0.9 time = 710
.meas tran vdout0_40ck141 FIND v(dout0_40) AT=710.025n

* CHECK dout0_41 Vdout0_41ck141 = 0 time = 710
.meas tran vdout0_41ck141 FIND v(dout0_41) AT=710.025n

* CHECK dout0_42 Vdout0_42ck141 = 0.9 time = 710
.meas tran vdout0_42ck141 FIND v(dout0_42) AT=710.025n

* CHECK dout0_43 Vdout0_43ck141 = 0.9 time = 710
.meas tran vdout0_43ck141 FIND v(dout0_43) AT=710.025n

* CHECK dout0_44 Vdout0_44ck141 = 0 time = 710
.meas tran vdout0_44ck141 FIND v(dout0_44) AT=710.025n

* CHECK dout0_45 Vdout0_45ck141 = 0.9 time = 710
.meas tran vdout0_45ck141 FIND v(dout0_45) AT=710.025n

* CHECK dout0_46 Vdout0_46ck141 = 0 time = 710
.meas tran vdout0_46ck141 FIND v(dout0_46) AT=710.025n

* CHECK dout0_47 Vdout0_47ck141 = 0 time = 710
.meas tran vdout0_47ck141 FIND v(dout0_47) AT=710.025n

* CHECK dout0_48 Vdout0_48ck141 = 0 time = 710
.meas tran vdout0_48ck141 FIND v(dout0_48) AT=710.025n

* CHECK dout0_49 Vdout0_49ck141 = 0.9 time = 710
.meas tran vdout0_49ck141 FIND v(dout0_49) AT=710.025n

* CHECK dout0_50 Vdout0_50ck141 = 0 time = 710
.meas tran vdout0_50ck141 FIND v(dout0_50) AT=710.025n

* CHECK dout0_51 Vdout0_51ck141 = 0 time = 710
.meas tran vdout0_51ck141 FIND v(dout0_51) AT=710.025n

* CHECK dout0_52 Vdout0_52ck141 = 0.9 time = 710
.meas tran vdout0_52ck141 FIND v(dout0_52) AT=710.025n

* CHECK dout0_53 Vdout0_53ck141 = 0 time = 710
.meas tran vdout0_53ck141 FIND v(dout0_53) AT=710.025n

* CHECK dout0_54 Vdout0_54ck141 = 0.9 time = 710
.meas tran vdout0_54ck141 FIND v(dout0_54) AT=710.025n

* CHECK dout0_55 Vdout0_55ck141 = 0 time = 710
.meas tran vdout0_55ck141 FIND v(dout0_55) AT=710.025n

* CHECK dout0_56 Vdout0_56ck141 = 0 time = 710
.meas tran vdout0_56ck141 FIND v(dout0_56) AT=710.025n

* CHECK dout0_57 Vdout0_57ck141 = 0 time = 710
.meas tran vdout0_57ck141 FIND v(dout0_57) AT=710.025n

* CHECK dout0_58 Vdout0_58ck141 = 0 time = 710
.meas tran vdout0_58ck141 FIND v(dout0_58) AT=710.025n

* CHECK dout0_59 Vdout0_59ck141 = 0 time = 710
.meas tran vdout0_59ck141 FIND v(dout0_59) AT=710.025n

* CHECK dout0_60 Vdout0_60ck141 = 0 time = 710
.meas tran vdout0_60ck141 FIND v(dout0_60) AT=710.025n

* CHECK dout0_61 Vdout0_61ck141 = 0.9 time = 710
.meas tran vdout0_61ck141 FIND v(dout0_61) AT=710.025n

* CHECK dout0_62 Vdout0_62ck141 = 0.9 time = 710
.meas tran vdout0_62ck141 FIND v(dout0_62) AT=710.025n

* CHECK dout0_63 Vdout0_63ck141 = 0.9 time = 710
.meas tran vdout0_63ck141 FIND v(dout0_63) AT=710.025n

* CHECK dout0_0 Vdout0_0ck142 = 0.9 time = 715
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=715.025n

* CHECK dout0_1 Vdout0_1ck142 = 0.9 time = 715
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=715.025n

* CHECK dout0_2 Vdout0_2ck142 = 0.9 time = 715
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=715.025n

* CHECK dout0_3 Vdout0_3ck142 = 0 time = 715
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=715.025n

* CHECK dout0_4 Vdout0_4ck142 = 0 time = 715
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=715.025n

* CHECK dout0_5 Vdout0_5ck142 = 0 time = 715
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=715.025n

* CHECK dout0_6 Vdout0_6ck142 = 0 time = 715
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=715.025n

* CHECK dout0_7 Vdout0_7ck142 = 0.9 time = 715
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=715.025n

* CHECK dout0_8 Vdout0_8ck142 = 0 time = 715
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=715.025n

* CHECK dout0_9 Vdout0_9ck142 = 0 time = 715
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=715.025n

* CHECK dout0_10 Vdout0_10ck142 = 0 time = 715
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=715.025n

* CHECK dout0_11 Vdout0_11ck142 = 0 time = 715
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=715.025n

* CHECK dout0_12 Vdout0_12ck142 = 0 time = 715
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=715.025n

* CHECK dout0_13 Vdout0_13ck142 = 0 time = 715
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=715.025n

* CHECK dout0_14 Vdout0_14ck142 = 0.9 time = 715
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=715.025n

* CHECK dout0_15 Vdout0_15ck142 = 0.9 time = 715
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=715.025n

* CHECK dout0_16 Vdout0_16ck142 = 0 time = 715
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=715.025n

* CHECK dout0_17 Vdout0_17ck142 = 0 time = 715
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=715.025n

* CHECK dout0_18 Vdout0_18ck142 = 0 time = 715
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=715.025n

* CHECK dout0_19 Vdout0_19ck142 = 0 time = 715
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=715.025n

* CHECK dout0_20 Vdout0_20ck142 = 0.9 time = 715
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=715.025n

* CHECK dout0_21 Vdout0_21ck142 = 0 time = 715
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=715.025n

* CHECK dout0_22 Vdout0_22ck142 = 0 time = 715
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=715.025n

* CHECK dout0_23 Vdout0_23ck142 = 0 time = 715
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=715.025n

* CHECK dout0_24 Vdout0_24ck142 = 0.9 time = 715
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=715.025n

* CHECK dout0_25 Vdout0_25ck142 = 0 time = 715
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=715.025n

* CHECK dout0_26 Vdout0_26ck142 = 0.9 time = 715
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=715.025n

* CHECK dout0_27 Vdout0_27ck142 = 0.9 time = 715
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=715.025n

* CHECK dout0_28 Vdout0_28ck142 = 0 time = 715
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=715.025n

* CHECK dout0_29 Vdout0_29ck142 = 0.9 time = 715
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=715.025n

* CHECK dout0_30 Vdout0_30ck142 = 0.9 time = 715
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=715.025n

* CHECK dout0_31 Vdout0_31ck142 = 0.9 time = 715
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=715.025n

* CHECK dout0_32 Vdout0_32ck142 = 0.9 time = 715
.meas tran vdout0_32ck142 FIND v(dout0_32) AT=715.025n

* CHECK dout0_33 Vdout0_33ck142 = 0 time = 715
.meas tran vdout0_33ck142 FIND v(dout0_33) AT=715.025n

* CHECK dout0_34 Vdout0_34ck142 = 0 time = 715
.meas tran vdout0_34ck142 FIND v(dout0_34) AT=715.025n

* CHECK dout0_35 Vdout0_35ck142 = 0 time = 715
.meas tran vdout0_35ck142 FIND v(dout0_35) AT=715.025n

* CHECK dout0_36 Vdout0_36ck142 = 0.9 time = 715
.meas tran vdout0_36ck142 FIND v(dout0_36) AT=715.025n

* CHECK dout0_37 Vdout0_37ck142 = 0.9 time = 715
.meas tran vdout0_37ck142 FIND v(dout0_37) AT=715.025n

* CHECK dout0_38 Vdout0_38ck142 = 0.9 time = 715
.meas tran vdout0_38ck142 FIND v(dout0_38) AT=715.025n

* CHECK dout0_39 Vdout0_39ck142 = 0 time = 715
.meas tran vdout0_39ck142 FIND v(dout0_39) AT=715.025n

* CHECK dout0_40 Vdout0_40ck142 = 0.9 time = 715
.meas tran vdout0_40ck142 FIND v(dout0_40) AT=715.025n

* CHECK dout0_41 Vdout0_41ck142 = 0 time = 715
.meas tran vdout0_41ck142 FIND v(dout0_41) AT=715.025n

* CHECK dout0_42 Vdout0_42ck142 = 0.9 time = 715
.meas tran vdout0_42ck142 FIND v(dout0_42) AT=715.025n

* CHECK dout0_43 Vdout0_43ck142 = 0.9 time = 715
.meas tran vdout0_43ck142 FIND v(dout0_43) AT=715.025n

* CHECK dout0_44 Vdout0_44ck142 = 0 time = 715
.meas tran vdout0_44ck142 FIND v(dout0_44) AT=715.025n

* CHECK dout0_45 Vdout0_45ck142 = 0.9 time = 715
.meas tran vdout0_45ck142 FIND v(dout0_45) AT=715.025n

* CHECK dout0_46 Vdout0_46ck142 = 0 time = 715
.meas tran vdout0_46ck142 FIND v(dout0_46) AT=715.025n

* CHECK dout0_47 Vdout0_47ck142 = 0 time = 715
.meas tran vdout0_47ck142 FIND v(dout0_47) AT=715.025n

* CHECK dout0_48 Vdout0_48ck142 = 0 time = 715
.meas tran vdout0_48ck142 FIND v(dout0_48) AT=715.025n

* CHECK dout0_49 Vdout0_49ck142 = 0.9 time = 715
.meas tran vdout0_49ck142 FIND v(dout0_49) AT=715.025n

* CHECK dout0_50 Vdout0_50ck142 = 0 time = 715
.meas tran vdout0_50ck142 FIND v(dout0_50) AT=715.025n

* CHECK dout0_51 Vdout0_51ck142 = 0 time = 715
.meas tran vdout0_51ck142 FIND v(dout0_51) AT=715.025n

* CHECK dout0_52 Vdout0_52ck142 = 0.9 time = 715
.meas tran vdout0_52ck142 FIND v(dout0_52) AT=715.025n

* CHECK dout0_53 Vdout0_53ck142 = 0 time = 715
.meas tran vdout0_53ck142 FIND v(dout0_53) AT=715.025n

* CHECK dout0_54 Vdout0_54ck142 = 0.9 time = 715
.meas tran vdout0_54ck142 FIND v(dout0_54) AT=715.025n

* CHECK dout0_55 Vdout0_55ck142 = 0 time = 715
.meas tran vdout0_55ck142 FIND v(dout0_55) AT=715.025n

* CHECK dout0_56 Vdout0_56ck142 = 0 time = 715
.meas tran vdout0_56ck142 FIND v(dout0_56) AT=715.025n

* CHECK dout0_57 Vdout0_57ck142 = 0 time = 715
.meas tran vdout0_57ck142 FIND v(dout0_57) AT=715.025n

* CHECK dout0_58 Vdout0_58ck142 = 0 time = 715
.meas tran vdout0_58ck142 FIND v(dout0_58) AT=715.025n

* CHECK dout0_59 Vdout0_59ck142 = 0 time = 715
.meas tran vdout0_59ck142 FIND v(dout0_59) AT=715.025n

* CHECK dout0_60 Vdout0_60ck142 = 0 time = 715
.meas tran vdout0_60ck142 FIND v(dout0_60) AT=715.025n

* CHECK dout0_61 Vdout0_61ck142 = 0.9 time = 715
.meas tran vdout0_61ck142 FIND v(dout0_61) AT=715.025n

* CHECK dout0_62 Vdout0_62ck142 = 0.9 time = 715
.meas tran vdout0_62ck142 FIND v(dout0_62) AT=715.025n

* CHECK dout0_63 Vdout0_63ck142 = 0.9 time = 715
.meas tran vdout0_63ck142 FIND v(dout0_63) AT=715.025n

* CHECK dout0_0 Vdout0_0ck143 = 0.9 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0.9 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 0.9 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 0.9 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 0 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 0 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 0.9 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 0.9 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 0 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 0 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 0 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 0.9 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 0 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 0 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 0.9 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 0 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0.9 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 0.9 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0.9 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 0.9 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 0.9 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_32 Vdout0_32ck143 = 0.9 time = 720
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=720.025n

* CHECK dout0_33 Vdout0_33ck143 = 0 time = 720
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=720.025n

* CHECK dout0_34 Vdout0_34ck143 = 0 time = 720
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=720.025n

* CHECK dout0_35 Vdout0_35ck143 = 0 time = 720
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=720.025n

* CHECK dout0_36 Vdout0_36ck143 = 0.9 time = 720
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=720.025n

* CHECK dout0_37 Vdout0_37ck143 = 0.9 time = 720
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=720.025n

* CHECK dout0_38 Vdout0_38ck143 = 0.9 time = 720
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=720.025n

* CHECK dout0_39 Vdout0_39ck143 = 0 time = 720
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=720.025n

* CHECK dout0_40 Vdout0_40ck143 = 0.9 time = 720
.meas tran vdout0_40ck143 FIND v(dout0_40) AT=720.025n

* CHECK dout0_41 Vdout0_41ck143 = 0 time = 720
.meas tran vdout0_41ck143 FIND v(dout0_41) AT=720.025n

* CHECK dout0_42 Vdout0_42ck143 = 0.9 time = 720
.meas tran vdout0_42ck143 FIND v(dout0_42) AT=720.025n

* CHECK dout0_43 Vdout0_43ck143 = 0.9 time = 720
.meas tran vdout0_43ck143 FIND v(dout0_43) AT=720.025n

* CHECK dout0_44 Vdout0_44ck143 = 0 time = 720
.meas tran vdout0_44ck143 FIND v(dout0_44) AT=720.025n

* CHECK dout0_45 Vdout0_45ck143 = 0.9 time = 720
.meas tran vdout0_45ck143 FIND v(dout0_45) AT=720.025n

* CHECK dout0_46 Vdout0_46ck143 = 0 time = 720
.meas tran vdout0_46ck143 FIND v(dout0_46) AT=720.025n

* CHECK dout0_47 Vdout0_47ck143 = 0 time = 720
.meas tran vdout0_47ck143 FIND v(dout0_47) AT=720.025n

* CHECK dout0_48 Vdout0_48ck143 = 0 time = 720
.meas tran vdout0_48ck143 FIND v(dout0_48) AT=720.025n

* CHECK dout0_49 Vdout0_49ck143 = 0.9 time = 720
.meas tran vdout0_49ck143 FIND v(dout0_49) AT=720.025n

* CHECK dout0_50 Vdout0_50ck143 = 0 time = 720
.meas tran vdout0_50ck143 FIND v(dout0_50) AT=720.025n

* CHECK dout0_51 Vdout0_51ck143 = 0 time = 720
.meas tran vdout0_51ck143 FIND v(dout0_51) AT=720.025n

* CHECK dout0_52 Vdout0_52ck143 = 0.9 time = 720
.meas tran vdout0_52ck143 FIND v(dout0_52) AT=720.025n

* CHECK dout0_53 Vdout0_53ck143 = 0 time = 720
.meas tran vdout0_53ck143 FIND v(dout0_53) AT=720.025n

* CHECK dout0_54 Vdout0_54ck143 = 0.9 time = 720
.meas tran vdout0_54ck143 FIND v(dout0_54) AT=720.025n

* CHECK dout0_55 Vdout0_55ck143 = 0 time = 720
.meas tran vdout0_55ck143 FIND v(dout0_55) AT=720.025n

* CHECK dout0_56 Vdout0_56ck143 = 0 time = 720
.meas tran vdout0_56ck143 FIND v(dout0_56) AT=720.025n

* CHECK dout0_57 Vdout0_57ck143 = 0 time = 720
.meas tran vdout0_57ck143 FIND v(dout0_57) AT=720.025n

* CHECK dout0_58 Vdout0_58ck143 = 0 time = 720
.meas tran vdout0_58ck143 FIND v(dout0_58) AT=720.025n

* CHECK dout0_59 Vdout0_59ck143 = 0 time = 720
.meas tran vdout0_59ck143 FIND v(dout0_59) AT=720.025n

* CHECK dout0_60 Vdout0_60ck143 = 0 time = 720
.meas tran vdout0_60ck143 FIND v(dout0_60) AT=720.025n

* CHECK dout0_61 Vdout0_61ck143 = 0.9 time = 720
.meas tran vdout0_61ck143 FIND v(dout0_61) AT=720.025n

* CHECK dout0_62 Vdout0_62ck143 = 0.9 time = 720
.meas tran vdout0_62ck143 FIND v(dout0_62) AT=720.025n

* CHECK dout0_63 Vdout0_63ck143 = 0.9 time = 720
.meas tran vdout0_63ck143 FIND v(dout0_63) AT=720.025n

* CHECK dout0_0 Vdout0_0ck146 = 0.9 time = 735
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=735.025n

* CHECK dout0_1 Vdout0_1ck146 = 0.9 time = 735
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=735.025n

* CHECK dout0_2 Vdout0_2ck146 = 0.9 time = 735
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=735.025n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 735
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=735.025n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 735
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=735.025n

* CHECK dout0_5 Vdout0_5ck146 = 0 time = 735
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=735.025n

* CHECK dout0_6 Vdout0_6ck146 = 0 time = 735
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=735.025n

* CHECK dout0_7 Vdout0_7ck146 = 0.9 time = 735
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=735.025n

* CHECK dout0_8 Vdout0_8ck146 = 0 time = 735
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=735.025n

* CHECK dout0_9 Vdout0_9ck146 = 0 time = 735
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=735.025n

* CHECK dout0_10 Vdout0_10ck146 = 0 time = 735
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=735.025n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 735
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=735.025n

* CHECK dout0_12 Vdout0_12ck146 = 0 time = 735
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=735.025n

* CHECK dout0_13 Vdout0_13ck146 = 0 time = 735
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=735.025n

* CHECK dout0_14 Vdout0_14ck146 = 0.9 time = 735
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=735.025n

* CHECK dout0_15 Vdout0_15ck146 = 0.9 time = 735
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=735.025n

* CHECK dout0_16 Vdout0_16ck146 = 0 time = 735
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=735.025n

* CHECK dout0_17 Vdout0_17ck146 = 0 time = 735
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=735.025n

* CHECK dout0_18 Vdout0_18ck146 = 0 time = 735
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=735.025n

* CHECK dout0_19 Vdout0_19ck146 = 0 time = 735
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=735.025n

* CHECK dout0_20 Vdout0_20ck146 = 0.9 time = 735
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=735.025n

* CHECK dout0_21 Vdout0_21ck146 = 0 time = 735
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=735.025n

* CHECK dout0_22 Vdout0_22ck146 = 0 time = 735
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=735.025n

* CHECK dout0_23 Vdout0_23ck146 = 0 time = 735
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=735.025n

* CHECK dout0_24 Vdout0_24ck146 = 0.9 time = 735
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=735.025n

* CHECK dout0_25 Vdout0_25ck146 = 0 time = 735
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=735.025n

* CHECK dout0_26 Vdout0_26ck146 = 0.9 time = 735
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=735.025n

* CHECK dout0_27 Vdout0_27ck146 = 0.9 time = 735
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=735.025n

* CHECK dout0_28 Vdout0_28ck146 = 0 time = 735
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=735.025n

* CHECK dout0_29 Vdout0_29ck146 = 0.9 time = 735
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=735.025n

* CHECK dout0_30 Vdout0_30ck146 = 0.9 time = 735
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=735.025n

* CHECK dout0_31 Vdout0_31ck146 = 0.9 time = 735
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=735.025n

* CHECK dout0_32 Vdout0_32ck146 = 0.9 time = 735
.meas tran vdout0_32ck146 FIND v(dout0_32) AT=735.025n

* CHECK dout0_33 Vdout0_33ck146 = 0 time = 735
.meas tran vdout0_33ck146 FIND v(dout0_33) AT=735.025n

* CHECK dout0_34 Vdout0_34ck146 = 0 time = 735
.meas tran vdout0_34ck146 FIND v(dout0_34) AT=735.025n

* CHECK dout0_35 Vdout0_35ck146 = 0 time = 735
.meas tran vdout0_35ck146 FIND v(dout0_35) AT=735.025n

* CHECK dout0_36 Vdout0_36ck146 = 0.9 time = 735
.meas tran vdout0_36ck146 FIND v(dout0_36) AT=735.025n

* CHECK dout0_37 Vdout0_37ck146 = 0.9 time = 735
.meas tran vdout0_37ck146 FIND v(dout0_37) AT=735.025n

* CHECK dout0_38 Vdout0_38ck146 = 0.9 time = 735
.meas tran vdout0_38ck146 FIND v(dout0_38) AT=735.025n

* CHECK dout0_39 Vdout0_39ck146 = 0 time = 735
.meas tran vdout0_39ck146 FIND v(dout0_39) AT=735.025n

* CHECK dout0_40 Vdout0_40ck146 = 0.9 time = 735
.meas tran vdout0_40ck146 FIND v(dout0_40) AT=735.025n

* CHECK dout0_41 Vdout0_41ck146 = 0 time = 735
.meas tran vdout0_41ck146 FIND v(dout0_41) AT=735.025n

* CHECK dout0_42 Vdout0_42ck146 = 0.9 time = 735
.meas tran vdout0_42ck146 FIND v(dout0_42) AT=735.025n

* CHECK dout0_43 Vdout0_43ck146 = 0.9 time = 735
.meas tran vdout0_43ck146 FIND v(dout0_43) AT=735.025n

* CHECK dout0_44 Vdout0_44ck146 = 0 time = 735
.meas tran vdout0_44ck146 FIND v(dout0_44) AT=735.025n

* CHECK dout0_45 Vdout0_45ck146 = 0.9 time = 735
.meas tran vdout0_45ck146 FIND v(dout0_45) AT=735.025n

* CHECK dout0_46 Vdout0_46ck146 = 0 time = 735
.meas tran vdout0_46ck146 FIND v(dout0_46) AT=735.025n

* CHECK dout0_47 Vdout0_47ck146 = 0 time = 735
.meas tran vdout0_47ck146 FIND v(dout0_47) AT=735.025n

* CHECK dout0_48 Vdout0_48ck146 = 0 time = 735
.meas tran vdout0_48ck146 FIND v(dout0_48) AT=735.025n

* CHECK dout0_49 Vdout0_49ck146 = 0.9 time = 735
.meas tran vdout0_49ck146 FIND v(dout0_49) AT=735.025n

* CHECK dout0_50 Vdout0_50ck146 = 0 time = 735
.meas tran vdout0_50ck146 FIND v(dout0_50) AT=735.025n

* CHECK dout0_51 Vdout0_51ck146 = 0 time = 735
.meas tran vdout0_51ck146 FIND v(dout0_51) AT=735.025n

* CHECK dout0_52 Vdout0_52ck146 = 0.9 time = 735
.meas tran vdout0_52ck146 FIND v(dout0_52) AT=735.025n

* CHECK dout0_53 Vdout0_53ck146 = 0 time = 735
.meas tran vdout0_53ck146 FIND v(dout0_53) AT=735.025n

* CHECK dout0_54 Vdout0_54ck146 = 0.9 time = 735
.meas tran vdout0_54ck146 FIND v(dout0_54) AT=735.025n

* CHECK dout0_55 Vdout0_55ck146 = 0 time = 735
.meas tran vdout0_55ck146 FIND v(dout0_55) AT=735.025n

* CHECK dout0_56 Vdout0_56ck146 = 0 time = 735
.meas tran vdout0_56ck146 FIND v(dout0_56) AT=735.025n

* CHECK dout0_57 Vdout0_57ck146 = 0 time = 735
.meas tran vdout0_57ck146 FIND v(dout0_57) AT=735.025n

* CHECK dout0_58 Vdout0_58ck146 = 0 time = 735
.meas tran vdout0_58ck146 FIND v(dout0_58) AT=735.025n

* CHECK dout0_59 Vdout0_59ck146 = 0 time = 735
.meas tran vdout0_59ck146 FIND v(dout0_59) AT=735.025n

* CHECK dout0_60 Vdout0_60ck146 = 0 time = 735
.meas tran vdout0_60ck146 FIND v(dout0_60) AT=735.025n

* CHECK dout0_61 Vdout0_61ck146 = 0.9 time = 735
.meas tran vdout0_61ck146 FIND v(dout0_61) AT=735.025n

* CHECK dout0_62 Vdout0_62ck146 = 0.9 time = 735
.meas tran vdout0_62ck146 FIND v(dout0_62) AT=735.025n

* CHECK dout0_63 Vdout0_63ck146 = 0.9 time = 735
.meas tran vdout0_63ck146 FIND v(dout0_63) AT=735.025n

* CHECK dout0_0 Vdout0_0ck147 = 0 time = 740
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=740.025n

* CHECK dout0_1 Vdout0_1ck147 = 0.9 time = 740
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=740.025n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 740
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=740.025n

* CHECK dout0_3 Vdout0_3ck147 = 0.9 time = 740
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=740.025n

* CHECK dout0_4 Vdout0_4ck147 = 0 time = 740
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=740.025n

* CHECK dout0_5 Vdout0_5ck147 = 0 time = 740
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=740.025n

* CHECK dout0_6 Vdout0_6ck147 = 0.9 time = 740
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=740.025n

* CHECK dout0_7 Vdout0_7ck147 = 0.9 time = 740
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=740.025n

* CHECK dout0_8 Vdout0_8ck147 = 0 time = 740
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=740.025n

* CHECK dout0_9 Vdout0_9ck147 = 0 time = 740
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=740.025n

* CHECK dout0_10 Vdout0_10ck147 = 0.9 time = 740
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=740.025n

* CHECK dout0_11 Vdout0_11ck147 = 0.9 time = 740
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=740.025n

* CHECK dout0_12 Vdout0_12ck147 = 0.9 time = 740
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=740.025n

* CHECK dout0_13 Vdout0_13ck147 = 0.9 time = 740
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=740.025n

* CHECK dout0_14 Vdout0_14ck147 = 0.9 time = 740
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=740.025n

* CHECK dout0_15 Vdout0_15ck147 = 0.9 time = 740
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=740.025n

* CHECK dout0_16 Vdout0_16ck147 = 0.9 time = 740
.meas tran vdout0_16ck147 FIND v(dout0_16) AT=740.025n

* CHECK dout0_17 Vdout0_17ck147 = 0 time = 740
.meas tran vdout0_17ck147 FIND v(dout0_17) AT=740.025n

* CHECK dout0_18 Vdout0_18ck147 = 0.9 time = 740
.meas tran vdout0_18ck147 FIND v(dout0_18) AT=740.025n

* CHECK dout0_19 Vdout0_19ck147 = 0.9 time = 740
.meas tran vdout0_19ck147 FIND v(dout0_19) AT=740.025n

* CHECK dout0_20 Vdout0_20ck147 = 0 time = 740
.meas tran vdout0_20ck147 FIND v(dout0_20) AT=740.025n

* CHECK dout0_21 Vdout0_21ck147 = 0 time = 740
.meas tran vdout0_21ck147 FIND v(dout0_21) AT=740.025n

* CHECK dout0_22 Vdout0_22ck147 = 0 time = 740
.meas tran vdout0_22ck147 FIND v(dout0_22) AT=740.025n

* CHECK dout0_23 Vdout0_23ck147 = 0 time = 740
.meas tran vdout0_23ck147 FIND v(dout0_23) AT=740.025n

* CHECK dout0_24 Vdout0_24ck147 = 0.9 time = 740
.meas tran vdout0_24ck147 FIND v(dout0_24) AT=740.025n

* CHECK dout0_25 Vdout0_25ck147 = 0.9 time = 740
.meas tran vdout0_25ck147 FIND v(dout0_25) AT=740.025n

* CHECK dout0_26 Vdout0_26ck147 = 0 time = 740
.meas tran vdout0_26ck147 FIND v(dout0_26) AT=740.025n

* CHECK dout0_27 Vdout0_27ck147 = 0.9 time = 740
.meas tran vdout0_27ck147 FIND v(dout0_27) AT=740.025n

* CHECK dout0_28 Vdout0_28ck147 = 0.9 time = 740
.meas tran vdout0_28ck147 FIND v(dout0_28) AT=740.025n

* CHECK dout0_29 Vdout0_29ck147 = 0.9 time = 740
.meas tran vdout0_29ck147 FIND v(dout0_29) AT=740.025n

* CHECK dout0_30 Vdout0_30ck147 = 0 time = 740
.meas tran vdout0_30ck147 FIND v(dout0_30) AT=740.025n

* CHECK dout0_31 Vdout0_31ck147 = 0 time = 740
.meas tran vdout0_31ck147 FIND v(dout0_31) AT=740.025n

* CHECK dout0_32 Vdout0_32ck147 = 0.9 time = 740
.meas tran vdout0_32ck147 FIND v(dout0_32) AT=740.025n

* CHECK dout0_33 Vdout0_33ck147 = 0.9 time = 740
.meas tran vdout0_33ck147 FIND v(dout0_33) AT=740.025n

* CHECK dout0_34 Vdout0_34ck147 = 0 time = 740
.meas tran vdout0_34ck147 FIND v(dout0_34) AT=740.025n

* CHECK dout0_35 Vdout0_35ck147 = 0 time = 740
.meas tran vdout0_35ck147 FIND v(dout0_35) AT=740.025n

* CHECK dout0_36 Vdout0_36ck147 = 0.9 time = 740
.meas tran vdout0_36ck147 FIND v(dout0_36) AT=740.025n

* CHECK dout0_37 Vdout0_37ck147 = 0 time = 740
.meas tran vdout0_37ck147 FIND v(dout0_37) AT=740.025n

* CHECK dout0_38 Vdout0_38ck147 = 0.9 time = 740
.meas tran vdout0_38ck147 FIND v(dout0_38) AT=740.025n

* CHECK dout0_39 Vdout0_39ck147 = 0.9 time = 740
.meas tran vdout0_39ck147 FIND v(dout0_39) AT=740.025n

* CHECK dout0_40 Vdout0_40ck147 = 0 time = 740
.meas tran vdout0_40ck147 FIND v(dout0_40) AT=740.025n

* CHECK dout0_41 Vdout0_41ck147 = 0.9 time = 740
.meas tran vdout0_41ck147 FIND v(dout0_41) AT=740.025n

* CHECK dout0_42 Vdout0_42ck147 = 0 time = 740
.meas tran vdout0_42ck147 FIND v(dout0_42) AT=740.025n

* CHECK dout0_43 Vdout0_43ck147 = 0.9 time = 740
.meas tran vdout0_43ck147 FIND v(dout0_43) AT=740.025n

* CHECK dout0_44 Vdout0_44ck147 = 0.9 time = 740
.meas tran vdout0_44ck147 FIND v(dout0_44) AT=740.025n

* CHECK dout0_45 Vdout0_45ck147 = 0 time = 740
.meas tran vdout0_45ck147 FIND v(dout0_45) AT=740.025n

* CHECK dout0_46 Vdout0_46ck147 = 0 time = 740
.meas tran vdout0_46ck147 FIND v(dout0_46) AT=740.025n

* CHECK dout0_47 Vdout0_47ck147 = 0.9 time = 740
.meas tran vdout0_47ck147 FIND v(dout0_47) AT=740.025n

* CHECK dout0_48 Vdout0_48ck147 = 0.9 time = 740
.meas tran vdout0_48ck147 FIND v(dout0_48) AT=740.025n

* CHECK dout0_49 Vdout0_49ck147 = 0.9 time = 740
.meas tran vdout0_49ck147 FIND v(dout0_49) AT=740.025n

* CHECK dout0_50 Vdout0_50ck147 = 0.9 time = 740
.meas tran vdout0_50ck147 FIND v(dout0_50) AT=740.025n

* CHECK dout0_51 Vdout0_51ck147 = 0 time = 740
.meas tran vdout0_51ck147 FIND v(dout0_51) AT=740.025n

* CHECK dout0_52 Vdout0_52ck147 = 0.9 time = 740
.meas tran vdout0_52ck147 FIND v(dout0_52) AT=740.025n

* CHECK dout0_53 Vdout0_53ck147 = 0 time = 740
.meas tran vdout0_53ck147 FIND v(dout0_53) AT=740.025n

* CHECK dout0_54 Vdout0_54ck147 = 0.9 time = 740
.meas tran vdout0_54ck147 FIND v(dout0_54) AT=740.025n

* CHECK dout0_55 Vdout0_55ck147 = 0.9 time = 740
.meas tran vdout0_55ck147 FIND v(dout0_55) AT=740.025n

* CHECK dout0_56 Vdout0_56ck147 = 0 time = 740
.meas tran vdout0_56ck147 FIND v(dout0_56) AT=740.025n

* CHECK dout0_57 Vdout0_57ck147 = 0 time = 740
.meas tran vdout0_57ck147 FIND v(dout0_57) AT=740.025n

* CHECK dout0_58 Vdout0_58ck147 = 0 time = 740
.meas tran vdout0_58ck147 FIND v(dout0_58) AT=740.025n

* CHECK dout0_59 Vdout0_59ck147 = 0.9 time = 740
.meas tran vdout0_59ck147 FIND v(dout0_59) AT=740.025n

* CHECK dout0_60 Vdout0_60ck147 = 0 time = 740
.meas tran vdout0_60ck147 FIND v(dout0_60) AT=740.025n

* CHECK dout0_61 Vdout0_61ck147 = 0.9 time = 740
.meas tran vdout0_61ck147 FIND v(dout0_61) AT=740.025n

* CHECK dout0_62 Vdout0_62ck147 = 0 time = 740
.meas tran vdout0_62ck147 FIND v(dout0_62) AT=740.025n

* CHECK dout0_63 Vdout0_63ck147 = 0 time = 740
.meas tran vdout0_63ck147 FIND v(dout0_63) AT=740.025n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 745
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=745.025n

* CHECK dout0_1 Vdout0_1ck148 = 0.9 time = 745
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=745.025n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 745
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=745.025n

* CHECK dout0_3 Vdout0_3ck148 = 0.9 time = 745
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=745.025n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 745
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=745.025n

* CHECK dout0_5 Vdout0_5ck148 = 0 time = 745
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=745.025n

* CHECK dout0_6 Vdout0_6ck148 = 0.9 time = 745
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=745.025n

* CHECK dout0_7 Vdout0_7ck148 = 0.9 time = 745
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=745.025n

* CHECK dout0_8 Vdout0_8ck148 = 0 time = 745
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=745.025n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 745
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=745.025n

* CHECK dout0_10 Vdout0_10ck148 = 0.9 time = 745
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=745.025n

* CHECK dout0_11 Vdout0_11ck148 = 0.9 time = 745
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=745.025n

* CHECK dout0_12 Vdout0_12ck148 = 0.9 time = 745
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=745.025n

* CHECK dout0_13 Vdout0_13ck148 = 0.9 time = 745
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=745.025n

* CHECK dout0_14 Vdout0_14ck148 = 0.9 time = 745
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=745.025n

* CHECK dout0_15 Vdout0_15ck148 = 0.9 time = 745
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=745.025n

* CHECK dout0_16 Vdout0_16ck148 = 0.9 time = 745
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=745.025n

* CHECK dout0_17 Vdout0_17ck148 = 0 time = 745
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=745.025n

* CHECK dout0_18 Vdout0_18ck148 = 0.9 time = 745
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=745.025n

* CHECK dout0_19 Vdout0_19ck148 = 0.9 time = 745
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=745.025n

* CHECK dout0_20 Vdout0_20ck148 = 0 time = 745
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=745.025n

* CHECK dout0_21 Vdout0_21ck148 = 0 time = 745
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=745.025n

* CHECK dout0_22 Vdout0_22ck148 = 0 time = 745
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=745.025n

* CHECK dout0_23 Vdout0_23ck148 = 0 time = 745
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=745.025n

* CHECK dout0_24 Vdout0_24ck148 = 0.9 time = 745
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=745.025n

* CHECK dout0_25 Vdout0_25ck148 = 0.9 time = 745
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=745.025n

* CHECK dout0_26 Vdout0_26ck148 = 0 time = 745
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=745.025n

* CHECK dout0_27 Vdout0_27ck148 = 0.9 time = 745
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=745.025n

* CHECK dout0_28 Vdout0_28ck148 = 0.9 time = 745
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=745.025n

* CHECK dout0_29 Vdout0_29ck148 = 0.9 time = 745
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=745.025n

* CHECK dout0_30 Vdout0_30ck148 = 0 time = 745
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=745.025n

* CHECK dout0_31 Vdout0_31ck148 = 0 time = 745
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=745.025n

* CHECK dout0_32 Vdout0_32ck148 = 0.9 time = 745
.meas tran vdout0_32ck148 FIND v(dout0_32) AT=745.025n

* CHECK dout0_33 Vdout0_33ck148 = 0.9 time = 745
.meas tran vdout0_33ck148 FIND v(dout0_33) AT=745.025n

* CHECK dout0_34 Vdout0_34ck148 = 0 time = 745
.meas tran vdout0_34ck148 FIND v(dout0_34) AT=745.025n

* CHECK dout0_35 Vdout0_35ck148 = 0 time = 745
.meas tran vdout0_35ck148 FIND v(dout0_35) AT=745.025n

* CHECK dout0_36 Vdout0_36ck148 = 0.9 time = 745
.meas tran vdout0_36ck148 FIND v(dout0_36) AT=745.025n

* CHECK dout0_37 Vdout0_37ck148 = 0 time = 745
.meas tran vdout0_37ck148 FIND v(dout0_37) AT=745.025n

* CHECK dout0_38 Vdout0_38ck148 = 0.9 time = 745
.meas tran vdout0_38ck148 FIND v(dout0_38) AT=745.025n

* CHECK dout0_39 Vdout0_39ck148 = 0.9 time = 745
.meas tran vdout0_39ck148 FIND v(dout0_39) AT=745.025n

* CHECK dout0_40 Vdout0_40ck148 = 0 time = 745
.meas tran vdout0_40ck148 FIND v(dout0_40) AT=745.025n

* CHECK dout0_41 Vdout0_41ck148 = 0.9 time = 745
.meas tran vdout0_41ck148 FIND v(dout0_41) AT=745.025n

* CHECK dout0_42 Vdout0_42ck148 = 0 time = 745
.meas tran vdout0_42ck148 FIND v(dout0_42) AT=745.025n

* CHECK dout0_43 Vdout0_43ck148 = 0.9 time = 745
.meas tran vdout0_43ck148 FIND v(dout0_43) AT=745.025n

* CHECK dout0_44 Vdout0_44ck148 = 0.9 time = 745
.meas tran vdout0_44ck148 FIND v(dout0_44) AT=745.025n

* CHECK dout0_45 Vdout0_45ck148 = 0 time = 745
.meas tran vdout0_45ck148 FIND v(dout0_45) AT=745.025n

* CHECK dout0_46 Vdout0_46ck148 = 0 time = 745
.meas tran vdout0_46ck148 FIND v(dout0_46) AT=745.025n

* CHECK dout0_47 Vdout0_47ck148 = 0.9 time = 745
.meas tran vdout0_47ck148 FIND v(dout0_47) AT=745.025n

* CHECK dout0_48 Vdout0_48ck148 = 0.9 time = 745
.meas tran vdout0_48ck148 FIND v(dout0_48) AT=745.025n

* CHECK dout0_49 Vdout0_49ck148 = 0.9 time = 745
.meas tran vdout0_49ck148 FIND v(dout0_49) AT=745.025n

* CHECK dout0_50 Vdout0_50ck148 = 0.9 time = 745
.meas tran vdout0_50ck148 FIND v(dout0_50) AT=745.025n

* CHECK dout0_51 Vdout0_51ck148 = 0 time = 745
.meas tran vdout0_51ck148 FIND v(dout0_51) AT=745.025n

* CHECK dout0_52 Vdout0_52ck148 = 0.9 time = 745
.meas tran vdout0_52ck148 FIND v(dout0_52) AT=745.025n

* CHECK dout0_53 Vdout0_53ck148 = 0 time = 745
.meas tran vdout0_53ck148 FIND v(dout0_53) AT=745.025n

* CHECK dout0_54 Vdout0_54ck148 = 0.9 time = 745
.meas tran vdout0_54ck148 FIND v(dout0_54) AT=745.025n

* CHECK dout0_55 Vdout0_55ck148 = 0.9 time = 745
.meas tran vdout0_55ck148 FIND v(dout0_55) AT=745.025n

* CHECK dout0_56 Vdout0_56ck148 = 0 time = 745
.meas tran vdout0_56ck148 FIND v(dout0_56) AT=745.025n

* CHECK dout0_57 Vdout0_57ck148 = 0 time = 745
.meas tran vdout0_57ck148 FIND v(dout0_57) AT=745.025n

* CHECK dout0_58 Vdout0_58ck148 = 0 time = 745
.meas tran vdout0_58ck148 FIND v(dout0_58) AT=745.025n

* CHECK dout0_59 Vdout0_59ck148 = 0.9 time = 745
.meas tran vdout0_59ck148 FIND v(dout0_59) AT=745.025n

* CHECK dout0_60 Vdout0_60ck148 = 0 time = 745
.meas tran vdout0_60ck148 FIND v(dout0_60) AT=745.025n

* CHECK dout0_61 Vdout0_61ck148 = 0.9 time = 745
.meas tran vdout0_61ck148 FIND v(dout0_61) AT=745.025n

* CHECK dout0_62 Vdout0_62ck148 = 0 time = 745
.meas tran vdout0_62ck148 FIND v(dout0_62) AT=745.025n

* CHECK dout0_63 Vdout0_63ck148 = 0 time = 745
.meas tran vdout0_63ck148 FIND v(dout0_63) AT=745.025n

* CHECK dout0_0 Vdout0_0ck153 = 0.9 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 0.9 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0.9 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 0.9 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0.9 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0.9 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 0.9 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 0 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 0 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 0.9 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0.9 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 0 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0.9 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 0 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 0.9 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 0.9 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 0 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0.9 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0.9 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0.9 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 0.9 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 0 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 0.9 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0.9 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 0 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 0.9 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_32 Vdout0_32ck153 = 0 time = 770
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=770.025n

* CHECK dout0_33 Vdout0_33ck153 = 0 time = 770
.meas tran vdout0_33ck153 FIND v(dout0_33) AT=770.025n

* CHECK dout0_34 Vdout0_34ck153 = 0.9 time = 770
.meas tran vdout0_34ck153 FIND v(dout0_34) AT=770.025n

* CHECK dout0_35 Vdout0_35ck153 = 0.9 time = 770
.meas tran vdout0_35ck153 FIND v(dout0_35) AT=770.025n

* CHECK dout0_36 Vdout0_36ck153 = 0.9 time = 770
.meas tran vdout0_36ck153 FIND v(dout0_36) AT=770.025n

* CHECK dout0_37 Vdout0_37ck153 = 0 time = 770
.meas tran vdout0_37ck153 FIND v(dout0_37) AT=770.025n

* CHECK dout0_38 Vdout0_38ck153 = 0 time = 770
.meas tran vdout0_38ck153 FIND v(dout0_38) AT=770.025n

* CHECK dout0_39 Vdout0_39ck153 = 0 time = 770
.meas tran vdout0_39ck153 FIND v(dout0_39) AT=770.025n

* CHECK dout0_40 Vdout0_40ck153 = 0 time = 770
.meas tran vdout0_40ck153 FIND v(dout0_40) AT=770.025n

* CHECK dout0_41 Vdout0_41ck153 = 0.9 time = 770
.meas tran vdout0_41ck153 FIND v(dout0_41) AT=770.025n

* CHECK dout0_42 Vdout0_42ck153 = 0 time = 770
.meas tran vdout0_42ck153 FIND v(dout0_42) AT=770.025n

* CHECK dout0_43 Vdout0_43ck153 = 0.9 time = 770
.meas tran vdout0_43ck153 FIND v(dout0_43) AT=770.025n

* CHECK dout0_44 Vdout0_44ck153 = 0 time = 770
.meas tran vdout0_44ck153 FIND v(dout0_44) AT=770.025n

* CHECK dout0_45 Vdout0_45ck153 = 0 time = 770
.meas tran vdout0_45ck153 FIND v(dout0_45) AT=770.025n

* CHECK dout0_46 Vdout0_46ck153 = 0 time = 770
.meas tran vdout0_46ck153 FIND v(dout0_46) AT=770.025n

* CHECK dout0_47 Vdout0_47ck153 = 0.9 time = 770
.meas tran vdout0_47ck153 FIND v(dout0_47) AT=770.025n

* CHECK dout0_48 Vdout0_48ck153 = 0 time = 770
.meas tran vdout0_48ck153 FIND v(dout0_48) AT=770.025n

* CHECK dout0_49 Vdout0_49ck153 = 0.9 time = 770
.meas tran vdout0_49ck153 FIND v(dout0_49) AT=770.025n

* CHECK dout0_50 Vdout0_50ck153 = 0.9 time = 770
.meas tran vdout0_50ck153 FIND v(dout0_50) AT=770.025n

* CHECK dout0_51 Vdout0_51ck153 = 0.9 time = 770
.meas tran vdout0_51ck153 FIND v(dout0_51) AT=770.025n

* CHECK dout0_52 Vdout0_52ck153 = 0.9 time = 770
.meas tran vdout0_52ck153 FIND v(dout0_52) AT=770.025n

* CHECK dout0_53 Vdout0_53ck153 = 0 time = 770
.meas tran vdout0_53ck153 FIND v(dout0_53) AT=770.025n

* CHECK dout0_54 Vdout0_54ck153 = 0.9 time = 770
.meas tran vdout0_54ck153 FIND v(dout0_54) AT=770.025n

* CHECK dout0_55 Vdout0_55ck153 = 0 time = 770
.meas tran vdout0_55ck153 FIND v(dout0_55) AT=770.025n

* CHECK dout0_56 Vdout0_56ck153 = 0 time = 770
.meas tran vdout0_56ck153 FIND v(dout0_56) AT=770.025n

* CHECK dout0_57 Vdout0_57ck153 = 0.9 time = 770
.meas tran vdout0_57ck153 FIND v(dout0_57) AT=770.025n

* CHECK dout0_58 Vdout0_58ck153 = 0 time = 770
.meas tran vdout0_58ck153 FIND v(dout0_58) AT=770.025n

* CHECK dout0_59 Vdout0_59ck153 = 0.9 time = 770
.meas tran vdout0_59ck153 FIND v(dout0_59) AT=770.025n

* CHECK dout0_60 Vdout0_60ck153 = 0 time = 770
.meas tran vdout0_60ck153 FIND v(dout0_60) AT=770.025n

* CHECK dout0_61 Vdout0_61ck153 = 0.9 time = 770
.meas tran vdout0_61ck153 FIND v(dout0_61) AT=770.025n

* CHECK dout0_62 Vdout0_62ck153 = 0 time = 770
.meas tran vdout0_62ck153 FIND v(dout0_62) AT=770.025n

* CHECK dout0_63 Vdout0_63ck153 = 0.9 time = 770
.meas tran vdout0_63ck153 FIND v(dout0_63) AT=770.025n

* CHECK dout0_0 Vdout0_0ck154 = 0.9 time = 775
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=775.025n

* CHECK dout0_1 Vdout0_1ck154 = 0.9 time = 775
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=775.025n

* CHECK dout0_2 Vdout0_2ck154 = 0.9 time = 775
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=775.025n

* CHECK dout0_3 Vdout0_3ck154 = 0 time = 775
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=775.025n

* CHECK dout0_4 Vdout0_4ck154 = 0.9 time = 775
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=775.025n

* CHECK dout0_5 Vdout0_5ck154 = 0.9 time = 775
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=775.025n

* CHECK dout0_6 Vdout0_6ck154 = 0.9 time = 775
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=775.025n

* CHECK dout0_7 Vdout0_7ck154 = 0.9 time = 775
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=775.025n

* CHECK dout0_8 Vdout0_8ck154 = 0 time = 775
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=775.025n

* CHECK dout0_9 Vdout0_9ck154 = 0 time = 775
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=775.025n

* CHECK dout0_10 Vdout0_10ck154 = 0 time = 775
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=775.025n

* CHECK dout0_11 Vdout0_11ck154 = 0.9 time = 775
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=775.025n

* CHECK dout0_12 Vdout0_12ck154 = 0.9 time = 775
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=775.025n

* CHECK dout0_13 Vdout0_13ck154 = 0 time = 775
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=775.025n

* CHECK dout0_14 Vdout0_14ck154 = 0.9 time = 775
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=775.025n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 775
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=775.025n

* CHECK dout0_16 Vdout0_16ck154 = 0.9 time = 775
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=775.025n

* CHECK dout0_17 Vdout0_17ck154 = 0 time = 775
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=775.025n

* CHECK dout0_18 Vdout0_18ck154 = 0.9 time = 775
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=775.025n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 775
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=775.025n

* CHECK dout0_20 Vdout0_20ck154 = 0.9 time = 775
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=775.025n

* CHECK dout0_21 Vdout0_21ck154 = 0 time = 775
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=775.025n

* CHECK dout0_22 Vdout0_22ck154 = 0 time = 775
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=775.025n

* CHECK dout0_23 Vdout0_23ck154 = 0.9 time = 775
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=775.025n

* CHECK dout0_24 Vdout0_24ck154 = 0 time = 775
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=775.025n

* CHECK dout0_25 Vdout0_25ck154 = 0.9 time = 775
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=775.025n

* CHECK dout0_26 Vdout0_26ck154 = 0.9 time = 775
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=775.025n

* CHECK dout0_27 Vdout0_27ck154 = 0 time = 775
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=775.025n

* CHECK dout0_28 Vdout0_28ck154 = 0.9 time = 775
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=775.025n

* CHECK dout0_29 Vdout0_29ck154 = 0.9 time = 775
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=775.025n

* CHECK dout0_30 Vdout0_30ck154 = 0 time = 775
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=775.025n

* CHECK dout0_31 Vdout0_31ck154 = 0.9 time = 775
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=775.025n

* CHECK dout0_32 Vdout0_32ck154 = 0 time = 775
.meas tran vdout0_32ck154 FIND v(dout0_32) AT=775.025n

* CHECK dout0_33 Vdout0_33ck154 = 0 time = 775
.meas tran vdout0_33ck154 FIND v(dout0_33) AT=775.025n

* CHECK dout0_34 Vdout0_34ck154 = 0.9 time = 775
.meas tran vdout0_34ck154 FIND v(dout0_34) AT=775.025n

* CHECK dout0_35 Vdout0_35ck154 = 0.9 time = 775
.meas tran vdout0_35ck154 FIND v(dout0_35) AT=775.025n

* CHECK dout0_36 Vdout0_36ck154 = 0.9 time = 775
.meas tran vdout0_36ck154 FIND v(dout0_36) AT=775.025n

* CHECK dout0_37 Vdout0_37ck154 = 0 time = 775
.meas tran vdout0_37ck154 FIND v(dout0_37) AT=775.025n

* CHECK dout0_38 Vdout0_38ck154 = 0 time = 775
.meas tran vdout0_38ck154 FIND v(dout0_38) AT=775.025n

* CHECK dout0_39 Vdout0_39ck154 = 0 time = 775
.meas tran vdout0_39ck154 FIND v(dout0_39) AT=775.025n

* CHECK dout0_40 Vdout0_40ck154 = 0 time = 775
.meas tran vdout0_40ck154 FIND v(dout0_40) AT=775.025n

* CHECK dout0_41 Vdout0_41ck154 = 0.9 time = 775
.meas tran vdout0_41ck154 FIND v(dout0_41) AT=775.025n

* CHECK dout0_42 Vdout0_42ck154 = 0 time = 775
.meas tran vdout0_42ck154 FIND v(dout0_42) AT=775.025n

* CHECK dout0_43 Vdout0_43ck154 = 0.9 time = 775
.meas tran vdout0_43ck154 FIND v(dout0_43) AT=775.025n

* CHECK dout0_44 Vdout0_44ck154 = 0 time = 775
.meas tran vdout0_44ck154 FIND v(dout0_44) AT=775.025n

* CHECK dout0_45 Vdout0_45ck154 = 0 time = 775
.meas tran vdout0_45ck154 FIND v(dout0_45) AT=775.025n

* CHECK dout0_46 Vdout0_46ck154 = 0 time = 775
.meas tran vdout0_46ck154 FIND v(dout0_46) AT=775.025n

* CHECK dout0_47 Vdout0_47ck154 = 0.9 time = 775
.meas tran vdout0_47ck154 FIND v(dout0_47) AT=775.025n

* CHECK dout0_48 Vdout0_48ck154 = 0 time = 775
.meas tran vdout0_48ck154 FIND v(dout0_48) AT=775.025n

* CHECK dout0_49 Vdout0_49ck154 = 0.9 time = 775
.meas tran vdout0_49ck154 FIND v(dout0_49) AT=775.025n

* CHECK dout0_50 Vdout0_50ck154 = 0.9 time = 775
.meas tran vdout0_50ck154 FIND v(dout0_50) AT=775.025n

* CHECK dout0_51 Vdout0_51ck154 = 0.9 time = 775
.meas tran vdout0_51ck154 FIND v(dout0_51) AT=775.025n

* CHECK dout0_52 Vdout0_52ck154 = 0.9 time = 775
.meas tran vdout0_52ck154 FIND v(dout0_52) AT=775.025n

* CHECK dout0_53 Vdout0_53ck154 = 0 time = 775
.meas tran vdout0_53ck154 FIND v(dout0_53) AT=775.025n

* CHECK dout0_54 Vdout0_54ck154 = 0.9 time = 775
.meas tran vdout0_54ck154 FIND v(dout0_54) AT=775.025n

* CHECK dout0_55 Vdout0_55ck154 = 0 time = 775
.meas tran vdout0_55ck154 FIND v(dout0_55) AT=775.025n

* CHECK dout0_56 Vdout0_56ck154 = 0 time = 775
.meas tran vdout0_56ck154 FIND v(dout0_56) AT=775.025n

* CHECK dout0_57 Vdout0_57ck154 = 0.9 time = 775
.meas tran vdout0_57ck154 FIND v(dout0_57) AT=775.025n

* CHECK dout0_58 Vdout0_58ck154 = 0 time = 775
.meas tran vdout0_58ck154 FIND v(dout0_58) AT=775.025n

* CHECK dout0_59 Vdout0_59ck154 = 0.9 time = 775
.meas tran vdout0_59ck154 FIND v(dout0_59) AT=775.025n

* CHECK dout0_60 Vdout0_60ck154 = 0 time = 775
.meas tran vdout0_60ck154 FIND v(dout0_60) AT=775.025n

* CHECK dout0_61 Vdout0_61ck154 = 0.9 time = 775
.meas tran vdout0_61ck154 FIND v(dout0_61) AT=775.025n

* CHECK dout0_62 Vdout0_62ck154 = 0 time = 775
.meas tran vdout0_62ck154 FIND v(dout0_62) AT=775.025n

* CHECK dout0_63 Vdout0_63ck154 = 0.9 time = 775
.meas tran vdout0_63ck154 FIND v(dout0_63) AT=775.025n

* CHECK dout0_0 Vdout0_0ck157 = 0.9 time = 790
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=790.025n

* CHECK dout0_1 Vdout0_1ck157 = 0.9 time = 790
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=790.025n

* CHECK dout0_2 Vdout0_2ck157 = 0.9 time = 790
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=790.025n

* CHECK dout0_3 Vdout0_3ck157 = 0.9 time = 790
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=790.025n

* CHECK dout0_4 Vdout0_4ck157 = 0.9 time = 790
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=790.025n

* CHECK dout0_5 Vdout0_5ck157 = 0.9 time = 790
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=790.025n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 790
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=790.025n

* CHECK dout0_7 Vdout0_7ck157 = 0.9 time = 790
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=790.025n

* CHECK dout0_8 Vdout0_8ck157 = 0 time = 790
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=790.025n

* CHECK dout0_9 Vdout0_9ck157 = 0.9 time = 790
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=790.025n

* CHECK dout0_10 Vdout0_10ck157 = 0.9 time = 790
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=790.025n

* CHECK dout0_11 Vdout0_11ck157 = 0 time = 790
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=790.025n

* CHECK dout0_12 Vdout0_12ck157 = 0.9 time = 790
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=790.025n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 790
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=790.025n

* CHECK dout0_14 Vdout0_14ck157 = 0.9 time = 790
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=790.025n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 790
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=790.025n

* CHECK dout0_16 Vdout0_16ck157 = 0.9 time = 790
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=790.025n

* CHECK dout0_17 Vdout0_17ck157 = 0 time = 790
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=790.025n

* CHECK dout0_18 Vdout0_18ck157 = 0.9 time = 790
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=790.025n

* CHECK dout0_19 Vdout0_19ck157 = 0 time = 790
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=790.025n

* CHECK dout0_20 Vdout0_20ck157 = 0.9 time = 790
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=790.025n

* CHECK dout0_21 Vdout0_21ck157 = 0.9 time = 790
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=790.025n

* CHECK dout0_22 Vdout0_22ck157 = 0 time = 790
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=790.025n

* CHECK dout0_23 Vdout0_23ck157 = 0 time = 790
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=790.025n

* CHECK dout0_24 Vdout0_24ck157 = 0.9 time = 790
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=790.025n

* CHECK dout0_25 Vdout0_25ck157 = 0.9 time = 790
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=790.025n

* CHECK dout0_26 Vdout0_26ck157 = 0.9 time = 790
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=790.025n

* CHECK dout0_27 Vdout0_27ck157 = 0 time = 790
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=790.025n

* CHECK dout0_28 Vdout0_28ck157 = 0 time = 790
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=790.025n

* CHECK dout0_29 Vdout0_29ck157 = 0.9 time = 790
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=790.025n

* CHECK dout0_30 Vdout0_30ck157 = 0.9 time = 790
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=790.025n

* CHECK dout0_31 Vdout0_31ck157 = 0 time = 790
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=790.025n

* CHECK dout0_32 Vdout0_32ck157 = 0 time = 790
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=790.025n

* CHECK dout0_33 Vdout0_33ck157 = 0 time = 790
.meas tran vdout0_33ck157 FIND v(dout0_33) AT=790.025n

* CHECK dout0_34 Vdout0_34ck157 = 0.9 time = 790
.meas tran vdout0_34ck157 FIND v(dout0_34) AT=790.025n

* CHECK dout0_35 Vdout0_35ck157 = 0.9 time = 790
.meas tran vdout0_35ck157 FIND v(dout0_35) AT=790.025n

* CHECK dout0_36 Vdout0_36ck157 = 0 time = 790
.meas tran vdout0_36ck157 FIND v(dout0_36) AT=790.025n

* CHECK dout0_37 Vdout0_37ck157 = 0.9 time = 790
.meas tran vdout0_37ck157 FIND v(dout0_37) AT=790.025n

* CHECK dout0_38 Vdout0_38ck157 = 0.9 time = 790
.meas tran vdout0_38ck157 FIND v(dout0_38) AT=790.025n

* CHECK dout0_39 Vdout0_39ck157 = 0.9 time = 790
.meas tran vdout0_39ck157 FIND v(dout0_39) AT=790.025n

* CHECK dout0_40 Vdout0_40ck157 = 0 time = 790
.meas tran vdout0_40ck157 FIND v(dout0_40) AT=790.025n

* CHECK dout0_41 Vdout0_41ck157 = 0 time = 790
.meas tran vdout0_41ck157 FIND v(dout0_41) AT=790.025n

* CHECK dout0_42 Vdout0_42ck157 = 0 time = 790
.meas tran vdout0_42ck157 FIND v(dout0_42) AT=790.025n

* CHECK dout0_43 Vdout0_43ck157 = 0 time = 790
.meas tran vdout0_43ck157 FIND v(dout0_43) AT=790.025n

* CHECK dout0_44 Vdout0_44ck157 = 0.9 time = 790
.meas tran vdout0_44ck157 FIND v(dout0_44) AT=790.025n

* CHECK dout0_45 Vdout0_45ck157 = 0.9 time = 790
.meas tran vdout0_45ck157 FIND v(dout0_45) AT=790.025n

* CHECK dout0_46 Vdout0_46ck157 = 0 time = 790
.meas tran vdout0_46ck157 FIND v(dout0_46) AT=790.025n

* CHECK dout0_47 Vdout0_47ck157 = 0.9 time = 790
.meas tran vdout0_47ck157 FIND v(dout0_47) AT=790.025n

* CHECK dout0_48 Vdout0_48ck157 = 0.9 time = 790
.meas tran vdout0_48ck157 FIND v(dout0_48) AT=790.025n

* CHECK dout0_49 Vdout0_49ck157 = 0 time = 790
.meas tran vdout0_49ck157 FIND v(dout0_49) AT=790.025n

* CHECK dout0_50 Vdout0_50ck157 = 0.9 time = 790
.meas tran vdout0_50ck157 FIND v(dout0_50) AT=790.025n

* CHECK dout0_51 Vdout0_51ck157 = 0 time = 790
.meas tran vdout0_51ck157 FIND v(dout0_51) AT=790.025n

* CHECK dout0_52 Vdout0_52ck157 = 0.9 time = 790
.meas tran vdout0_52ck157 FIND v(dout0_52) AT=790.025n

* CHECK dout0_53 Vdout0_53ck157 = 0.9 time = 790
.meas tran vdout0_53ck157 FIND v(dout0_53) AT=790.025n

* CHECK dout0_54 Vdout0_54ck157 = 0 time = 790
.meas tran vdout0_54ck157 FIND v(dout0_54) AT=790.025n

* CHECK dout0_55 Vdout0_55ck157 = 0 time = 790
.meas tran vdout0_55ck157 FIND v(dout0_55) AT=790.025n

* CHECK dout0_56 Vdout0_56ck157 = 0.9 time = 790
.meas tran vdout0_56ck157 FIND v(dout0_56) AT=790.025n

* CHECK dout0_57 Vdout0_57ck157 = 0 time = 790
.meas tran vdout0_57ck157 FIND v(dout0_57) AT=790.025n

* CHECK dout0_58 Vdout0_58ck157 = 0.9 time = 790
.meas tran vdout0_58ck157 FIND v(dout0_58) AT=790.025n

* CHECK dout0_59 Vdout0_59ck157 = 0 time = 790
.meas tran vdout0_59ck157 FIND v(dout0_59) AT=790.025n

* CHECK dout0_60 Vdout0_60ck157 = 0.9 time = 790
.meas tran vdout0_60ck157 FIND v(dout0_60) AT=790.025n

* CHECK dout0_61 Vdout0_61ck157 = 0 time = 790
.meas tran vdout0_61ck157 FIND v(dout0_61) AT=790.025n

* CHECK dout0_62 Vdout0_62ck157 = 0.9 time = 790
.meas tran vdout0_62ck157 FIND v(dout0_62) AT=790.025n

* CHECK dout0_63 Vdout0_63ck157 = 0 time = 790
.meas tran vdout0_63ck157 FIND v(dout0_63) AT=790.025n

* CHECK dout0_0 Vdout0_0ck159 = 0.9 time = 800
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=800.025n

* CHECK dout0_1 Vdout0_1ck159 = 0.9 time = 800
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=800.025n

* CHECK dout0_2 Vdout0_2ck159 = 0.9 time = 800
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=800.025n

* CHECK dout0_3 Vdout0_3ck159 = 0.9 time = 800
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=800.025n

* CHECK dout0_4 Vdout0_4ck159 = 0.9 time = 800
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=800.025n

* CHECK dout0_5 Vdout0_5ck159 = 0.9 time = 800
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=800.025n

* CHECK dout0_6 Vdout0_6ck159 = 0 time = 800
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=800.025n

* CHECK dout0_7 Vdout0_7ck159 = 0.9 time = 800
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=800.025n

* CHECK dout0_8 Vdout0_8ck159 = 0 time = 800
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=800.025n

* CHECK dout0_9 Vdout0_9ck159 = 0.9 time = 800
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=800.025n

* CHECK dout0_10 Vdout0_10ck159 = 0.9 time = 800
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=800.025n

* CHECK dout0_11 Vdout0_11ck159 = 0 time = 800
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=800.025n

* CHECK dout0_12 Vdout0_12ck159 = 0.9 time = 800
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=800.025n

* CHECK dout0_13 Vdout0_13ck159 = 0 time = 800
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=800.025n

* CHECK dout0_14 Vdout0_14ck159 = 0.9 time = 800
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=800.025n

* CHECK dout0_15 Vdout0_15ck159 = 0 time = 800
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=800.025n

* CHECK dout0_16 Vdout0_16ck159 = 0.9 time = 800
.meas tran vdout0_16ck159 FIND v(dout0_16) AT=800.025n

* CHECK dout0_17 Vdout0_17ck159 = 0 time = 800
.meas tran vdout0_17ck159 FIND v(dout0_17) AT=800.025n

* CHECK dout0_18 Vdout0_18ck159 = 0.9 time = 800
.meas tran vdout0_18ck159 FIND v(dout0_18) AT=800.025n

* CHECK dout0_19 Vdout0_19ck159 = 0 time = 800
.meas tran vdout0_19ck159 FIND v(dout0_19) AT=800.025n

* CHECK dout0_20 Vdout0_20ck159 = 0.9 time = 800
.meas tran vdout0_20ck159 FIND v(dout0_20) AT=800.025n

* CHECK dout0_21 Vdout0_21ck159 = 0.9 time = 800
.meas tran vdout0_21ck159 FIND v(dout0_21) AT=800.025n

* CHECK dout0_22 Vdout0_22ck159 = 0 time = 800
.meas tran vdout0_22ck159 FIND v(dout0_22) AT=800.025n

* CHECK dout0_23 Vdout0_23ck159 = 0 time = 800
.meas tran vdout0_23ck159 FIND v(dout0_23) AT=800.025n

* CHECK dout0_24 Vdout0_24ck159 = 0.9 time = 800
.meas tran vdout0_24ck159 FIND v(dout0_24) AT=800.025n

* CHECK dout0_25 Vdout0_25ck159 = 0.9 time = 800
.meas tran vdout0_25ck159 FIND v(dout0_25) AT=800.025n

* CHECK dout0_26 Vdout0_26ck159 = 0.9 time = 800
.meas tran vdout0_26ck159 FIND v(dout0_26) AT=800.025n

* CHECK dout0_27 Vdout0_27ck159 = 0 time = 800
.meas tran vdout0_27ck159 FIND v(dout0_27) AT=800.025n

* CHECK dout0_28 Vdout0_28ck159 = 0 time = 800
.meas tran vdout0_28ck159 FIND v(dout0_28) AT=800.025n

* CHECK dout0_29 Vdout0_29ck159 = 0.9 time = 800
.meas tran vdout0_29ck159 FIND v(dout0_29) AT=800.025n

* CHECK dout0_30 Vdout0_30ck159 = 0.9 time = 800
.meas tran vdout0_30ck159 FIND v(dout0_30) AT=800.025n

* CHECK dout0_31 Vdout0_31ck159 = 0 time = 800
.meas tran vdout0_31ck159 FIND v(dout0_31) AT=800.025n

* CHECK dout0_32 Vdout0_32ck159 = 0 time = 800
.meas tran vdout0_32ck159 FIND v(dout0_32) AT=800.025n

* CHECK dout0_33 Vdout0_33ck159 = 0 time = 800
.meas tran vdout0_33ck159 FIND v(dout0_33) AT=800.025n

* CHECK dout0_34 Vdout0_34ck159 = 0.9 time = 800
.meas tran vdout0_34ck159 FIND v(dout0_34) AT=800.025n

* CHECK dout0_35 Vdout0_35ck159 = 0.9 time = 800
.meas tran vdout0_35ck159 FIND v(dout0_35) AT=800.025n

* CHECK dout0_36 Vdout0_36ck159 = 0 time = 800
.meas tran vdout0_36ck159 FIND v(dout0_36) AT=800.025n

* CHECK dout0_37 Vdout0_37ck159 = 0.9 time = 800
.meas tran vdout0_37ck159 FIND v(dout0_37) AT=800.025n

* CHECK dout0_38 Vdout0_38ck159 = 0.9 time = 800
.meas tran vdout0_38ck159 FIND v(dout0_38) AT=800.025n

* CHECK dout0_39 Vdout0_39ck159 = 0.9 time = 800
.meas tran vdout0_39ck159 FIND v(dout0_39) AT=800.025n

* CHECK dout0_40 Vdout0_40ck159 = 0 time = 800
.meas tran vdout0_40ck159 FIND v(dout0_40) AT=800.025n

* CHECK dout0_41 Vdout0_41ck159 = 0 time = 800
.meas tran vdout0_41ck159 FIND v(dout0_41) AT=800.025n

* CHECK dout0_42 Vdout0_42ck159 = 0 time = 800
.meas tran vdout0_42ck159 FIND v(dout0_42) AT=800.025n

* CHECK dout0_43 Vdout0_43ck159 = 0 time = 800
.meas tran vdout0_43ck159 FIND v(dout0_43) AT=800.025n

* CHECK dout0_44 Vdout0_44ck159 = 0.9 time = 800
.meas tran vdout0_44ck159 FIND v(dout0_44) AT=800.025n

* CHECK dout0_45 Vdout0_45ck159 = 0.9 time = 800
.meas tran vdout0_45ck159 FIND v(dout0_45) AT=800.025n

* CHECK dout0_46 Vdout0_46ck159 = 0 time = 800
.meas tran vdout0_46ck159 FIND v(dout0_46) AT=800.025n

* CHECK dout0_47 Vdout0_47ck159 = 0.9 time = 800
.meas tran vdout0_47ck159 FIND v(dout0_47) AT=800.025n

* CHECK dout0_48 Vdout0_48ck159 = 0.9 time = 800
.meas tran vdout0_48ck159 FIND v(dout0_48) AT=800.025n

* CHECK dout0_49 Vdout0_49ck159 = 0 time = 800
.meas tran vdout0_49ck159 FIND v(dout0_49) AT=800.025n

* CHECK dout0_50 Vdout0_50ck159 = 0.9 time = 800
.meas tran vdout0_50ck159 FIND v(dout0_50) AT=800.025n

* CHECK dout0_51 Vdout0_51ck159 = 0 time = 800
.meas tran vdout0_51ck159 FIND v(dout0_51) AT=800.025n

* CHECK dout0_52 Vdout0_52ck159 = 0.9 time = 800
.meas tran vdout0_52ck159 FIND v(dout0_52) AT=800.025n

* CHECK dout0_53 Vdout0_53ck159 = 0.9 time = 800
.meas tran vdout0_53ck159 FIND v(dout0_53) AT=800.025n

* CHECK dout0_54 Vdout0_54ck159 = 0 time = 800
.meas tran vdout0_54ck159 FIND v(dout0_54) AT=800.025n

* CHECK dout0_55 Vdout0_55ck159 = 0 time = 800
.meas tran vdout0_55ck159 FIND v(dout0_55) AT=800.025n

* CHECK dout0_56 Vdout0_56ck159 = 0.9 time = 800
.meas tran vdout0_56ck159 FIND v(dout0_56) AT=800.025n

* CHECK dout0_57 Vdout0_57ck159 = 0 time = 800
.meas tran vdout0_57ck159 FIND v(dout0_57) AT=800.025n

* CHECK dout0_58 Vdout0_58ck159 = 0.9 time = 800
.meas tran vdout0_58ck159 FIND v(dout0_58) AT=800.025n

* CHECK dout0_59 Vdout0_59ck159 = 0 time = 800
.meas tran vdout0_59ck159 FIND v(dout0_59) AT=800.025n

* CHECK dout0_60 Vdout0_60ck159 = 0.9 time = 800
.meas tran vdout0_60ck159 FIND v(dout0_60) AT=800.025n

* CHECK dout0_61 Vdout0_61ck159 = 0 time = 800
.meas tran vdout0_61ck159 FIND v(dout0_61) AT=800.025n

* CHECK dout0_62 Vdout0_62ck159 = 0.9 time = 800
.meas tran vdout0_62ck159 FIND v(dout0_62) AT=800.025n

* CHECK dout0_63 Vdout0_63ck159 = 0 time = 800
.meas tran vdout0_63ck159 FIND v(dout0_63) AT=800.025n

* CHECK dout0_0 Vdout0_0ck160 = 0.9 time = 805
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=805.025n

* CHECK dout0_1 Vdout0_1ck160 = 0.9 time = 805
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=805.025n

* CHECK dout0_2 Vdout0_2ck160 = 0.9 time = 805
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=805.025n

* CHECK dout0_3 Vdout0_3ck160 = 0.9 time = 805
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=805.025n

* CHECK dout0_4 Vdout0_4ck160 = 0.9 time = 805
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=805.025n

* CHECK dout0_5 Vdout0_5ck160 = 0.9 time = 805
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=805.025n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 805
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=805.025n

* CHECK dout0_7 Vdout0_7ck160 = 0.9 time = 805
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=805.025n

* CHECK dout0_8 Vdout0_8ck160 = 0 time = 805
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=805.025n

* CHECK dout0_9 Vdout0_9ck160 = 0.9 time = 805
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=805.025n

* CHECK dout0_10 Vdout0_10ck160 = 0.9 time = 805
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=805.025n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 805
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=805.025n

* CHECK dout0_12 Vdout0_12ck160 = 0.9 time = 805
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=805.025n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 805
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=805.025n

* CHECK dout0_14 Vdout0_14ck160 = 0.9 time = 805
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=805.025n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 805
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=805.025n

* CHECK dout0_16 Vdout0_16ck160 = 0.9 time = 805
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=805.025n

* CHECK dout0_17 Vdout0_17ck160 = 0 time = 805
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=805.025n

* CHECK dout0_18 Vdout0_18ck160 = 0.9 time = 805
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=805.025n

* CHECK dout0_19 Vdout0_19ck160 = 0 time = 805
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=805.025n

* CHECK dout0_20 Vdout0_20ck160 = 0.9 time = 805
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=805.025n

* CHECK dout0_21 Vdout0_21ck160 = 0.9 time = 805
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=805.025n

* CHECK dout0_22 Vdout0_22ck160 = 0 time = 805
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=805.025n

* CHECK dout0_23 Vdout0_23ck160 = 0 time = 805
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=805.025n

* CHECK dout0_24 Vdout0_24ck160 = 0.9 time = 805
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=805.025n

* CHECK dout0_25 Vdout0_25ck160 = 0.9 time = 805
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=805.025n

* CHECK dout0_26 Vdout0_26ck160 = 0.9 time = 805
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=805.025n

* CHECK dout0_27 Vdout0_27ck160 = 0 time = 805
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=805.025n

* CHECK dout0_28 Vdout0_28ck160 = 0 time = 805
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=805.025n

* CHECK dout0_29 Vdout0_29ck160 = 0.9 time = 805
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=805.025n

* CHECK dout0_30 Vdout0_30ck160 = 0.9 time = 805
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=805.025n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 805
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=805.025n

* CHECK dout0_32 Vdout0_32ck160 = 0 time = 805
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=805.025n

* CHECK dout0_33 Vdout0_33ck160 = 0 time = 805
.meas tran vdout0_33ck160 FIND v(dout0_33) AT=805.025n

* CHECK dout0_34 Vdout0_34ck160 = 0.9 time = 805
.meas tran vdout0_34ck160 FIND v(dout0_34) AT=805.025n

* CHECK dout0_35 Vdout0_35ck160 = 0.9 time = 805
.meas tran vdout0_35ck160 FIND v(dout0_35) AT=805.025n

* CHECK dout0_36 Vdout0_36ck160 = 0 time = 805
.meas tran vdout0_36ck160 FIND v(dout0_36) AT=805.025n

* CHECK dout0_37 Vdout0_37ck160 = 0.9 time = 805
.meas tran vdout0_37ck160 FIND v(dout0_37) AT=805.025n

* CHECK dout0_38 Vdout0_38ck160 = 0.9 time = 805
.meas tran vdout0_38ck160 FIND v(dout0_38) AT=805.025n

* CHECK dout0_39 Vdout0_39ck160 = 0.9 time = 805
.meas tran vdout0_39ck160 FIND v(dout0_39) AT=805.025n

* CHECK dout0_40 Vdout0_40ck160 = 0 time = 805
.meas tran vdout0_40ck160 FIND v(dout0_40) AT=805.025n

* CHECK dout0_41 Vdout0_41ck160 = 0 time = 805
.meas tran vdout0_41ck160 FIND v(dout0_41) AT=805.025n

* CHECK dout0_42 Vdout0_42ck160 = 0 time = 805
.meas tran vdout0_42ck160 FIND v(dout0_42) AT=805.025n

* CHECK dout0_43 Vdout0_43ck160 = 0 time = 805
.meas tran vdout0_43ck160 FIND v(dout0_43) AT=805.025n

* CHECK dout0_44 Vdout0_44ck160 = 0.9 time = 805
.meas tran vdout0_44ck160 FIND v(dout0_44) AT=805.025n

* CHECK dout0_45 Vdout0_45ck160 = 0.9 time = 805
.meas tran vdout0_45ck160 FIND v(dout0_45) AT=805.025n

* CHECK dout0_46 Vdout0_46ck160 = 0 time = 805
.meas tran vdout0_46ck160 FIND v(dout0_46) AT=805.025n

* CHECK dout0_47 Vdout0_47ck160 = 0.9 time = 805
.meas tran vdout0_47ck160 FIND v(dout0_47) AT=805.025n

* CHECK dout0_48 Vdout0_48ck160 = 0.9 time = 805
.meas tran vdout0_48ck160 FIND v(dout0_48) AT=805.025n

* CHECK dout0_49 Vdout0_49ck160 = 0 time = 805
.meas tran vdout0_49ck160 FIND v(dout0_49) AT=805.025n

* CHECK dout0_50 Vdout0_50ck160 = 0.9 time = 805
.meas tran vdout0_50ck160 FIND v(dout0_50) AT=805.025n

* CHECK dout0_51 Vdout0_51ck160 = 0 time = 805
.meas tran vdout0_51ck160 FIND v(dout0_51) AT=805.025n

* CHECK dout0_52 Vdout0_52ck160 = 0.9 time = 805
.meas tran vdout0_52ck160 FIND v(dout0_52) AT=805.025n

* CHECK dout0_53 Vdout0_53ck160 = 0.9 time = 805
.meas tran vdout0_53ck160 FIND v(dout0_53) AT=805.025n

* CHECK dout0_54 Vdout0_54ck160 = 0 time = 805
.meas tran vdout0_54ck160 FIND v(dout0_54) AT=805.025n

* CHECK dout0_55 Vdout0_55ck160 = 0 time = 805
.meas tran vdout0_55ck160 FIND v(dout0_55) AT=805.025n

* CHECK dout0_56 Vdout0_56ck160 = 0.9 time = 805
.meas tran vdout0_56ck160 FIND v(dout0_56) AT=805.025n

* CHECK dout0_57 Vdout0_57ck160 = 0 time = 805
.meas tran vdout0_57ck160 FIND v(dout0_57) AT=805.025n

* CHECK dout0_58 Vdout0_58ck160 = 0.9 time = 805
.meas tran vdout0_58ck160 FIND v(dout0_58) AT=805.025n

* CHECK dout0_59 Vdout0_59ck160 = 0 time = 805
.meas tran vdout0_59ck160 FIND v(dout0_59) AT=805.025n

* CHECK dout0_60 Vdout0_60ck160 = 0.9 time = 805
.meas tran vdout0_60ck160 FIND v(dout0_60) AT=805.025n

* CHECK dout0_61 Vdout0_61ck160 = 0 time = 805
.meas tran vdout0_61ck160 FIND v(dout0_61) AT=805.025n

* CHECK dout0_62 Vdout0_62ck160 = 0.9 time = 805
.meas tran vdout0_62ck160 FIND v(dout0_62) AT=805.025n

* CHECK dout0_63 Vdout0_63ck160 = 0 time = 805
.meas tran vdout0_63ck160 FIND v(dout0_63) AT=805.025n

* CHECK dout0_0 Vdout0_0ck161 = 0.9 time = 810
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=810.025n

* CHECK dout0_1 Vdout0_1ck161 = 0.9 time = 810
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=810.025n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 810
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=810.025n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 810
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=810.025n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 810
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=810.025n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 810
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=810.025n

* CHECK dout0_6 Vdout0_6ck161 = 0.9 time = 810
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=810.025n

* CHECK dout0_7 Vdout0_7ck161 = 0.9 time = 810
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=810.025n

* CHECK dout0_8 Vdout0_8ck161 = 0 time = 810
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=810.025n

* CHECK dout0_9 Vdout0_9ck161 = 0 time = 810
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=810.025n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 810
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=810.025n

* CHECK dout0_11 Vdout0_11ck161 = 0.9 time = 810
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=810.025n

* CHECK dout0_12 Vdout0_12ck161 = 0.9 time = 810
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=810.025n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 810
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=810.025n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 810
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=810.025n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 810
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=810.025n

* CHECK dout0_16 Vdout0_16ck161 = 0 time = 810
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=810.025n

* CHECK dout0_17 Vdout0_17ck161 = 0.9 time = 810
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=810.025n

* CHECK dout0_18 Vdout0_18ck161 = 0 time = 810
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=810.025n

* CHECK dout0_19 Vdout0_19ck161 = 0 time = 810
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=810.025n

* CHECK dout0_20 Vdout0_20ck161 = 0 time = 810
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=810.025n

* CHECK dout0_21 Vdout0_21ck161 = 0.9 time = 810
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=810.025n

* CHECK dout0_22 Vdout0_22ck161 = 0.9 time = 810
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=810.025n

* CHECK dout0_23 Vdout0_23ck161 = 0.9 time = 810
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=810.025n

* CHECK dout0_24 Vdout0_24ck161 = 0 time = 810
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=810.025n

* CHECK dout0_25 Vdout0_25ck161 = 0.9 time = 810
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=810.025n

* CHECK dout0_26 Vdout0_26ck161 = 0 time = 810
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=810.025n

* CHECK dout0_27 Vdout0_27ck161 = 0.9 time = 810
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=810.025n

* CHECK dout0_28 Vdout0_28ck161 = 0.9 time = 810
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=810.025n

* CHECK dout0_29 Vdout0_29ck161 = 0 time = 810
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=810.025n

* CHECK dout0_30 Vdout0_30ck161 = 0 time = 810
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=810.025n

* CHECK dout0_31 Vdout0_31ck161 = 0.9 time = 810
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=810.025n

* CHECK dout0_32 Vdout0_32ck161 = 0.9 time = 810
.meas tran vdout0_32ck161 FIND v(dout0_32) AT=810.025n

* CHECK dout0_33 Vdout0_33ck161 = 0.9 time = 810
.meas tran vdout0_33ck161 FIND v(dout0_33) AT=810.025n

* CHECK dout0_34 Vdout0_34ck161 = 0.9 time = 810
.meas tran vdout0_34ck161 FIND v(dout0_34) AT=810.025n

* CHECK dout0_35 Vdout0_35ck161 = 0.9 time = 810
.meas tran vdout0_35ck161 FIND v(dout0_35) AT=810.025n

* CHECK dout0_36 Vdout0_36ck161 = 0 time = 810
.meas tran vdout0_36ck161 FIND v(dout0_36) AT=810.025n

* CHECK dout0_37 Vdout0_37ck161 = 0 time = 810
.meas tran vdout0_37ck161 FIND v(dout0_37) AT=810.025n

* CHECK dout0_38 Vdout0_38ck161 = 0 time = 810
.meas tran vdout0_38ck161 FIND v(dout0_38) AT=810.025n

* CHECK dout0_39 Vdout0_39ck161 = 0.9 time = 810
.meas tran vdout0_39ck161 FIND v(dout0_39) AT=810.025n

* CHECK dout0_40 Vdout0_40ck161 = 0.9 time = 810
.meas tran vdout0_40ck161 FIND v(dout0_40) AT=810.025n

* CHECK dout0_41 Vdout0_41ck161 = 0 time = 810
.meas tran vdout0_41ck161 FIND v(dout0_41) AT=810.025n

* CHECK dout0_42 Vdout0_42ck161 = 0 time = 810
.meas tran vdout0_42ck161 FIND v(dout0_42) AT=810.025n

* CHECK dout0_43 Vdout0_43ck161 = 0.9 time = 810
.meas tran vdout0_43ck161 FIND v(dout0_43) AT=810.025n

* CHECK dout0_44 Vdout0_44ck161 = 0 time = 810
.meas tran vdout0_44ck161 FIND v(dout0_44) AT=810.025n

* CHECK dout0_45 Vdout0_45ck161 = 0.9 time = 810
.meas tran vdout0_45ck161 FIND v(dout0_45) AT=810.025n

* CHECK dout0_46 Vdout0_46ck161 = 0.9 time = 810
.meas tran vdout0_46ck161 FIND v(dout0_46) AT=810.025n

* CHECK dout0_47 Vdout0_47ck161 = 0.9 time = 810
.meas tran vdout0_47ck161 FIND v(dout0_47) AT=810.025n

* CHECK dout0_48 Vdout0_48ck161 = 0 time = 810
.meas tran vdout0_48ck161 FIND v(dout0_48) AT=810.025n

* CHECK dout0_49 Vdout0_49ck161 = 0.9 time = 810
.meas tran vdout0_49ck161 FIND v(dout0_49) AT=810.025n

* CHECK dout0_50 Vdout0_50ck161 = 0 time = 810
.meas tran vdout0_50ck161 FIND v(dout0_50) AT=810.025n

* CHECK dout0_51 Vdout0_51ck161 = 0 time = 810
.meas tran vdout0_51ck161 FIND v(dout0_51) AT=810.025n

* CHECK dout0_52 Vdout0_52ck161 = 0 time = 810
.meas tran vdout0_52ck161 FIND v(dout0_52) AT=810.025n

* CHECK dout0_53 Vdout0_53ck161 = 0.9 time = 810
.meas tran vdout0_53ck161 FIND v(dout0_53) AT=810.025n

* CHECK dout0_54 Vdout0_54ck161 = 0.9 time = 810
.meas tran vdout0_54ck161 FIND v(dout0_54) AT=810.025n

* CHECK dout0_55 Vdout0_55ck161 = 0.9 time = 810
.meas tran vdout0_55ck161 FIND v(dout0_55) AT=810.025n

* CHECK dout0_56 Vdout0_56ck161 = 0 time = 810
.meas tran vdout0_56ck161 FIND v(dout0_56) AT=810.025n

* CHECK dout0_57 Vdout0_57ck161 = 0.9 time = 810
.meas tran vdout0_57ck161 FIND v(dout0_57) AT=810.025n

* CHECK dout0_58 Vdout0_58ck161 = 0.9 time = 810
.meas tran vdout0_58ck161 FIND v(dout0_58) AT=810.025n

* CHECK dout0_59 Vdout0_59ck161 = 0 time = 810
.meas tran vdout0_59ck161 FIND v(dout0_59) AT=810.025n

* CHECK dout0_60 Vdout0_60ck161 = 0 time = 810
.meas tran vdout0_60ck161 FIND v(dout0_60) AT=810.025n

* CHECK dout0_61 Vdout0_61ck161 = 0 time = 810
.meas tran vdout0_61ck161 FIND v(dout0_61) AT=810.025n

* CHECK dout0_62 Vdout0_62ck161 = 0 time = 810
.meas tran vdout0_62ck161 FIND v(dout0_62) AT=810.025n

* CHECK dout0_63 Vdout0_63ck161 = 0 time = 810
.meas tran vdout0_63ck161 FIND v(dout0_63) AT=810.025n

* CHECK dout0_0 Vdout0_0ck162 = 0.9 time = 815
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=815.025n

* CHECK dout0_1 Vdout0_1ck162 = 0.9 time = 815
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=815.025n

* CHECK dout0_2 Vdout0_2ck162 = 0.9 time = 815
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=815.025n

* CHECK dout0_3 Vdout0_3ck162 = 0.9 time = 815
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=815.025n

* CHECK dout0_4 Vdout0_4ck162 = 0.9 time = 815
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=815.025n

* CHECK dout0_5 Vdout0_5ck162 = 0.9 time = 815
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=815.025n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 815
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=815.025n

* CHECK dout0_7 Vdout0_7ck162 = 0.9 time = 815
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=815.025n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 815
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=815.025n

* CHECK dout0_9 Vdout0_9ck162 = 0.9 time = 815
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=815.025n

* CHECK dout0_10 Vdout0_10ck162 = 0.9 time = 815
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=815.025n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 815
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=815.025n

* CHECK dout0_12 Vdout0_12ck162 = 0.9 time = 815
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=815.025n

* CHECK dout0_13 Vdout0_13ck162 = 0 time = 815
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=815.025n

* CHECK dout0_14 Vdout0_14ck162 = 0.9 time = 815
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=815.025n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 815
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=815.025n

* CHECK dout0_16 Vdout0_16ck162 = 0.9 time = 815
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=815.025n

* CHECK dout0_17 Vdout0_17ck162 = 0 time = 815
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=815.025n

* CHECK dout0_18 Vdout0_18ck162 = 0.9 time = 815
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=815.025n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 815
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=815.025n

* CHECK dout0_20 Vdout0_20ck162 = 0.9 time = 815
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=815.025n

* CHECK dout0_21 Vdout0_21ck162 = 0.9 time = 815
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=815.025n

* CHECK dout0_22 Vdout0_22ck162 = 0 time = 815
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=815.025n

* CHECK dout0_23 Vdout0_23ck162 = 0 time = 815
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=815.025n

* CHECK dout0_24 Vdout0_24ck162 = 0.9 time = 815
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=815.025n

* CHECK dout0_25 Vdout0_25ck162 = 0.9 time = 815
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=815.025n

* CHECK dout0_26 Vdout0_26ck162 = 0.9 time = 815
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=815.025n

* CHECK dout0_27 Vdout0_27ck162 = 0 time = 815
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=815.025n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 815
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=815.025n

* CHECK dout0_29 Vdout0_29ck162 = 0.9 time = 815
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=815.025n

* CHECK dout0_30 Vdout0_30ck162 = 0.9 time = 815
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=815.025n

* CHECK dout0_31 Vdout0_31ck162 = 0 time = 815
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=815.025n

* CHECK dout0_32 Vdout0_32ck162 = 0 time = 815
.meas tran vdout0_32ck162 FIND v(dout0_32) AT=815.025n

* CHECK dout0_33 Vdout0_33ck162 = 0 time = 815
.meas tran vdout0_33ck162 FIND v(dout0_33) AT=815.025n

* CHECK dout0_34 Vdout0_34ck162 = 0.9 time = 815
.meas tran vdout0_34ck162 FIND v(dout0_34) AT=815.025n

* CHECK dout0_35 Vdout0_35ck162 = 0.9 time = 815
.meas tran vdout0_35ck162 FIND v(dout0_35) AT=815.025n

* CHECK dout0_36 Vdout0_36ck162 = 0 time = 815
.meas tran vdout0_36ck162 FIND v(dout0_36) AT=815.025n

* CHECK dout0_37 Vdout0_37ck162 = 0.9 time = 815
.meas tran vdout0_37ck162 FIND v(dout0_37) AT=815.025n

* CHECK dout0_38 Vdout0_38ck162 = 0.9 time = 815
.meas tran vdout0_38ck162 FIND v(dout0_38) AT=815.025n

* CHECK dout0_39 Vdout0_39ck162 = 0.9 time = 815
.meas tran vdout0_39ck162 FIND v(dout0_39) AT=815.025n

* CHECK dout0_40 Vdout0_40ck162 = 0 time = 815
.meas tran vdout0_40ck162 FIND v(dout0_40) AT=815.025n

* CHECK dout0_41 Vdout0_41ck162 = 0 time = 815
.meas tran vdout0_41ck162 FIND v(dout0_41) AT=815.025n

* CHECK dout0_42 Vdout0_42ck162 = 0 time = 815
.meas tran vdout0_42ck162 FIND v(dout0_42) AT=815.025n

* CHECK dout0_43 Vdout0_43ck162 = 0 time = 815
.meas tran vdout0_43ck162 FIND v(dout0_43) AT=815.025n

* CHECK dout0_44 Vdout0_44ck162 = 0.9 time = 815
.meas tran vdout0_44ck162 FIND v(dout0_44) AT=815.025n

* CHECK dout0_45 Vdout0_45ck162 = 0.9 time = 815
.meas tran vdout0_45ck162 FIND v(dout0_45) AT=815.025n

* CHECK dout0_46 Vdout0_46ck162 = 0 time = 815
.meas tran vdout0_46ck162 FIND v(dout0_46) AT=815.025n

* CHECK dout0_47 Vdout0_47ck162 = 0.9 time = 815
.meas tran vdout0_47ck162 FIND v(dout0_47) AT=815.025n

* CHECK dout0_48 Vdout0_48ck162 = 0.9 time = 815
.meas tran vdout0_48ck162 FIND v(dout0_48) AT=815.025n

* CHECK dout0_49 Vdout0_49ck162 = 0 time = 815
.meas tran vdout0_49ck162 FIND v(dout0_49) AT=815.025n

* CHECK dout0_50 Vdout0_50ck162 = 0.9 time = 815
.meas tran vdout0_50ck162 FIND v(dout0_50) AT=815.025n

* CHECK dout0_51 Vdout0_51ck162 = 0 time = 815
.meas tran vdout0_51ck162 FIND v(dout0_51) AT=815.025n

* CHECK dout0_52 Vdout0_52ck162 = 0.9 time = 815
.meas tran vdout0_52ck162 FIND v(dout0_52) AT=815.025n

* CHECK dout0_53 Vdout0_53ck162 = 0.9 time = 815
.meas tran vdout0_53ck162 FIND v(dout0_53) AT=815.025n

* CHECK dout0_54 Vdout0_54ck162 = 0 time = 815
.meas tran vdout0_54ck162 FIND v(dout0_54) AT=815.025n

* CHECK dout0_55 Vdout0_55ck162 = 0 time = 815
.meas tran vdout0_55ck162 FIND v(dout0_55) AT=815.025n

* CHECK dout0_56 Vdout0_56ck162 = 0.9 time = 815
.meas tran vdout0_56ck162 FIND v(dout0_56) AT=815.025n

* CHECK dout0_57 Vdout0_57ck162 = 0 time = 815
.meas tran vdout0_57ck162 FIND v(dout0_57) AT=815.025n

* CHECK dout0_58 Vdout0_58ck162 = 0.9 time = 815
.meas tran vdout0_58ck162 FIND v(dout0_58) AT=815.025n

* CHECK dout0_59 Vdout0_59ck162 = 0 time = 815
.meas tran vdout0_59ck162 FIND v(dout0_59) AT=815.025n

* CHECK dout0_60 Vdout0_60ck162 = 0.9 time = 815
.meas tran vdout0_60ck162 FIND v(dout0_60) AT=815.025n

* CHECK dout0_61 Vdout0_61ck162 = 0 time = 815
.meas tran vdout0_61ck162 FIND v(dout0_61) AT=815.025n

* CHECK dout0_62 Vdout0_62ck162 = 0.9 time = 815
.meas tran vdout0_62ck162 FIND v(dout0_62) AT=815.025n

* CHECK dout0_63 Vdout0_63ck162 = 0 time = 815
.meas tran vdout0_63ck162 FIND v(dout0_63) AT=815.025n

* CHECK dout0_0 Vdout0_0ck163 = 0.9 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0.9 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 0.9 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0.9 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0.9 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0.9 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 0 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0.9 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0.9 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0.9 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0.9 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0.9 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 0 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0.9 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 0 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 0.9 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0.9 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0.9 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0.9 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0.9 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0.9 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 0 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0.9 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0.9 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 0 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_32 Vdout0_32ck163 = 0 time = 820
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=820.025n

* CHECK dout0_33 Vdout0_33ck163 = 0 time = 820
.meas tran vdout0_33ck163 FIND v(dout0_33) AT=820.025n

* CHECK dout0_34 Vdout0_34ck163 = 0.9 time = 820
.meas tran vdout0_34ck163 FIND v(dout0_34) AT=820.025n

* CHECK dout0_35 Vdout0_35ck163 = 0.9 time = 820
.meas tran vdout0_35ck163 FIND v(dout0_35) AT=820.025n

* CHECK dout0_36 Vdout0_36ck163 = 0 time = 820
.meas tran vdout0_36ck163 FIND v(dout0_36) AT=820.025n

* CHECK dout0_37 Vdout0_37ck163 = 0.9 time = 820
.meas tran vdout0_37ck163 FIND v(dout0_37) AT=820.025n

* CHECK dout0_38 Vdout0_38ck163 = 0.9 time = 820
.meas tran vdout0_38ck163 FIND v(dout0_38) AT=820.025n

* CHECK dout0_39 Vdout0_39ck163 = 0.9 time = 820
.meas tran vdout0_39ck163 FIND v(dout0_39) AT=820.025n

* CHECK dout0_40 Vdout0_40ck163 = 0 time = 820
.meas tran vdout0_40ck163 FIND v(dout0_40) AT=820.025n

* CHECK dout0_41 Vdout0_41ck163 = 0 time = 820
.meas tran vdout0_41ck163 FIND v(dout0_41) AT=820.025n

* CHECK dout0_42 Vdout0_42ck163 = 0 time = 820
.meas tran vdout0_42ck163 FIND v(dout0_42) AT=820.025n

* CHECK dout0_43 Vdout0_43ck163 = 0 time = 820
.meas tran vdout0_43ck163 FIND v(dout0_43) AT=820.025n

* CHECK dout0_44 Vdout0_44ck163 = 0.9 time = 820
.meas tran vdout0_44ck163 FIND v(dout0_44) AT=820.025n

* CHECK dout0_45 Vdout0_45ck163 = 0.9 time = 820
.meas tran vdout0_45ck163 FIND v(dout0_45) AT=820.025n

* CHECK dout0_46 Vdout0_46ck163 = 0 time = 820
.meas tran vdout0_46ck163 FIND v(dout0_46) AT=820.025n

* CHECK dout0_47 Vdout0_47ck163 = 0.9 time = 820
.meas tran vdout0_47ck163 FIND v(dout0_47) AT=820.025n

* CHECK dout0_48 Vdout0_48ck163 = 0.9 time = 820
.meas tran vdout0_48ck163 FIND v(dout0_48) AT=820.025n

* CHECK dout0_49 Vdout0_49ck163 = 0 time = 820
.meas tran vdout0_49ck163 FIND v(dout0_49) AT=820.025n

* CHECK dout0_50 Vdout0_50ck163 = 0.9 time = 820
.meas tran vdout0_50ck163 FIND v(dout0_50) AT=820.025n

* CHECK dout0_51 Vdout0_51ck163 = 0 time = 820
.meas tran vdout0_51ck163 FIND v(dout0_51) AT=820.025n

* CHECK dout0_52 Vdout0_52ck163 = 0.9 time = 820
.meas tran vdout0_52ck163 FIND v(dout0_52) AT=820.025n

* CHECK dout0_53 Vdout0_53ck163 = 0.9 time = 820
.meas tran vdout0_53ck163 FIND v(dout0_53) AT=820.025n

* CHECK dout0_54 Vdout0_54ck163 = 0 time = 820
.meas tran vdout0_54ck163 FIND v(dout0_54) AT=820.025n

* CHECK dout0_55 Vdout0_55ck163 = 0 time = 820
.meas tran vdout0_55ck163 FIND v(dout0_55) AT=820.025n

* CHECK dout0_56 Vdout0_56ck163 = 0.9 time = 820
.meas tran vdout0_56ck163 FIND v(dout0_56) AT=820.025n

* CHECK dout0_57 Vdout0_57ck163 = 0 time = 820
.meas tran vdout0_57ck163 FIND v(dout0_57) AT=820.025n

* CHECK dout0_58 Vdout0_58ck163 = 0.9 time = 820
.meas tran vdout0_58ck163 FIND v(dout0_58) AT=820.025n

* CHECK dout0_59 Vdout0_59ck163 = 0 time = 820
.meas tran vdout0_59ck163 FIND v(dout0_59) AT=820.025n

* CHECK dout0_60 Vdout0_60ck163 = 0.9 time = 820
.meas tran vdout0_60ck163 FIND v(dout0_60) AT=820.025n

* CHECK dout0_61 Vdout0_61ck163 = 0 time = 820
.meas tran vdout0_61ck163 FIND v(dout0_61) AT=820.025n

* CHECK dout0_62 Vdout0_62ck163 = 0.9 time = 820
.meas tran vdout0_62ck163 FIND v(dout0_62) AT=820.025n

* CHECK dout0_63 Vdout0_63ck163 = 0 time = 820
.meas tran vdout0_63ck163 FIND v(dout0_63) AT=820.025n

* CHECK dout0_0 Vdout0_0ck166 = 0.9 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 0.9 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 0.9 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 0.9 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 0.9 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 0.9 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0.9 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 0 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 0.9 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0.9 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0.9 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 0 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 0.9 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 0.9 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 0 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0.9 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 0 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 0.9 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0.9 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 0 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 0.9 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0.9 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 0.9 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 0.9 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 0.9 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_32 Vdout0_32ck166 = 0 time = 835
.meas tran vdout0_32ck166 FIND v(dout0_32) AT=835.025n

* CHECK dout0_33 Vdout0_33ck166 = 0 time = 835
.meas tran vdout0_33ck166 FIND v(dout0_33) AT=835.025n

* CHECK dout0_34 Vdout0_34ck166 = 0.9 time = 835
.meas tran vdout0_34ck166 FIND v(dout0_34) AT=835.025n

* CHECK dout0_35 Vdout0_35ck166 = 0.9 time = 835
.meas tran vdout0_35ck166 FIND v(dout0_35) AT=835.025n

* CHECK dout0_36 Vdout0_36ck166 = 0 time = 835
.meas tran vdout0_36ck166 FIND v(dout0_36) AT=835.025n

* CHECK dout0_37 Vdout0_37ck166 = 0.9 time = 835
.meas tran vdout0_37ck166 FIND v(dout0_37) AT=835.025n

* CHECK dout0_38 Vdout0_38ck166 = 0.9 time = 835
.meas tran vdout0_38ck166 FIND v(dout0_38) AT=835.025n

* CHECK dout0_39 Vdout0_39ck166 = 0.9 time = 835
.meas tran vdout0_39ck166 FIND v(dout0_39) AT=835.025n

* CHECK dout0_40 Vdout0_40ck166 = 0 time = 835
.meas tran vdout0_40ck166 FIND v(dout0_40) AT=835.025n

* CHECK dout0_41 Vdout0_41ck166 = 0 time = 835
.meas tran vdout0_41ck166 FIND v(dout0_41) AT=835.025n

* CHECK dout0_42 Vdout0_42ck166 = 0 time = 835
.meas tran vdout0_42ck166 FIND v(dout0_42) AT=835.025n

* CHECK dout0_43 Vdout0_43ck166 = 0 time = 835
.meas tran vdout0_43ck166 FIND v(dout0_43) AT=835.025n

* CHECK dout0_44 Vdout0_44ck166 = 0.9 time = 835
.meas tran vdout0_44ck166 FIND v(dout0_44) AT=835.025n

* CHECK dout0_45 Vdout0_45ck166 = 0.9 time = 835
.meas tran vdout0_45ck166 FIND v(dout0_45) AT=835.025n

* CHECK dout0_46 Vdout0_46ck166 = 0 time = 835
.meas tran vdout0_46ck166 FIND v(dout0_46) AT=835.025n

* CHECK dout0_47 Vdout0_47ck166 = 0.9 time = 835
.meas tran vdout0_47ck166 FIND v(dout0_47) AT=835.025n

* CHECK dout0_48 Vdout0_48ck166 = 0.9 time = 835
.meas tran vdout0_48ck166 FIND v(dout0_48) AT=835.025n

* CHECK dout0_49 Vdout0_49ck166 = 0 time = 835
.meas tran vdout0_49ck166 FIND v(dout0_49) AT=835.025n

* CHECK dout0_50 Vdout0_50ck166 = 0.9 time = 835
.meas tran vdout0_50ck166 FIND v(dout0_50) AT=835.025n

* CHECK dout0_51 Vdout0_51ck166 = 0 time = 835
.meas tran vdout0_51ck166 FIND v(dout0_51) AT=835.025n

* CHECK dout0_52 Vdout0_52ck166 = 0.9 time = 835
.meas tran vdout0_52ck166 FIND v(dout0_52) AT=835.025n

* CHECK dout0_53 Vdout0_53ck166 = 0.9 time = 835
.meas tran vdout0_53ck166 FIND v(dout0_53) AT=835.025n

* CHECK dout0_54 Vdout0_54ck166 = 0 time = 835
.meas tran vdout0_54ck166 FIND v(dout0_54) AT=835.025n

* CHECK dout0_55 Vdout0_55ck166 = 0 time = 835
.meas tran vdout0_55ck166 FIND v(dout0_55) AT=835.025n

* CHECK dout0_56 Vdout0_56ck166 = 0.9 time = 835
.meas tran vdout0_56ck166 FIND v(dout0_56) AT=835.025n

* CHECK dout0_57 Vdout0_57ck166 = 0 time = 835
.meas tran vdout0_57ck166 FIND v(dout0_57) AT=835.025n

* CHECK dout0_58 Vdout0_58ck166 = 0.9 time = 835
.meas tran vdout0_58ck166 FIND v(dout0_58) AT=835.025n

* CHECK dout0_59 Vdout0_59ck166 = 0 time = 835
.meas tran vdout0_59ck166 FIND v(dout0_59) AT=835.025n

* CHECK dout0_60 Vdout0_60ck166 = 0.9 time = 835
.meas tran vdout0_60ck166 FIND v(dout0_60) AT=835.025n

* CHECK dout0_61 Vdout0_61ck166 = 0 time = 835
.meas tran vdout0_61ck166 FIND v(dout0_61) AT=835.025n

* CHECK dout0_62 Vdout0_62ck166 = 0.9 time = 835
.meas tran vdout0_62ck166 FIND v(dout0_62) AT=835.025n

* CHECK dout0_63 Vdout0_63ck166 = 0 time = 835
.meas tran vdout0_63ck166 FIND v(dout0_63) AT=835.025n

* CHECK dout0_0 Vdout0_0ck168 = 0.9 time = 845
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=845.025n

* CHECK dout0_1 Vdout0_1ck168 = 0.9 time = 845
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=845.025n

* CHECK dout0_2 Vdout0_2ck168 = 0.9 time = 845
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=845.025n

* CHECK dout0_3 Vdout0_3ck168 = 0.9 time = 845
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=845.025n

* CHECK dout0_4 Vdout0_4ck168 = 0.9 time = 845
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=845.025n

* CHECK dout0_5 Vdout0_5ck168 = 0.9 time = 845
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=845.025n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 845
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=845.025n

* CHECK dout0_7 Vdout0_7ck168 = 0.9 time = 845
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=845.025n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 845
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=845.025n

* CHECK dout0_9 Vdout0_9ck168 = 0.9 time = 845
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=845.025n

* CHECK dout0_10 Vdout0_10ck168 = 0.9 time = 845
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=845.025n

* CHECK dout0_11 Vdout0_11ck168 = 0 time = 845
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=845.025n

* CHECK dout0_12 Vdout0_12ck168 = 0.9 time = 845
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=845.025n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 845
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=845.025n

* CHECK dout0_14 Vdout0_14ck168 = 0.9 time = 845
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=845.025n

* CHECK dout0_15 Vdout0_15ck168 = 0 time = 845
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=845.025n

* CHECK dout0_16 Vdout0_16ck168 = 0.9 time = 845
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=845.025n

* CHECK dout0_17 Vdout0_17ck168 = 0 time = 845
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=845.025n

* CHECK dout0_18 Vdout0_18ck168 = 0.9 time = 845
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=845.025n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 845
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=845.025n

* CHECK dout0_20 Vdout0_20ck168 = 0.9 time = 845
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=845.025n

* CHECK dout0_21 Vdout0_21ck168 = 0.9 time = 845
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=845.025n

* CHECK dout0_22 Vdout0_22ck168 = 0 time = 845
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=845.025n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 845
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=845.025n

* CHECK dout0_24 Vdout0_24ck168 = 0.9 time = 845
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=845.025n

* CHECK dout0_25 Vdout0_25ck168 = 0.9 time = 845
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=845.025n

* CHECK dout0_26 Vdout0_26ck168 = 0.9 time = 845
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=845.025n

* CHECK dout0_27 Vdout0_27ck168 = 0 time = 845
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=845.025n

* CHECK dout0_28 Vdout0_28ck168 = 0 time = 845
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=845.025n

* CHECK dout0_29 Vdout0_29ck168 = 0.9 time = 845
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=845.025n

* CHECK dout0_30 Vdout0_30ck168 = 0.9 time = 845
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=845.025n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 845
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=845.025n

* CHECK dout0_32 Vdout0_32ck168 = 0 time = 845
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=845.025n

* CHECK dout0_33 Vdout0_33ck168 = 0 time = 845
.meas tran vdout0_33ck168 FIND v(dout0_33) AT=845.025n

* CHECK dout0_34 Vdout0_34ck168 = 0.9 time = 845
.meas tran vdout0_34ck168 FIND v(dout0_34) AT=845.025n

* CHECK dout0_35 Vdout0_35ck168 = 0.9 time = 845
.meas tran vdout0_35ck168 FIND v(dout0_35) AT=845.025n

* CHECK dout0_36 Vdout0_36ck168 = 0 time = 845
.meas tran vdout0_36ck168 FIND v(dout0_36) AT=845.025n

* CHECK dout0_37 Vdout0_37ck168 = 0.9 time = 845
.meas tran vdout0_37ck168 FIND v(dout0_37) AT=845.025n

* CHECK dout0_38 Vdout0_38ck168 = 0.9 time = 845
.meas tran vdout0_38ck168 FIND v(dout0_38) AT=845.025n

* CHECK dout0_39 Vdout0_39ck168 = 0.9 time = 845
.meas tran vdout0_39ck168 FIND v(dout0_39) AT=845.025n

* CHECK dout0_40 Vdout0_40ck168 = 0 time = 845
.meas tran vdout0_40ck168 FIND v(dout0_40) AT=845.025n

* CHECK dout0_41 Vdout0_41ck168 = 0 time = 845
.meas tran vdout0_41ck168 FIND v(dout0_41) AT=845.025n

* CHECK dout0_42 Vdout0_42ck168 = 0 time = 845
.meas tran vdout0_42ck168 FIND v(dout0_42) AT=845.025n

* CHECK dout0_43 Vdout0_43ck168 = 0 time = 845
.meas tran vdout0_43ck168 FIND v(dout0_43) AT=845.025n

* CHECK dout0_44 Vdout0_44ck168 = 0.9 time = 845
.meas tran vdout0_44ck168 FIND v(dout0_44) AT=845.025n

* CHECK dout0_45 Vdout0_45ck168 = 0.9 time = 845
.meas tran vdout0_45ck168 FIND v(dout0_45) AT=845.025n

* CHECK dout0_46 Vdout0_46ck168 = 0 time = 845
.meas tran vdout0_46ck168 FIND v(dout0_46) AT=845.025n

* CHECK dout0_47 Vdout0_47ck168 = 0.9 time = 845
.meas tran vdout0_47ck168 FIND v(dout0_47) AT=845.025n

* CHECK dout0_48 Vdout0_48ck168 = 0.9 time = 845
.meas tran vdout0_48ck168 FIND v(dout0_48) AT=845.025n

* CHECK dout0_49 Vdout0_49ck168 = 0 time = 845
.meas tran vdout0_49ck168 FIND v(dout0_49) AT=845.025n

* CHECK dout0_50 Vdout0_50ck168 = 0.9 time = 845
.meas tran vdout0_50ck168 FIND v(dout0_50) AT=845.025n

* CHECK dout0_51 Vdout0_51ck168 = 0 time = 845
.meas tran vdout0_51ck168 FIND v(dout0_51) AT=845.025n

* CHECK dout0_52 Vdout0_52ck168 = 0.9 time = 845
.meas tran vdout0_52ck168 FIND v(dout0_52) AT=845.025n

* CHECK dout0_53 Vdout0_53ck168 = 0.9 time = 845
.meas tran vdout0_53ck168 FIND v(dout0_53) AT=845.025n

* CHECK dout0_54 Vdout0_54ck168 = 0 time = 845
.meas tran vdout0_54ck168 FIND v(dout0_54) AT=845.025n

* CHECK dout0_55 Vdout0_55ck168 = 0 time = 845
.meas tran vdout0_55ck168 FIND v(dout0_55) AT=845.025n

* CHECK dout0_56 Vdout0_56ck168 = 0.9 time = 845
.meas tran vdout0_56ck168 FIND v(dout0_56) AT=845.025n

* CHECK dout0_57 Vdout0_57ck168 = 0 time = 845
.meas tran vdout0_57ck168 FIND v(dout0_57) AT=845.025n

* CHECK dout0_58 Vdout0_58ck168 = 0.9 time = 845
.meas tran vdout0_58ck168 FIND v(dout0_58) AT=845.025n

* CHECK dout0_59 Vdout0_59ck168 = 0 time = 845
.meas tran vdout0_59ck168 FIND v(dout0_59) AT=845.025n

* CHECK dout0_60 Vdout0_60ck168 = 0.9 time = 845
.meas tran vdout0_60ck168 FIND v(dout0_60) AT=845.025n

* CHECK dout0_61 Vdout0_61ck168 = 0 time = 845
.meas tran vdout0_61ck168 FIND v(dout0_61) AT=845.025n

* CHECK dout0_62 Vdout0_62ck168 = 0.9 time = 845
.meas tran vdout0_62ck168 FIND v(dout0_62) AT=845.025n

* CHECK dout0_63 Vdout0_63ck168 = 0 time = 845
.meas tran vdout0_63ck168 FIND v(dout0_63) AT=845.025n

* CHECK dout0_0 Vdout0_0ck169 = 0.9 time = 850
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=850.025n

* CHECK dout0_1 Vdout0_1ck169 = 0.9 time = 850
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=850.025n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 850
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=850.025n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 850
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=850.025n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 850
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=850.025n

* CHECK dout0_5 Vdout0_5ck169 = 0 time = 850
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=850.025n

* CHECK dout0_6 Vdout0_6ck169 = 0.9 time = 850
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=850.025n

* CHECK dout0_7 Vdout0_7ck169 = 0.9 time = 850
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=850.025n

* CHECK dout0_8 Vdout0_8ck169 = 0 time = 850
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=850.025n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 850
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=850.025n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 850
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=850.025n

* CHECK dout0_11 Vdout0_11ck169 = 0.9 time = 850
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=850.025n

* CHECK dout0_12 Vdout0_12ck169 = 0.9 time = 850
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=850.025n

* CHECK dout0_13 Vdout0_13ck169 = 0 time = 850
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=850.025n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 850
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=850.025n

* CHECK dout0_15 Vdout0_15ck169 = 0 time = 850
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=850.025n

* CHECK dout0_16 Vdout0_16ck169 = 0 time = 850
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=850.025n

* CHECK dout0_17 Vdout0_17ck169 = 0.9 time = 850
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=850.025n

* CHECK dout0_18 Vdout0_18ck169 = 0 time = 850
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=850.025n

* CHECK dout0_19 Vdout0_19ck169 = 0 time = 850
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=850.025n

* CHECK dout0_20 Vdout0_20ck169 = 0 time = 850
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=850.025n

* CHECK dout0_21 Vdout0_21ck169 = 0.9 time = 850
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=850.025n

* CHECK dout0_22 Vdout0_22ck169 = 0.9 time = 850
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=850.025n

* CHECK dout0_23 Vdout0_23ck169 = 0.9 time = 850
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=850.025n

* CHECK dout0_24 Vdout0_24ck169 = 0 time = 850
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=850.025n

* CHECK dout0_25 Vdout0_25ck169 = 0.9 time = 850
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=850.025n

* CHECK dout0_26 Vdout0_26ck169 = 0 time = 850
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=850.025n

* CHECK dout0_27 Vdout0_27ck169 = 0.9 time = 850
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=850.025n

* CHECK dout0_28 Vdout0_28ck169 = 0.9 time = 850
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=850.025n

* CHECK dout0_29 Vdout0_29ck169 = 0 time = 850
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=850.025n

* CHECK dout0_30 Vdout0_30ck169 = 0 time = 850
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=850.025n

* CHECK dout0_31 Vdout0_31ck169 = 0.9 time = 850
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=850.025n

* CHECK dout0_32 Vdout0_32ck169 = 0.9 time = 850
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=850.025n

* CHECK dout0_33 Vdout0_33ck169 = 0.9 time = 850
.meas tran vdout0_33ck169 FIND v(dout0_33) AT=850.025n

* CHECK dout0_34 Vdout0_34ck169 = 0.9 time = 850
.meas tran vdout0_34ck169 FIND v(dout0_34) AT=850.025n

* CHECK dout0_35 Vdout0_35ck169 = 0.9 time = 850
.meas tran vdout0_35ck169 FIND v(dout0_35) AT=850.025n

* CHECK dout0_36 Vdout0_36ck169 = 0 time = 850
.meas tran vdout0_36ck169 FIND v(dout0_36) AT=850.025n

* CHECK dout0_37 Vdout0_37ck169 = 0 time = 850
.meas tran vdout0_37ck169 FIND v(dout0_37) AT=850.025n

* CHECK dout0_38 Vdout0_38ck169 = 0 time = 850
.meas tran vdout0_38ck169 FIND v(dout0_38) AT=850.025n

* CHECK dout0_39 Vdout0_39ck169 = 0.9 time = 850
.meas tran vdout0_39ck169 FIND v(dout0_39) AT=850.025n

* CHECK dout0_40 Vdout0_40ck169 = 0.9 time = 850
.meas tran vdout0_40ck169 FIND v(dout0_40) AT=850.025n

* CHECK dout0_41 Vdout0_41ck169 = 0 time = 850
.meas tran vdout0_41ck169 FIND v(dout0_41) AT=850.025n

* CHECK dout0_42 Vdout0_42ck169 = 0 time = 850
.meas tran vdout0_42ck169 FIND v(dout0_42) AT=850.025n

* CHECK dout0_43 Vdout0_43ck169 = 0.9 time = 850
.meas tran vdout0_43ck169 FIND v(dout0_43) AT=850.025n

* CHECK dout0_44 Vdout0_44ck169 = 0 time = 850
.meas tran vdout0_44ck169 FIND v(dout0_44) AT=850.025n

* CHECK dout0_45 Vdout0_45ck169 = 0.9 time = 850
.meas tran vdout0_45ck169 FIND v(dout0_45) AT=850.025n

* CHECK dout0_46 Vdout0_46ck169 = 0.9 time = 850
.meas tran vdout0_46ck169 FIND v(dout0_46) AT=850.025n

* CHECK dout0_47 Vdout0_47ck169 = 0.9 time = 850
.meas tran vdout0_47ck169 FIND v(dout0_47) AT=850.025n

* CHECK dout0_48 Vdout0_48ck169 = 0 time = 850
.meas tran vdout0_48ck169 FIND v(dout0_48) AT=850.025n

* CHECK dout0_49 Vdout0_49ck169 = 0.9 time = 850
.meas tran vdout0_49ck169 FIND v(dout0_49) AT=850.025n

* CHECK dout0_50 Vdout0_50ck169 = 0 time = 850
.meas tran vdout0_50ck169 FIND v(dout0_50) AT=850.025n

* CHECK dout0_51 Vdout0_51ck169 = 0 time = 850
.meas tran vdout0_51ck169 FIND v(dout0_51) AT=850.025n

* CHECK dout0_52 Vdout0_52ck169 = 0 time = 850
.meas tran vdout0_52ck169 FIND v(dout0_52) AT=850.025n

* CHECK dout0_53 Vdout0_53ck169 = 0.9 time = 850
.meas tran vdout0_53ck169 FIND v(dout0_53) AT=850.025n

* CHECK dout0_54 Vdout0_54ck169 = 0.9 time = 850
.meas tran vdout0_54ck169 FIND v(dout0_54) AT=850.025n

* CHECK dout0_55 Vdout0_55ck169 = 0.9 time = 850
.meas tran vdout0_55ck169 FIND v(dout0_55) AT=850.025n

* CHECK dout0_56 Vdout0_56ck169 = 0 time = 850
.meas tran vdout0_56ck169 FIND v(dout0_56) AT=850.025n

* CHECK dout0_57 Vdout0_57ck169 = 0.9 time = 850
.meas tran vdout0_57ck169 FIND v(dout0_57) AT=850.025n

* CHECK dout0_58 Vdout0_58ck169 = 0.9 time = 850
.meas tran vdout0_58ck169 FIND v(dout0_58) AT=850.025n

* CHECK dout0_59 Vdout0_59ck169 = 0 time = 850
.meas tran vdout0_59ck169 FIND v(dout0_59) AT=850.025n

* CHECK dout0_60 Vdout0_60ck169 = 0 time = 850
.meas tran vdout0_60ck169 FIND v(dout0_60) AT=850.025n

* CHECK dout0_61 Vdout0_61ck169 = 0 time = 850
.meas tran vdout0_61ck169 FIND v(dout0_61) AT=850.025n

* CHECK dout0_62 Vdout0_62ck169 = 0 time = 850
.meas tran vdout0_62ck169 FIND v(dout0_62) AT=850.025n

* CHECK dout0_63 Vdout0_63ck169 = 0 time = 850
.meas tran vdout0_63ck169 FIND v(dout0_63) AT=850.025n

* CHECK dout0_0 Vdout0_0ck171 = 0.9 time = 860
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=860.025n

* CHECK dout0_1 Vdout0_1ck171 = 0.9 time = 860
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=860.025n

* CHECK dout0_2 Vdout0_2ck171 = 0 time = 860
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=860.025n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 860
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=860.025n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 860
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=860.025n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 860
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=860.025n

* CHECK dout0_6 Vdout0_6ck171 = 0.9 time = 860
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=860.025n

* CHECK dout0_7 Vdout0_7ck171 = 0.9 time = 860
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=860.025n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 860
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=860.025n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 860
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=860.025n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 860
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=860.025n

* CHECK dout0_11 Vdout0_11ck171 = 0.9 time = 860
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=860.025n

* CHECK dout0_12 Vdout0_12ck171 = 0.9 time = 860
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=860.025n

* CHECK dout0_13 Vdout0_13ck171 = 0 time = 860
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=860.025n

* CHECK dout0_14 Vdout0_14ck171 = 0 time = 860
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=860.025n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 860
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=860.025n

* CHECK dout0_16 Vdout0_16ck171 = 0 time = 860
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=860.025n

* CHECK dout0_17 Vdout0_17ck171 = 0.9 time = 860
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=860.025n

* CHECK dout0_18 Vdout0_18ck171 = 0 time = 860
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=860.025n

* CHECK dout0_19 Vdout0_19ck171 = 0 time = 860
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=860.025n

* CHECK dout0_20 Vdout0_20ck171 = 0 time = 860
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=860.025n

* CHECK dout0_21 Vdout0_21ck171 = 0.9 time = 860
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=860.025n

* CHECK dout0_22 Vdout0_22ck171 = 0.9 time = 860
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=860.025n

* CHECK dout0_23 Vdout0_23ck171 = 0.9 time = 860
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=860.025n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 860
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=860.025n

* CHECK dout0_25 Vdout0_25ck171 = 0.9 time = 860
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=860.025n

* CHECK dout0_26 Vdout0_26ck171 = 0 time = 860
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=860.025n

* CHECK dout0_27 Vdout0_27ck171 = 0.9 time = 860
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=860.025n

* CHECK dout0_28 Vdout0_28ck171 = 0.9 time = 860
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=860.025n

* CHECK dout0_29 Vdout0_29ck171 = 0 time = 860
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=860.025n

* CHECK dout0_30 Vdout0_30ck171 = 0 time = 860
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=860.025n

* CHECK dout0_31 Vdout0_31ck171 = 0.9 time = 860
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=860.025n

* CHECK dout0_32 Vdout0_32ck171 = 0.9 time = 860
.meas tran vdout0_32ck171 FIND v(dout0_32) AT=860.025n

* CHECK dout0_33 Vdout0_33ck171 = 0.9 time = 860
.meas tran vdout0_33ck171 FIND v(dout0_33) AT=860.025n

* CHECK dout0_34 Vdout0_34ck171 = 0.9 time = 860
.meas tran vdout0_34ck171 FIND v(dout0_34) AT=860.025n

* CHECK dout0_35 Vdout0_35ck171 = 0.9 time = 860
.meas tran vdout0_35ck171 FIND v(dout0_35) AT=860.025n

* CHECK dout0_36 Vdout0_36ck171 = 0 time = 860
.meas tran vdout0_36ck171 FIND v(dout0_36) AT=860.025n

* CHECK dout0_37 Vdout0_37ck171 = 0 time = 860
.meas tran vdout0_37ck171 FIND v(dout0_37) AT=860.025n

* CHECK dout0_38 Vdout0_38ck171 = 0 time = 860
.meas tran vdout0_38ck171 FIND v(dout0_38) AT=860.025n

* CHECK dout0_39 Vdout0_39ck171 = 0.9 time = 860
.meas tran vdout0_39ck171 FIND v(dout0_39) AT=860.025n

* CHECK dout0_40 Vdout0_40ck171 = 0.9 time = 860
.meas tran vdout0_40ck171 FIND v(dout0_40) AT=860.025n

* CHECK dout0_41 Vdout0_41ck171 = 0 time = 860
.meas tran vdout0_41ck171 FIND v(dout0_41) AT=860.025n

* CHECK dout0_42 Vdout0_42ck171 = 0 time = 860
.meas tran vdout0_42ck171 FIND v(dout0_42) AT=860.025n

* CHECK dout0_43 Vdout0_43ck171 = 0.9 time = 860
.meas tran vdout0_43ck171 FIND v(dout0_43) AT=860.025n

* CHECK dout0_44 Vdout0_44ck171 = 0 time = 860
.meas tran vdout0_44ck171 FIND v(dout0_44) AT=860.025n

* CHECK dout0_45 Vdout0_45ck171 = 0.9 time = 860
.meas tran vdout0_45ck171 FIND v(dout0_45) AT=860.025n

* CHECK dout0_46 Vdout0_46ck171 = 0.9 time = 860
.meas tran vdout0_46ck171 FIND v(dout0_46) AT=860.025n

* CHECK dout0_47 Vdout0_47ck171 = 0.9 time = 860
.meas tran vdout0_47ck171 FIND v(dout0_47) AT=860.025n

* CHECK dout0_48 Vdout0_48ck171 = 0 time = 860
.meas tran vdout0_48ck171 FIND v(dout0_48) AT=860.025n

* CHECK dout0_49 Vdout0_49ck171 = 0.9 time = 860
.meas tran vdout0_49ck171 FIND v(dout0_49) AT=860.025n

* CHECK dout0_50 Vdout0_50ck171 = 0 time = 860
.meas tran vdout0_50ck171 FIND v(dout0_50) AT=860.025n

* CHECK dout0_51 Vdout0_51ck171 = 0 time = 860
.meas tran vdout0_51ck171 FIND v(dout0_51) AT=860.025n

* CHECK dout0_52 Vdout0_52ck171 = 0 time = 860
.meas tran vdout0_52ck171 FIND v(dout0_52) AT=860.025n

* CHECK dout0_53 Vdout0_53ck171 = 0.9 time = 860
.meas tran vdout0_53ck171 FIND v(dout0_53) AT=860.025n

* CHECK dout0_54 Vdout0_54ck171 = 0.9 time = 860
.meas tran vdout0_54ck171 FIND v(dout0_54) AT=860.025n

* CHECK dout0_55 Vdout0_55ck171 = 0.9 time = 860
.meas tran vdout0_55ck171 FIND v(dout0_55) AT=860.025n

* CHECK dout0_56 Vdout0_56ck171 = 0 time = 860
.meas tran vdout0_56ck171 FIND v(dout0_56) AT=860.025n

* CHECK dout0_57 Vdout0_57ck171 = 0.9 time = 860
.meas tran vdout0_57ck171 FIND v(dout0_57) AT=860.025n

* CHECK dout0_58 Vdout0_58ck171 = 0.9 time = 860
.meas tran vdout0_58ck171 FIND v(dout0_58) AT=860.025n

* CHECK dout0_59 Vdout0_59ck171 = 0 time = 860
.meas tran vdout0_59ck171 FIND v(dout0_59) AT=860.025n

* CHECK dout0_60 Vdout0_60ck171 = 0 time = 860
.meas tran vdout0_60ck171 FIND v(dout0_60) AT=860.025n

* CHECK dout0_61 Vdout0_61ck171 = 0 time = 860
.meas tran vdout0_61ck171 FIND v(dout0_61) AT=860.025n

* CHECK dout0_62 Vdout0_62ck171 = 0 time = 860
.meas tran vdout0_62ck171 FIND v(dout0_62) AT=860.025n

* CHECK dout0_63 Vdout0_63ck171 = 0 time = 860
.meas tran vdout0_63ck171 FIND v(dout0_63) AT=860.025n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 870
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=870.025n

* CHECK dout0_1 Vdout0_1ck173 = 0.9 time = 870
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=870.025n

* CHECK dout0_2 Vdout0_2ck173 = 0.9 time = 870
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=870.025n

* CHECK dout0_3 Vdout0_3ck173 = 0.9 time = 870
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=870.025n

* CHECK dout0_4 Vdout0_4ck173 = 0.9 time = 870
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=870.025n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 870
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=870.025n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 870
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=870.025n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 870
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=870.025n

* CHECK dout0_8 Vdout0_8ck173 = 0 time = 870
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=870.025n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 870
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=870.025n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 870
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=870.025n

* CHECK dout0_11 Vdout0_11ck173 = 0.9 time = 870
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=870.025n

* CHECK dout0_12 Vdout0_12ck173 = 0 time = 870
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=870.025n

* CHECK dout0_13 Vdout0_13ck173 = 0.9 time = 870
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=870.025n

* CHECK dout0_14 Vdout0_14ck173 = 0 time = 870
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=870.025n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 870
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=870.025n

* CHECK dout0_16 Vdout0_16ck173 = 0.9 time = 870
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=870.025n

* CHECK dout0_17 Vdout0_17ck173 = 0 time = 870
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=870.025n

* CHECK dout0_18 Vdout0_18ck173 = 0 time = 870
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=870.025n

* CHECK dout0_19 Vdout0_19ck173 = 0.9 time = 870
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=870.025n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 870
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=870.025n

* CHECK dout0_21 Vdout0_21ck173 = 0.9 time = 870
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=870.025n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 870
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=870.025n

* CHECK dout0_23 Vdout0_23ck173 = 0.9 time = 870
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=870.025n

* CHECK dout0_24 Vdout0_24ck173 = 0 time = 870
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=870.025n

* CHECK dout0_25 Vdout0_25ck173 = 0.9 time = 870
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=870.025n

* CHECK dout0_26 Vdout0_26ck173 = 0.9 time = 870
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=870.025n

* CHECK dout0_27 Vdout0_27ck173 = 0.9 time = 870
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=870.025n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 870
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=870.025n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 870
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=870.025n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 870
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=870.025n

* CHECK dout0_31 Vdout0_31ck173 = 0.9 time = 870
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=870.025n

* CHECK dout0_32 Vdout0_32ck173 = 0 time = 870
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=870.025n

* CHECK dout0_33 Vdout0_33ck173 = 0.9 time = 870
.meas tran vdout0_33ck173 FIND v(dout0_33) AT=870.025n

* CHECK dout0_34 Vdout0_34ck173 = 0 time = 870
.meas tran vdout0_34ck173 FIND v(dout0_34) AT=870.025n

* CHECK dout0_35 Vdout0_35ck173 = 0.9 time = 870
.meas tran vdout0_35ck173 FIND v(dout0_35) AT=870.025n

* CHECK dout0_36 Vdout0_36ck173 = 0 time = 870
.meas tran vdout0_36ck173 FIND v(dout0_36) AT=870.025n

* CHECK dout0_37 Vdout0_37ck173 = 0 time = 870
.meas tran vdout0_37ck173 FIND v(dout0_37) AT=870.025n

* CHECK dout0_38 Vdout0_38ck173 = 0 time = 870
.meas tran vdout0_38ck173 FIND v(dout0_38) AT=870.025n

* CHECK dout0_39 Vdout0_39ck173 = 0.9 time = 870
.meas tran vdout0_39ck173 FIND v(dout0_39) AT=870.025n

* CHECK dout0_40 Vdout0_40ck173 = 0.9 time = 870
.meas tran vdout0_40ck173 FIND v(dout0_40) AT=870.025n

* CHECK dout0_41 Vdout0_41ck173 = 0 time = 870
.meas tran vdout0_41ck173 FIND v(dout0_41) AT=870.025n

* CHECK dout0_42 Vdout0_42ck173 = 0 time = 870
.meas tran vdout0_42ck173 FIND v(dout0_42) AT=870.025n

* CHECK dout0_43 Vdout0_43ck173 = 0 time = 870
.meas tran vdout0_43ck173 FIND v(dout0_43) AT=870.025n

* CHECK dout0_44 Vdout0_44ck173 = 0 time = 870
.meas tran vdout0_44ck173 FIND v(dout0_44) AT=870.025n

* CHECK dout0_45 Vdout0_45ck173 = 0 time = 870
.meas tran vdout0_45ck173 FIND v(dout0_45) AT=870.025n

* CHECK dout0_46 Vdout0_46ck173 = 0 time = 870
.meas tran vdout0_46ck173 FIND v(dout0_46) AT=870.025n

* CHECK dout0_47 Vdout0_47ck173 = 0.9 time = 870
.meas tran vdout0_47ck173 FIND v(dout0_47) AT=870.025n

* CHECK dout0_48 Vdout0_48ck173 = 0 time = 870
.meas tran vdout0_48ck173 FIND v(dout0_48) AT=870.025n

* CHECK dout0_49 Vdout0_49ck173 = 0.9 time = 870
.meas tran vdout0_49ck173 FIND v(dout0_49) AT=870.025n

* CHECK dout0_50 Vdout0_50ck173 = 0 time = 870
.meas tran vdout0_50ck173 FIND v(dout0_50) AT=870.025n

* CHECK dout0_51 Vdout0_51ck173 = 0 time = 870
.meas tran vdout0_51ck173 FIND v(dout0_51) AT=870.025n

* CHECK dout0_52 Vdout0_52ck173 = 0.9 time = 870
.meas tran vdout0_52ck173 FIND v(dout0_52) AT=870.025n

* CHECK dout0_53 Vdout0_53ck173 = 0 time = 870
.meas tran vdout0_53ck173 FIND v(dout0_53) AT=870.025n

* CHECK dout0_54 Vdout0_54ck173 = 0 time = 870
.meas tran vdout0_54ck173 FIND v(dout0_54) AT=870.025n

* CHECK dout0_55 Vdout0_55ck173 = 0 time = 870
.meas tran vdout0_55ck173 FIND v(dout0_55) AT=870.025n

* CHECK dout0_56 Vdout0_56ck173 = 0 time = 870
.meas tran vdout0_56ck173 FIND v(dout0_56) AT=870.025n

* CHECK dout0_57 Vdout0_57ck173 = 0.9 time = 870
.meas tran vdout0_57ck173 FIND v(dout0_57) AT=870.025n

* CHECK dout0_58 Vdout0_58ck173 = 0 time = 870
.meas tran vdout0_58ck173 FIND v(dout0_58) AT=870.025n

* CHECK dout0_59 Vdout0_59ck173 = 0.9 time = 870
.meas tran vdout0_59ck173 FIND v(dout0_59) AT=870.025n

* CHECK dout0_60 Vdout0_60ck173 = 0.9 time = 870
.meas tran vdout0_60ck173 FIND v(dout0_60) AT=870.025n

* CHECK dout0_61 Vdout0_61ck173 = 0 time = 870
.meas tran vdout0_61ck173 FIND v(dout0_61) AT=870.025n

* CHECK dout0_62 Vdout0_62ck173 = 0.9 time = 870
.meas tran vdout0_62ck173 FIND v(dout0_62) AT=870.025n

* CHECK dout0_63 Vdout0_63ck173 = 0 time = 870
.meas tran vdout0_63ck173 FIND v(dout0_63) AT=870.025n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 0.9 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 0.9 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 0.9 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 0.9 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 0 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 0.9 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 0.9 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 0 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 0 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 0.9 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 0 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 0.9 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 0 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 0.9 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 0 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0.9 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 0 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 0.9 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 0.9 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 0.9 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 0 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 0 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 0.9 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_32 Vdout0_32ck174 = 0 time = 875
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=875.025n

* CHECK dout0_33 Vdout0_33ck174 = 0.9 time = 875
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=875.025n

* CHECK dout0_34 Vdout0_34ck174 = 0 time = 875
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=875.025n

* CHECK dout0_35 Vdout0_35ck174 = 0.9 time = 875
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=875.025n

* CHECK dout0_36 Vdout0_36ck174 = 0 time = 875
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=875.025n

* CHECK dout0_37 Vdout0_37ck174 = 0 time = 875
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=875.025n

* CHECK dout0_38 Vdout0_38ck174 = 0 time = 875
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=875.025n

* CHECK dout0_39 Vdout0_39ck174 = 0.9 time = 875
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=875.025n

* CHECK dout0_40 Vdout0_40ck174 = 0.9 time = 875
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=875.025n

* CHECK dout0_41 Vdout0_41ck174 = 0 time = 875
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=875.025n

* CHECK dout0_42 Vdout0_42ck174 = 0 time = 875
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=875.025n

* CHECK dout0_43 Vdout0_43ck174 = 0 time = 875
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=875.025n

* CHECK dout0_44 Vdout0_44ck174 = 0 time = 875
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=875.025n

* CHECK dout0_45 Vdout0_45ck174 = 0 time = 875
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=875.025n

* CHECK dout0_46 Vdout0_46ck174 = 0 time = 875
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=875.025n

* CHECK dout0_47 Vdout0_47ck174 = 0.9 time = 875
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=875.025n

* CHECK dout0_48 Vdout0_48ck174 = 0 time = 875
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=875.025n

* CHECK dout0_49 Vdout0_49ck174 = 0.9 time = 875
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=875.025n

* CHECK dout0_50 Vdout0_50ck174 = 0 time = 875
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=875.025n

* CHECK dout0_51 Vdout0_51ck174 = 0 time = 875
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=875.025n

* CHECK dout0_52 Vdout0_52ck174 = 0.9 time = 875
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=875.025n

* CHECK dout0_53 Vdout0_53ck174 = 0 time = 875
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=875.025n

* CHECK dout0_54 Vdout0_54ck174 = 0 time = 875
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=875.025n

* CHECK dout0_55 Vdout0_55ck174 = 0 time = 875
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=875.025n

* CHECK dout0_56 Vdout0_56ck174 = 0 time = 875
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=875.025n

* CHECK dout0_57 Vdout0_57ck174 = 0.9 time = 875
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=875.025n

* CHECK dout0_58 Vdout0_58ck174 = 0 time = 875
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=875.025n

* CHECK dout0_59 Vdout0_59ck174 = 0.9 time = 875
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=875.025n

* CHECK dout0_60 Vdout0_60ck174 = 0.9 time = 875
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=875.025n

* CHECK dout0_61 Vdout0_61ck174 = 0 time = 875
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=875.025n

* CHECK dout0_62 Vdout0_62ck174 = 0.9 time = 875
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=875.025n

* CHECK dout0_63 Vdout0_63ck174 = 0 time = 875
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=875.025n

* CHECK dout0_0 Vdout0_0ck175 = 0.9 time = 880
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=880.025n

* CHECK dout0_1 Vdout0_1ck175 = 0.9 time = 880
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=880.025n

* CHECK dout0_2 Vdout0_2ck175 = 0.9 time = 880
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=880.025n

* CHECK dout0_3 Vdout0_3ck175 = 0.9 time = 880
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=880.025n

* CHECK dout0_4 Vdout0_4ck175 = 0.9 time = 880
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=880.025n

* CHECK dout0_5 Vdout0_5ck175 = 0.9 time = 880
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=880.025n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 880
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=880.025n

* CHECK dout0_7 Vdout0_7ck175 = 0.9 time = 880
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=880.025n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 880
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=880.025n

* CHECK dout0_9 Vdout0_9ck175 = 0.9 time = 880
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=880.025n

* CHECK dout0_10 Vdout0_10ck175 = 0.9 time = 880
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=880.025n

* CHECK dout0_11 Vdout0_11ck175 = 0 time = 880
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=880.025n

* CHECK dout0_12 Vdout0_12ck175 = 0.9 time = 880
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=880.025n

* CHECK dout0_13 Vdout0_13ck175 = 0 time = 880
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=880.025n

* CHECK dout0_14 Vdout0_14ck175 = 0.9 time = 880
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=880.025n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 880
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=880.025n

* CHECK dout0_16 Vdout0_16ck175 = 0.9 time = 880
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=880.025n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 880
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=880.025n

* CHECK dout0_18 Vdout0_18ck175 = 0.9 time = 880
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=880.025n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 880
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=880.025n

* CHECK dout0_20 Vdout0_20ck175 = 0.9 time = 880
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=880.025n

* CHECK dout0_21 Vdout0_21ck175 = 0.9 time = 880
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=880.025n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 880
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=880.025n

* CHECK dout0_23 Vdout0_23ck175 = 0 time = 880
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=880.025n

* CHECK dout0_24 Vdout0_24ck175 = 0.9 time = 880
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=880.025n

* CHECK dout0_25 Vdout0_25ck175 = 0.9 time = 880
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=880.025n

* CHECK dout0_26 Vdout0_26ck175 = 0.9 time = 880
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=880.025n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 880
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=880.025n

* CHECK dout0_28 Vdout0_28ck175 = 0 time = 880
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=880.025n

* CHECK dout0_29 Vdout0_29ck175 = 0.9 time = 880
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=880.025n

* CHECK dout0_30 Vdout0_30ck175 = 0.9 time = 880
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=880.025n

* CHECK dout0_31 Vdout0_31ck175 = 0 time = 880
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=880.025n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 880
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=880.025n

* CHECK dout0_33 Vdout0_33ck175 = 0 time = 880
.meas tran vdout0_33ck175 FIND v(dout0_33) AT=880.025n

* CHECK dout0_34 Vdout0_34ck175 = 0.9 time = 880
.meas tran vdout0_34ck175 FIND v(dout0_34) AT=880.025n

* CHECK dout0_35 Vdout0_35ck175 = 0.9 time = 880
.meas tran vdout0_35ck175 FIND v(dout0_35) AT=880.025n

* CHECK dout0_36 Vdout0_36ck175 = 0 time = 880
.meas tran vdout0_36ck175 FIND v(dout0_36) AT=880.025n

* CHECK dout0_37 Vdout0_37ck175 = 0.9 time = 880
.meas tran vdout0_37ck175 FIND v(dout0_37) AT=880.025n

* CHECK dout0_38 Vdout0_38ck175 = 0.9 time = 880
.meas tran vdout0_38ck175 FIND v(dout0_38) AT=880.025n

* CHECK dout0_39 Vdout0_39ck175 = 0.9 time = 880
.meas tran vdout0_39ck175 FIND v(dout0_39) AT=880.025n

* CHECK dout0_40 Vdout0_40ck175 = 0 time = 880
.meas tran vdout0_40ck175 FIND v(dout0_40) AT=880.025n

* CHECK dout0_41 Vdout0_41ck175 = 0 time = 880
.meas tran vdout0_41ck175 FIND v(dout0_41) AT=880.025n

* CHECK dout0_42 Vdout0_42ck175 = 0 time = 880
.meas tran vdout0_42ck175 FIND v(dout0_42) AT=880.025n

* CHECK dout0_43 Vdout0_43ck175 = 0 time = 880
.meas tran vdout0_43ck175 FIND v(dout0_43) AT=880.025n

* CHECK dout0_44 Vdout0_44ck175 = 0.9 time = 880
.meas tran vdout0_44ck175 FIND v(dout0_44) AT=880.025n

* CHECK dout0_45 Vdout0_45ck175 = 0.9 time = 880
.meas tran vdout0_45ck175 FIND v(dout0_45) AT=880.025n

* CHECK dout0_46 Vdout0_46ck175 = 0 time = 880
.meas tran vdout0_46ck175 FIND v(dout0_46) AT=880.025n

* CHECK dout0_47 Vdout0_47ck175 = 0.9 time = 880
.meas tran vdout0_47ck175 FIND v(dout0_47) AT=880.025n

* CHECK dout0_48 Vdout0_48ck175 = 0.9 time = 880
.meas tran vdout0_48ck175 FIND v(dout0_48) AT=880.025n

* CHECK dout0_49 Vdout0_49ck175 = 0 time = 880
.meas tran vdout0_49ck175 FIND v(dout0_49) AT=880.025n

* CHECK dout0_50 Vdout0_50ck175 = 0.9 time = 880
.meas tran vdout0_50ck175 FIND v(dout0_50) AT=880.025n

* CHECK dout0_51 Vdout0_51ck175 = 0 time = 880
.meas tran vdout0_51ck175 FIND v(dout0_51) AT=880.025n

* CHECK dout0_52 Vdout0_52ck175 = 0.9 time = 880
.meas tran vdout0_52ck175 FIND v(dout0_52) AT=880.025n

* CHECK dout0_53 Vdout0_53ck175 = 0.9 time = 880
.meas tran vdout0_53ck175 FIND v(dout0_53) AT=880.025n

* CHECK dout0_54 Vdout0_54ck175 = 0 time = 880
.meas tran vdout0_54ck175 FIND v(dout0_54) AT=880.025n

* CHECK dout0_55 Vdout0_55ck175 = 0 time = 880
.meas tran vdout0_55ck175 FIND v(dout0_55) AT=880.025n

* CHECK dout0_56 Vdout0_56ck175 = 0.9 time = 880
.meas tran vdout0_56ck175 FIND v(dout0_56) AT=880.025n

* CHECK dout0_57 Vdout0_57ck175 = 0 time = 880
.meas tran vdout0_57ck175 FIND v(dout0_57) AT=880.025n

* CHECK dout0_58 Vdout0_58ck175 = 0.9 time = 880
.meas tran vdout0_58ck175 FIND v(dout0_58) AT=880.025n

* CHECK dout0_59 Vdout0_59ck175 = 0 time = 880
.meas tran vdout0_59ck175 FIND v(dout0_59) AT=880.025n

* CHECK dout0_60 Vdout0_60ck175 = 0.9 time = 880
.meas tran vdout0_60ck175 FIND v(dout0_60) AT=880.025n

* CHECK dout0_61 Vdout0_61ck175 = 0 time = 880
.meas tran vdout0_61ck175 FIND v(dout0_61) AT=880.025n

* CHECK dout0_62 Vdout0_62ck175 = 0.9 time = 880
.meas tran vdout0_62ck175 FIND v(dout0_62) AT=880.025n

* CHECK dout0_63 Vdout0_63ck175 = 0 time = 880
.meas tran vdout0_63ck175 FIND v(dout0_63) AT=880.025n

* CHECK dout0_0 Vdout0_0ck176 = 0.9 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 0.9 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 0.9 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 0.9 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 0.9 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 0.9 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0.9 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 0.9 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 0.9 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0.9 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 0 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0.9 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 0.9 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 0 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 0.9 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 0 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 0.9 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 0.9 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0.9 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 0.9 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 0.9 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0.9 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 0.9 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 0 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_32 Vdout0_32ck176 = 0 time = 885
.meas tran vdout0_32ck176 FIND v(dout0_32) AT=885.025n

* CHECK dout0_33 Vdout0_33ck176 = 0 time = 885
.meas tran vdout0_33ck176 FIND v(dout0_33) AT=885.025n

* CHECK dout0_34 Vdout0_34ck176 = 0.9 time = 885
.meas tran vdout0_34ck176 FIND v(dout0_34) AT=885.025n

* CHECK dout0_35 Vdout0_35ck176 = 0.9 time = 885
.meas tran vdout0_35ck176 FIND v(dout0_35) AT=885.025n

* CHECK dout0_36 Vdout0_36ck176 = 0 time = 885
.meas tran vdout0_36ck176 FIND v(dout0_36) AT=885.025n

* CHECK dout0_37 Vdout0_37ck176 = 0.9 time = 885
.meas tran vdout0_37ck176 FIND v(dout0_37) AT=885.025n

* CHECK dout0_38 Vdout0_38ck176 = 0.9 time = 885
.meas tran vdout0_38ck176 FIND v(dout0_38) AT=885.025n

* CHECK dout0_39 Vdout0_39ck176 = 0.9 time = 885
.meas tran vdout0_39ck176 FIND v(dout0_39) AT=885.025n

* CHECK dout0_40 Vdout0_40ck176 = 0 time = 885
.meas tran vdout0_40ck176 FIND v(dout0_40) AT=885.025n

* CHECK dout0_41 Vdout0_41ck176 = 0 time = 885
.meas tran vdout0_41ck176 FIND v(dout0_41) AT=885.025n

* CHECK dout0_42 Vdout0_42ck176 = 0 time = 885
.meas tran vdout0_42ck176 FIND v(dout0_42) AT=885.025n

* CHECK dout0_43 Vdout0_43ck176 = 0 time = 885
.meas tran vdout0_43ck176 FIND v(dout0_43) AT=885.025n

* CHECK dout0_44 Vdout0_44ck176 = 0.9 time = 885
.meas tran vdout0_44ck176 FIND v(dout0_44) AT=885.025n

* CHECK dout0_45 Vdout0_45ck176 = 0.9 time = 885
.meas tran vdout0_45ck176 FIND v(dout0_45) AT=885.025n

* CHECK dout0_46 Vdout0_46ck176 = 0 time = 885
.meas tran vdout0_46ck176 FIND v(dout0_46) AT=885.025n

* CHECK dout0_47 Vdout0_47ck176 = 0.9 time = 885
.meas tran vdout0_47ck176 FIND v(dout0_47) AT=885.025n

* CHECK dout0_48 Vdout0_48ck176 = 0.9 time = 885
.meas tran vdout0_48ck176 FIND v(dout0_48) AT=885.025n

* CHECK dout0_49 Vdout0_49ck176 = 0 time = 885
.meas tran vdout0_49ck176 FIND v(dout0_49) AT=885.025n

* CHECK dout0_50 Vdout0_50ck176 = 0.9 time = 885
.meas tran vdout0_50ck176 FIND v(dout0_50) AT=885.025n

* CHECK dout0_51 Vdout0_51ck176 = 0 time = 885
.meas tran vdout0_51ck176 FIND v(dout0_51) AT=885.025n

* CHECK dout0_52 Vdout0_52ck176 = 0.9 time = 885
.meas tran vdout0_52ck176 FIND v(dout0_52) AT=885.025n

* CHECK dout0_53 Vdout0_53ck176 = 0.9 time = 885
.meas tran vdout0_53ck176 FIND v(dout0_53) AT=885.025n

* CHECK dout0_54 Vdout0_54ck176 = 0 time = 885
.meas tran vdout0_54ck176 FIND v(dout0_54) AT=885.025n

* CHECK dout0_55 Vdout0_55ck176 = 0 time = 885
.meas tran vdout0_55ck176 FIND v(dout0_55) AT=885.025n

* CHECK dout0_56 Vdout0_56ck176 = 0.9 time = 885
.meas tran vdout0_56ck176 FIND v(dout0_56) AT=885.025n

* CHECK dout0_57 Vdout0_57ck176 = 0 time = 885
.meas tran vdout0_57ck176 FIND v(dout0_57) AT=885.025n

* CHECK dout0_58 Vdout0_58ck176 = 0.9 time = 885
.meas tran vdout0_58ck176 FIND v(dout0_58) AT=885.025n

* CHECK dout0_59 Vdout0_59ck176 = 0 time = 885
.meas tran vdout0_59ck176 FIND v(dout0_59) AT=885.025n

* CHECK dout0_60 Vdout0_60ck176 = 0.9 time = 885
.meas tran vdout0_60ck176 FIND v(dout0_60) AT=885.025n

* CHECK dout0_61 Vdout0_61ck176 = 0 time = 885
.meas tran vdout0_61ck176 FIND v(dout0_61) AT=885.025n

* CHECK dout0_62 Vdout0_62ck176 = 0.9 time = 885
.meas tran vdout0_62ck176 FIND v(dout0_62) AT=885.025n

* CHECK dout0_63 Vdout0_63ck176 = 0 time = 885
.meas tran vdout0_63ck176 FIND v(dout0_63) AT=885.025n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 895
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=895.025n

* CHECK dout0_1 Vdout0_1ck178 = 0.9 time = 895
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=895.025n

* CHECK dout0_2 Vdout0_2ck178 = 0.9 time = 895
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=895.025n

* CHECK dout0_3 Vdout0_3ck178 = 0.9 time = 895
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=895.025n

* CHECK dout0_4 Vdout0_4ck178 = 0.9 time = 895
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=895.025n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 895
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=895.025n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 895
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=895.025n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 895
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=895.025n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 895
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=895.025n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 895
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=895.025n

* CHECK dout0_10 Vdout0_10ck178 = 0 time = 895
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=895.025n

* CHECK dout0_11 Vdout0_11ck178 = 0.9 time = 895
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=895.025n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 895
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=895.025n

* CHECK dout0_13 Vdout0_13ck178 = 0.9 time = 895
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=895.025n

* CHECK dout0_14 Vdout0_14ck178 = 0 time = 895
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=895.025n

* CHECK dout0_15 Vdout0_15ck178 = 0 time = 895
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=895.025n

* CHECK dout0_16 Vdout0_16ck178 = 0.9 time = 895
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=895.025n

* CHECK dout0_17 Vdout0_17ck178 = 0 time = 895
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=895.025n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 895
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=895.025n

* CHECK dout0_19 Vdout0_19ck178 = 0.9 time = 895
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=895.025n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 895
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=895.025n

* CHECK dout0_21 Vdout0_21ck178 = 0.9 time = 895
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=895.025n

* CHECK dout0_22 Vdout0_22ck178 = 0 time = 895
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=895.025n

* CHECK dout0_23 Vdout0_23ck178 = 0.9 time = 895
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=895.025n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 895
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=895.025n

* CHECK dout0_25 Vdout0_25ck178 = 0.9 time = 895
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=895.025n

* CHECK dout0_26 Vdout0_26ck178 = 0.9 time = 895
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=895.025n

* CHECK dout0_27 Vdout0_27ck178 = 0.9 time = 895
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=895.025n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 895
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=895.025n

* CHECK dout0_29 Vdout0_29ck178 = 0 time = 895
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=895.025n

* CHECK dout0_30 Vdout0_30ck178 = 0 time = 895
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=895.025n

* CHECK dout0_31 Vdout0_31ck178 = 0.9 time = 895
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=895.025n

* CHECK dout0_32 Vdout0_32ck178 = 0 time = 895
.meas tran vdout0_32ck178 FIND v(dout0_32) AT=895.025n

* CHECK dout0_33 Vdout0_33ck178 = 0.9 time = 895
.meas tran vdout0_33ck178 FIND v(dout0_33) AT=895.025n

* CHECK dout0_34 Vdout0_34ck178 = 0 time = 895
.meas tran vdout0_34ck178 FIND v(dout0_34) AT=895.025n

* CHECK dout0_35 Vdout0_35ck178 = 0.9 time = 895
.meas tran vdout0_35ck178 FIND v(dout0_35) AT=895.025n

* CHECK dout0_36 Vdout0_36ck178 = 0 time = 895
.meas tran vdout0_36ck178 FIND v(dout0_36) AT=895.025n

* CHECK dout0_37 Vdout0_37ck178 = 0 time = 895
.meas tran vdout0_37ck178 FIND v(dout0_37) AT=895.025n

* CHECK dout0_38 Vdout0_38ck178 = 0 time = 895
.meas tran vdout0_38ck178 FIND v(dout0_38) AT=895.025n

* CHECK dout0_39 Vdout0_39ck178 = 0.9 time = 895
.meas tran vdout0_39ck178 FIND v(dout0_39) AT=895.025n

* CHECK dout0_40 Vdout0_40ck178 = 0.9 time = 895
.meas tran vdout0_40ck178 FIND v(dout0_40) AT=895.025n

* CHECK dout0_41 Vdout0_41ck178 = 0 time = 895
.meas tran vdout0_41ck178 FIND v(dout0_41) AT=895.025n

* CHECK dout0_42 Vdout0_42ck178 = 0 time = 895
.meas tran vdout0_42ck178 FIND v(dout0_42) AT=895.025n

* CHECK dout0_43 Vdout0_43ck178 = 0 time = 895
.meas tran vdout0_43ck178 FIND v(dout0_43) AT=895.025n

* CHECK dout0_44 Vdout0_44ck178 = 0 time = 895
.meas tran vdout0_44ck178 FIND v(dout0_44) AT=895.025n

* CHECK dout0_45 Vdout0_45ck178 = 0 time = 895
.meas tran vdout0_45ck178 FIND v(dout0_45) AT=895.025n

* CHECK dout0_46 Vdout0_46ck178 = 0 time = 895
.meas tran vdout0_46ck178 FIND v(dout0_46) AT=895.025n

* CHECK dout0_47 Vdout0_47ck178 = 0.9 time = 895
.meas tran vdout0_47ck178 FIND v(dout0_47) AT=895.025n

* CHECK dout0_48 Vdout0_48ck178 = 0 time = 895
.meas tran vdout0_48ck178 FIND v(dout0_48) AT=895.025n

* CHECK dout0_49 Vdout0_49ck178 = 0.9 time = 895
.meas tran vdout0_49ck178 FIND v(dout0_49) AT=895.025n

* CHECK dout0_50 Vdout0_50ck178 = 0 time = 895
.meas tran vdout0_50ck178 FIND v(dout0_50) AT=895.025n

* CHECK dout0_51 Vdout0_51ck178 = 0 time = 895
.meas tran vdout0_51ck178 FIND v(dout0_51) AT=895.025n

* CHECK dout0_52 Vdout0_52ck178 = 0.9 time = 895
.meas tran vdout0_52ck178 FIND v(dout0_52) AT=895.025n

* CHECK dout0_53 Vdout0_53ck178 = 0 time = 895
.meas tran vdout0_53ck178 FIND v(dout0_53) AT=895.025n

* CHECK dout0_54 Vdout0_54ck178 = 0 time = 895
.meas tran vdout0_54ck178 FIND v(dout0_54) AT=895.025n

* CHECK dout0_55 Vdout0_55ck178 = 0 time = 895
.meas tran vdout0_55ck178 FIND v(dout0_55) AT=895.025n

* CHECK dout0_56 Vdout0_56ck178 = 0 time = 895
.meas tran vdout0_56ck178 FIND v(dout0_56) AT=895.025n

* CHECK dout0_57 Vdout0_57ck178 = 0.9 time = 895
.meas tran vdout0_57ck178 FIND v(dout0_57) AT=895.025n

* CHECK dout0_58 Vdout0_58ck178 = 0 time = 895
.meas tran vdout0_58ck178 FIND v(dout0_58) AT=895.025n

* CHECK dout0_59 Vdout0_59ck178 = 0.9 time = 895
.meas tran vdout0_59ck178 FIND v(dout0_59) AT=895.025n

* CHECK dout0_60 Vdout0_60ck178 = 0.9 time = 895
.meas tran vdout0_60ck178 FIND v(dout0_60) AT=895.025n

* CHECK dout0_61 Vdout0_61ck178 = 0 time = 895
.meas tran vdout0_61ck178 FIND v(dout0_61) AT=895.025n

* CHECK dout0_62 Vdout0_62ck178 = 0.9 time = 895
.meas tran vdout0_62ck178 FIND v(dout0_62) AT=895.025n

* CHECK dout0_63 Vdout0_63ck178 = 0 time = 895
.meas tran vdout0_63ck178 FIND v(dout0_63) AT=895.025n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 905
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=905.025n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 905
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=905.025n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 905
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=905.025n

* CHECK dout0_3 Vdout0_3ck180 = 0.9 time = 905
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=905.025n

* CHECK dout0_4 Vdout0_4ck180 = 0 time = 905
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=905.025n

* CHECK dout0_5 Vdout0_5ck180 = 0.9 time = 905
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=905.025n

* CHECK dout0_6 Vdout0_6ck180 = 0 time = 905
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=905.025n

* CHECK dout0_7 Vdout0_7ck180 = 0 time = 905
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=905.025n

* CHECK dout0_8 Vdout0_8ck180 = 0.9 time = 905
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=905.025n

* CHECK dout0_9 Vdout0_9ck180 = 0 time = 905
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=905.025n

* CHECK dout0_10 Vdout0_10ck180 = 0.9 time = 905
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=905.025n

* CHECK dout0_11 Vdout0_11ck180 = 0.9 time = 905
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=905.025n

* CHECK dout0_12 Vdout0_12ck180 = 0.9 time = 905
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=905.025n

* CHECK dout0_13 Vdout0_13ck180 = 0.9 time = 905
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=905.025n

* CHECK dout0_14 Vdout0_14ck180 = 0.9 time = 905
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=905.025n

* CHECK dout0_15 Vdout0_15ck180 = 0 time = 905
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=905.025n

* CHECK dout0_16 Vdout0_16ck180 = 0.9 time = 905
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=905.025n

* CHECK dout0_17 Vdout0_17ck180 = 0 time = 905
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=905.025n

* CHECK dout0_18 Vdout0_18ck180 = 0 time = 905
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=905.025n

* CHECK dout0_19 Vdout0_19ck180 = 0.9 time = 905
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=905.025n

* CHECK dout0_20 Vdout0_20ck180 = 0.9 time = 905
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=905.025n

* CHECK dout0_21 Vdout0_21ck180 = 0.9 time = 905
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=905.025n

* CHECK dout0_22 Vdout0_22ck180 = 0 time = 905
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=905.025n

* CHECK dout0_23 Vdout0_23ck180 = 0.9 time = 905
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=905.025n

* CHECK dout0_24 Vdout0_24ck180 = 0.9 time = 905
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=905.025n

* CHECK dout0_25 Vdout0_25ck180 = 0.9 time = 905
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=905.025n

* CHECK dout0_26 Vdout0_26ck180 = 0 time = 905
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=905.025n

* CHECK dout0_27 Vdout0_27ck180 = 0 time = 905
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=905.025n

* CHECK dout0_28 Vdout0_28ck180 = 0.9 time = 905
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=905.025n

* CHECK dout0_29 Vdout0_29ck180 = 0.9 time = 905
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=905.025n

* CHECK dout0_30 Vdout0_30ck180 = 0 time = 905
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=905.025n

* CHECK dout0_31 Vdout0_31ck180 = 0.9 time = 905
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=905.025n

* CHECK dout0_32 Vdout0_32ck180 = 0 time = 905
.meas tran vdout0_32ck180 FIND v(dout0_32) AT=905.025n

* CHECK dout0_33 Vdout0_33ck180 = 0 time = 905
.meas tran vdout0_33ck180 FIND v(dout0_33) AT=905.025n

* CHECK dout0_34 Vdout0_34ck180 = 0.9 time = 905
.meas tran vdout0_34ck180 FIND v(dout0_34) AT=905.025n

* CHECK dout0_35 Vdout0_35ck180 = 0 time = 905
.meas tran vdout0_35ck180 FIND v(dout0_35) AT=905.025n

* CHECK dout0_36 Vdout0_36ck180 = 0.9 time = 905
.meas tran vdout0_36ck180 FIND v(dout0_36) AT=905.025n

* CHECK dout0_37 Vdout0_37ck180 = 0.9 time = 905
.meas tran vdout0_37ck180 FIND v(dout0_37) AT=905.025n

* CHECK dout0_38 Vdout0_38ck180 = 0.9 time = 905
.meas tran vdout0_38ck180 FIND v(dout0_38) AT=905.025n

* CHECK dout0_39 Vdout0_39ck180 = 0.9 time = 905
.meas tran vdout0_39ck180 FIND v(dout0_39) AT=905.025n

* CHECK dout0_40 Vdout0_40ck180 = 0.9 time = 905
.meas tran vdout0_40ck180 FIND v(dout0_40) AT=905.025n

* CHECK dout0_41 Vdout0_41ck180 = 0 time = 905
.meas tran vdout0_41ck180 FIND v(dout0_41) AT=905.025n

* CHECK dout0_42 Vdout0_42ck180 = 0.9 time = 905
.meas tran vdout0_42ck180 FIND v(dout0_42) AT=905.025n

* CHECK dout0_43 Vdout0_43ck180 = 0.9 time = 905
.meas tran vdout0_43ck180 FIND v(dout0_43) AT=905.025n

* CHECK dout0_44 Vdout0_44ck180 = 0.9 time = 905
.meas tran vdout0_44ck180 FIND v(dout0_44) AT=905.025n

* CHECK dout0_45 Vdout0_45ck180 = 0 time = 905
.meas tran vdout0_45ck180 FIND v(dout0_45) AT=905.025n

* CHECK dout0_46 Vdout0_46ck180 = 0 time = 905
.meas tran vdout0_46ck180 FIND v(dout0_46) AT=905.025n

* CHECK dout0_47 Vdout0_47ck180 = 0 time = 905
.meas tran vdout0_47ck180 FIND v(dout0_47) AT=905.025n

* CHECK dout0_48 Vdout0_48ck180 = 0 time = 905
.meas tran vdout0_48ck180 FIND v(dout0_48) AT=905.025n

* CHECK dout0_49 Vdout0_49ck180 = 0 time = 905
.meas tran vdout0_49ck180 FIND v(dout0_49) AT=905.025n

* CHECK dout0_50 Vdout0_50ck180 = 0 time = 905
.meas tran vdout0_50ck180 FIND v(dout0_50) AT=905.025n

* CHECK dout0_51 Vdout0_51ck180 = 0 time = 905
.meas tran vdout0_51ck180 FIND v(dout0_51) AT=905.025n

* CHECK dout0_52 Vdout0_52ck180 = 0.9 time = 905
.meas tran vdout0_52ck180 FIND v(dout0_52) AT=905.025n

* CHECK dout0_53 Vdout0_53ck180 = 0 time = 905
.meas tran vdout0_53ck180 FIND v(dout0_53) AT=905.025n

* CHECK dout0_54 Vdout0_54ck180 = 0.9 time = 905
.meas tran vdout0_54ck180 FIND v(dout0_54) AT=905.025n

* CHECK dout0_55 Vdout0_55ck180 = 0.9 time = 905
.meas tran vdout0_55ck180 FIND v(dout0_55) AT=905.025n

* CHECK dout0_56 Vdout0_56ck180 = 0 time = 905
.meas tran vdout0_56ck180 FIND v(dout0_56) AT=905.025n

* CHECK dout0_57 Vdout0_57ck180 = 0 time = 905
.meas tran vdout0_57ck180 FIND v(dout0_57) AT=905.025n

* CHECK dout0_58 Vdout0_58ck180 = 0.9 time = 905
.meas tran vdout0_58ck180 FIND v(dout0_58) AT=905.025n

* CHECK dout0_59 Vdout0_59ck180 = 0 time = 905
.meas tran vdout0_59ck180 FIND v(dout0_59) AT=905.025n

* CHECK dout0_60 Vdout0_60ck180 = 0 time = 905
.meas tran vdout0_60ck180 FIND v(dout0_60) AT=905.025n

* CHECK dout0_61 Vdout0_61ck180 = 0 time = 905
.meas tran vdout0_61ck180 FIND v(dout0_61) AT=905.025n

* CHECK dout0_62 Vdout0_62ck180 = 0 time = 905
.meas tran vdout0_62ck180 FIND v(dout0_62) AT=905.025n

* CHECK dout0_63 Vdout0_63ck180 = 0 time = 905
.meas tran vdout0_63ck180 FIND v(dout0_63) AT=905.025n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 0 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0.9 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 0.9 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0.9 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0.9 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 0.9 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0.9 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 0.9 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 0.9 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0.9 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 0 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0.9 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 0.9 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0.9 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 0 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 0.9 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0.9 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 0.9 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 0.9 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0.9 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0.9 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_32 Vdout0_32ck181 = 0 time = 910
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=910.025n

* CHECK dout0_33 Vdout0_33ck181 = 0 time = 910
.meas tran vdout0_33ck181 FIND v(dout0_33) AT=910.025n

* CHECK dout0_34 Vdout0_34ck181 = 0.9 time = 910
.meas tran vdout0_34ck181 FIND v(dout0_34) AT=910.025n

* CHECK dout0_35 Vdout0_35ck181 = 0 time = 910
.meas tran vdout0_35ck181 FIND v(dout0_35) AT=910.025n

* CHECK dout0_36 Vdout0_36ck181 = 0.9 time = 910
.meas tran vdout0_36ck181 FIND v(dout0_36) AT=910.025n

* CHECK dout0_37 Vdout0_37ck181 = 0.9 time = 910
.meas tran vdout0_37ck181 FIND v(dout0_37) AT=910.025n

* CHECK dout0_38 Vdout0_38ck181 = 0.9 time = 910
.meas tran vdout0_38ck181 FIND v(dout0_38) AT=910.025n

* CHECK dout0_39 Vdout0_39ck181 = 0.9 time = 910
.meas tran vdout0_39ck181 FIND v(dout0_39) AT=910.025n

* CHECK dout0_40 Vdout0_40ck181 = 0.9 time = 910
.meas tran vdout0_40ck181 FIND v(dout0_40) AT=910.025n

* CHECK dout0_41 Vdout0_41ck181 = 0 time = 910
.meas tran vdout0_41ck181 FIND v(dout0_41) AT=910.025n

* CHECK dout0_42 Vdout0_42ck181 = 0.9 time = 910
.meas tran vdout0_42ck181 FIND v(dout0_42) AT=910.025n

* CHECK dout0_43 Vdout0_43ck181 = 0.9 time = 910
.meas tran vdout0_43ck181 FIND v(dout0_43) AT=910.025n

* CHECK dout0_44 Vdout0_44ck181 = 0.9 time = 910
.meas tran vdout0_44ck181 FIND v(dout0_44) AT=910.025n

* CHECK dout0_45 Vdout0_45ck181 = 0 time = 910
.meas tran vdout0_45ck181 FIND v(dout0_45) AT=910.025n

* CHECK dout0_46 Vdout0_46ck181 = 0 time = 910
.meas tran vdout0_46ck181 FIND v(dout0_46) AT=910.025n

* CHECK dout0_47 Vdout0_47ck181 = 0 time = 910
.meas tran vdout0_47ck181 FIND v(dout0_47) AT=910.025n

* CHECK dout0_48 Vdout0_48ck181 = 0 time = 910
.meas tran vdout0_48ck181 FIND v(dout0_48) AT=910.025n

* CHECK dout0_49 Vdout0_49ck181 = 0 time = 910
.meas tran vdout0_49ck181 FIND v(dout0_49) AT=910.025n

* CHECK dout0_50 Vdout0_50ck181 = 0 time = 910
.meas tran vdout0_50ck181 FIND v(dout0_50) AT=910.025n

* CHECK dout0_51 Vdout0_51ck181 = 0 time = 910
.meas tran vdout0_51ck181 FIND v(dout0_51) AT=910.025n

* CHECK dout0_52 Vdout0_52ck181 = 0.9 time = 910
.meas tran vdout0_52ck181 FIND v(dout0_52) AT=910.025n

* CHECK dout0_53 Vdout0_53ck181 = 0 time = 910
.meas tran vdout0_53ck181 FIND v(dout0_53) AT=910.025n

* CHECK dout0_54 Vdout0_54ck181 = 0.9 time = 910
.meas tran vdout0_54ck181 FIND v(dout0_54) AT=910.025n

* CHECK dout0_55 Vdout0_55ck181 = 0.9 time = 910
.meas tran vdout0_55ck181 FIND v(dout0_55) AT=910.025n

* CHECK dout0_56 Vdout0_56ck181 = 0 time = 910
.meas tran vdout0_56ck181 FIND v(dout0_56) AT=910.025n

* CHECK dout0_57 Vdout0_57ck181 = 0 time = 910
.meas tran vdout0_57ck181 FIND v(dout0_57) AT=910.025n

* CHECK dout0_58 Vdout0_58ck181 = 0.9 time = 910
.meas tran vdout0_58ck181 FIND v(dout0_58) AT=910.025n

* CHECK dout0_59 Vdout0_59ck181 = 0 time = 910
.meas tran vdout0_59ck181 FIND v(dout0_59) AT=910.025n

* CHECK dout0_60 Vdout0_60ck181 = 0 time = 910
.meas tran vdout0_60ck181 FIND v(dout0_60) AT=910.025n

* CHECK dout0_61 Vdout0_61ck181 = 0 time = 910
.meas tran vdout0_61ck181 FIND v(dout0_61) AT=910.025n

* CHECK dout0_62 Vdout0_62ck181 = 0 time = 910
.meas tran vdout0_62ck181 FIND v(dout0_62) AT=910.025n

* CHECK dout0_63 Vdout0_63ck181 = 0 time = 910
.meas tran vdout0_63ck181 FIND v(dout0_63) AT=910.025n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 915
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=915.025n

* CHECK dout0_1 Vdout0_1ck182 = 0 time = 915
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=915.025n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 915
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=915.025n

* CHECK dout0_3 Vdout0_3ck182 = 0.9 time = 915
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=915.025n

* CHECK dout0_4 Vdout0_4ck182 = 0 time = 915
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=915.025n

* CHECK dout0_5 Vdout0_5ck182 = 0.9 time = 915
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=915.025n

* CHECK dout0_6 Vdout0_6ck182 = 0 time = 915
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=915.025n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 915
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=915.025n

* CHECK dout0_8 Vdout0_8ck182 = 0.9 time = 915
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=915.025n

* CHECK dout0_9 Vdout0_9ck182 = 0 time = 915
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=915.025n

* CHECK dout0_10 Vdout0_10ck182 = 0.9 time = 915
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=915.025n

* CHECK dout0_11 Vdout0_11ck182 = 0.9 time = 915
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=915.025n

* CHECK dout0_12 Vdout0_12ck182 = 0.9 time = 915
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=915.025n

* CHECK dout0_13 Vdout0_13ck182 = 0.9 time = 915
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=915.025n

* CHECK dout0_14 Vdout0_14ck182 = 0.9 time = 915
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=915.025n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 915
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=915.025n

* CHECK dout0_16 Vdout0_16ck182 = 0.9 time = 915
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=915.025n

* CHECK dout0_17 Vdout0_17ck182 = 0 time = 915
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=915.025n

* CHECK dout0_18 Vdout0_18ck182 = 0 time = 915
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=915.025n

* CHECK dout0_19 Vdout0_19ck182 = 0.9 time = 915
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=915.025n

* CHECK dout0_20 Vdout0_20ck182 = 0.9 time = 915
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=915.025n

* CHECK dout0_21 Vdout0_21ck182 = 0.9 time = 915
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=915.025n

* CHECK dout0_22 Vdout0_22ck182 = 0 time = 915
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=915.025n

* CHECK dout0_23 Vdout0_23ck182 = 0.9 time = 915
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=915.025n

* CHECK dout0_24 Vdout0_24ck182 = 0.9 time = 915
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=915.025n

* CHECK dout0_25 Vdout0_25ck182 = 0.9 time = 915
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=915.025n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 915
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=915.025n

* CHECK dout0_27 Vdout0_27ck182 = 0 time = 915
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=915.025n

* CHECK dout0_28 Vdout0_28ck182 = 0.9 time = 915
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=915.025n

* CHECK dout0_29 Vdout0_29ck182 = 0.9 time = 915
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=915.025n

* CHECK dout0_30 Vdout0_30ck182 = 0 time = 915
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=915.025n

* CHECK dout0_31 Vdout0_31ck182 = 0.9 time = 915
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=915.025n

* CHECK dout0_32 Vdout0_32ck182 = 0 time = 915
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=915.025n

* CHECK dout0_33 Vdout0_33ck182 = 0 time = 915
.meas tran vdout0_33ck182 FIND v(dout0_33) AT=915.025n

* CHECK dout0_34 Vdout0_34ck182 = 0.9 time = 915
.meas tran vdout0_34ck182 FIND v(dout0_34) AT=915.025n

* CHECK dout0_35 Vdout0_35ck182 = 0 time = 915
.meas tran vdout0_35ck182 FIND v(dout0_35) AT=915.025n

* CHECK dout0_36 Vdout0_36ck182 = 0.9 time = 915
.meas tran vdout0_36ck182 FIND v(dout0_36) AT=915.025n

* CHECK dout0_37 Vdout0_37ck182 = 0.9 time = 915
.meas tran vdout0_37ck182 FIND v(dout0_37) AT=915.025n

* CHECK dout0_38 Vdout0_38ck182 = 0.9 time = 915
.meas tran vdout0_38ck182 FIND v(dout0_38) AT=915.025n

* CHECK dout0_39 Vdout0_39ck182 = 0.9 time = 915
.meas tran vdout0_39ck182 FIND v(dout0_39) AT=915.025n

* CHECK dout0_40 Vdout0_40ck182 = 0.9 time = 915
.meas tran vdout0_40ck182 FIND v(dout0_40) AT=915.025n

* CHECK dout0_41 Vdout0_41ck182 = 0 time = 915
.meas tran vdout0_41ck182 FIND v(dout0_41) AT=915.025n

* CHECK dout0_42 Vdout0_42ck182 = 0.9 time = 915
.meas tran vdout0_42ck182 FIND v(dout0_42) AT=915.025n

* CHECK dout0_43 Vdout0_43ck182 = 0.9 time = 915
.meas tran vdout0_43ck182 FIND v(dout0_43) AT=915.025n

* CHECK dout0_44 Vdout0_44ck182 = 0.9 time = 915
.meas tran vdout0_44ck182 FIND v(dout0_44) AT=915.025n

* CHECK dout0_45 Vdout0_45ck182 = 0 time = 915
.meas tran vdout0_45ck182 FIND v(dout0_45) AT=915.025n

* CHECK dout0_46 Vdout0_46ck182 = 0 time = 915
.meas tran vdout0_46ck182 FIND v(dout0_46) AT=915.025n

* CHECK dout0_47 Vdout0_47ck182 = 0 time = 915
.meas tran vdout0_47ck182 FIND v(dout0_47) AT=915.025n

* CHECK dout0_48 Vdout0_48ck182 = 0 time = 915
.meas tran vdout0_48ck182 FIND v(dout0_48) AT=915.025n

* CHECK dout0_49 Vdout0_49ck182 = 0 time = 915
.meas tran vdout0_49ck182 FIND v(dout0_49) AT=915.025n

* CHECK dout0_50 Vdout0_50ck182 = 0 time = 915
.meas tran vdout0_50ck182 FIND v(dout0_50) AT=915.025n

* CHECK dout0_51 Vdout0_51ck182 = 0 time = 915
.meas tran vdout0_51ck182 FIND v(dout0_51) AT=915.025n

* CHECK dout0_52 Vdout0_52ck182 = 0.9 time = 915
.meas tran vdout0_52ck182 FIND v(dout0_52) AT=915.025n

* CHECK dout0_53 Vdout0_53ck182 = 0 time = 915
.meas tran vdout0_53ck182 FIND v(dout0_53) AT=915.025n

* CHECK dout0_54 Vdout0_54ck182 = 0.9 time = 915
.meas tran vdout0_54ck182 FIND v(dout0_54) AT=915.025n

* CHECK dout0_55 Vdout0_55ck182 = 0.9 time = 915
.meas tran vdout0_55ck182 FIND v(dout0_55) AT=915.025n

* CHECK dout0_56 Vdout0_56ck182 = 0 time = 915
.meas tran vdout0_56ck182 FIND v(dout0_56) AT=915.025n

* CHECK dout0_57 Vdout0_57ck182 = 0 time = 915
.meas tran vdout0_57ck182 FIND v(dout0_57) AT=915.025n

* CHECK dout0_58 Vdout0_58ck182 = 0.9 time = 915
.meas tran vdout0_58ck182 FIND v(dout0_58) AT=915.025n

* CHECK dout0_59 Vdout0_59ck182 = 0 time = 915
.meas tran vdout0_59ck182 FIND v(dout0_59) AT=915.025n

* CHECK dout0_60 Vdout0_60ck182 = 0 time = 915
.meas tran vdout0_60ck182 FIND v(dout0_60) AT=915.025n

* CHECK dout0_61 Vdout0_61ck182 = 0 time = 915
.meas tran vdout0_61ck182 FIND v(dout0_61) AT=915.025n

* CHECK dout0_62 Vdout0_62ck182 = 0 time = 915
.meas tran vdout0_62ck182 FIND v(dout0_62) AT=915.025n

* CHECK dout0_63 Vdout0_63ck182 = 0 time = 915
.meas tran vdout0_63ck182 FIND v(dout0_63) AT=915.025n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 920
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=920.025n

* CHECK dout0_1 Vdout0_1ck183 = 0 time = 920
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=920.025n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 920
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=920.025n

* CHECK dout0_3 Vdout0_3ck183 = 0.9 time = 920
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=920.025n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 920
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=920.025n

* CHECK dout0_5 Vdout0_5ck183 = 0.9 time = 920
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=920.025n

* CHECK dout0_6 Vdout0_6ck183 = 0 time = 920
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=920.025n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 920
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=920.025n

* CHECK dout0_8 Vdout0_8ck183 = 0.9 time = 920
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=920.025n

* CHECK dout0_9 Vdout0_9ck183 = 0 time = 920
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=920.025n

* CHECK dout0_10 Vdout0_10ck183 = 0.9 time = 920
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=920.025n

* CHECK dout0_11 Vdout0_11ck183 = 0.9 time = 920
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=920.025n

* CHECK dout0_12 Vdout0_12ck183 = 0.9 time = 920
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=920.025n

* CHECK dout0_13 Vdout0_13ck183 = 0.9 time = 920
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=920.025n

* CHECK dout0_14 Vdout0_14ck183 = 0.9 time = 920
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=920.025n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 920
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=920.025n

* CHECK dout0_16 Vdout0_16ck183 = 0.9 time = 920
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=920.025n

* CHECK dout0_17 Vdout0_17ck183 = 0 time = 920
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=920.025n

* CHECK dout0_18 Vdout0_18ck183 = 0 time = 920
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=920.025n

* CHECK dout0_19 Vdout0_19ck183 = 0.9 time = 920
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=920.025n

* CHECK dout0_20 Vdout0_20ck183 = 0.9 time = 920
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=920.025n

* CHECK dout0_21 Vdout0_21ck183 = 0.9 time = 920
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=920.025n

* CHECK dout0_22 Vdout0_22ck183 = 0 time = 920
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=920.025n

* CHECK dout0_23 Vdout0_23ck183 = 0.9 time = 920
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=920.025n

* CHECK dout0_24 Vdout0_24ck183 = 0.9 time = 920
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=920.025n

* CHECK dout0_25 Vdout0_25ck183 = 0.9 time = 920
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=920.025n

* CHECK dout0_26 Vdout0_26ck183 = 0 time = 920
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=920.025n

* CHECK dout0_27 Vdout0_27ck183 = 0 time = 920
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=920.025n

* CHECK dout0_28 Vdout0_28ck183 = 0.9 time = 920
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=920.025n

* CHECK dout0_29 Vdout0_29ck183 = 0.9 time = 920
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=920.025n

* CHECK dout0_30 Vdout0_30ck183 = 0 time = 920
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=920.025n

* CHECK dout0_31 Vdout0_31ck183 = 0.9 time = 920
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=920.025n

* CHECK dout0_32 Vdout0_32ck183 = 0 time = 920
.meas tran vdout0_32ck183 FIND v(dout0_32) AT=920.025n

* CHECK dout0_33 Vdout0_33ck183 = 0 time = 920
.meas tran vdout0_33ck183 FIND v(dout0_33) AT=920.025n

* CHECK dout0_34 Vdout0_34ck183 = 0.9 time = 920
.meas tran vdout0_34ck183 FIND v(dout0_34) AT=920.025n

* CHECK dout0_35 Vdout0_35ck183 = 0 time = 920
.meas tran vdout0_35ck183 FIND v(dout0_35) AT=920.025n

* CHECK dout0_36 Vdout0_36ck183 = 0.9 time = 920
.meas tran vdout0_36ck183 FIND v(dout0_36) AT=920.025n

* CHECK dout0_37 Vdout0_37ck183 = 0.9 time = 920
.meas tran vdout0_37ck183 FIND v(dout0_37) AT=920.025n

* CHECK dout0_38 Vdout0_38ck183 = 0.9 time = 920
.meas tran vdout0_38ck183 FIND v(dout0_38) AT=920.025n

* CHECK dout0_39 Vdout0_39ck183 = 0.9 time = 920
.meas tran vdout0_39ck183 FIND v(dout0_39) AT=920.025n

* CHECK dout0_40 Vdout0_40ck183 = 0.9 time = 920
.meas tran vdout0_40ck183 FIND v(dout0_40) AT=920.025n

* CHECK dout0_41 Vdout0_41ck183 = 0 time = 920
.meas tran vdout0_41ck183 FIND v(dout0_41) AT=920.025n

* CHECK dout0_42 Vdout0_42ck183 = 0.9 time = 920
.meas tran vdout0_42ck183 FIND v(dout0_42) AT=920.025n

* CHECK dout0_43 Vdout0_43ck183 = 0.9 time = 920
.meas tran vdout0_43ck183 FIND v(dout0_43) AT=920.025n

* CHECK dout0_44 Vdout0_44ck183 = 0.9 time = 920
.meas tran vdout0_44ck183 FIND v(dout0_44) AT=920.025n

* CHECK dout0_45 Vdout0_45ck183 = 0 time = 920
.meas tran vdout0_45ck183 FIND v(dout0_45) AT=920.025n

* CHECK dout0_46 Vdout0_46ck183 = 0 time = 920
.meas tran vdout0_46ck183 FIND v(dout0_46) AT=920.025n

* CHECK dout0_47 Vdout0_47ck183 = 0 time = 920
.meas tran vdout0_47ck183 FIND v(dout0_47) AT=920.025n

* CHECK dout0_48 Vdout0_48ck183 = 0 time = 920
.meas tran vdout0_48ck183 FIND v(dout0_48) AT=920.025n

* CHECK dout0_49 Vdout0_49ck183 = 0 time = 920
.meas tran vdout0_49ck183 FIND v(dout0_49) AT=920.025n

* CHECK dout0_50 Vdout0_50ck183 = 0 time = 920
.meas tran vdout0_50ck183 FIND v(dout0_50) AT=920.025n

* CHECK dout0_51 Vdout0_51ck183 = 0 time = 920
.meas tran vdout0_51ck183 FIND v(dout0_51) AT=920.025n

* CHECK dout0_52 Vdout0_52ck183 = 0.9 time = 920
.meas tran vdout0_52ck183 FIND v(dout0_52) AT=920.025n

* CHECK dout0_53 Vdout0_53ck183 = 0 time = 920
.meas tran vdout0_53ck183 FIND v(dout0_53) AT=920.025n

* CHECK dout0_54 Vdout0_54ck183 = 0.9 time = 920
.meas tran vdout0_54ck183 FIND v(dout0_54) AT=920.025n

* CHECK dout0_55 Vdout0_55ck183 = 0.9 time = 920
.meas tran vdout0_55ck183 FIND v(dout0_55) AT=920.025n

* CHECK dout0_56 Vdout0_56ck183 = 0 time = 920
.meas tran vdout0_56ck183 FIND v(dout0_56) AT=920.025n

* CHECK dout0_57 Vdout0_57ck183 = 0 time = 920
.meas tran vdout0_57ck183 FIND v(dout0_57) AT=920.025n

* CHECK dout0_58 Vdout0_58ck183 = 0.9 time = 920
.meas tran vdout0_58ck183 FIND v(dout0_58) AT=920.025n

* CHECK dout0_59 Vdout0_59ck183 = 0 time = 920
.meas tran vdout0_59ck183 FIND v(dout0_59) AT=920.025n

* CHECK dout0_60 Vdout0_60ck183 = 0 time = 920
.meas tran vdout0_60ck183 FIND v(dout0_60) AT=920.025n

* CHECK dout0_61 Vdout0_61ck183 = 0 time = 920
.meas tran vdout0_61ck183 FIND v(dout0_61) AT=920.025n

* CHECK dout0_62 Vdout0_62ck183 = 0 time = 920
.meas tran vdout0_62ck183 FIND v(dout0_62) AT=920.025n

* CHECK dout0_63 Vdout0_63ck183 = 0 time = 920
.meas tran vdout0_63ck183 FIND v(dout0_63) AT=920.025n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 930
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=930.025n

* CHECK dout0_1 Vdout0_1ck185 = 0.9 time = 930
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=930.025n

* CHECK dout0_2 Vdout0_2ck185 = 0.9 time = 930
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=930.025n

* CHECK dout0_3 Vdout0_3ck185 = 0.9 time = 930
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=930.025n

* CHECK dout0_4 Vdout0_4ck185 = 0.9 time = 930
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=930.025n

* CHECK dout0_5 Vdout0_5ck185 = 0 time = 930
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=930.025n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 930
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=930.025n

* CHECK dout0_7 Vdout0_7ck185 = 0 time = 930
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=930.025n

* CHECK dout0_8 Vdout0_8ck185 = 0 time = 930
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=930.025n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 930
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=930.025n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 930
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=930.025n

* CHECK dout0_11 Vdout0_11ck185 = 0.9 time = 930
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=930.025n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 930
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=930.025n

* CHECK dout0_13 Vdout0_13ck185 = 0.9 time = 930
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=930.025n

* CHECK dout0_14 Vdout0_14ck185 = 0 time = 930
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=930.025n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 930
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=930.025n

* CHECK dout0_16 Vdout0_16ck185 = 0.9 time = 930
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=930.025n

* CHECK dout0_17 Vdout0_17ck185 = 0 time = 930
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=930.025n

* CHECK dout0_18 Vdout0_18ck185 = 0 time = 930
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=930.025n

* CHECK dout0_19 Vdout0_19ck185 = 0.9 time = 930
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=930.025n

* CHECK dout0_20 Vdout0_20ck185 = 0 time = 930
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=930.025n

* CHECK dout0_21 Vdout0_21ck185 = 0.9 time = 930
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=930.025n

* CHECK dout0_22 Vdout0_22ck185 = 0 time = 930
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=930.025n

* CHECK dout0_23 Vdout0_23ck185 = 0.9 time = 930
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=930.025n

* CHECK dout0_24 Vdout0_24ck185 = 0 time = 930
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=930.025n

* CHECK dout0_25 Vdout0_25ck185 = 0.9 time = 930
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=930.025n

* CHECK dout0_26 Vdout0_26ck185 = 0.9 time = 930
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=930.025n

* CHECK dout0_27 Vdout0_27ck185 = 0.9 time = 930
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=930.025n

* CHECK dout0_28 Vdout0_28ck185 = 0 time = 930
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=930.025n

* CHECK dout0_29 Vdout0_29ck185 = 0 time = 930
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=930.025n

* CHECK dout0_30 Vdout0_30ck185 = 0 time = 930
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=930.025n

* CHECK dout0_31 Vdout0_31ck185 = 0.9 time = 930
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=930.025n

* CHECK dout0_32 Vdout0_32ck185 = 0 time = 930
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=930.025n

* CHECK dout0_33 Vdout0_33ck185 = 0.9 time = 930
.meas tran vdout0_33ck185 FIND v(dout0_33) AT=930.025n

* CHECK dout0_34 Vdout0_34ck185 = 0 time = 930
.meas tran vdout0_34ck185 FIND v(dout0_34) AT=930.025n

* CHECK dout0_35 Vdout0_35ck185 = 0.9 time = 930
.meas tran vdout0_35ck185 FIND v(dout0_35) AT=930.025n

* CHECK dout0_36 Vdout0_36ck185 = 0 time = 930
.meas tran vdout0_36ck185 FIND v(dout0_36) AT=930.025n

* CHECK dout0_37 Vdout0_37ck185 = 0 time = 930
.meas tran vdout0_37ck185 FIND v(dout0_37) AT=930.025n

* CHECK dout0_38 Vdout0_38ck185 = 0 time = 930
.meas tran vdout0_38ck185 FIND v(dout0_38) AT=930.025n

* CHECK dout0_39 Vdout0_39ck185 = 0.9 time = 930
.meas tran vdout0_39ck185 FIND v(dout0_39) AT=930.025n

* CHECK dout0_40 Vdout0_40ck185 = 0.9 time = 930
.meas tran vdout0_40ck185 FIND v(dout0_40) AT=930.025n

* CHECK dout0_41 Vdout0_41ck185 = 0 time = 930
.meas tran vdout0_41ck185 FIND v(dout0_41) AT=930.025n

* CHECK dout0_42 Vdout0_42ck185 = 0 time = 930
.meas tran vdout0_42ck185 FIND v(dout0_42) AT=930.025n

* CHECK dout0_43 Vdout0_43ck185 = 0 time = 930
.meas tran vdout0_43ck185 FIND v(dout0_43) AT=930.025n

* CHECK dout0_44 Vdout0_44ck185 = 0 time = 930
.meas tran vdout0_44ck185 FIND v(dout0_44) AT=930.025n

* CHECK dout0_45 Vdout0_45ck185 = 0 time = 930
.meas tran vdout0_45ck185 FIND v(dout0_45) AT=930.025n

* CHECK dout0_46 Vdout0_46ck185 = 0 time = 930
.meas tran vdout0_46ck185 FIND v(dout0_46) AT=930.025n

* CHECK dout0_47 Vdout0_47ck185 = 0.9 time = 930
.meas tran vdout0_47ck185 FIND v(dout0_47) AT=930.025n

* CHECK dout0_48 Vdout0_48ck185 = 0 time = 930
.meas tran vdout0_48ck185 FIND v(dout0_48) AT=930.025n

* CHECK dout0_49 Vdout0_49ck185 = 0.9 time = 930
.meas tran vdout0_49ck185 FIND v(dout0_49) AT=930.025n

* CHECK dout0_50 Vdout0_50ck185 = 0 time = 930
.meas tran vdout0_50ck185 FIND v(dout0_50) AT=930.025n

* CHECK dout0_51 Vdout0_51ck185 = 0 time = 930
.meas tran vdout0_51ck185 FIND v(dout0_51) AT=930.025n

* CHECK dout0_52 Vdout0_52ck185 = 0.9 time = 930
.meas tran vdout0_52ck185 FIND v(dout0_52) AT=930.025n

* CHECK dout0_53 Vdout0_53ck185 = 0 time = 930
.meas tran vdout0_53ck185 FIND v(dout0_53) AT=930.025n

* CHECK dout0_54 Vdout0_54ck185 = 0 time = 930
.meas tran vdout0_54ck185 FIND v(dout0_54) AT=930.025n

* CHECK dout0_55 Vdout0_55ck185 = 0 time = 930
.meas tran vdout0_55ck185 FIND v(dout0_55) AT=930.025n

* CHECK dout0_56 Vdout0_56ck185 = 0 time = 930
.meas tran vdout0_56ck185 FIND v(dout0_56) AT=930.025n

* CHECK dout0_57 Vdout0_57ck185 = 0.9 time = 930
.meas tran vdout0_57ck185 FIND v(dout0_57) AT=930.025n

* CHECK dout0_58 Vdout0_58ck185 = 0 time = 930
.meas tran vdout0_58ck185 FIND v(dout0_58) AT=930.025n

* CHECK dout0_59 Vdout0_59ck185 = 0.9 time = 930
.meas tran vdout0_59ck185 FIND v(dout0_59) AT=930.025n

* CHECK dout0_60 Vdout0_60ck185 = 0.9 time = 930
.meas tran vdout0_60ck185 FIND v(dout0_60) AT=930.025n

* CHECK dout0_61 Vdout0_61ck185 = 0 time = 930
.meas tran vdout0_61ck185 FIND v(dout0_61) AT=930.025n

* CHECK dout0_62 Vdout0_62ck185 = 0.9 time = 930
.meas tran vdout0_62ck185 FIND v(dout0_62) AT=930.025n

* CHECK dout0_63 Vdout0_63ck185 = 0 time = 930
.meas tran vdout0_63ck185 FIND v(dout0_63) AT=930.025n

* CHECK dout0_0 Vdout0_0ck186 = 0 time = 935
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=935.025n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 935
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=935.025n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 935
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=935.025n

* CHECK dout0_3 Vdout0_3ck186 = 0.9 time = 935
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=935.025n

* CHECK dout0_4 Vdout0_4ck186 = 0 time = 935
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=935.025n

* CHECK dout0_5 Vdout0_5ck186 = 0.9 time = 935
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=935.025n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 935
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=935.025n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 935
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=935.025n

* CHECK dout0_8 Vdout0_8ck186 = 0.9 time = 935
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=935.025n

* CHECK dout0_9 Vdout0_9ck186 = 0 time = 935
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=935.025n

* CHECK dout0_10 Vdout0_10ck186 = 0.9 time = 935
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=935.025n

* CHECK dout0_11 Vdout0_11ck186 = 0.9 time = 935
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=935.025n

* CHECK dout0_12 Vdout0_12ck186 = 0.9 time = 935
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=935.025n

* CHECK dout0_13 Vdout0_13ck186 = 0.9 time = 935
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=935.025n

* CHECK dout0_14 Vdout0_14ck186 = 0.9 time = 935
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=935.025n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 935
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=935.025n

* CHECK dout0_16 Vdout0_16ck186 = 0.9 time = 935
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=935.025n

* CHECK dout0_17 Vdout0_17ck186 = 0 time = 935
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=935.025n

* CHECK dout0_18 Vdout0_18ck186 = 0 time = 935
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=935.025n

* CHECK dout0_19 Vdout0_19ck186 = 0.9 time = 935
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=935.025n

* CHECK dout0_20 Vdout0_20ck186 = 0.9 time = 935
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=935.025n

* CHECK dout0_21 Vdout0_21ck186 = 0.9 time = 935
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=935.025n

* CHECK dout0_22 Vdout0_22ck186 = 0 time = 935
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=935.025n

* CHECK dout0_23 Vdout0_23ck186 = 0.9 time = 935
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=935.025n

* CHECK dout0_24 Vdout0_24ck186 = 0.9 time = 935
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=935.025n

* CHECK dout0_25 Vdout0_25ck186 = 0.9 time = 935
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=935.025n

* CHECK dout0_26 Vdout0_26ck186 = 0 time = 935
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=935.025n

* CHECK dout0_27 Vdout0_27ck186 = 0 time = 935
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=935.025n

* CHECK dout0_28 Vdout0_28ck186 = 0.9 time = 935
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=935.025n

* CHECK dout0_29 Vdout0_29ck186 = 0.9 time = 935
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=935.025n

* CHECK dout0_30 Vdout0_30ck186 = 0 time = 935
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=935.025n

* CHECK dout0_31 Vdout0_31ck186 = 0.9 time = 935
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=935.025n

* CHECK dout0_32 Vdout0_32ck186 = 0 time = 935
.meas tran vdout0_32ck186 FIND v(dout0_32) AT=935.025n

* CHECK dout0_33 Vdout0_33ck186 = 0 time = 935
.meas tran vdout0_33ck186 FIND v(dout0_33) AT=935.025n

* CHECK dout0_34 Vdout0_34ck186 = 0.9 time = 935
.meas tran vdout0_34ck186 FIND v(dout0_34) AT=935.025n

* CHECK dout0_35 Vdout0_35ck186 = 0 time = 935
.meas tran vdout0_35ck186 FIND v(dout0_35) AT=935.025n

* CHECK dout0_36 Vdout0_36ck186 = 0.9 time = 935
.meas tran vdout0_36ck186 FIND v(dout0_36) AT=935.025n

* CHECK dout0_37 Vdout0_37ck186 = 0.9 time = 935
.meas tran vdout0_37ck186 FIND v(dout0_37) AT=935.025n

* CHECK dout0_38 Vdout0_38ck186 = 0.9 time = 935
.meas tran vdout0_38ck186 FIND v(dout0_38) AT=935.025n

* CHECK dout0_39 Vdout0_39ck186 = 0.9 time = 935
.meas tran vdout0_39ck186 FIND v(dout0_39) AT=935.025n

* CHECK dout0_40 Vdout0_40ck186 = 0.9 time = 935
.meas tran vdout0_40ck186 FIND v(dout0_40) AT=935.025n

* CHECK dout0_41 Vdout0_41ck186 = 0 time = 935
.meas tran vdout0_41ck186 FIND v(dout0_41) AT=935.025n

* CHECK dout0_42 Vdout0_42ck186 = 0.9 time = 935
.meas tran vdout0_42ck186 FIND v(dout0_42) AT=935.025n

* CHECK dout0_43 Vdout0_43ck186 = 0.9 time = 935
.meas tran vdout0_43ck186 FIND v(dout0_43) AT=935.025n

* CHECK dout0_44 Vdout0_44ck186 = 0.9 time = 935
.meas tran vdout0_44ck186 FIND v(dout0_44) AT=935.025n

* CHECK dout0_45 Vdout0_45ck186 = 0 time = 935
.meas tran vdout0_45ck186 FIND v(dout0_45) AT=935.025n

* CHECK dout0_46 Vdout0_46ck186 = 0 time = 935
.meas tran vdout0_46ck186 FIND v(dout0_46) AT=935.025n

* CHECK dout0_47 Vdout0_47ck186 = 0 time = 935
.meas tran vdout0_47ck186 FIND v(dout0_47) AT=935.025n

* CHECK dout0_48 Vdout0_48ck186 = 0 time = 935
.meas tran vdout0_48ck186 FIND v(dout0_48) AT=935.025n

* CHECK dout0_49 Vdout0_49ck186 = 0 time = 935
.meas tran vdout0_49ck186 FIND v(dout0_49) AT=935.025n

* CHECK dout0_50 Vdout0_50ck186 = 0 time = 935
.meas tran vdout0_50ck186 FIND v(dout0_50) AT=935.025n

* CHECK dout0_51 Vdout0_51ck186 = 0 time = 935
.meas tran vdout0_51ck186 FIND v(dout0_51) AT=935.025n

* CHECK dout0_52 Vdout0_52ck186 = 0.9 time = 935
.meas tran vdout0_52ck186 FIND v(dout0_52) AT=935.025n

* CHECK dout0_53 Vdout0_53ck186 = 0 time = 935
.meas tran vdout0_53ck186 FIND v(dout0_53) AT=935.025n

* CHECK dout0_54 Vdout0_54ck186 = 0.9 time = 935
.meas tran vdout0_54ck186 FIND v(dout0_54) AT=935.025n

* CHECK dout0_55 Vdout0_55ck186 = 0.9 time = 935
.meas tran vdout0_55ck186 FIND v(dout0_55) AT=935.025n

* CHECK dout0_56 Vdout0_56ck186 = 0 time = 935
.meas tran vdout0_56ck186 FIND v(dout0_56) AT=935.025n

* CHECK dout0_57 Vdout0_57ck186 = 0 time = 935
.meas tran vdout0_57ck186 FIND v(dout0_57) AT=935.025n

* CHECK dout0_58 Vdout0_58ck186 = 0.9 time = 935
.meas tran vdout0_58ck186 FIND v(dout0_58) AT=935.025n

* CHECK dout0_59 Vdout0_59ck186 = 0 time = 935
.meas tran vdout0_59ck186 FIND v(dout0_59) AT=935.025n

* CHECK dout0_60 Vdout0_60ck186 = 0 time = 935
.meas tran vdout0_60ck186 FIND v(dout0_60) AT=935.025n

* CHECK dout0_61 Vdout0_61ck186 = 0 time = 935
.meas tran vdout0_61ck186 FIND v(dout0_61) AT=935.025n

* CHECK dout0_62 Vdout0_62ck186 = 0 time = 935
.meas tran vdout0_62ck186 FIND v(dout0_62) AT=935.025n

* CHECK dout0_63 Vdout0_63ck186 = 0 time = 935
.meas tran vdout0_63ck186 FIND v(dout0_63) AT=935.025n

* CHECK dout0_0 Vdout0_0ck188 = 0 time = 945
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=945.025n

* CHECK dout0_1 Vdout0_1ck188 = 0.9 time = 945
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=945.025n

* CHECK dout0_2 Vdout0_2ck188 = 0.9 time = 945
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=945.025n

* CHECK dout0_3 Vdout0_3ck188 = 0.9 time = 945
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=945.025n

* CHECK dout0_4 Vdout0_4ck188 = 0.9 time = 945
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=945.025n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 945
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=945.025n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 945
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=945.025n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 945
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=945.025n

* CHECK dout0_8 Vdout0_8ck188 = 0 time = 945
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=945.025n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 945
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=945.025n

* CHECK dout0_10 Vdout0_10ck188 = 0 time = 945
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=945.025n

* CHECK dout0_11 Vdout0_11ck188 = 0.9 time = 945
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=945.025n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 945
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=945.025n

* CHECK dout0_13 Vdout0_13ck188 = 0.9 time = 945
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=945.025n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 945
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=945.025n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 945
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=945.025n

* CHECK dout0_16 Vdout0_16ck188 = 0.9 time = 945
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=945.025n

* CHECK dout0_17 Vdout0_17ck188 = 0 time = 945
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=945.025n

* CHECK dout0_18 Vdout0_18ck188 = 0 time = 945
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=945.025n

* CHECK dout0_19 Vdout0_19ck188 = 0.9 time = 945
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=945.025n

* CHECK dout0_20 Vdout0_20ck188 = 0 time = 945
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=945.025n

* CHECK dout0_21 Vdout0_21ck188 = 0.9 time = 945
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=945.025n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 945
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=945.025n

* CHECK dout0_23 Vdout0_23ck188 = 0.9 time = 945
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=945.025n

* CHECK dout0_24 Vdout0_24ck188 = 0 time = 945
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=945.025n

* CHECK dout0_25 Vdout0_25ck188 = 0.9 time = 945
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=945.025n

* CHECK dout0_26 Vdout0_26ck188 = 0.9 time = 945
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=945.025n

* CHECK dout0_27 Vdout0_27ck188 = 0.9 time = 945
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=945.025n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 945
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=945.025n

* CHECK dout0_29 Vdout0_29ck188 = 0 time = 945
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=945.025n

* CHECK dout0_30 Vdout0_30ck188 = 0 time = 945
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=945.025n

* CHECK dout0_31 Vdout0_31ck188 = 0.9 time = 945
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=945.025n

* CHECK dout0_32 Vdout0_32ck188 = 0 time = 945
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=945.025n

* CHECK dout0_33 Vdout0_33ck188 = 0.9 time = 945
.meas tran vdout0_33ck188 FIND v(dout0_33) AT=945.025n

* CHECK dout0_34 Vdout0_34ck188 = 0 time = 945
.meas tran vdout0_34ck188 FIND v(dout0_34) AT=945.025n

* CHECK dout0_35 Vdout0_35ck188 = 0.9 time = 945
.meas tran vdout0_35ck188 FIND v(dout0_35) AT=945.025n

* CHECK dout0_36 Vdout0_36ck188 = 0 time = 945
.meas tran vdout0_36ck188 FIND v(dout0_36) AT=945.025n

* CHECK dout0_37 Vdout0_37ck188 = 0 time = 945
.meas tran vdout0_37ck188 FIND v(dout0_37) AT=945.025n

* CHECK dout0_38 Vdout0_38ck188 = 0 time = 945
.meas tran vdout0_38ck188 FIND v(dout0_38) AT=945.025n

* CHECK dout0_39 Vdout0_39ck188 = 0.9 time = 945
.meas tran vdout0_39ck188 FIND v(dout0_39) AT=945.025n

* CHECK dout0_40 Vdout0_40ck188 = 0.9 time = 945
.meas tran vdout0_40ck188 FIND v(dout0_40) AT=945.025n

* CHECK dout0_41 Vdout0_41ck188 = 0 time = 945
.meas tran vdout0_41ck188 FIND v(dout0_41) AT=945.025n

* CHECK dout0_42 Vdout0_42ck188 = 0 time = 945
.meas tran vdout0_42ck188 FIND v(dout0_42) AT=945.025n

* CHECK dout0_43 Vdout0_43ck188 = 0 time = 945
.meas tran vdout0_43ck188 FIND v(dout0_43) AT=945.025n

* CHECK dout0_44 Vdout0_44ck188 = 0 time = 945
.meas tran vdout0_44ck188 FIND v(dout0_44) AT=945.025n

* CHECK dout0_45 Vdout0_45ck188 = 0 time = 945
.meas tran vdout0_45ck188 FIND v(dout0_45) AT=945.025n

* CHECK dout0_46 Vdout0_46ck188 = 0 time = 945
.meas tran vdout0_46ck188 FIND v(dout0_46) AT=945.025n

* CHECK dout0_47 Vdout0_47ck188 = 0.9 time = 945
.meas tran vdout0_47ck188 FIND v(dout0_47) AT=945.025n

* CHECK dout0_48 Vdout0_48ck188 = 0 time = 945
.meas tran vdout0_48ck188 FIND v(dout0_48) AT=945.025n

* CHECK dout0_49 Vdout0_49ck188 = 0.9 time = 945
.meas tran vdout0_49ck188 FIND v(dout0_49) AT=945.025n

* CHECK dout0_50 Vdout0_50ck188 = 0 time = 945
.meas tran vdout0_50ck188 FIND v(dout0_50) AT=945.025n

* CHECK dout0_51 Vdout0_51ck188 = 0 time = 945
.meas tran vdout0_51ck188 FIND v(dout0_51) AT=945.025n

* CHECK dout0_52 Vdout0_52ck188 = 0.9 time = 945
.meas tran vdout0_52ck188 FIND v(dout0_52) AT=945.025n

* CHECK dout0_53 Vdout0_53ck188 = 0 time = 945
.meas tran vdout0_53ck188 FIND v(dout0_53) AT=945.025n

* CHECK dout0_54 Vdout0_54ck188 = 0 time = 945
.meas tran vdout0_54ck188 FIND v(dout0_54) AT=945.025n

* CHECK dout0_55 Vdout0_55ck188 = 0 time = 945
.meas tran vdout0_55ck188 FIND v(dout0_55) AT=945.025n

* CHECK dout0_56 Vdout0_56ck188 = 0 time = 945
.meas tran vdout0_56ck188 FIND v(dout0_56) AT=945.025n

* CHECK dout0_57 Vdout0_57ck188 = 0.9 time = 945
.meas tran vdout0_57ck188 FIND v(dout0_57) AT=945.025n

* CHECK dout0_58 Vdout0_58ck188 = 0 time = 945
.meas tran vdout0_58ck188 FIND v(dout0_58) AT=945.025n

* CHECK dout0_59 Vdout0_59ck188 = 0.9 time = 945
.meas tran vdout0_59ck188 FIND v(dout0_59) AT=945.025n

* CHECK dout0_60 Vdout0_60ck188 = 0.9 time = 945
.meas tran vdout0_60ck188 FIND v(dout0_60) AT=945.025n

* CHECK dout0_61 Vdout0_61ck188 = 0 time = 945
.meas tran vdout0_61ck188 FIND v(dout0_61) AT=945.025n

* CHECK dout0_62 Vdout0_62ck188 = 0.9 time = 945
.meas tran vdout0_62ck188 FIND v(dout0_62) AT=945.025n

* CHECK dout0_63 Vdout0_63ck188 = 0 time = 945
.meas tran vdout0_63ck188 FIND v(dout0_63) AT=945.025n

* CHECK dout0_0 Vdout0_0ck190 = 0 time = 955
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=955.025n

* CHECK dout0_1 Vdout0_1ck190 = 0.9 time = 955
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=955.025n

* CHECK dout0_2 Vdout0_2ck190 = 0.9 time = 955
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=955.025n

* CHECK dout0_3 Vdout0_3ck190 = 0.9 time = 955
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=955.025n

* CHECK dout0_4 Vdout0_4ck190 = 0.9 time = 955
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=955.025n

* CHECK dout0_5 Vdout0_5ck190 = 0 time = 955
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=955.025n

* CHECK dout0_6 Vdout0_6ck190 = 0 time = 955
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=955.025n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 955
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=955.025n

* CHECK dout0_8 Vdout0_8ck190 = 0 time = 955
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=955.025n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 955
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=955.025n

* CHECK dout0_10 Vdout0_10ck190 = 0 time = 955
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=955.025n

* CHECK dout0_11 Vdout0_11ck190 = 0.9 time = 955
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=955.025n

* CHECK dout0_12 Vdout0_12ck190 = 0 time = 955
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=955.025n

* CHECK dout0_13 Vdout0_13ck190 = 0.9 time = 955
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=955.025n

* CHECK dout0_14 Vdout0_14ck190 = 0 time = 955
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=955.025n

* CHECK dout0_15 Vdout0_15ck190 = 0 time = 955
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=955.025n

* CHECK dout0_16 Vdout0_16ck190 = 0.9 time = 955
.meas tran vdout0_16ck190 FIND v(dout0_16) AT=955.025n

* CHECK dout0_17 Vdout0_17ck190 = 0 time = 955
.meas tran vdout0_17ck190 FIND v(dout0_17) AT=955.025n

* CHECK dout0_18 Vdout0_18ck190 = 0 time = 955
.meas tran vdout0_18ck190 FIND v(dout0_18) AT=955.025n

* CHECK dout0_19 Vdout0_19ck190 = 0.9 time = 955
.meas tran vdout0_19ck190 FIND v(dout0_19) AT=955.025n

* CHECK dout0_20 Vdout0_20ck190 = 0 time = 955
.meas tran vdout0_20ck190 FIND v(dout0_20) AT=955.025n

* CHECK dout0_21 Vdout0_21ck190 = 0.9 time = 955
.meas tran vdout0_21ck190 FIND v(dout0_21) AT=955.025n

* CHECK dout0_22 Vdout0_22ck190 = 0 time = 955
.meas tran vdout0_22ck190 FIND v(dout0_22) AT=955.025n

* CHECK dout0_23 Vdout0_23ck190 = 0.9 time = 955
.meas tran vdout0_23ck190 FIND v(dout0_23) AT=955.025n

* CHECK dout0_24 Vdout0_24ck190 = 0 time = 955
.meas tran vdout0_24ck190 FIND v(dout0_24) AT=955.025n

* CHECK dout0_25 Vdout0_25ck190 = 0.9 time = 955
.meas tran vdout0_25ck190 FIND v(dout0_25) AT=955.025n

* CHECK dout0_26 Vdout0_26ck190 = 0.9 time = 955
.meas tran vdout0_26ck190 FIND v(dout0_26) AT=955.025n

* CHECK dout0_27 Vdout0_27ck190 = 0.9 time = 955
.meas tran vdout0_27ck190 FIND v(dout0_27) AT=955.025n

* CHECK dout0_28 Vdout0_28ck190 = 0 time = 955
.meas tran vdout0_28ck190 FIND v(dout0_28) AT=955.025n

* CHECK dout0_29 Vdout0_29ck190 = 0 time = 955
.meas tran vdout0_29ck190 FIND v(dout0_29) AT=955.025n

* CHECK dout0_30 Vdout0_30ck190 = 0 time = 955
.meas tran vdout0_30ck190 FIND v(dout0_30) AT=955.025n

* CHECK dout0_31 Vdout0_31ck190 = 0.9 time = 955
.meas tran vdout0_31ck190 FIND v(dout0_31) AT=955.025n

* CHECK dout0_32 Vdout0_32ck190 = 0 time = 955
.meas tran vdout0_32ck190 FIND v(dout0_32) AT=955.025n

* CHECK dout0_33 Vdout0_33ck190 = 0.9 time = 955
.meas tran vdout0_33ck190 FIND v(dout0_33) AT=955.025n

* CHECK dout0_34 Vdout0_34ck190 = 0 time = 955
.meas tran vdout0_34ck190 FIND v(dout0_34) AT=955.025n

* CHECK dout0_35 Vdout0_35ck190 = 0.9 time = 955
.meas tran vdout0_35ck190 FIND v(dout0_35) AT=955.025n

* CHECK dout0_36 Vdout0_36ck190 = 0 time = 955
.meas tran vdout0_36ck190 FIND v(dout0_36) AT=955.025n

* CHECK dout0_37 Vdout0_37ck190 = 0 time = 955
.meas tran vdout0_37ck190 FIND v(dout0_37) AT=955.025n

* CHECK dout0_38 Vdout0_38ck190 = 0 time = 955
.meas tran vdout0_38ck190 FIND v(dout0_38) AT=955.025n

* CHECK dout0_39 Vdout0_39ck190 = 0.9 time = 955
.meas tran vdout0_39ck190 FIND v(dout0_39) AT=955.025n

* CHECK dout0_40 Vdout0_40ck190 = 0.9 time = 955
.meas tran vdout0_40ck190 FIND v(dout0_40) AT=955.025n

* CHECK dout0_41 Vdout0_41ck190 = 0 time = 955
.meas tran vdout0_41ck190 FIND v(dout0_41) AT=955.025n

* CHECK dout0_42 Vdout0_42ck190 = 0 time = 955
.meas tran vdout0_42ck190 FIND v(dout0_42) AT=955.025n

* CHECK dout0_43 Vdout0_43ck190 = 0 time = 955
.meas tran vdout0_43ck190 FIND v(dout0_43) AT=955.025n

* CHECK dout0_44 Vdout0_44ck190 = 0 time = 955
.meas tran vdout0_44ck190 FIND v(dout0_44) AT=955.025n

* CHECK dout0_45 Vdout0_45ck190 = 0 time = 955
.meas tran vdout0_45ck190 FIND v(dout0_45) AT=955.025n

* CHECK dout0_46 Vdout0_46ck190 = 0 time = 955
.meas tran vdout0_46ck190 FIND v(dout0_46) AT=955.025n

* CHECK dout0_47 Vdout0_47ck190 = 0.9 time = 955
.meas tran vdout0_47ck190 FIND v(dout0_47) AT=955.025n

* CHECK dout0_48 Vdout0_48ck190 = 0 time = 955
.meas tran vdout0_48ck190 FIND v(dout0_48) AT=955.025n

* CHECK dout0_49 Vdout0_49ck190 = 0.9 time = 955
.meas tran vdout0_49ck190 FIND v(dout0_49) AT=955.025n

* CHECK dout0_50 Vdout0_50ck190 = 0 time = 955
.meas tran vdout0_50ck190 FIND v(dout0_50) AT=955.025n

* CHECK dout0_51 Vdout0_51ck190 = 0 time = 955
.meas tran vdout0_51ck190 FIND v(dout0_51) AT=955.025n

* CHECK dout0_52 Vdout0_52ck190 = 0.9 time = 955
.meas tran vdout0_52ck190 FIND v(dout0_52) AT=955.025n

* CHECK dout0_53 Vdout0_53ck190 = 0 time = 955
.meas tran vdout0_53ck190 FIND v(dout0_53) AT=955.025n

* CHECK dout0_54 Vdout0_54ck190 = 0 time = 955
.meas tran vdout0_54ck190 FIND v(dout0_54) AT=955.025n

* CHECK dout0_55 Vdout0_55ck190 = 0 time = 955
.meas tran vdout0_55ck190 FIND v(dout0_55) AT=955.025n

* CHECK dout0_56 Vdout0_56ck190 = 0 time = 955
.meas tran vdout0_56ck190 FIND v(dout0_56) AT=955.025n

* CHECK dout0_57 Vdout0_57ck190 = 0.9 time = 955
.meas tran vdout0_57ck190 FIND v(dout0_57) AT=955.025n

* CHECK dout0_58 Vdout0_58ck190 = 0 time = 955
.meas tran vdout0_58ck190 FIND v(dout0_58) AT=955.025n

* CHECK dout0_59 Vdout0_59ck190 = 0.9 time = 955
.meas tran vdout0_59ck190 FIND v(dout0_59) AT=955.025n

* CHECK dout0_60 Vdout0_60ck190 = 0.9 time = 955
.meas tran vdout0_60ck190 FIND v(dout0_60) AT=955.025n

* CHECK dout0_61 Vdout0_61ck190 = 0 time = 955
.meas tran vdout0_61ck190 FIND v(dout0_61) AT=955.025n

* CHECK dout0_62 Vdout0_62ck190 = 0.9 time = 955
.meas tran vdout0_62ck190 FIND v(dout0_62) AT=955.025n

* CHECK dout0_63 Vdout0_63ck190 = 0 time = 955
.meas tran vdout0_63ck190 FIND v(dout0_63) AT=955.025n

* CHECK dout0_0 Vdout0_0ck191 = 0 time = 960
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=960.025n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 960
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=960.025n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 960
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=960.025n

* CHECK dout0_3 Vdout0_3ck191 = 0.9 time = 960
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=960.025n

* CHECK dout0_4 Vdout0_4ck191 = 0 time = 960
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=960.025n

* CHECK dout0_5 Vdout0_5ck191 = 0.9 time = 960
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=960.025n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 960
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=960.025n

* CHECK dout0_7 Vdout0_7ck191 = 0 time = 960
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=960.025n

* CHECK dout0_8 Vdout0_8ck191 = 0.9 time = 960
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=960.025n

* CHECK dout0_9 Vdout0_9ck191 = 0 time = 960
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=960.025n

* CHECK dout0_10 Vdout0_10ck191 = 0.9 time = 960
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=960.025n

* CHECK dout0_11 Vdout0_11ck191 = 0.9 time = 960
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=960.025n

* CHECK dout0_12 Vdout0_12ck191 = 0.9 time = 960
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=960.025n

* CHECK dout0_13 Vdout0_13ck191 = 0.9 time = 960
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=960.025n

* CHECK dout0_14 Vdout0_14ck191 = 0.9 time = 960
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=960.025n

* CHECK dout0_15 Vdout0_15ck191 = 0 time = 960
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=960.025n

* CHECK dout0_16 Vdout0_16ck191 = 0.9 time = 960
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=960.025n

* CHECK dout0_17 Vdout0_17ck191 = 0 time = 960
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=960.025n

* CHECK dout0_18 Vdout0_18ck191 = 0 time = 960
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=960.025n

* CHECK dout0_19 Vdout0_19ck191 = 0.9 time = 960
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=960.025n

* CHECK dout0_20 Vdout0_20ck191 = 0.9 time = 960
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=960.025n

* CHECK dout0_21 Vdout0_21ck191 = 0.9 time = 960
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=960.025n

* CHECK dout0_22 Vdout0_22ck191 = 0 time = 960
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=960.025n

* CHECK dout0_23 Vdout0_23ck191 = 0.9 time = 960
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=960.025n

* CHECK dout0_24 Vdout0_24ck191 = 0.9 time = 960
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=960.025n

* CHECK dout0_25 Vdout0_25ck191 = 0.9 time = 960
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=960.025n

* CHECK dout0_26 Vdout0_26ck191 = 0 time = 960
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=960.025n

* CHECK dout0_27 Vdout0_27ck191 = 0 time = 960
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=960.025n

* CHECK dout0_28 Vdout0_28ck191 = 0.9 time = 960
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=960.025n

* CHECK dout0_29 Vdout0_29ck191 = 0.9 time = 960
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=960.025n

* CHECK dout0_30 Vdout0_30ck191 = 0 time = 960
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=960.025n

* CHECK dout0_31 Vdout0_31ck191 = 0.9 time = 960
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=960.025n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 960
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=960.025n

* CHECK dout0_33 Vdout0_33ck191 = 0 time = 960
.meas tran vdout0_33ck191 FIND v(dout0_33) AT=960.025n

* CHECK dout0_34 Vdout0_34ck191 = 0.9 time = 960
.meas tran vdout0_34ck191 FIND v(dout0_34) AT=960.025n

* CHECK dout0_35 Vdout0_35ck191 = 0 time = 960
.meas tran vdout0_35ck191 FIND v(dout0_35) AT=960.025n

* CHECK dout0_36 Vdout0_36ck191 = 0.9 time = 960
.meas tran vdout0_36ck191 FIND v(dout0_36) AT=960.025n

* CHECK dout0_37 Vdout0_37ck191 = 0.9 time = 960
.meas tran vdout0_37ck191 FIND v(dout0_37) AT=960.025n

* CHECK dout0_38 Vdout0_38ck191 = 0.9 time = 960
.meas tran vdout0_38ck191 FIND v(dout0_38) AT=960.025n

* CHECK dout0_39 Vdout0_39ck191 = 0.9 time = 960
.meas tran vdout0_39ck191 FIND v(dout0_39) AT=960.025n

* CHECK dout0_40 Vdout0_40ck191 = 0.9 time = 960
.meas tran vdout0_40ck191 FIND v(dout0_40) AT=960.025n

* CHECK dout0_41 Vdout0_41ck191 = 0 time = 960
.meas tran vdout0_41ck191 FIND v(dout0_41) AT=960.025n

* CHECK dout0_42 Vdout0_42ck191 = 0.9 time = 960
.meas tran vdout0_42ck191 FIND v(dout0_42) AT=960.025n

* CHECK dout0_43 Vdout0_43ck191 = 0.9 time = 960
.meas tran vdout0_43ck191 FIND v(dout0_43) AT=960.025n

* CHECK dout0_44 Vdout0_44ck191 = 0.9 time = 960
.meas tran vdout0_44ck191 FIND v(dout0_44) AT=960.025n

* CHECK dout0_45 Vdout0_45ck191 = 0 time = 960
.meas tran vdout0_45ck191 FIND v(dout0_45) AT=960.025n

* CHECK dout0_46 Vdout0_46ck191 = 0 time = 960
.meas tran vdout0_46ck191 FIND v(dout0_46) AT=960.025n

* CHECK dout0_47 Vdout0_47ck191 = 0 time = 960
.meas tran vdout0_47ck191 FIND v(dout0_47) AT=960.025n

* CHECK dout0_48 Vdout0_48ck191 = 0 time = 960
.meas tran vdout0_48ck191 FIND v(dout0_48) AT=960.025n

* CHECK dout0_49 Vdout0_49ck191 = 0 time = 960
.meas tran vdout0_49ck191 FIND v(dout0_49) AT=960.025n

* CHECK dout0_50 Vdout0_50ck191 = 0 time = 960
.meas tran vdout0_50ck191 FIND v(dout0_50) AT=960.025n

* CHECK dout0_51 Vdout0_51ck191 = 0 time = 960
.meas tran vdout0_51ck191 FIND v(dout0_51) AT=960.025n

* CHECK dout0_52 Vdout0_52ck191 = 0.9 time = 960
.meas tran vdout0_52ck191 FIND v(dout0_52) AT=960.025n

* CHECK dout0_53 Vdout0_53ck191 = 0 time = 960
.meas tran vdout0_53ck191 FIND v(dout0_53) AT=960.025n

* CHECK dout0_54 Vdout0_54ck191 = 0.9 time = 960
.meas tran vdout0_54ck191 FIND v(dout0_54) AT=960.025n

* CHECK dout0_55 Vdout0_55ck191 = 0.9 time = 960
.meas tran vdout0_55ck191 FIND v(dout0_55) AT=960.025n

* CHECK dout0_56 Vdout0_56ck191 = 0 time = 960
.meas tran vdout0_56ck191 FIND v(dout0_56) AT=960.025n

* CHECK dout0_57 Vdout0_57ck191 = 0 time = 960
.meas tran vdout0_57ck191 FIND v(dout0_57) AT=960.025n

* CHECK dout0_58 Vdout0_58ck191 = 0.9 time = 960
.meas tran vdout0_58ck191 FIND v(dout0_58) AT=960.025n

* CHECK dout0_59 Vdout0_59ck191 = 0 time = 960
.meas tran vdout0_59ck191 FIND v(dout0_59) AT=960.025n

* CHECK dout0_60 Vdout0_60ck191 = 0 time = 960
.meas tran vdout0_60ck191 FIND v(dout0_60) AT=960.025n

* CHECK dout0_61 Vdout0_61ck191 = 0 time = 960
.meas tran vdout0_61ck191 FIND v(dout0_61) AT=960.025n

* CHECK dout0_62 Vdout0_62ck191 = 0 time = 960
.meas tran vdout0_62ck191 FIND v(dout0_62) AT=960.025n

* CHECK dout0_63 Vdout0_63ck191 = 0 time = 960
.meas tran vdout0_63ck191 FIND v(dout0_63) AT=960.025n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 965
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=965.025n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 965
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=965.025n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 965
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=965.025n

* CHECK dout0_3 Vdout0_3ck192 = 0.9 time = 965
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=965.025n

* CHECK dout0_4 Vdout0_4ck192 = 0 time = 965
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=965.025n

* CHECK dout0_5 Vdout0_5ck192 = 0.9 time = 965
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=965.025n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 965
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=965.025n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 965
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=965.025n

* CHECK dout0_8 Vdout0_8ck192 = 0.9 time = 965
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=965.025n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 965
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=965.025n

* CHECK dout0_10 Vdout0_10ck192 = 0.9 time = 965
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=965.025n

* CHECK dout0_11 Vdout0_11ck192 = 0.9 time = 965
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=965.025n

* CHECK dout0_12 Vdout0_12ck192 = 0.9 time = 965
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=965.025n

* CHECK dout0_13 Vdout0_13ck192 = 0.9 time = 965
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=965.025n

* CHECK dout0_14 Vdout0_14ck192 = 0.9 time = 965
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=965.025n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 965
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=965.025n

* CHECK dout0_16 Vdout0_16ck192 = 0.9 time = 965
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=965.025n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 965
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=965.025n

* CHECK dout0_18 Vdout0_18ck192 = 0 time = 965
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=965.025n

* CHECK dout0_19 Vdout0_19ck192 = 0.9 time = 965
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=965.025n

* CHECK dout0_20 Vdout0_20ck192 = 0.9 time = 965
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=965.025n

* CHECK dout0_21 Vdout0_21ck192 = 0.9 time = 965
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=965.025n

* CHECK dout0_22 Vdout0_22ck192 = 0 time = 965
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=965.025n

* CHECK dout0_23 Vdout0_23ck192 = 0.9 time = 965
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=965.025n

* CHECK dout0_24 Vdout0_24ck192 = 0.9 time = 965
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=965.025n

* CHECK dout0_25 Vdout0_25ck192 = 0.9 time = 965
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=965.025n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 965
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=965.025n

* CHECK dout0_27 Vdout0_27ck192 = 0 time = 965
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=965.025n

* CHECK dout0_28 Vdout0_28ck192 = 0.9 time = 965
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=965.025n

* CHECK dout0_29 Vdout0_29ck192 = 0.9 time = 965
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=965.025n

* CHECK dout0_30 Vdout0_30ck192 = 0 time = 965
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=965.025n

* CHECK dout0_31 Vdout0_31ck192 = 0.9 time = 965
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=965.025n

* CHECK dout0_32 Vdout0_32ck192 = 0 time = 965
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=965.025n

* CHECK dout0_33 Vdout0_33ck192 = 0 time = 965
.meas tran vdout0_33ck192 FIND v(dout0_33) AT=965.025n

* CHECK dout0_34 Vdout0_34ck192 = 0.9 time = 965
.meas tran vdout0_34ck192 FIND v(dout0_34) AT=965.025n

* CHECK dout0_35 Vdout0_35ck192 = 0 time = 965
.meas tran vdout0_35ck192 FIND v(dout0_35) AT=965.025n

* CHECK dout0_36 Vdout0_36ck192 = 0.9 time = 965
.meas tran vdout0_36ck192 FIND v(dout0_36) AT=965.025n

* CHECK dout0_37 Vdout0_37ck192 = 0.9 time = 965
.meas tran vdout0_37ck192 FIND v(dout0_37) AT=965.025n

* CHECK dout0_38 Vdout0_38ck192 = 0.9 time = 965
.meas tran vdout0_38ck192 FIND v(dout0_38) AT=965.025n

* CHECK dout0_39 Vdout0_39ck192 = 0.9 time = 965
.meas tran vdout0_39ck192 FIND v(dout0_39) AT=965.025n

* CHECK dout0_40 Vdout0_40ck192 = 0.9 time = 965
.meas tran vdout0_40ck192 FIND v(dout0_40) AT=965.025n

* CHECK dout0_41 Vdout0_41ck192 = 0 time = 965
.meas tran vdout0_41ck192 FIND v(dout0_41) AT=965.025n

* CHECK dout0_42 Vdout0_42ck192 = 0.9 time = 965
.meas tran vdout0_42ck192 FIND v(dout0_42) AT=965.025n

* CHECK dout0_43 Vdout0_43ck192 = 0.9 time = 965
.meas tran vdout0_43ck192 FIND v(dout0_43) AT=965.025n

* CHECK dout0_44 Vdout0_44ck192 = 0.9 time = 965
.meas tran vdout0_44ck192 FIND v(dout0_44) AT=965.025n

* CHECK dout0_45 Vdout0_45ck192 = 0 time = 965
.meas tran vdout0_45ck192 FIND v(dout0_45) AT=965.025n

* CHECK dout0_46 Vdout0_46ck192 = 0 time = 965
.meas tran vdout0_46ck192 FIND v(dout0_46) AT=965.025n

* CHECK dout0_47 Vdout0_47ck192 = 0 time = 965
.meas tran vdout0_47ck192 FIND v(dout0_47) AT=965.025n

* CHECK dout0_48 Vdout0_48ck192 = 0 time = 965
.meas tran vdout0_48ck192 FIND v(dout0_48) AT=965.025n

* CHECK dout0_49 Vdout0_49ck192 = 0 time = 965
.meas tran vdout0_49ck192 FIND v(dout0_49) AT=965.025n

* CHECK dout0_50 Vdout0_50ck192 = 0 time = 965
.meas tran vdout0_50ck192 FIND v(dout0_50) AT=965.025n

* CHECK dout0_51 Vdout0_51ck192 = 0 time = 965
.meas tran vdout0_51ck192 FIND v(dout0_51) AT=965.025n

* CHECK dout0_52 Vdout0_52ck192 = 0.9 time = 965
.meas tran vdout0_52ck192 FIND v(dout0_52) AT=965.025n

* CHECK dout0_53 Vdout0_53ck192 = 0 time = 965
.meas tran vdout0_53ck192 FIND v(dout0_53) AT=965.025n

* CHECK dout0_54 Vdout0_54ck192 = 0.9 time = 965
.meas tran vdout0_54ck192 FIND v(dout0_54) AT=965.025n

* CHECK dout0_55 Vdout0_55ck192 = 0.9 time = 965
.meas tran vdout0_55ck192 FIND v(dout0_55) AT=965.025n

* CHECK dout0_56 Vdout0_56ck192 = 0 time = 965
.meas tran vdout0_56ck192 FIND v(dout0_56) AT=965.025n

* CHECK dout0_57 Vdout0_57ck192 = 0 time = 965
.meas tran vdout0_57ck192 FIND v(dout0_57) AT=965.025n

* CHECK dout0_58 Vdout0_58ck192 = 0.9 time = 965
.meas tran vdout0_58ck192 FIND v(dout0_58) AT=965.025n

* CHECK dout0_59 Vdout0_59ck192 = 0 time = 965
.meas tran vdout0_59ck192 FIND v(dout0_59) AT=965.025n

* CHECK dout0_60 Vdout0_60ck192 = 0 time = 965
.meas tran vdout0_60ck192 FIND v(dout0_60) AT=965.025n

* CHECK dout0_61 Vdout0_61ck192 = 0 time = 965
.meas tran vdout0_61ck192 FIND v(dout0_61) AT=965.025n

* CHECK dout0_62 Vdout0_62ck192 = 0 time = 965
.meas tran vdout0_62ck192 FIND v(dout0_62) AT=965.025n

* CHECK dout0_63 Vdout0_63ck192 = 0 time = 965
.meas tran vdout0_63ck192 FIND v(dout0_63) AT=965.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0.9 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0.9 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0.9 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 0.9 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0.9 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 0.9 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0.9 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0.9 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0.9 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 0 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0.9 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0.9 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0.9 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0.9 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0.9 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0.9 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0.9 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0.9 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0.9 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_32 Vdout0_32ck193 = 0 time = 970
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=970.025n

* CHECK dout0_33 Vdout0_33ck193 = 0 time = 970
.meas tran vdout0_33ck193 FIND v(dout0_33) AT=970.025n

* CHECK dout0_34 Vdout0_34ck193 = 0.9 time = 970
.meas tran vdout0_34ck193 FIND v(dout0_34) AT=970.025n

* CHECK dout0_35 Vdout0_35ck193 = 0 time = 970
.meas tran vdout0_35ck193 FIND v(dout0_35) AT=970.025n

* CHECK dout0_36 Vdout0_36ck193 = 0.9 time = 970
.meas tran vdout0_36ck193 FIND v(dout0_36) AT=970.025n

* CHECK dout0_37 Vdout0_37ck193 = 0.9 time = 970
.meas tran vdout0_37ck193 FIND v(dout0_37) AT=970.025n

* CHECK dout0_38 Vdout0_38ck193 = 0.9 time = 970
.meas tran vdout0_38ck193 FIND v(dout0_38) AT=970.025n

* CHECK dout0_39 Vdout0_39ck193 = 0.9 time = 970
.meas tran vdout0_39ck193 FIND v(dout0_39) AT=970.025n

* CHECK dout0_40 Vdout0_40ck193 = 0.9 time = 970
.meas tran vdout0_40ck193 FIND v(dout0_40) AT=970.025n

* CHECK dout0_41 Vdout0_41ck193 = 0 time = 970
.meas tran vdout0_41ck193 FIND v(dout0_41) AT=970.025n

* CHECK dout0_42 Vdout0_42ck193 = 0.9 time = 970
.meas tran vdout0_42ck193 FIND v(dout0_42) AT=970.025n

* CHECK dout0_43 Vdout0_43ck193 = 0.9 time = 970
.meas tran vdout0_43ck193 FIND v(dout0_43) AT=970.025n

* CHECK dout0_44 Vdout0_44ck193 = 0.9 time = 970
.meas tran vdout0_44ck193 FIND v(dout0_44) AT=970.025n

* CHECK dout0_45 Vdout0_45ck193 = 0 time = 970
.meas tran vdout0_45ck193 FIND v(dout0_45) AT=970.025n

* CHECK dout0_46 Vdout0_46ck193 = 0 time = 970
.meas tran vdout0_46ck193 FIND v(dout0_46) AT=970.025n

* CHECK dout0_47 Vdout0_47ck193 = 0 time = 970
.meas tran vdout0_47ck193 FIND v(dout0_47) AT=970.025n

* CHECK dout0_48 Vdout0_48ck193 = 0 time = 970
.meas tran vdout0_48ck193 FIND v(dout0_48) AT=970.025n

* CHECK dout0_49 Vdout0_49ck193 = 0 time = 970
.meas tran vdout0_49ck193 FIND v(dout0_49) AT=970.025n

* CHECK dout0_50 Vdout0_50ck193 = 0 time = 970
.meas tran vdout0_50ck193 FIND v(dout0_50) AT=970.025n

* CHECK dout0_51 Vdout0_51ck193 = 0 time = 970
.meas tran vdout0_51ck193 FIND v(dout0_51) AT=970.025n

* CHECK dout0_52 Vdout0_52ck193 = 0.9 time = 970
.meas tran vdout0_52ck193 FIND v(dout0_52) AT=970.025n

* CHECK dout0_53 Vdout0_53ck193 = 0 time = 970
.meas tran vdout0_53ck193 FIND v(dout0_53) AT=970.025n

* CHECK dout0_54 Vdout0_54ck193 = 0.9 time = 970
.meas tran vdout0_54ck193 FIND v(dout0_54) AT=970.025n

* CHECK dout0_55 Vdout0_55ck193 = 0.9 time = 970
.meas tran vdout0_55ck193 FIND v(dout0_55) AT=970.025n

* CHECK dout0_56 Vdout0_56ck193 = 0 time = 970
.meas tran vdout0_56ck193 FIND v(dout0_56) AT=970.025n

* CHECK dout0_57 Vdout0_57ck193 = 0 time = 970
.meas tran vdout0_57ck193 FIND v(dout0_57) AT=970.025n

* CHECK dout0_58 Vdout0_58ck193 = 0.9 time = 970
.meas tran vdout0_58ck193 FIND v(dout0_58) AT=970.025n

* CHECK dout0_59 Vdout0_59ck193 = 0 time = 970
.meas tran vdout0_59ck193 FIND v(dout0_59) AT=970.025n

* CHECK dout0_60 Vdout0_60ck193 = 0 time = 970
.meas tran vdout0_60ck193 FIND v(dout0_60) AT=970.025n

* CHECK dout0_61 Vdout0_61ck193 = 0 time = 970
.meas tran vdout0_61ck193 FIND v(dout0_61) AT=970.025n

* CHECK dout0_62 Vdout0_62ck193 = 0 time = 970
.meas tran vdout0_62ck193 FIND v(dout0_62) AT=970.025n

* CHECK dout0_63 Vdout0_63ck193 = 0 time = 970
.meas tran vdout0_63ck193 FIND v(dout0_63) AT=970.025n

* CHECK dout0_0 Vdout0_0ck194 = 0 time = 975
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=975.025n

* CHECK dout0_1 Vdout0_1ck194 = 0.9 time = 975
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=975.025n

* CHECK dout0_2 Vdout0_2ck194 = 0.9 time = 975
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=975.025n

* CHECK dout0_3 Vdout0_3ck194 = 0.9 time = 975
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=975.025n

* CHECK dout0_4 Vdout0_4ck194 = 0.9 time = 975
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=975.025n

* CHECK dout0_5 Vdout0_5ck194 = 0 time = 975
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=975.025n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 975
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=975.025n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 975
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=975.025n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 975
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=975.025n

* CHECK dout0_9 Vdout0_9ck194 = 0 time = 975
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=975.025n

* CHECK dout0_10 Vdout0_10ck194 = 0 time = 975
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=975.025n

* CHECK dout0_11 Vdout0_11ck194 = 0.9 time = 975
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=975.025n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 975
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=975.025n

* CHECK dout0_13 Vdout0_13ck194 = 0.9 time = 975
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=975.025n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 975
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=975.025n

* CHECK dout0_15 Vdout0_15ck194 = 0 time = 975
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=975.025n

* CHECK dout0_16 Vdout0_16ck194 = 0.9 time = 975
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=975.025n

* CHECK dout0_17 Vdout0_17ck194 = 0 time = 975
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=975.025n

* CHECK dout0_18 Vdout0_18ck194 = 0 time = 975
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=975.025n

* CHECK dout0_19 Vdout0_19ck194 = 0.9 time = 975
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=975.025n

* CHECK dout0_20 Vdout0_20ck194 = 0 time = 975
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=975.025n

* CHECK dout0_21 Vdout0_21ck194 = 0.9 time = 975
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=975.025n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 975
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=975.025n

* CHECK dout0_23 Vdout0_23ck194 = 0.9 time = 975
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=975.025n

* CHECK dout0_24 Vdout0_24ck194 = 0 time = 975
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=975.025n

* CHECK dout0_25 Vdout0_25ck194 = 0.9 time = 975
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=975.025n

* CHECK dout0_26 Vdout0_26ck194 = 0.9 time = 975
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=975.025n

* CHECK dout0_27 Vdout0_27ck194 = 0.9 time = 975
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=975.025n

* CHECK dout0_28 Vdout0_28ck194 = 0 time = 975
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=975.025n

* CHECK dout0_29 Vdout0_29ck194 = 0 time = 975
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=975.025n

* CHECK dout0_30 Vdout0_30ck194 = 0 time = 975
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=975.025n

* CHECK dout0_31 Vdout0_31ck194 = 0.9 time = 975
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=975.025n

* CHECK dout0_32 Vdout0_32ck194 = 0 time = 975
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=975.025n

* CHECK dout0_33 Vdout0_33ck194 = 0.9 time = 975
.meas tran vdout0_33ck194 FIND v(dout0_33) AT=975.025n

* CHECK dout0_34 Vdout0_34ck194 = 0 time = 975
.meas tran vdout0_34ck194 FIND v(dout0_34) AT=975.025n

* CHECK dout0_35 Vdout0_35ck194 = 0.9 time = 975
.meas tran vdout0_35ck194 FIND v(dout0_35) AT=975.025n

* CHECK dout0_36 Vdout0_36ck194 = 0 time = 975
.meas tran vdout0_36ck194 FIND v(dout0_36) AT=975.025n

* CHECK dout0_37 Vdout0_37ck194 = 0 time = 975
.meas tran vdout0_37ck194 FIND v(dout0_37) AT=975.025n

* CHECK dout0_38 Vdout0_38ck194 = 0 time = 975
.meas tran vdout0_38ck194 FIND v(dout0_38) AT=975.025n

* CHECK dout0_39 Vdout0_39ck194 = 0.9 time = 975
.meas tran vdout0_39ck194 FIND v(dout0_39) AT=975.025n

* CHECK dout0_40 Vdout0_40ck194 = 0.9 time = 975
.meas tran vdout0_40ck194 FIND v(dout0_40) AT=975.025n

* CHECK dout0_41 Vdout0_41ck194 = 0 time = 975
.meas tran vdout0_41ck194 FIND v(dout0_41) AT=975.025n

* CHECK dout0_42 Vdout0_42ck194 = 0 time = 975
.meas tran vdout0_42ck194 FIND v(dout0_42) AT=975.025n

* CHECK dout0_43 Vdout0_43ck194 = 0 time = 975
.meas tran vdout0_43ck194 FIND v(dout0_43) AT=975.025n

* CHECK dout0_44 Vdout0_44ck194 = 0 time = 975
.meas tran vdout0_44ck194 FIND v(dout0_44) AT=975.025n

* CHECK dout0_45 Vdout0_45ck194 = 0 time = 975
.meas tran vdout0_45ck194 FIND v(dout0_45) AT=975.025n

* CHECK dout0_46 Vdout0_46ck194 = 0 time = 975
.meas tran vdout0_46ck194 FIND v(dout0_46) AT=975.025n

* CHECK dout0_47 Vdout0_47ck194 = 0.9 time = 975
.meas tran vdout0_47ck194 FIND v(dout0_47) AT=975.025n

* CHECK dout0_48 Vdout0_48ck194 = 0 time = 975
.meas tran vdout0_48ck194 FIND v(dout0_48) AT=975.025n

* CHECK dout0_49 Vdout0_49ck194 = 0.9 time = 975
.meas tran vdout0_49ck194 FIND v(dout0_49) AT=975.025n

* CHECK dout0_50 Vdout0_50ck194 = 0 time = 975
.meas tran vdout0_50ck194 FIND v(dout0_50) AT=975.025n

* CHECK dout0_51 Vdout0_51ck194 = 0 time = 975
.meas tran vdout0_51ck194 FIND v(dout0_51) AT=975.025n

* CHECK dout0_52 Vdout0_52ck194 = 0.9 time = 975
.meas tran vdout0_52ck194 FIND v(dout0_52) AT=975.025n

* CHECK dout0_53 Vdout0_53ck194 = 0 time = 975
.meas tran vdout0_53ck194 FIND v(dout0_53) AT=975.025n

* CHECK dout0_54 Vdout0_54ck194 = 0 time = 975
.meas tran vdout0_54ck194 FIND v(dout0_54) AT=975.025n

* CHECK dout0_55 Vdout0_55ck194 = 0 time = 975
.meas tran vdout0_55ck194 FIND v(dout0_55) AT=975.025n

* CHECK dout0_56 Vdout0_56ck194 = 0 time = 975
.meas tran vdout0_56ck194 FIND v(dout0_56) AT=975.025n

* CHECK dout0_57 Vdout0_57ck194 = 0.9 time = 975
.meas tran vdout0_57ck194 FIND v(dout0_57) AT=975.025n

* CHECK dout0_58 Vdout0_58ck194 = 0 time = 975
.meas tran vdout0_58ck194 FIND v(dout0_58) AT=975.025n

* CHECK dout0_59 Vdout0_59ck194 = 0.9 time = 975
.meas tran vdout0_59ck194 FIND v(dout0_59) AT=975.025n

* CHECK dout0_60 Vdout0_60ck194 = 0.9 time = 975
.meas tran vdout0_60ck194 FIND v(dout0_60) AT=975.025n

* CHECK dout0_61 Vdout0_61ck194 = 0 time = 975
.meas tran vdout0_61ck194 FIND v(dout0_61) AT=975.025n

* CHECK dout0_62 Vdout0_62ck194 = 0.9 time = 975
.meas tran vdout0_62ck194 FIND v(dout0_62) AT=975.025n

* CHECK dout0_63 Vdout0_63ck194 = 0 time = 975
.meas tran vdout0_63ck194 FIND v(dout0_63) AT=975.025n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 990
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=990.025n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 990
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=990.025n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 990
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=990.025n

* CHECK dout0_3 Vdout0_3ck197 = 0.9 time = 990
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=990.025n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 990
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=990.025n

* CHECK dout0_5 Vdout0_5ck197 = 0.9 time = 990
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=990.025n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 990
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=990.025n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 990
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=990.025n

* CHECK dout0_8 Vdout0_8ck197 = 0.9 time = 990
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=990.025n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 990
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=990.025n

* CHECK dout0_10 Vdout0_10ck197 = 0.9 time = 990
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=990.025n

* CHECK dout0_11 Vdout0_11ck197 = 0.9 time = 990
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=990.025n

* CHECK dout0_12 Vdout0_12ck197 = 0.9 time = 990
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=990.025n

* CHECK dout0_13 Vdout0_13ck197 = 0.9 time = 990
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=990.025n

* CHECK dout0_14 Vdout0_14ck197 = 0.9 time = 990
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=990.025n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 990
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=990.025n

* CHECK dout0_16 Vdout0_16ck197 = 0.9 time = 990
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=990.025n

* CHECK dout0_17 Vdout0_17ck197 = 0 time = 990
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=990.025n

* CHECK dout0_18 Vdout0_18ck197 = 0 time = 990
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=990.025n

* CHECK dout0_19 Vdout0_19ck197 = 0.9 time = 990
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=990.025n

* CHECK dout0_20 Vdout0_20ck197 = 0.9 time = 990
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=990.025n

* CHECK dout0_21 Vdout0_21ck197 = 0.9 time = 990
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=990.025n

* CHECK dout0_22 Vdout0_22ck197 = 0 time = 990
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=990.025n

* CHECK dout0_23 Vdout0_23ck197 = 0.9 time = 990
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=990.025n

* CHECK dout0_24 Vdout0_24ck197 = 0.9 time = 990
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=990.025n

* CHECK dout0_25 Vdout0_25ck197 = 0.9 time = 990
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=990.025n

* CHECK dout0_26 Vdout0_26ck197 = 0 time = 990
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=990.025n

* CHECK dout0_27 Vdout0_27ck197 = 0 time = 990
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=990.025n

* CHECK dout0_28 Vdout0_28ck197 = 0.9 time = 990
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=990.025n

* CHECK dout0_29 Vdout0_29ck197 = 0.9 time = 990
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=990.025n

* CHECK dout0_30 Vdout0_30ck197 = 0 time = 990
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=990.025n

* CHECK dout0_31 Vdout0_31ck197 = 0.9 time = 990
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=990.025n

* CHECK dout0_32 Vdout0_32ck197 = 0 time = 990
.meas tran vdout0_32ck197 FIND v(dout0_32) AT=990.025n

* CHECK dout0_33 Vdout0_33ck197 = 0 time = 990
.meas tran vdout0_33ck197 FIND v(dout0_33) AT=990.025n

* CHECK dout0_34 Vdout0_34ck197 = 0.9 time = 990
.meas tran vdout0_34ck197 FIND v(dout0_34) AT=990.025n

* CHECK dout0_35 Vdout0_35ck197 = 0 time = 990
.meas tran vdout0_35ck197 FIND v(dout0_35) AT=990.025n

* CHECK dout0_36 Vdout0_36ck197 = 0.9 time = 990
.meas tran vdout0_36ck197 FIND v(dout0_36) AT=990.025n

* CHECK dout0_37 Vdout0_37ck197 = 0.9 time = 990
.meas tran vdout0_37ck197 FIND v(dout0_37) AT=990.025n

* CHECK dout0_38 Vdout0_38ck197 = 0.9 time = 990
.meas tran vdout0_38ck197 FIND v(dout0_38) AT=990.025n

* CHECK dout0_39 Vdout0_39ck197 = 0.9 time = 990
.meas tran vdout0_39ck197 FIND v(dout0_39) AT=990.025n

* CHECK dout0_40 Vdout0_40ck197 = 0.9 time = 990
.meas tran vdout0_40ck197 FIND v(dout0_40) AT=990.025n

* CHECK dout0_41 Vdout0_41ck197 = 0 time = 990
.meas tran vdout0_41ck197 FIND v(dout0_41) AT=990.025n

* CHECK dout0_42 Vdout0_42ck197 = 0.9 time = 990
.meas tran vdout0_42ck197 FIND v(dout0_42) AT=990.025n

* CHECK dout0_43 Vdout0_43ck197 = 0.9 time = 990
.meas tran vdout0_43ck197 FIND v(dout0_43) AT=990.025n

* CHECK dout0_44 Vdout0_44ck197 = 0.9 time = 990
.meas tran vdout0_44ck197 FIND v(dout0_44) AT=990.025n

* CHECK dout0_45 Vdout0_45ck197 = 0 time = 990
.meas tran vdout0_45ck197 FIND v(dout0_45) AT=990.025n

* CHECK dout0_46 Vdout0_46ck197 = 0 time = 990
.meas tran vdout0_46ck197 FIND v(dout0_46) AT=990.025n

* CHECK dout0_47 Vdout0_47ck197 = 0 time = 990
.meas tran vdout0_47ck197 FIND v(dout0_47) AT=990.025n

* CHECK dout0_48 Vdout0_48ck197 = 0 time = 990
.meas tran vdout0_48ck197 FIND v(dout0_48) AT=990.025n

* CHECK dout0_49 Vdout0_49ck197 = 0 time = 990
.meas tran vdout0_49ck197 FIND v(dout0_49) AT=990.025n

* CHECK dout0_50 Vdout0_50ck197 = 0 time = 990
.meas tran vdout0_50ck197 FIND v(dout0_50) AT=990.025n

* CHECK dout0_51 Vdout0_51ck197 = 0 time = 990
.meas tran vdout0_51ck197 FIND v(dout0_51) AT=990.025n

* CHECK dout0_52 Vdout0_52ck197 = 0.9 time = 990
.meas tran vdout0_52ck197 FIND v(dout0_52) AT=990.025n

* CHECK dout0_53 Vdout0_53ck197 = 0 time = 990
.meas tran vdout0_53ck197 FIND v(dout0_53) AT=990.025n

* CHECK dout0_54 Vdout0_54ck197 = 0.9 time = 990
.meas tran vdout0_54ck197 FIND v(dout0_54) AT=990.025n

* CHECK dout0_55 Vdout0_55ck197 = 0.9 time = 990
.meas tran vdout0_55ck197 FIND v(dout0_55) AT=990.025n

* CHECK dout0_56 Vdout0_56ck197 = 0 time = 990
.meas tran vdout0_56ck197 FIND v(dout0_56) AT=990.025n

* CHECK dout0_57 Vdout0_57ck197 = 0 time = 990
.meas tran vdout0_57ck197 FIND v(dout0_57) AT=990.025n

* CHECK dout0_58 Vdout0_58ck197 = 0.9 time = 990
.meas tran vdout0_58ck197 FIND v(dout0_58) AT=990.025n

* CHECK dout0_59 Vdout0_59ck197 = 0 time = 990
.meas tran vdout0_59ck197 FIND v(dout0_59) AT=990.025n

* CHECK dout0_60 Vdout0_60ck197 = 0 time = 990
.meas tran vdout0_60ck197 FIND v(dout0_60) AT=990.025n

* CHECK dout0_61 Vdout0_61ck197 = 0 time = 990
.meas tran vdout0_61ck197 FIND v(dout0_61) AT=990.025n

* CHECK dout0_62 Vdout0_62ck197 = 0 time = 990
.meas tran vdout0_62ck197 FIND v(dout0_62) AT=990.025n

* CHECK dout0_63 Vdout0_63ck197 = 0 time = 990
.meas tran vdout0_63ck197 FIND v(dout0_63) AT=990.025n

* CHECK dout0_0 Vdout0_0ck198 = 0 time = 995
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=995.025n

* CHECK dout0_1 Vdout0_1ck198 = 0 time = 995
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=995.025n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 995
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=995.025n

* CHECK dout0_3 Vdout0_3ck198 = 0.9 time = 995
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=995.025n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 995
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=995.025n

* CHECK dout0_5 Vdout0_5ck198 = 0.9 time = 995
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=995.025n

* CHECK dout0_6 Vdout0_6ck198 = 0 time = 995
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=995.025n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 995
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=995.025n

* CHECK dout0_8 Vdout0_8ck198 = 0.9 time = 995
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=995.025n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 995
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=995.025n

* CHECK dout0_10 Vdout0_10ck198 = 0.9 time = 995
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=995.025n

* CHECK dout0_11 Vdout0_11ck198 = 0.9 time = 995
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=995.025n

* CHECK dout0_12 Vdout0_12ck198 = 0.9 time = 995
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=995.025n

* CHECK dout0_13 Vdout0_13ck198 = 0.9 time = 995
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=995.025n

* CHECK dout0_14 Vdout0_14ck198 = 0.9 time = 995
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=995.025n

* CHECK dout0_15 Vdout0_15ck198 = 0 time = 995
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=995.025n

* CHECK dout0_16 Vdout0_16ck198 = 0.9 time = 995
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=995.025n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 995
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=995.025n

* CHECK dout0_18 Vdout0_18ck198 = 0 time = 995
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=995.025n

* CHECK dout0_19 Vdout0_19ck198 = 0.9 time = 995
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=995.025n

* CHECK dout0_20 Vdout0_20ck198 = 0.9 time = 995
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=995.025n

* CHECK dout0_21 Vdout0_21ck198 = 0.9 time = 995
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=995.025n

* CHECK dout0_22 Vdout0_22ck198 = 0 time = 995
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=995.025n

* CHECK dout0_23 Vdout0_23ck198 = 0.9 time = 995
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=995.025n

* CHECK dout0_24 Vdout0_24ck198 = 0.9 time = 995
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=995.025n

* CHECK dout0_25 Vdout0_25ck198 = 0.9 time = 995
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=995.025n

* CHECK dout0_26 Vdout0_26ck198 = 0 time = 995
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=995.025n

* CHECK dout0_27 Vdout0_27ck198 = 0 time = 995
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=995.025n

* CHECK dout0_28 Vdout0_28ck198 = 0.9 time = 995
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=995.025n

* CHECK dout0_29 Vdout0_29ck198 = 0.9 time = 995
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=995.025n

* CHECK dout0_30 Vdout0_30ck198 = 0 time = 995
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=995.025n

* CHECK dout0_31 Vdout0_31ck198 = 0.9 time = 995
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=995.025n

* CHECK dout0_32 Vdout0_32ck198 = 0 time = 995
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=995.025n

* CHECK dout0_33 Vdout0_33ck198 = 0 time = 995
.meas tran vdout0_33ck198 FIND v(dout0_33) AT=995.025n

* CHECK dout0_34 Vdout0_34ck198 = 0.9 time = 995
.meas tran vdout0_34ck198 FIND v(dout0_34) AT=995.025n

* CHECK dout0_35 Vdout0_35ck198 = 0 time = 995
.meas tran vdout0_35ck198 FIND v(dout0_35) AT=995.025n

* CHECK dout0_36 Vdout0_36ck198 = 0.9 time = 995
.meas tran vdout0_36ck198 FIND v(dout0_36) AT=995.025n

* CHECK dout0_37 Vdout0_37ck198 = 0.9 time = 995
.meas tran vdout0_37ck198 FIND v(dout0_37) AT=995.025n

* CHECK dout0_38 Vdout0_38ck198 = 0.9 time = 995
.meas tran vdout0_38ck198 FIND v(dout0_38) AT=995.025n

* CHECK dout0_39 Vdout0_39ck198 = 0.9 time = 995
.meas tran vdout0_39ck198 FIND v(dout0_39) AT=995.025n

* CHECK dout0_40 Vdout0_40ck198 = 0.9 time = 995
.meas tran vdout0_40ck198 FIND v(dout0_40) AT=995.025n

* CHECK dout0_41 Vdout0_41ck198 = 0 time = 995
.meas tran vdout0_41ck198 FIND v(dout0_41) AT=995.025n

* CHECK dout0_42 Vdout0_42ck198 = 0.9 time = 995
.meas tran vdout0_42ck198 FIND v(dout0_42) AT=995.025n

* CHECK dout0_43 Vdout0_43ck198 = 0.9 time = 995
.meas tran vdout0_43ck198 FIND v(dout0_43) AT=995.025n

* CHECK dout0_44 Vdout0_44ck198 = 0.9 time = 995
.meas tran vdout0_44ck198 FIND v(dout0_44) AT=995.025n

* CHECK dout0_45 Vdout0_45ck198 = 0 time = 995
.meas tran vdout0_45ck198 FIND v(dout0_45) AT=995.025n

* CHECK dout0_46 Vdout0_46ck198 = 0 time = 995
.meas tran vdout0_46ck198 FIND v(dout0_46) AT=995.025n

* CHECK dout0_47 Vdout0_47ck198 = 0 time = 995
.meas tran vdout0_47ck198 FIND v(dout0_47) AT=995.025n

* CHECK dout0_48 Vdout0_48ck198 = 0 time = 995
.meas tran vdout0_48ck198 FIND v(dout0_48) AT=995.025n

* CHECK dout0_49 Vdout0_49ck198 = 0 time = 995
.meas tran vdout0_49ck198 FIND v(dout0_49) AT=995.025n

* CHECK dout0_50 Vdout0_50ck198 = 0 time = 995
.meas tran vdout0_50ck198 FIND v(dout0_50) AT=995.025n

* CHECK dout0_51 Vdout0_51ck198 = 0 time = 995
.meas tran vdout0_51ck198 FIND v(dout0_51) AT=995.025n

* CHECK dout0_52 Vdout0_52ck198 = 0.9 time = 995
.meas tran vdout0_52ck198 FIND v(dout0_52) AT=995.025n

* CHECK dout0_53 Vdout0_53ck198 = 0 time = 995
.meas tran vdout0_53ck198 FIND v(dout0_53) AT=995.025n

* CHECK dout0_54 Vdout0_54ck198 = 0.9 time = 995
.meas tran vdout0_54ck198 FIND v(dout0_54) AT=995.025n

* CHECK dout0_55 Vdout0_55ck198 = 0.9 time = 995
.meas tran vdout0_55ck198 FIND v(dout0_55) AT=995.025n

* CHECK dout0_56 Vdout0_56ck198 = 0 time = 995
.meas tran vdout0_56ck198 FIND v(dout0_56) AT=995.025n

* CHECK dout0_57 Vdout0_57ck198 = 0 time = 995
.meas tran vdout0_57ck198 FIND v(dout0_57) AT=995.025n

* CHECK dout0_58 Vdout0_58ck198 = 0.9 time = 995
.meas tran vdout0_58ck198 FIND v(dout0_58) AT=995.025n

* CHECK dout0_59 Vdout0_59ck198 = 0 time = 995
.meas tran vdout0_59ck198 FIND v(dout0_59) AT=995.025n

* CHECK dout0_60 Vdout0_60ck198 = 0 time = 995
.meas tran vdout0_60ck198 FIND v(dout0_60) AT=995.025n

* CHECK dout0_61 Vdout0_61ck198 = 0 time = 995
.meas tran vdout0_61ck198 FIND v(dout0_61) AT=995.025n

* CHECK dout0_62 Vdout0_62ck198 = 0 time = 995
.meas tran vdout0_62ck198 FIND v(dout0_62) AT=995.025n

* CHECK dout0_63 Vdout0_63ck198 = 0 time = 995
.meas tran vdout0_63ck198 FIND v(dout0_63) AT=995.025n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 1000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=1000.025n

* CHECK dout0_1 Vdout0_1ck199 = 0 time = 1000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=1000.025n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 1000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=1000.025n

* CHECK dout0_3 Vdout0_3ck199 = 0.9 time = 1000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=1000.025n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 1000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=1000.025n

* CHECK dout0_5 Vdout0_5ck199 = 0.9 time = 1000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=1000.025n

* CHECK dout0_6 Vdout0_6ck199 = 0 time = 1000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=1000.025n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 1000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=1000.025n

* CHECK dout0_8 Vdout0_8ck199 = 0.9 time = 1000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=1000.025n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 1000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=1000.025n

* CHECK dout0_10 Vdout0_10ck199 = 0.9 time = 1000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=1000.025n

* CHECK dout0_11 Vdout0_11ck199 = 0.9 time = 1000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=1000.025n

* CHECK dout0_12 Vdout0_12ck199 = 0.9 time = 1000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=1000.025n

* CHECK dout0_13 Vdout0_13ck199 = 0.9 time = 1000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=1000.025n

* CHECK dout0_14 Vdout0_14ck199 = 0.9 time = 1000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=1000.025n

* CHECK dout0_15 Vdout0_15ck199 = 0 time = 1000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=1000.025n

* CHECK dout0_16 Vdout0_16ck199 = 0.9 time = 1000
.meas tran vdout0_16ck199 FIND v(dout0_16) AT=1000.025n

* CHECK dout0_17 Vdout0_17ck199 = 0 time = 1000
.meas tran vdout0_17ck199 FIND v(dout0_17) AT=1000.025n

* CHECK dout0_18 Vdout0_18ck199 = 0 time = 1000
.meas tran vdout0_18ck199 FIND v(dout0_18) AT=1000.025n

* CHECK dout0_19 Vdout0_19ck199 = 0.9 time = 1000
.meas tran vdout0_19ck199 FIND v(dout0_19) AT=1000.025n

* CHECK dout0_20 Vdout0_20ck199 = 0.9 time = 1000
.meas tran vdout0_20ck199 FIND v(dout0_20) AT=1000.025n

* CHECK dout0_21 Vdout0_21ck199 = 0.9 time = 1000
.meas tran vdout0_21ck199 FIND v(dout0_21) AT=1000.025n

* CHECK dout0_22 Vdout0_22ck199 = 0 time = 1000
.meas tran vdout0_22ck199 FIND v(dout0_22) AT=1000.025n

* CHECK dout0_23 Vdout0_23ck199 = 0.9 time = 1000
.meas tran vdout0_23ck199 FIND v(dout0_23) AT=1000.025n

* CHECK dout0_24 Vdout0_24ck199 = 0.9 time = 1000
.meas tran vdout0_24ck199 FIND v(dout0_24) AT=1000.025n

* CHECK dout0_25 Vdout0_25ck199 = 0.9 time = 1000
.meas tran vdout0_25ck199 FIND v(dout0_25) AT=1000.025n

* CHECK dout0_26 Vdout0_26ck199 = 0 time = 1000
.meas tran vdout0_26ck199 FIND v(dout0_26) AT=1000.025n

* CHECK dout0_27 Vdout0_27ck199 = 0 time = 1000
.meas tran vdout0_27ck199 FIND v(dout0_27) AT=1000.025n

* CHECK dout0_28 Vdout0_28ck199 = 0.9 time = 1000
.meas tran vdout0_28ck199 FIND v(dout0_28) AT=1000.025n

* CHECK dout0_29 Vdout0_29ck199 = 0.9 time = 1000
.meas tran vdout0_29ck199 FIND v(dout0_29) AT=1000.025n

* CHECK dout0_30 Vdout0_30ck199 = 0 time = 1000
.meas tran vdout0_30ck199 FIND v(dout0_30) AT=1000.025n

* CHECK dout0_31 Vdout0_31ck199 = 0.9 time = 1000
.meas tran vdout0_31ck199 FIND v(dout0_31) AT=1000.025n

* CHECK dout0_32 Vdout0_32ck199 = 0 time = 1000
.meas tran vdout0_32ck199 FIND v(dout0_32) AT=1000.025n

* CHECK dout0_33 Vdout0_33ck199 = 0 time = 1000
.meas tran vdout0_33ck199 FIND v(dout0_33) AT=1000.025n

* CHECK dout0_34 Vdout0_34ck199 = 0.9 time = 1000
.meas tran vdout0_34ck199 FIND v(dout0_34) AT=1000.025n

* CHECK dout0_35 Vdout0_35ck199 = 0 time = 1000
.meas tran vdout0_35ck199 FIND v(dout0_35) AT=1000.025n

* CHECK dout0_36 Vdout0_36ck199 = 0.9 time = 1000
.meas tran vdout0_36ck199 FIND v(dout0_36) AT=1000.025n

* CHECK dout0_37 Vdout0_37ck199 = 0.9 time = 1000
.meas tran vdout0_37ck199 FIND v(dout0_37) AT=1000.025n

* CHECK dout0_38 Vdout0_38ck199 = 0.9 time = 1000
.meas tran vdout0_38ck199 FIND v(dout0_38) AT=1000.025n

* CHECK dout0_39 Vdout0_39ck199 = 0.9 time = 1000
.meas tran vdout0_39ck199 FIND v(dout0_39) AT=1000.025n

* CHECK dout0_40 Vdout0_40ck199 = 0.9 time = 1000
.meas tran vdout0_40ck199 FIND v(dout0_40) AT=1000.025n

* CHECK dout0_41 Vdout0_41ck199 = 0 time = 1000
.meas tran vdout0_41ck199 FIND v(dout0_41) AT=1000.025n

* CHECK dout0_42 Vdout0_42ck199 = 0.9 time = 1000
.meas tran vdout0_42ck199 FIND v(dout0_42) AT=1000.025n

* CHECK dout0_43 Vdout0_43ck199 = 0.9 time = 1000
.meas tran vdout0_43ck199 FIND v(dout0_43) AT=1000.025n

* CHECK dout0_44 Vdout0_44ck199 = 0.9 time = 1000
.meas tran vdout0_44ck199 FIND v(dout0_44) AT=1000.025n

* CHECK dout0_45 Vdout0_45ck199 = 0 time = 1000
.meas tran vdout0_45ck199 FIND v(dout0_45) AT=1000.025n

* CHECK dout0_46 Vdout0_46ck199 = 0 time = 1000
.meas tran vdout0_46ck199 FIND v(dout0_46) AT=1000.025n

* CHECK dout0_47 Vdout0_47ck199 = 0 time = 1000
.meas tran vdout0_47ck199 FIND v(dout0_47) AT=1000.025n

* CHECK dout0_48 Vdout0_48ck199 = 0 time = 1000
.meas tran vdout0_48ck199 FIND v(dout0_48) AT=1000.025n

* CHECK dout0_49 Vdout0_49ck199 = 0 time = 1000
.meas tran vdout0_49ck199 FIND v(dout0_49) AT=1000.025n

* CHECK dout0_50 Vdout0_50ck199 = 0 time = 1000
.meas tran vdout0_50ck199 FIND v(dout0_50) AT=1000.025n

* CHECK dout0_51 Vdout0_51ck199 = 0 time = 1000
.meas tran vdout0_51ck199 FIND v(dout0_51) AT=1000.025n

* CHECK dout0_52 Vdout0_52ck199 = 0.9 time = 1000
.meas tran vdout0_52ck199 FIND v(dout0_52) AT=1000.025n

* CHECK dout0_53 Vdout0_53ck199 = 0 time = 1000
.meas tran vdout0_53ck199 FIND v(dout0_53) AT=1000.025n

* CHECK dout0_54 Vdout0_54ck199 = 0.9 time = 1000
.meas tran vdout0_54ck199 FIND v(dout0_54) AT=1000.025n

* CHECK dout0_55 Vdout0_55ck199 = 0.9 time = 1000
.meas tran vdout0_55ck199 FIND v(dout0_55) AT=1000.025n

* CHECK dout0_56 Vdout0_56ck199 = 0 time = 1000
.meas tran vdout0_56ck199 FIND v(dout0_56) AT=1000.025n

* CHECK dout0_57 Vdout0_57ck199 = 0 time = 1000
.meas tran vdout0_57ck199 FIND v(dout0_57) AT=1000.025n

* CHECK dout0_58 Vdout0_58ck199 = 0.9 time = 1000
.meas tran vdout0_58ck199 FIND v(dout0_58) AT=1000.025n

* CHECK dout0_59 Vdout0_59ck199 = 0 time = 1000
.meas tran vdout0_59ck199 FIND v(dout0_59) AT=1000.025n

* CHECK dout0_60 Vdout0_60ck199 = 0 time = 1000
.meas tran vdout0_60ck199 FIND v(dout0_60) AT=1000.025n

* CHECK dout0_61 Vdout0_61ck199 = 0 time = 1000
.meas tran vdout0_61ck199 FIND v(dout0_61) AT=1000.025n

* CHECK dout0_62 Vdout0_62ck199 = 0 time = 1000
.meas tran vdout0_62ck199 FIND v(dout0_62) AT=1000.025n

* CHECK dout0_63 Vdout0_63ck199 = 0 time = 1000
.meas tran vdout0_63ck199 FIND v(dout0_63) AT=1000.025n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 1005
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=1005.025n

* CHECK dout0_1 Vdout0_1ck200 = 0.9 time = 1005
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=1005.025n

* CHECK dout0_2 Vdout0_2ck200 = 0.9 time = 1005
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=1005.025n

* CHECK dout0_3 Vdout0_3ck200 = 0 time = 1005
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=1005.025n

* CHECK dout0_4 Vdout0_4ck200 = 0 time = 1005
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=1005.025n

* CHECK dout0_5 Vdout0_5ck200 = 0.9 time = 1005
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=1005.025n

* CHECK dout0_6 Vdout0_6ck200 = 0.9 time = 1005
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=1005.025n

* CHECK dout0_7 Vdout0_7ck200 = 0 time = 1005
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=1005.025n

* CHECK dout0_8 Vdout0_8ck200 = 0 time = 1005
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=1005.025n

* CHECK dout0_9 Vdout0_9ck200 = 0 time = 1005
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=1005.025n

* CHECK dout0_10 Vdout0_10ck200 = 0 time = 1005
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=1005.025n

* CHECK dout0_11 Vdout0_11ck200 = 0 time = 1005
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=1005.025n

* CHECK dout0_12 Vdout0_12ck200 = 0.9 time = 1005
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=1005.025n

* CHECK dout0_13 Vdout0_13ck200 = 0 time = 1005
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=1005.025n

* CHECK dout0_14 Vdout0_14ck200 = 0.9 time = 1005
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=1005.025n

* CHECK dout0_15 Vdout0_15ck200 = 0.9 time = 1005
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=1005.025n

* CHECK dout0_16 Vdout0_16ck200 = 0.9 time = 1005
.meas tran vdout0_16ck200 FIND v(dout0_16) AT=1005.025n

* CHECK dout0_17 Vdout0_17ck200 = 0.9 time = 1005
.meas tran vdout0_17ck200 FIND v(dout0_17) AT=1005.025n

* CHECK dout0_18 Vdout0_18ck200 = 0 time = 1005
.meas tran vdout0_18ck200 FIND v(dout0_18) AT=1005.025n

* CHECK dout0_19 Vdout0_19ck200 = 0 time = 1005
.meas tran vdout0_19ck200 FIND v(dout0_19) AT=1005.025n

* CHECK dout0_20 Vdout0_20ck200 = 0.9 time = 1005
.meas tran vdout0_20ck200 FIND v(dout0_20) AT=1005.025n

* CHECK dout0_21 Vdout0_21ck200 = 0 time = 1005
.meas tran vdout0_21ck200 FIND v(dout0_21) AT=1005.025n

* CHECK dout0_22 Vdout0_22ck200 = 0.9 time = 1005
.meas tran vdout0_22ck200 FIND v(dout0_22) AT=1005.025n

* CHECK dout0_23 Vdout0_23ck200 = 0.9 time = 1005
.meas tran vdout0_23ck200 FIND v(dout0_23) AT=1005.025n

* CHECK dout0_24 Vdout0_24ck200 = 0.9 time = 1005
.meas tran vdout0_24ck200 FIND v(dout0_24) AT=1005.025n

* CHECK dout0_25 Vdout0_25ck200 = 0 time = 1005
.meas tran vdout0_25ck200 FIND v(dout0_25) AT=1005.025n

* CHECK dout0_26 Vdout0_26ck200 = 0 time = 1005
.meas tran vdout0_26ck200 FIND v(dout0_26) AT=1005.025n

* CHECK dout0_27 Vdout0_27ck200 = 0 time = 1005
.meas tran vdout0_27ck200 FIND v(dout0_27) AT=1005.025n

* CHECK dout0_28 Vdout0_28ck200 = 0.9 time = 1005
.meas tran vdout0_28ck200 FIND v(dout0_28) AT=1005.025n

* CHECK dout0_29 Vdout0_29ck200 = 0.9 time = 1005
.meas tran vdout0_29ck200 FIND v(dout0_29) AT=1005.025n

* CHECK dout0_30 Vdout0_30ck200 = 0.9 time = 1005
.meas tran vdout0_30ck200 FIND v(dout0_30) AT=1005.025n

* CHECK dout0_31 Vdout0_31ck200 = 0.9 time = 1005
.meas tran vdout0_31ck200 FIND v(dout0_31) AT=1005.025n

* CHECK dout0_32 Vdout0_32ck200 = 0.9 time = 1005
.meas tran vdout0_32ck200 FIND v(dout0_32) AT=1005.025n

* CHECK dout0_33 Vdout0_33ck200 = 0.9 time = 1005
.meas tran vdout0_33ck200 FIND v(dout0_33) AT=1005.025n

* CHECK dout0_34 Vdout0_34ck200 = 0 time = 1005
.meas tran vdout0_34ck200 FIND v(dout0_34) AT=1005.025n

* CHECK dout0_35 Vdout0_35ck200 = 0.9 time = 1005
.meas tran vdout0_35ck200 FIND v(dout0_35) AT=1005.025n

* CHECK dout0_36 Vdout0_36ck200 = 0 time = 1005
.meas tran vdout0_36ck200 FIND v(dout0_36) AT=1005.025n

* CHECK dout0_37 Vdout0_37ck200 = 0 time = 1005
.meas tran vdout0_37ck200 FIND v(dout0_37) AT=1005.025n

* CHECK dout0_38 Vdout0_38ck200 = 0 time = 1005
.meas tran vdout0_38ck200 FIND v(dout0_38) AT=1005.025n

* CHECK dout0_39 Vdout0_39ck200 = 0.9 time = 1005
.meas tran vdout0_39ck200 FIND v(dout0_39) AT=1005.025n

* CHECK dout0_40 Vdout0_40ck200 = 0 time = 1005
.meas tran vdout0_40ck200 FIND v(dout0_40) AT=1005.025n

* CHECK dout0_41 Vdout0_41ck200 = 0 time = 1005
.meas tran vdout0_41ck200 FIND v(dout0_41) AT=1005.025n

* CHECK dout0_42 Vdout0_42ck200 = 0.9 time = 1005
.meas tran vdout0_42ck200 FIND v(dout0_42) AT=1005.025n

* CHECK dout0_43 Vdout0_43ck200 = 0.9 time = 1005
.meas tran vdout0_43ck200 FIND v(dout0_43) AT=1005.025n

* CHECK dout0_44 Vdout0_44ck200 = 0 time = 1005
.meas tran vdout0_44ck200 FIND v(dout0_44) AT=1005.025n

* CHECK dout0_45 Vdout0_45ck200 = 0 time = 1005
.meas tran vdout0_45ck200 FIND v(dout0_45) AT=1005.025n

* CHECK dout0_46 Vdout0_46ck200 = 0 time = 1005
.meas tran vdout0_46ck200 FIND v(dout0_46) AT=1005.025n

* CHECK dout0_47 Vdout0_47ck200 = 0.9 time = 1005
.meas tran vdout0_47ck200 FIND v(dout0_47) AT=1005.025n

* CHECK dout0_48 Vdout0_48ck200 = 0 time = 1005
.meas tran vdout0_48ck200 FIND v(dout0_48) AT=1005.025n

* CHECK dout0_49 Vdout0_49ck200 = 0 time = 1005
.meas tran vdout0_49ck200 FIND v(dout0_49) AT=1005.025n

* CHECK dout0_50 Vdout0_50ck200 = 0.9 time = 1005
.meas tran vdout0_50ck200 FIND v(dout0_50) AT=1005.025n

* CHECK dout0_51 Vdout0_51ck200 = 0 time = 1005
.meas tran vdout0_51ck200 FIND v(dout0_51) AT=1005.025n

* CHECK dout0_52 Vdout0_52ck200 = 0 time = 1005
.meas tran vdout0_52ck200 FIND v(dout0_52) AT=1005.025n

* CHECK dout0_53 Vdout0_53ck200 = 0 time = 1005
.meas tran vdout0_53ck200 FIND v(dout0_53) AT=1005.025n

* CHECK dout0_54 Vdout0_54ck200 = 0 time = 1005
.meas tran vdout0_54ck200 FIND v(dout0_54) AT=1005.025n

* CHECK dout0_55 Vdout0_55ck200 = 0.9 time = 1005
.meas tran vdout0_55ck200 FIND v(dout0_55) AT=1005.025n

* CHECK dout0_56 Vdout0_56ck200 = 0 time = 1005
.meas tran vdout0_56ck200 FIND v(dout0_56) AT=1005.025n

* CHECK dout0_57 Vdout0_57ck200 = 0 time = 1005
.meas tran vdout0_57ck200 FIND v(dout0_57) AT=1005.025n

* CHECK dout0_58 Vdout0_58ck200 = 0 time = 1005
.meas tran vdout0_58ck200 FIND v(dout0_58) AT=1005.025n

* CHECK dout0_59 Vdout0_59ck200 = 0.9 time = 1005
.meas tran vdout0_59ck200 FIND v(dout0_59) AT=1005.025n

* CHECK dout0_60 Vdout0_60ck200 = 0 time = 1005
.meas tran vdout0_60ck200 FIND v(dout0_60) AT=1005.025n

* CHECK dout0_61 Vdout0_61ck200 = 0.9 time = 1005
.meas tran vdout0_61ck200 FIND v(dout0_61) AT=1005.025n

* CHECK dout0_62 Vdout0_62ck200 = 0.9 time = 1005
.meas tran vdout0_62ck200 FIND v(dout0_62) AT=1005.025n

* CHECK dout0_63 Vdout0_63ck200 = 0 time = 1005
.meas tran vdout0_63ck200 FIND v(dout0_63) AT=1005.025n

* CHECK dout0_0 Vdout0_0ck202 = 0 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0.9 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0.9 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 0.9 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0.9 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 0 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 0 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 0.9 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0.9 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0.9 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0.9 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 0.9 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 0 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 0.9 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 0.9 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 0.9 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 0.9 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 0 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 0.9 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 0.9 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 0.9 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 0.9 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_32 Vdout0_32ck202 = 0.9 time = 1015
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=1015.025n

* CHECK dout0_33 Vdout0_33ck202 = 0.9 time = 1015
.meas tran vdout0_33ck202 FIND v(dout0_33) AT=1015.025n

* CHECK dout0_34 Vdout0_34ck202 = 0 time = 1015
.meas tran vdout0_34ck202 FIND v(dout0_34) AT=1015.025n

* CHECK dout0_35 Vdout0_35ck202 = 0.9 time = 1015
.meas tran vdout0_35ck202 FIND v(dout0_35) AT=1015.025n

* CHECK dout0_36 Vdout0_36ck202 = 0 time = 1015
.meas tran vdout0_36ck202 FIND v(dout0_36) AT=1015.025n

* CHECK dout0_37 Vdout0_37ck202 = 0 time = 1015
.meas tran vdout0_37ck202 FIND v(dout0_37) AT=1015.025n

* CHECK dout0_38 Vdout0_38ck202 = 0 time = 1015
.meas tran vdout0_38ck202 FIND v(dout0_38) AT=1015.025n

* CHECK dout0_39 Vdout0_39ck202 = 0.9 time = 1015
.meas tran vdout0_39ck202 FIND v(dout0_39) AT=1015.025n

* CHECK dout0_40 Vdout0_40ck202 = 0 time = 1015
.meas tran vdout0_40ck202 FIND v(dout0_40) AT=1015.025n

* CHECK dout0_41 Vdout0_41ck202 = 0 time = 1015
.meas tran vdout0_41ck202 FIND v(dout0_41) AT=1015.025n

* CHECK dout0_42 Vdout0_42ck202 = 0.9 time = 1015
.meas tran vdout0_42ck202 FIND v(dout0_42) AT=1015.025n

* CHECK dout0_43 Vdout0_43ck202 = 0.9 time = 1015
.meas tran vdout0_43ck202 FIND v(dout0_43) AT=1015.025n

* CHECK dout0_44 Vdout0_44ck202 = 0 time = 1015
.meas tran vdout0_44ck202 FIND v(dout0_44) AT=1015.025n

* CHECK dout0_45 Vdout0_45ck202 = 0 time = 1015
.meas tran vdout0_45ck202 FIND v(dout0_45) AT=1015.025n

* CHECK dout0_46 Vdout0_46ck202 = 0 time = 1015
.meas tran vdout0_46ck202 FIND v(dout0_46) AT=1015.025n

* CHECK dout0_47 Vdout0_47ck202 = 0.9 time = 1015
.meas tran vdout0_47ck202 FIND v(dout0_47) AT=1015.025n

* CHECK dout0_48 Vdout0_48ck202 = 0 time = 1015
.meas tran vdout0_48ck202 FIND v(dout0_48) AT=1015.025n

* CHECK dout0_49 Vdout0_49ck202 = 0 time = 1015
.meas tran vdout0_49ck202 FIND v(dout0_49) AT=1015.025n

* CHECK dout0_50 Vdout0_50ck202 = 0.9 time = 1015
.meas tran vdout0_50ck202 FIND v(dout0_50) AT=1015.025n

* CHECK dout0_51 Vdout0_51ck202 = 0 time = 1015
.meas tran vdout0_51ck202 FIND v(dout0_51) AT=1015.025n

* CHECK dout0_52 Vdout0_52ck202 = 0 time = 1015
.meas tran vdout0_52ck202 FIND v(dout0_52) AT=1015.025n

* CHECK dout0_53 Vdout0_53ck202 = 0 time = 1015
.meas tran vdout0_53ck202 FIND v(dout0_53) AT=1015.025n

* CHECK dout0_54 Vdout0_54ck202 = 0 time = 1015
.meas tran vdout0_54ck202 FIND v(dout0_54) AT=1015.025n

* CHECK dout0_55 Vdout0_55ck202 = 0.9 time = 1015
.meas tran vdout0_55ck202 FIND v(dout0_55) AT=1015.025n

* CHECK dout0_56 Vdout0_56ck202 = 0 time = 1015
.meas tran vdout0_56ck202 FIND v(dout0_56) AT=1015.025n

* CHECK dout0_57 Vdout0_57ck202 = 0 time = 1015
.meas tran vdout0_57ck202 FIND v(dout0_57) AT=1015.025n

* CHECK dout0_58 Vdout0_58ck202 = 0 time = 1015
.meas tran vdout0_58ck202 FIND v(dout0_58) AT=1015.025n

* CHECK dout0_59 Vdout0_59ck202 = 0.9 time = 1015
.meas tran vdout0_59ck202 FIND v(dout0_59) AT=1015.025n

* CHECK dout0_60 Vdout0_60ck202 = 0 time = 1015
.meas tran vdout0_60ck202 FIND v(dout0_60) AT=1015.025n

* CHECK dout0_61 Vdout0_61ck202 = 0.9 time = 1015
.meas tran vdout0_61ck202 FIND v(dout0_61) AT=1015.025n

* CHECK dout0_62 Vdout0_62ck202 = 0.9 time = 1015
.meas tran vdout0_62ck202 FIND v(dout0_62) AT=1015.025n

* CHECK dout0_63 Vdout0_63ck202 = 0 time = 1015
.meas tran vdout0_63ck202 FIND v(dout0_63) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 1020
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=1020.025n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 1020
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=1020.025n

* CHECK dout0_2 Vdout0_2ck203 = 0 time = 1020
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=1020.025n

* CHECK dout0_3 Vdout0_3ck203 = 0.9 time = 1020
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=1020.025n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 1020
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=1020.025n

* CHECK dout0_5 Vdout0_5ck203 = 0.9 time = 1020
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=1020.025n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 1020
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=1020.025n

* CHECK dout0_7 Vdout0_7ck203 = 0 time = 1020
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=1020.025n

* CHECK dout0_8 Vdout0_8ck203 = 0.9 time = 1020
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=1020.025n

* CHECK dout0_9 Vdout0_9ck203 = 0 time = 1020
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=1020.025n

* CHECK dout0_10 Vdout0_10ck203 = 0.9 time = 1020
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=1020.025n

* CHECK dout0_11 Vdout0_11ck203 = 0.9 time = 1020
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=1020.025n

* CHECK dout0_12 Vdout0_12ck203 = 0.9 time = 1020
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=1020.025n

* CHECK dout0_13 Vdout0_13ck203 = 0.9 time = 1020
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=1020.025n

* CHECK dout0_14 Vdout0_14ck203 = 0.9 time = 1020
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=1020.025n

* CHECK dout0_15 Vdout0_15ck203 = 0 time = 1020
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=1020.025n

* CHECK dout0_16 Vdout0_16ck203 = 0.9 time = 1020
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=1020.025n

* CHECK dout0_17 Vdout0_17ck203 = 0 time = 1020
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=1020.025n

* CHECK dout0_18 Vdout0_18ck203 = 0 time = 1020
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=1020.025n

* CHECK dout0_19 Vdout0_19ck203 = 0.9 time = 1020
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=1020.025n

* CHECK dout0_20 Vdout0_20ck203 = 0.9 time = 1020
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=1020.025n

* CHECK dout0_21 Vdout0_21ck203 = 0.9 time = 1020
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=1020.025n

* CHECK dout0_22 Vdout0_22ck203 = 0 time = 1020
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=1020.025n

* CHECK dout0_23 Vdout0_23ck203 = 0.9 time = 1020
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=1020.025n

* CHECK dout0_24 Vdout0_24ck203 = 0.9 time = 1020
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=1020.025n

* CHECK dout0_25 Vdout0_25ck203 = 0.9 time = 1020
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=1020.025n

* CHECK dout0_26 Vdout0_26ck203 = 0 time = 1020
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=1020.025n

* CHECK dout0_27 Vdout0_27ck203 = 0 time = 1020
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=1020.025n

* CHECK dout0_28 Vdout0_28ck203 = 0.9 time = 1020
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=1020.025n

* CHECK dout0_29 Vdout0_29ck203 = 0.9 time = 1020
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=1020.025n

* CHECK dout0_30 Vdout0_30ck203 = 0 time = 1020
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=1020.025n

* CHECK dout0_31 Vdout0_31ck203 = 0.9 time = 1020
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=1020.025n

* CHECK dout0_32 Vdout0_32ck203 = 0 time = 1020
.meas tran vdout0_32ck203 FIND v(dout0_32) AT=1020.025n

* CHECK dout0_33 Vdout0_33ck203 = 0 time = 1020
.meas tran vdout0_33ck203 FIND v(dout0_33) AT=1020.025n

* CHECK dout0_34 Vdout0_34ck203 = 0.9 time = 1020
.meas tran vdout0_34ck203 FIND v(dout0_34) AT=1020.025n

* CHECK dout0_35 Vdout0_35ck203 = 0 time = 1020
.meas tran vdout0_35ck203 FIND v(dout0_35) AT=1020.025n

* CHECK dout0_36 Vdout0_36ck203 = 0.9 time = 1020
.meas tran vdout0_36ck203 FIND v(dout0_36) AT=1020.025n

* CHECK dout0_37 Vdout0_37ck203 = 0.9 time = 1020
.meas tran vdout0_37ck203 FIND v(dout0_37) AT=1020.025n

* CHECK dout0_38 Vdout0_38ck203 = 0.9 time = 1020
.meas tran vdout0_38ck203 FIND v(dout0_38) AT=1020.025n

* CHECK dout0_39 Vdout0_39ck203 = 0.9 time = 1020
.meas tran vdout0_39ck203 FIND v(dout0_39) AT=1020.025n

* CHECK dout0_40 Vdout0_40ck203 = 0.9 time = 1020
.meas tran vdout0_40ck203 FIND v(dout0_40) AT=1020.025n

* CHECK dout0_41 Vdout0_41ck203 = 0 time = 1020
.meas tran vdout0_41ck203 FIND v(dout0_41) AT=1020.025n

* CHECK dout0_42 Vdout0_42ck203 = 0.9 time = 1020
.meas tran vdout0_42ck203 FIND v(dout0_42) AT=1020.025n

* CHECK dout0_43 Vdout0_43ck203 = 0.9 time = 1020
.meas tran vdout0_43ck203 FIND v(dout0_43) AT=1020.025n

* CHECK dout0_44 Vdout0_44ck203 = 0.9 time = 1020
.meas tran vdout0_44ck203 FIND v(dout0_44) AT=1020.025n

* CHECK dout0_45 Vdout0_45ck203 = 0 time = 1020
.meas tran vdout0_45ck203 FIND v(dout0_45) AT=1020.025n

* CHECK dout0_46 Vdout0_46ck203 = 0 time = 1020
.meas tran vdout0_46ck203 FIND v(dout0_46) AT=1020.025n

* CHECK dout0_47 Vdout0_47ck203 = 0 time = 1020
.meas tran vdout0_47ck203 FIND v(dout0_47) AT=1020.025n

* CHECK dout0_48 Vdout0_48ck203 = 0 time = 1020
.meas tran vdout0_48ck203 FIND v(dout0_48) AT=1020.025n

* CHECK dout0_49 Vdout0_49ck203 = 0 time = 1020
.meas tran vdout0_49ck203 FIND v(dout0_49) AT=1020.025n

* CHECK dout0_50 Vdout0_50ck203 = 0 time = 1020
.meas tran vdout0_50ck203 FIND v(dout0_50) AT=1020.025n

* CHECK dout0_51 Vdout0_51ck203 = 0 time = 1020
.meas tran vdout0_51ck203 FIND v(dout0_51) AT=1020.025n

* CHECK dout0_52 Vdout0_52ck203 = 0.9 time = 1020
.meas tran vdout0_52ck203 FIND v(dout0_52) AT=1020.025n

* CHECK dout0_53 Vdout0_53ck203 = 0 time = 1020
.meas tran vdout0_53ck203 FIND v(dout0_53) AT=1020.025n

* CHECK dout0_54 Vdout0_54ck203 = 0.9 time = 1020
.meas tran vdout0_54ck203 FIND v(dout0_54) AT=1020.025n

* CHECK dout0_55 Vdout0_55ck203 = 0.9 time = 1020
.meas tran vdout0_55ck203 FIND v(dout0_55) AT=1020.025n

* CHECK dout0_56 Vdout0_56ck203 = 0 time = 1020
.meas tran vdout0_56ck203 FIND v(dout0_56) AT=1020.025n

* CHECK dout0_57 Vdout0_57ck203 = 0 time = 1020
.meas tran vdout0_57ck203 FIND v(dout0_57) AT=1020.025n

* CHECK dout0_58 Vdout0_58ck203 = 0.9 time = 1020
.meas tran vdout0_58ck203 FIND v(dout0_58) AT=1020.025n

* CHECK dout0_59 Vdout0_59ck203 = 0 time = 1020
.meas tran vdout0_59ck203 FIND v(dout0_59) AT=1020.025n

* CHECK dout0_60 Vdout0_60ck203 = 0 time = 1020
.meas tran vdout0_60ck203 FIND v(dout0_60) AT=1020.025n

* CHECK dout0_61 Vdout0_61ck203 = 0 time = 1020
.meas tran vdout0_61ck203 FIND v(dout0_61) AT=1020.025n

* CHECK dout0_62 Vdout0_62ck203 = 0 time = 1020
.meas tran vdout0_62ck203 FIND v(dout0_62) AT=1020.025n

* CHECK dout0_63 Vdout0_63ck203 = 0 time = 1020
.meas tran vdout0_63ck203 FIND v(dout0_63) AT=1020.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
