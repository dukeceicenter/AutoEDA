* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_32x120.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_32x120 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 din0_80 din0_81 din0_82 din0_83 din0_84 din0_85 din0_86 din0_87 din0_88 din0_89 din0_90 din0_91 din0_92 din0_93 din0_94 din0_95 din0_96 din0_97 din0_98 din0_99 din0_100 din0_101 din0_102 din0_103 din0_104 din0_105 din0_106 din0_107 din0_108 din0_109 din0_110 din0_111 din0_112 din0_113 din0_114 din0_115 din0_116 din0_117 din0_118 din0_119 a0_0 a0_1 a0_2 a0_3 a0_4 a1_0 a1_1 a1_2 a1_3 a1_4 CSB0 CSB1 clk0 clk1 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 dout1_72 dout1_73 dout1_74 dout1_75 dout1_76 dout1_77 dout1_78 dout1_79 dout1_80 dout1_81 dout1_82 dout1_83 dout1_84 dout1_85 dout1_86 dout1_87 dout1_88 dout1_89 dout1_90 dout1_91 dout1_92 dout1_93 dout1_94 dout1_95 dout1_96 dout1_97 dout1_98 dout1_99 dout1_100 dout1_101 dout1_102 dout1_103 dout1_104 dout1_105 dout1_106 dout1_107 dout1_108 dout1_109 dout1_110 dout1_111 dout1_112 dout1_113 dout1_114 dout1_115 dout1_116 dout1_117 dout1_118 dout1_119 vdd gnd freepdk45_sram_1w1r_32x120

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f
CD164 dout1_64  0 0.8364f
CD165 dout1_65  0 0.8364f
CD166 dout1_66  0 0.8364f
CD167 dout1_67  0 0.8364f
CD168 dout1_68  0 0.8364f
CD169 dout1_69  0 0.8364f
CD170 dout1_70  0 0.8364f
CD171 dout1_71  0 0.8364f
CD172 dout1_72  0 0.8364f
CD173 dout1_73  0 0.8364f
CD174 dout1_74  0 0.8364f
CD175 dout1_75  0 0.8364f
CD176 dout1_76  0 0.8364f
CD177 dout1_77  0 0.8364f
CD178 dout1_78  0 0.8364f
CD179 dout1_79  0 0.8364f
CD180 dout1_80  0 0.8364f
CD181 dout1_81  0 0.8364f
CD182 dout1_82  0 0.8364f
CD183 dout1_83  0 0.8364f
CD184 dout1_84  0 0.8364f
CD185 dout1_85  0 0.8364f
CD186 dout1_86  0 0.8364f
CD187 dout1_87  0 0.8364f
CD188 dout1_88  0 0.8364f
CD189 dout1_89  0 0.8364f
CD190 dout1_90  0 0.8364f
CD191 dout1_91  0 0.8364f
CD192 dout1_92  0 0.8364f
CD193 dout1_93  0 0.8364f
CD194 dout1_94  0 0.8364f
CD195 dout1_95  0 0.8364f
CD196 dout1_96  0 0.8364f
CD197 dout1_97  0 0.8364f
CD198 dout1_98  0 0.8364f
CD199 dout1_99  0 0.8364f
CD1100 dout1_100  0 0.8364f
CD1101 dout1_101  0 0.8364f
CD1102 dout1_102  0 0.8364f
CD1103 dout1_103  0 0.8364f
CD1104 dout1_104  0 0.8364f
CD1105 dout1_105  0 0.8364f
CD1106 dout1_106  0 0.8364f
CD1107 dout1_107  0 0.8364f
CD1108 dout1_108  0 0.8364f
CD1109 dout1_109  0 0.8364f
CD1110 dout1_110  0 0.8364f
CD1111 dout1_111  0 0.8364f
CD1112 dout1_112  0 0.8364f
CD1113 dout1_113  0 0.8364f
CD1114 dout1_114  0 0.8364f
CD1115 dout1_115  0 0.8364f
CD1116 dout1_116  0 0.8364f
CD1117 dout1_117  0 0.8364f
CD1118 dout1_118  0 0.8364f
CD1119 dout1_119  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_32x120.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_32x120.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_32x120.s_en
* q:	xfreepdk45_sram_1w1r_32x120.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_32x120.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 111111011010000010010101111000001111011011111011001101000010011111101010010101110100100100101011001110101101101111010011  to  address 00000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 010001111111001011111100001111000111001110010010100110001010111001101001110001011100100101001001111010100111100110010011  to  address 11110 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 010011001111000001011110010100001101110111001110111111010110011111001110111001111100110001001101001011011101010100010101  to  address 11110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 010011001111000001011110010100001101110111001110111111010110011111001110111001111100110001001101001011011101010100010101 from address 11110 (from port 1) during cycle 4 (20ns - 25ns)
*	Reading 010011001111000001011110010100001101110111001110111111010110011111001110111001111100110001001101001011011101010100010101 from address 11110 (from port 1) during cycle 5 (25ns - 30ns)
*	Reading 111111011010000010010101111000001111011011111011001101000010011111101010010101110100100100101011001110101101101111010011 from address 00000 (from port 1) during cycle 6 (30ns - 35ns)
*	Reading 010011001111000001011110010100001101110111001110111111010110011111001110111001111100110001001101001011011101010100010101 from address 11110 (from port 1) during cycle 8 (40ns - 45ns)
*	Writing 001001110101110110111110111111110110000111110101011111100011101110100110110000000011101101011000010001010000101010111111  to  address 11110 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing 000001100010010000101000000000001110010111000010000000011100000111010100000010001011100100001001011100101100111111100111  to  address 00000 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 000001100010010000101000000000001110010111000010000000011100000111010100000010001011100100001001011100101100111111100111 from address 00000 (from port 1) during cycle 11 (55ns - 60ns)
*	Writing 010001011100011110011011011010010111010011000010100011111000011110100000111011110011111011000101111111010110000011011110  to  address 00000 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 010001011100011110011011011010010111010011000010100011111000011110100000111011110011111011000101111111010110000011011110 from address 00000 (from port 1) during cycle 15 (75ns - 80ns)
*	Writing 011110100101110011010001101111101011010110100010101111010011001010111010111101000010101000001011010110101010110111101101  to  address 11110 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 010001011100011110011011011010010111010011000010100011111000011110100000111011110011111011000101111111010110000011011110 from address 00000 (from port 1) during cycle 19 (95ns - 100ns)
*	Writing 011010010011111101001001000101010001111101000101111011010111000110111111111011100001011100100010000000100010111000011100  to  address 00000 (from port 0) during cycle 20 (100ns - 105ns)
*	Writing 100000111100100111110110011110001111001011011001111101001111011101010011111101010111011000111111010100100001000011110111  to  address 11110 (from port 0) during cycle 21 (105ns - 110ns)
*	Writing 001011010011111001111010100011011000001001101100110001101011010010101100011110101011111111001100111001100101100011001011  to  address 00000 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 001011010011111001111010100011011000001001101100110001101011010010101100011110101011111111001100111001100101100011001011 from address 00000 (from port 1) during cycle 24 (120ns - 125ns)
*	Reading 100000111100100111110110011110001111001011011001111101001111011101010011111101010111011000111111010100100001000011110111 from address 11110 (from port 1) during cycle 25 (125ns - 130ns)
*	Reading 100000111100100111110110011110001111001011011001111101001111011101010011111101010111011000111111010100100001000011110111 from address 11110 (from port 1) during cycle 26 (130ns - 135ns)
*	Writing 011011001001100001100001001010110110011010101111011010101100000010111010111100100110001010110000111101001110001101100100  to  address 11110 (from port 0) during cycle 27 (135ns - 140ns)
*	Writing 010000100110110000001110000000010011110110010110001101100010000110110100101000100001010100010010100110011100100101100110  to  address 00000 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 011011001001100001100001001010110110011010101111011010101100000010111010111100100110001010110000111101001110001101100100 from address 11110 (from port 1) during cycle 29 (145ns - 150ns)
*	Writing 001110100011111101010001000111001001110001011111010000111001110111101111011000010101011001000011110110100100100101001100  to  address 11110 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 010000100110110000001110000000010011110110010110001101100010000110110100101000100001010100010010100110011100100101100110 from address 00000 (from port 1) during cycle 31 (155ns - 160ns)
*	Reading 001110100011111101010001000111001001110001011111010000111001110111101111011000010101011001000011110110100100100101001100 from address 11110 (from port 1) during cycle 33 (165ns - 170ns)
*	Writing 100001110000100110111000111100100001001011101111011110000101110111011101011111011010101111100100111001110100101111110111  to  address 11110 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing 111010001111010011100010000110010000100000101110011000011110011111110110101011101010001101110011011110111100100010011000  to  address 11110 (from port 0) during cycle 35 (175ns - 180ns)
*	Reading 010000100110110000001110000000010011110110010110001101100010000110110100101000100001010100010010100110011100100101100110 from address 00000 (from port 1) during cycle 35 (175ns - 180ns)
*	Reading 111010001111010011100010000110010000100000101110011000011110011111110110101011101010001101110011011110111100100010011000 from address 11110 (from port 1) during cycle 36 (180ns - 185ns)
*	Reading 010000100110110000001110000000010011110110010110001101100010000110110100101000100001010100010010100110011100100101100110 from address 00000 (from port 1) during cycle 38 (190ns - 195ns)
*	Reading 010000100110110000001110000000010011110110010110001101100010000110110100101000100001010100010010100110011100100101100110 from address 00000 (from port 1) during cycle 40 (200ns - 205ns)
*	Writing 001110100111010001010000001101011110000101101000101001010000110110000001111100111111000100100000000010010001110000100000  to  address 11110 (from port 0) during cycle 41 (205ns - 210ns)
*	Writing 001100110011110000011011001101011011111010000100101000011001100011010100100011101000000111101110000100010111011001001001  to  address 00000 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing 110111111100110110000000001000101011000100001001111110011110011101000011101001000001000100110111000101110100010101111010  to  address 11110 (from port 0) during cycle 43 (215ns - 220ns)
*	Reading 001100110011110000011011001101011011111010000100101000011001100011010100100011101000000111101110000100010111011001001001 from address 00000 (from port 1) during cycle 43 (215ns - 220ns)
*	Writing 111010110000100101110100010110011100110111101100100100010110011010110001011111110111001110101011000101011101001100001001  to  address 00000 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing 111110111101000011011101000011011001011011010011111001010000000111111110101101010100110111110110011001110111100110000010  to  address 00000 (from port 0) during cycle 46 (230ns - 235ns)
*	Writing 000110111000001100111111001000100011101011110011100010111110110010010001100000000000001110001111011011000100010001110011  to  address 11110 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 110101101010101101000000110101011100001100010001101101101100110011101011111111001100011010011000000101010111101011000000  to  address 11110 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 111110111101000011011101000011011001011011010011111001010000000111111110101101010100110111110110011001110111100110000010 from address 00000 (from port 1) during cycle 49 (245ns - 250ns)
*	Writing 101110011001110011011010010011101000100110110110101101001110011001111100110111100100001111011111011110001100100111111111  to  address 00000 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 110101101010101101000000110101011100001100010001101101101100110011101011111111001100011010011000000101010111101011000000 from address 11110 (from port 1) during cycle 55 (275ns - 280ns)
*	Writing 010000101111110000001101010110000111100010101011110100001100100101010111011100110000010101001111100011111001111001001101  to  address 00000 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 000111000111110101110111010111011000101100111111001001001010010001000001000111010011101000101010001111011000011101100101  to  address 00000 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 001000101101010010001011010010110100110011000001111110110111000101110001110111000101000111000000010001110001110010101111  to  address 11110 (from port 0) during cycle 61 (305ns - 310ns)
*	Writing 011110100001001010111010001001011001011101111110111101111010001000001101010110111101110111111110011010100000111000111001  to  address 11110 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 101000001010100111100001001110101001010111110110001111110100101110010110101110001100101000010100000011010010110011100110  to  address 11110 (from port 0) during cycle 63 (315ns - 320ns)
*	Reading 000111000111110101110111010111011000101100111111001001001010010001000001000111010011101000101010001111011000011101100101 from address 00000 (from port 1) during cycle 64 (320ns - 325ns)
*	Writing 001101111101110101010010111101011110001010011111010001010000101011010101110100100100110101011011110110111011100011100011  to  address 11110 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 001101111101110101010010111101011110001010011111010001010000101011010101110100100100110101011011110110111011100011100011 from address 11110 (from port 1) during cycle 68 (340ns - 345ns)
*	Writing 010111001110000011001101111111011110011100111011010011010100110101011011100100110110111000000011111010101100010110011010  to  address 00000 (from port 0) during cycle 69 (345ns - 350ns)
*	Writing 101101110000000011011011010111111011011111110101001110100010011100110000010010011001111011100011111110101110110101011010  to  address 00000 (from port 0) during cycle 71 (355ns - 360ns)
*	Writing 110001101100110110111110100001100101110111111011000010110101000010111001001000111011100101100111001010111100110011110011  to  address 00000 (from port 0) during cycle 72 (360ns - 365ns)
*	Reading 001101111101110101010010111101011110001010011111010001010000101011010101110100100100110101011011110110111011100011100011 from address 11110 (from port 1) during cycle 73 (365ns - 370ns)
*	Writing 111101010010110110100100111000110000111101001110101010000000110011011010111000100011110011010001010000101000110111110100  to  address 11110 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 110001101100110110111110100001100101110111111011000010110101000010111001001000111011100101100111001010111100110011110011 from address 00000 (from port 1) during cycle 74 (370ns - 375ns)
*	Reading 110001101100110110111110100001100101110111111011000010110101000010111001001000111011100101100111001010111100110011110011 from address 00000 (from port 1) during cycle 75 (375ns - 380ns)
*	Writing 000101100001111001011010100001100001111110111011111110001100111001011000000010110100000010001111010001100111000001100101  to  address 00000 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 000101100001111001011010100001100001111110111011111110001100111001011000000010110100000010001111010001100111000001100101 from address 00000 (from port 1) during cycle 77 (385ns - 390ns)
*	Writing 000111101001110101101010010110110011010111110000111110010100001101111111110000000011110111110100000011111001001011000100  to  address 11110 (from port 0) during cycle 79 (395ns - 400ns)
*	Writing 101110110000001000010100100011011101101011010000000000110110110111110110011010000110011101110000110000011000000111101000  to  address 00000 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 101110110000001000010100100011011101101011010000000000110110110111110110011010000110011101110000110000011000000111101000 from address 00000 (from port 1) during cycle 83 (415ns - 420ns)
*	Reading 000111101001110101101010010110110011010111110000111110010100001101111111110000000011110111110100000011111001001011000100 from address 11110 (from port 1) during cycle 84 (420ns - 425ns)
*	Writing 000111001000001110111001001010101001001111101011001000111111110100101100100010011000010001011011010100101101000111100101  to  address 11110 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 101110110000001000010100100011011101101011010000000000110110110111110110011010000110011101110000110000011000000111101000 from address 00000 (from port 1) during cycle 87 (435ns - 440ns)
*	Writing 100011000110000000100101010010111111100111010100010110001111001001010110000011001101110001101100110001001110000010101000  to  address 11110 (from port 0) during cycle 88 (440ns - 445ns)
*	Writing 010111110001100001100000010110010000111000001000101111101001110111110011111001111110111000001111101111101011010110010111  to  address 00000 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 100011000110000000100101010010111111100111010100010110001111001001010110000011001101110001101100110001001110000010101000 from address 11110 (from port 1) during cycle 89 (445ns - 450ns)
*	Writing 011101110001111110101111011111110101010100010000100100000110101101000101000100011100111010100101011100011101110010000011  to  address 00000 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 010101001001001111000100001000110111001010001110101001011101001100010010011100010000100101100110110011101011000011001011  to  address 11110 (from port 0) during cycle 91 (455ns - 460ns)
*	Writing 010110001000010010110110011011100000011010000110100010001100100110000111100010111111111000101010011010100101101001100000  to  address 00000 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 010101001001001111000100001000110111001010001110101001011101001100010010011100010000100101100110110011101011000011001011 from address 11110 (from port 1) during cycle 94 (470ns - 475ns)
*	Writing 000011010110011111110100101010111101100100111001000010011110011101000101111101100011101101011000101101100100110010010101  to  address 11110 (from port 0) during cycle 95 (475ns - 480ns)
*	Writing 111110101001110111010101101011001001001010011110101000001100101001000101001100011110001001000110010101110011010110000000  to  address 00000 (from port 0) during cycle 96 (480ns - 485ns)
*	Writing 111011010000011111010010000011101100010110011101111110101101010100110010100001100010100011011001010110101000100001010001  to  address 00000 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 010000111100011001100110110101000000010000011001010001100100000110001101011110010011011101000100000110110111111111101111  to  address 11110 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 111011010000011111010010000011101100010110011101111110101101010100110010100001100010100011011001010110101000100001010001 from address 00000 (from port 1) during cycle 101 (505ns - 510ns)
*	Writing 001100111001101110010000001011011011101010010101101011000000000111001101101100010011011100010000110111100110001001111001  to  address 00000 (from port 0) during cycle 102 (510ns - 515ns)
*	Writing 011100110100000111011000010111001111101110101110010101110101101001101111010110000011111011110111101111100110010011000101  to  address 11110 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 001100111001101110010000001011011011101010010101101011000000000111001101101100010011011100010000110111100110001001111001 from address 00000 (from port 1) during cycle 104 (520ns - 525ns)
*	Writing 101011110000110001101010101010110100100100001101001000101101001111111110011010000001100000110010000010001100110101100001  to  address 11110 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 101011110000110001101010101010110100100100001101001000101101001111111110011010000001100000110010000010001100110101100001 from address 11110 (from port 1) during cycle 109 (545ns - 550ns)
*	Writing 011010111111111000000101111101001011010110101001011000111101011111101001011111101010100000111000111000110001101010101110  to  address 00000 (from port 0) during cycle 112 (560ns - 565ns)
*	Writing 101110100100011011100101101010110110101011010101100100010011010001110011100101101111111000011010110100110110011100001001  to  address 11110 (from port 0) during cycle 114 (570ns - 575ns)
*	Writing 000100010101001111100111011111111011111110010110000001010001111010011110010110000110111111001011101101100011001110110011  to  address 11110 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 010000100100101010101001010010110010101111001010010000011111100100110111001110001011100100000000001110100000111101001010  to  address 11110 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 011110001001011111011011100010010101000011100111101100111011110111110101001110111111110011111001110110110000101001010111  to  address 00000 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 010000100100101010101001010010110010101111001010010000011111100100110111001110001011100100000000001110100000111101001010 from address 11110 (from port 1) during cycle 117 (585ns - 590ns)
*	Writing 111001110110011001010111111010001000101101110010001110110101000001101111110011110000011111010110111010001001100111110001  to  address 00000 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 111001110110011001010111111010001000101101110010001110110101000001101111110011110000011111010110111010001001100111110001 from address 00000 (from port 1) during cycle 119 (595ns - 600ns)
*	Writing 001101101100000110000011110010101101110011110110100101001001111101010000111101101010111110110110011010010110101000000100  to  address 00000 (from port 0) during cycle 120 (600ns - 605ns)
*	Writing 010111001110101110001000101111001000000010111000111111100101001011001000011100000101100000101000000010010010001010111000  to  address 00000 (from port 0) during cycle 121 (605ns - 610ns)
*	Writing 100110001111001101000110110000010100011101010110101111111001011011001010111111111001001001000010101110001000001011011100  to  address 11110 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing 111011010010001011111010101011000001111101010000000111110010111001100101110101011010010101111001101010000000001000000101  to  address 00000 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing 001011100101110101001100011011010100110011111110011001001100110101101010010001010110110110001100000100011001011011100111  to  address 11110 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 110000110101111100110110100011100110000110110011100110100110000111110101101001111101110111001011111010101000011011011011  to  address 00000 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 001011100101110101001100011011010100110011111110011001001100110101101010010001010110110110001100000100011001011011100111 from address 11110 (from port 1) during cycle 127 (635ns - 640ns)
*	Writing 001110000001101011100101010100111000100011111011111101010000011010111101000110111011111000110101110101110110010101100000  to  address 11110 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 110000110101111100110110100011100110000110110011100110100110000111110101101001111101110111001011111010101000011011011011 from address 00000 (from port 1) during cycle 129 (645ns - 650ns)
*	Writing 001110011111000110101000111100000111011111010001010110111101010111010011001000111110100011011000001000000010010011000100  to  address 11110 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing 000110010110001010111101100011010001011100111000111100110101010100010111100101000011011101010111100110000100010100100001  to  address 11110 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 110000110101111100110110100011100110000110110011100110100110000111110101101001111101110111001011111010101000011011011011 from address 00000 (from port 1) during cycle 132 (660ns - 665ns)
*	Writing 010111110100101101011011011110001111110000100110000111000101010000110110001010000010010011111011100100111111110100100010  to  address 00000 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing 101011011111110001111111011011010010000111110101110011101110110101111101111111101101010110100101101110100111101101111110  to  address 11110 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 010111110100101101011011011110001111110000100110000111000101010000110110001010000010010011111011100100111111110100100010 from address 00000 (from port 1) during cycle 134 (670ns - 675ns)
*	Writing 001010101001110101111100110111001000100001010000111111111000011011110111101011011010111001100101001101100101011000100111  to  address 11110 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 010111110100101101011011011110001111110000100110000111000101010000110110001010000010010011111011100100111111110100100010 from address 00000 (from port 1) during cycle 135 (675ns - 680ns)
*	Writing 010101011010111111010110010101000010111011101101011010001010110110000000011100101010110110111001001100000001000010100101  to  address 00000 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 001010101001110101111100110111001000100001010000111111111000011011110111101011011010111001100101001101100101011000100111 from address 11110 (from port 1) during cycle 137 (685ns - 690ns)
*	Writing 010110011000011001111110010111000010110000010101111110001110100000001010100111000010000100000010011011110101011111000100  to  address 11110 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 010101111000111010001101110110100011000101010101011010001001011111100011101000101111110001010010000010000000010111101010  to  address 11110 (from port 0) during cycle 140 (700ns - 705ns)
*	Writing 010110111010000010001101001000101011001101110100101110010111110000011011010000011010110010000111010001100001010001101001  to  address 11110 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 000101010000110101010111001011110011110000000011011110110111010111001111101000001001011100100000101011011001111100010000  to  address 00000 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 111111111010110110100101010010011001110000110000011010111001100111101101000001001110011111010011100011110010011011001110  to  address 00000 (from port 0) during cycle 145 (725ns - 730ns)
*	Reading 010110111010000010001101001000101011001101110100101110010111110000011011010000011010110010000111010001100001010001101001 from address 11110 (from port 1) during cycle 146 (730ns - 735ns)
*	Writing 001011110010000100101010010010100111100111000001011000100111001001000101011000011000000011010011011101101000110000111001  to  address 11110 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 001011110010000100101010010010100111100111000001011000100111001001000101011000011000000011010011011101101000110000111001 from address 11110 (from port 1) during cycle 148 (740ns - 745ns)
*	Writing 011110000110111011000110100100010100111101111000000101111000011100011110111000000010011110011010000110001101010110011111  to  address 00000 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 010111111011000001100111011100010101011100000011110000100011100000100011010000100000111001100100000111101000111101100000  to  address 11110 (from port 0) during cycle 150 (750ns - 755ns)
*	Writing 100110000000111011001101010111011001001111101101011010011000000011100000000000011110100110111011011100101010110001011111  to  address 00000 (from port 0) during cycle 151 (755ns - 760ns)
*	Writing 001010011000011101011101011100001010010110001001101110010001101010011011101011001111011100010101010000101011011100100011  to  address 11110 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 100110000000111011001101010111011001001111101101011010011000000011100000000000011110100110111011011100101010110001011111 from address 00000 (from port 1) during cycle 152 (760ns - 765ns)
*	Writing 001100011010001101000010001001000011110101101000110011011101110001011110010001110110001011011111010010011111101110001010  to  address 11110 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 100110000000111011001101010111011001001111101101011010011000000011100000000000011110100110111011011100101010110001011111 from address 00000 (from port 1) during cycle 153 (765ns - 770ns)
*	Writing 110101000010111100101011110110101111110101000100000101000001010100111001011000101000100010001001000110110000100000100011  to  address 00000 (from port 0) during cycle 154 (770ns - 775ns)
*	Reading 001100011010001101000010001001000011110101101000110011011101110001011110010001110110001011011111010010011111101110001010 from address 11110 (from port 1) during cycle 154 (770ns - 775ns)
*	Reading 001100011010001101000010001001000011110101101000110011011101110001011110010001110110001011011111010010011111101110001010 from address 11110 (from port 1) during cycle 155 (775ns - 780ns)
*	Writing 010010101001111100000010110101100110101100101011010001010000110111111010010011000110011010001100010101100000110001010100  to  address 11110 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 110101000010111100101011110110101111110101000100000101000001010100111001011000101000100010001001000110110000100000100011 from address 00000 (from port 1) during cycle 156 (780ns - 785ns)
*	Reading 010010101001111100000010110101100110101100101011010001010000110111111010010011000110011010001100010101100000110001010100 from address 11110 (from port 1) during cycle 157 (785ns - 790ns)
*	Reading 010010101001111100000010110101100110101100101011010001010000110111111010010011000110011010001100010101100000110001010100 from address 11110 (from port 1) during cycle 158 (790ns - 795ns)
*	Writing 111110000011101010010111111011101001101100111011100010100010010110000100101000001100101110100000010110100100000110011100  to  address 00000 (from port 0) during cycle 159 (795ns - 800ns)
*	Writing 001001000010001000010010111100011111010010110000000100010000110111101110111111001010001010000101011001011111000000011111  to  address 00000 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 010010101001111100000010110101100110101100101011010001010000110111111010010011000110011010001100010101100000110001010100 from address 11110 (from port 1) during cycle 162 (810ns - 815ns)
*	Writing 010011110011110110001001101110110111111010111100110011101011000001001001100110001011111011111101100001100001010100010010  to  address 11110 (from port 0) during cycle 163 (815ns - 820ns)
*	Writing 001101100101101001001110001000101111101010110110000011001110011011110110001001011100000010110000111110101111000000100100  to  address 00000 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 001101100101101001001110001000101111101010110110000011001110011011110110001001011100000010110000111110101111000000100100 from address 00000 (from port 1) during cycle 166 (830ns - 835ns)
*	Writing 100010000001011111110001000000001101100010011111001000010110000011111101000000110110010001011000001001110111010010011100  to  address 00000 (from port 0) during cycle 167 (835ns - 840ns)
*	Reading 010011110011110110001001101110110111111010111100110011101011000001001001100110001011111011111101100001100001010100010010 from address 11110 (from port 1) during cycle 167 (835ns - 840ns)
*	Writing 100001101111010010101111000010111110101010101100011011001010101111101000100001011101101101010011011000111001001001000000  to  address 00000 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 010011110011110110001001101110110111111010111100110011101011000001001001100110001011111011111101100001100001010100010010 from address 11110 (from port 1) during cycle 168 (840ns - 845ns)
*	Writing 000011001000000101110001010011000100110111100001011011100100011001010011111011011011110001000111100100111101001000111010  to  address 11110 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 100001101111010010101111000010111110101010101100011011001010101111101000100001011101101101010011011000111001001001000000 from address 00000 (from port 1) during cycle 172 (860ns - 865ns)
*	Reading 100001101111010010101111000010111110101010101100011011001010101111101000100001011101101101010011011000111001001001000000 from address 00000 (from port 1) during cycle 173 (865ns - 870ns)
*	Writing 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100  to  address 11110 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 100001101111010010101111000010111110101010101100011011001010101111101000100001011101101101010011011000111001001001000000 from address 00000 (from port 1) during cycle 176 (880ns - 885ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 177 (885ns - 890ns)
*	Writing 101110010110000100100110000000001110000110000110100001111101000100100000010101101111100110001000110100100110100001010110  to  address 00000 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 110110111001000111010000001101001011111101011011111100101000100101100001001111001100011000010101110100100010100101101101  to  address 00000 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 110110111001000111010000001101001011111101011011111100101000100101100001001111001100011000010101110100100010100101101101 from address 00000 (from port 1) during cycle 180 (900ns - 905ns)
*	Writing 001101000111001111010110011101011011001010101100010101000111100011000110011111010111011100001010000000001010100101110111  to  address 00000 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 101101110000100110010010000000100111011000111011000111001001101011110000001111011010100101110001101001011001111101100101  to  address 00000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 101101110000100110010010000000100111011000111011000111001001101011110000001111011010100101110001101001011001111101100101 from address 00000 (from port 1) during cycle 183 (915ns - 920ns)
*	Writing 010101010000000010010100110110100101010001010001001000000001001001110010111001011100110001111010000010010101010000010111  to  address 00000 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 185 (925ns - 930ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 187 (935ns - 940ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 189 (945ns - 950ns)
*	Writing 011011001111101010111000111001100010001110110001111100100111000010001101110110111100001111011111000010111010111001110000  to  address 00000 (from port 0) during cycle 190 (950ns - 955ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 190 (950ns - 955ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 192 (960ns - 965ns)
*	Reading 011011001111101010111000111001100010001110110001111100100111000010001101110110111100001111011111000010111010111001110000 from address 00000 (from port 1) during cycle 194 (970ns - 975ns)
*	Writing 011110011011101010100110010000001011101100101100110001000110000000010111100111010010001000111111000101101100011011100001  to  address 00000 (from port 0) during cycle 195 (975ns - 980ns)
*	Reading 100101111010101001100111001010101111110000011110111001110010000100111111100100011100100001000110111111100001100101001100 from address 11110 (from port 1) during cycle 195 (975ns - 980ns)
*	Writing 111010110010011110001000001001001101010110011111000000101100001100110000111101111111101100100000000011001100100101010110  to  address 11110 (from port 0) during cycle 196 (980ns - 985ns)
*	Writing 001011011000100011000000111100011100011001001100010001011011000111011110011101011100011011110101000010110001101011111111  to  address 11110 (from port 0) during cycle 198 (990ns - 995ns)
*	Writing 011001011110110110000011010110000100010100101010100000101011111001101111100010101111000101101100000010111100000010010110  to  address 00000 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 001011011000100011000000111100011100011001001100010001011011000111011110011101011100011011110101000010110001101011111111 from address 11110 (from port 1) during cycle 200 (1000ns - 1005ns)
*	Writing 000000110001110110100000010101100010100110100100010001110000010110011000101110001001110001011111101001001110011000110111  to  address 11110 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Writing 101111001010011110100001010001100011001101110010000110100010111010101001010010110101111110111111000100100010101111101111  to  address 00000 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 000000110001110110100000010101100010100110100100010001110000010110011000101110001001110001011111101001001110011000110111 from address 11110 (from port 1) during cycle 202 (1010ns - 1015ns)
*	Writing 001001111111010111101001110100110011000011100101010110101111111000000011111100000111100010011100101010100001110010000000  to  address 11110 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 101111001010011110100001010001100011001101110010000110100010111010101001010010110101111110111111000100100010101111101111 from address 00000 (from port 1) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_80  din0_80  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_81  din0_81  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_82  din0_82  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_83  din0_83  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_84  din0_84  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_85  din0_85  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_86  din0_86  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_87  din0_87  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_88  din0_88  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_89  din0_89  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_90  din0_90  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_91  din0_91  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_92  din0_92  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_93  din0_93  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_94  din0_94  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_95  din0_95  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_96  din0_96  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_97  din0_97  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_98  din0_98  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_99  din0_99  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_100  din0_100  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_101  din0_101  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_102  din0_102  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_103  din0_103  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_104  din0_104  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_105  din0_105  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_106  din0_106  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_107  din0_107  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_108  din0_108  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_109  din0_109  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_110  din0_110  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_111  din0_111  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_112  din0_112  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_113  din0_113  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_114  din0_114  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_115  din0_115  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_116  din0_116  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_117  din0_117  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_118  din0_118  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_119  din0_119  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_4  a1_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 0), (515, 1), (520, 0), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0.9 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0.9 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0.9 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0.9 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0.9 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0.9 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0.9 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0.9 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0.9 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0.9 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0.9 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0.9 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0.9 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0.9 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0.9 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0.9 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0.9 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0.9 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0.9 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0.9 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0.9 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0.9 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0.9 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0.9 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0.9 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0.9 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0.9 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0.9 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0.9 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0.9 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0.9 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0.9 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0.9 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_64 Vdout1_64ck4 = 0.9 time = 25
.meas tran vdout1_64ck4 FIND v(dout1_64) AT=25.025n

* CHECK dout1_65 Vdout1_65ck4 = 0 time = 25
.meas tran vdout1_65ck4 FIND v(dout1_65) AT=25.025n

* CHECK dout1_66 Vdout1_66ck4 = 0.9 time = 25
.meas tran vdout1_66ck4 FIND v(dout1_66) AT=25.025n

* CHECK dout1_67 Vdout1_67ck4 = 0.9 time = 25
.meas tran vdout1_67ck4 FIND v(dout1_67) AT=25.025n

* CHECK dout1_68 Vdout1_68ck4 = 0.9 time = 25
.meas tran vdout1_68ck4 FIND v(dout1_68) AT=25.025n

* CHECK dout1_69 Vdout1_69ck4 = 0.9 time = 25
.meas tran vdout1_69ck4 FIND v(dout1_69) AT=25.025n

* CHECK dout1_70 Vdout1_70ck4 = 0.9 time = 25
.meas tran vdout1_70ck4 FIND v(dout1_70) AT=25.025n

* CHECK dout1_71 Vdout1_71ck4 = 0.9 time = 25
.meas tran vdout1_71ck4 FIND v(dout1_71) AT=25.025n

* CHECK dout1_72 Vdout1_72ck4 = 0 time = 25
.meas tran vdout1_72ck4 FIND v(dout1_72) AT=25.025n

* CHECK dout1_73 Vdout1_73ck4 = 0.9 time = 25
.meas tran vdout1_73ck4 FIND v(dout1_73) AT=25.025n

* CHECK dout1_74 Vdout1_74ck4 = 0.9 time = 25
.meas tran vdout1_74ck4 FIND v(dout1_74) AT=25.025n

* CHECK dout1_75 Vdout1_75ck4 = 0.9 time = 25
.meas tran vdout1_75ck4 FIND v(dout1_75) AT=25.025n

* CHECK dout1_76 Vdout1_76ck4 = 0 time = 25
.meas tran vdout1_76ck4 FIND v(dout1_76) AT=25.025n

* CHECK dout1_77 Vdout1_77ck4 = 0 time = 25
.meas tran vdout1_77ck4 FIND v(dout1_77) AT=25.025n

* CHECK dout1_78 Vdout1_78ck4 = 0.9 time = 25
.meas tran vdout1_78ck4 FIND v(dout1_78) AT=25.025n

* CHECK dout1_79 Vdout1_79ck4 = 0.9 time = 25
.meas tran vdout1_79ck4 FIND v(dout1_79) AT=25.025n

* CHECK dout1_80 Vdout1_80ck4 = 0.9 time = 25
.meas tran vdout1_80ck4 FIND v(dout1_80) AT=25.025n

* CHECK dout1_81 Vdout1_81ck4 = 0 time = 25
.meas tran vdout1_81ck4 FIND v(dout1_81) AT=25.025n

* CHECK dout1_82 Vdout1_82ck4 = 0.9 time = 25
.meas tran vdout1_82ck4 FIND v(dout1_82) AT=25.025n

* CHECK dout1_83 Vdout1_83ck4 = 0.9 time = 25
.meas tran vdout1_83ck4 FIND v(dout1_83) AT=25.025n

* CHECK dout1_84 Vdout1_84ck4 = 0.9 time = 25
.meas tran vdout1_84ck4 FIND v(dout1_84) AT=25.025n

* CHECK dout1_85 Vdout1_85ck4 = 0 time = 25
.meas tran vdout1_85ck4 FIND v(dout1_85) AT=25.025n

* CHECK dout1_86 Vdout1_86ck4 = 0.9 time = 25
.meas tran vdout1_86ck4 FIND v(dout1_86) AT=25.025n

* CHECK dout1_87 Vdout1_87ck4 = 0.9 time = 25
.meas tran vdout1_87ck4 FIND v(dout1_87) AT=25.025n

* CHECK dout1_88 Vdout1_88ck4 = 0 time = 25
.meas tran vdout1_88ck4 FIND v(dout1_88) AT=25.025n

* CHECK dout1_89 Vdout1_89ck4 = 0 time = 25
.meas tran vdout1_89ck4 FIND v(dout1_89) AT=25.025n

* CHECK dout1_90 Vdout1_90ck4 = 0 time = 25
.meas tran vdout1_90ck4 FIND v(dout1_90) AT=25.025n

* CHECK dout1_91 Vdout1_91ck4 = 0 time = 25
.meas tran vdout1_91ck4 FIND v(dout1_91) AT=25.025n

* CHECK dout1_92 Vdout1_92ck4 = 0.9 time = 25
.meas tran vdout1_92ck4 FIND v(dout1_92) AT=25.025n

* CHECK dout1_93 Vdout1_93ck4 = 0 time = 25
.meas tran vdout1_93ck4 FIND v(dout1_93) AT=25.025n

* CHECK dout1_94 Vdout1_94ck4 = 0.9 time = 25
.meas tran vdout1_94ck4 FIND v(dout1_94) AT=25.025n

* CHECK dout1_95 Vdout1_95ck4 = 0 time = 25
.meas tran vdout1_95ck4 FIND v(dout1_95) AT=25.025n

* CHECK dout1_96 Vdout1_96ck4 = 0 time = 25
.meas tran vdout1_96ck4 FIND v(dout1_96) AT=25.025n

* CHECK dout1_97 Vdout1_97ck4 = 0.9 time = 25
.meas tran vdout1_97ck4 FIND v(dout1_97) AT=25.025n

* CHECK dout1_98 Vdout1_98ck4 = 0.9 time = 25
.meas tran vdout1_98ck4 FIND v(dout1_98) AT=25.025n

* CHECK dout1_99 Vdout1_99ck4 = 0.9 time = 25
.meas tran vdout1_99ck4 FIND v(dout1_99) AT=25.025n

* CHECK dout1_100 Vdout1_100ck4 = 0.9 time = 25
.meas tran vdout1_100ck4 FIND v(dout1_100) AT=25.025n

* CHECK dout1_101 Vdout1_101ck4 = 0 time = 25
.meas tran vdout1_101ck4 FIND v(dout1_101) AT=25.025n

* CHECK dout1_102 Vdout1_102ck4 = 0.9 time = 25
.meas tran vdout1_102ck4 FIND v(dout1_102) AT=25.025n

* CHECK dout1_103 Vdout1_103ck4 = 0 time = 25
.meas tran vdout1_103ck4 FIND v(dout1_103) AT=25.025n

* CHECK dout1_104 Vdout1_104ck4 = 0 time = 25
.meas tran vdout1_104ck4 FIND v(dout1_104) AT=25.025n

* CHECK dout1_105 Vdout1_105ck4 = 0 time = 25
.meas tran vdout1_105ck4 FIND v(dout1_105) AT=25.025n

* CHECK dout1_106 Vdout1_106ck4 = 0 time = 25
.meas tran vdout1_106ck4 FIND v(dout1_106) AT=25.025n

* CHECK dout1_107 Vdout1_107ck4 = 0 time = 25
.meas tran vdout1_107ck4 FIND v(dout1_107) AT=25.025n

* CHECK dout1_108 Vdout1_108ck4 = 0.9 time = 25
.meas tran vdout1_108ck4 FIND v(dout1_108) AT=25.025n

* CHECK dout1_109 Vdout1_109ck4 = 0.9 time = 25
.meas tran vdout1_109ck4 FIND v(dout1_109) AT=25.025n

* CHECK dout1_110 Vdout1_110ck4 = 0.9 time = 25
.meas tran vdout1_110ck4 FIND v(dout1_110) AT=25.025n

* CHECK dout1_111 Vdout1_111ck4 = 0.9 time = 25
.meas tran vdout1_111ck4 FIND v(dout1_111) AT=25.025n

* CHECK dout1_112 Vdout1_112ck4 = 0 time = 25
.meas tran vdout1_112ck4 FIND v(dout1_112) AT=25.025n

* CHECK dout1_113 Vdout1_113ck4 = 0 time = 25
.meas tran vdout1_113ck4 FIND v(dout1_113) AT=25.025n

* CHECK dout1_114 Vdout1_114ck4 = 0.9 time = 25
.meas tran vdout1_114ck4 FIND v(dout1_114) AT=25.025n

* CHECK dout1_115 Vdout1_115ck4 = 0.9 time = 25
.meas tran vdout1_115ck4 FIND v(dout1_115) AT=25.025n

* CHECK dout1_116 Vdout1_116ck4 = 0 time = 25
.meas tran vdout1_116ck4 FIND v(dout1_116) AT=25.025n

* CHECK dout1_117 Vdout1_117ck4 = 0 time = 25
.meas tran vdout1_117ck4 FIND v(dout1_117) AT=25.025n

* CHECK dout1_118 Vdout1_118ck4 = 0.9 time = 25
.meas tran vdout1_118ck4 FIND v(dout1_118) AT=25.025n

* CHECK dout1_119 Vdout1_119ck4 = 0 time = 25
.meas tran vdout1_119ck4 FIND v(dout1_119) AT=25.025n

* CHECK dout1_0 Vdout1_0ck5 = 0.9 time = 30
.meas tran vdout1_0ck5 FIND v(dout1_0) AT=30.025n

* CHECK dout1_1 Vdout1_1ck5 = 0 time = 30
.meas tran vdout1_1ck5 FIND v(dout1_1) AT=30.025n

* CHECK dout1_2 Vdout1_2ck5 = 0.9 time = 30
.meas tran vdout1_2ck5 FIND v(dout1_2) AT=30.025n

* CHECK dout1_3 Vdout1_3ck5 = 0 time = 30
.meas tran vdout1_3ck5 FIND v(dout1_3) AT=30.025n

* CHECK dout1_4 Vdout1_4ck5 = 0.9 time = 30
.meas tran vdout1_4ck5 FIND v(dout1_4) AT=30.025n

* CHECK dout1_5 Vdout1_5ck5 = 0 time = 30
.meas tran vdout1_5ck5 FIND v(dout1_5) AT=30.025n

* CHECK dout1_6 Vdout1_6ck5 = 0 time = 30
.meas tran vdout1_6ck5 FIND v(dout1_6) AT=30.025n

* CHECK dout1_7 Vdout1_7ck5 = 0 time = 30
.meas tran vdout1_7ck5 FIND v(dout1_7) AT=30.025n

* CHECK dout1_8 Vdout1_8ck5 = 0.9 time = 30
.meas tran vdout1_8ck5 FIND v(dout1_8) AT=30.025n

* CHECK dout1_9 Vdout1_9ck5 = 0 time = 30
.meas tran vdout1_9ck5 FIND v(dout1_9) AT=30.025n

* CHECK dout1_10 Vdout1_10ck5 = 0.9 time = 30
.meas tran vdout1_10ck5 FIND v(dout1_10) AT=30.025n

* CHECK dout1_11 Vdout1_11ck5 = 0 time = 30
.meas tran vdout1_11ck5 FIND v(dout1_11) AT=30.025n

* CHECK dout1_12 Vdout1_12ck5 = 0.9 time = 30
.meas tran vdout1_12ck5 FIND v(dout1_12) AT=30.025n

* CHECK dout1_13 Vdout1_13ck5 = 0 time = 30
.meas tran vdout1_13ck5 FIND v(dout1_13) AT=30.025n

* CHECK dout1_14 Vdout1_14ck5 = 0.9 time = 30
.meas tran vdout1_14ck5 FIND v(dout1_14) AT=30.025n

* CHECK dout1_15 Vdout1_15ck5 = 0.9 time = 30
.meas tran vdout1_15ck5 FIND v(dout1_15) AT=30.025n

* CHECK dout1_16 Vdout1_16ck5 = 0.9 time = 30
.meas tran vdout1_16ck5 FIND v(dout1_16) AT=30.025n

* CHECK dout1_17 Vdout1_17ck5 = 0 time = 30
.meas tran vdout1_17ck5 FIND v(dout1_17) AT=30.025n

* CHECK dout1_18 Vdout1_18ck5 = 0.9 time = 30
.meas tran vdout1_18ck5 FIND v(dout1_18) AT=30.025n

* CHECK dout1_19 Vdout1_19ck5 = 0.9 time = 30
.meas tran vdout1_19ck5 FIND v(dout1_19) AT=30.025n

* CHECK dout1_20 Vdout1_20ck5 = 0 time = 30
.meas tran vdout1_20ck5 FIND v(dout1_20) AT=30.025n

* CHECK dout1_21 Vdout1_21ck5 = 0.9 time = 30
.meas tran vdout1_21ck5 FIND v(dout1_21) AT=30.025n

* CHECK dout1_22 Vdout1_22ck5 = 0 time = 30
.meas tran vdout1_22ck5 FIND v(dout1_22) AT=30.025n

* CHECK dout1_23 Vdout1_23ck5 = 0 time = 30
.meas tran vdout1_23ck5 FIND v(dout1_23) AT=30.025n

* CHECK dout1_24 Vdout1_24ck5 = 0.9 time = 30
.meas tran vdout1_24ck5 FIND v(dout1_24) AT=30.025n

* CHECK dout1_25 Vdout1_25ck5 = 0 time = 30
.meas tran vdout1_25ck5 FIND v(dout1_25) AT=30.025n

* CHECK dout1_26 Vdout1_26ck5 = 0.9 time = 30
.meas tran vdout1_26ck5 FIND v(dout1_26) AT=30.025n

* CHECK dout1_27 Vdout1_27ck5 = 0.9 time = 30
.meas tran vdout1_27ck5 FIND v(dout1_27) AT=30.025n

* CHECK dout1_28 Vdout1_28ck5 = 0 time = 30
.meas tran vdout1_28ck5 FIND v(dout1_28) AT=30.025n

* CHECK dout1_29 Vdout1_29ck5 = 0 time = 30
.meas tran vdout1_29ck5 FIND v(dout1_29) AT=30.025n

* CHECK dout1_30 Vdout1_30ck5 = 0.9 time = 30
.meas tran vdout1_30ck5 FIND v(dout1_30) AT=30.025n

* CHECK dout1_31 Vdout1_31ck5 = 0 time = 30
.meas tran vdout1_31ck5 FIND v(dout1_31) AT=30.025n

* CHECK dout1_32 Vdout1_32ck5 = 0 time = 30
.meas tran vdout1_32ck5 FIND v(dout1_32) AT=30.025n

* CHECK dout1_33 Vdout1_33ck5 = 0 time = 30
.meas tran vdout1_33ck5 FIND v(dout1_33) AT=30.025n

* CHECK dout1_34 Vdout1_34ck5 = 0.9 time = 30
.meas tran vdout1_34ck5 FIND v(dout1_34) AT=30.025n

* CHECK dout1_35 Vdout1_35ck5 = 0.9 time = 30
.meas tran vdout1_35ck5 FIND v(dout1_35) AT=30.025n

* CHECK dout1_36 Vdout1_36ck5 = 0 time = 30
.meas tran vdout1_36ck5 FIND v(dout1_36) AT=30.025n

* CHECK dout1_37 Vdout1_37ck5 = 0 time = 30
.meas tran vdout1_37ck5 FIND v(dout1_37) AT=30.025n

* CHECK dout1_38 Vdout1_38ck5 = 0.9 time = 30
.meas tran vdout1_38ck5 FIND v(dout1_38) AT=30.025n

* CHECK dout1_39 Vdout1_39ck5 = 0.9 time = 30
.meas tran vdout1_39ck5 FIND v(dout1_39) AT=30.025n

* CHECK dout1_40 Vdout1_40ck5 = 0.9 time = 30
.meas tran vdout1_40ck5 FIND v(dout1_40) AT=30.025n

* CHECK dout1_41 Vdout1_41ck5 = 0.9 time = 30
.meas tran vdout1_41ck5 FIND v(dout1_41) AT=30.025n

* CHECK dout1_42 Vdout1_42ck5 = 0.9 time = 30
.meas tran vdout1_42ck5 FIND v(dout1_42) AT=30.025n

* CHECK dout1_43 Vdout1_43ck5 = 0 time = 30
.meas tran vdout1_43ck5 FIND v(dout1_43) AT=30.025n

* CHECK dout1_44 Vdout1_44ck5 = 0 time = 30
.meas tran vdout1_44ck5 FIND v(dout1_44) AT=30.025n

* CHECK dout1_45 Vdout1_45ck5 = 0.9 time = 30
.meas tran vdout1_45ck5 FIND v(dout1_45) AT=30.025n

* CHECK dout1_46 Vdout1_46ck5 = 0.9 time = 30
.meas tran vdout1_46ck5 FIND v(dout1_46) AT=30.025n

* CHECK dout1_47 Vdout1_47ck5 = 0.9 time = 30
.meas tran vdout1_47ck5 FIND v(dout1_47) AT=30.025n

* CHECK dout1_48 Vdout1_48ck5 = 0 time = 30
.meas tran vdout1_48ck5 FIND v(dout1_48) AT=30.025n

* CHECK dout1_49 Vdout1_49ck5 = 0.9 time = 30
.meas tran vdout1_49ck5 FIND v(dout1_49) AT=30.025n

* CHECK dout1_50 Vdout1_50ck5 = 0.9 time = 30
.meas tran vdout1_50ck5 FIND v(dout1_50) AT=30.025n

* CHECK dout1_51 Vdout1_51ck5 = 0.9 time = 30
.meas tran vdout1_51ck5 FIND v(dout1_51) AT=30.025n

* CHECK dout1_52 Vdout1_52ck5 = 0 time = 30
.meas tran vdout1_52ck5 FIND v(dout1_52) AT=30.025n

* CHECK dout1_53 Vdout1_53ck5 = 0 time = 30
.meas tran vdout1_53ck5 FIND v(dout1_53) AT=30.025n

* CHECK dout1_54 Vdout1_54ck5 = 0.9 time = 30
.meas tran vdout1_54ck5 FIND v(dout1_54) AT=30.025n

* CHECK dout1_55 Vdout1_55ck5 = 0.9 time = 30
.meas tran vdout1_55ck5 FIND v(dout1_55) AT=30.025n

* CHECK dout1_56 Vdout1_56ck5 = 0.9 time = 30
.meas tran vdout1_56ck5 FIND v(dout1_56) AT=30.025n

* CHECK dout1_57 Vdout1_57ck5 = 0.9 time = 30
.meas tran vdout1_57ck5 FIND v(dout1_57) AT=30.025n

* CHECK dout1_58 Vdout1_58ck5 = 0.9 time = 30
.meas tran vdout1_58ck5 FIND v(dout1_58) AT=30.025n

* CHECK dout1_59 Vdout1_59ck5 = 0 time = 30
.meas tran vdout1_59ck5 FIND v(dout1_59) AT=30.025n

* CHECK dout1_60 Vdout1_60ck5 = 0 time = 30
.meas tran vdout1_60ck5 FIND v(dout1_60) AT=30.025n

* CHECK dout1_61 Vdout1_61ck5 = 0.9 time = 30
.meas tran vdout1_61ck5 FIND v(dout1_61) AT=30.025n

* CHECK dout1_62 Vdout1_62ck5 = 0.9 time = 30
.meas tran vdout1_62ck5 FIND v(dout1_62) AT=30.025n

* CHECK dout1_63 Vdout1_63ck5 = 0 time = 30
.meas tran vdout1_63ck5 FIND v(dout1_63) AT=30.025n

* CHECK dout1_64 Vdout1_64ck5 = 0.9 time = 30
.meas tran vdout1_64ck5 FIND v(dout1_64) AT=30.025n

* CHECK dout1_65 Vdout1_65ck5 = 0 time = 30
.meas tran vdout1_65ck5 FIND v(dout1_65) AT=30.025n

* CHECK dout1_66 Vdout1_66ck5 = 0.9 time = 30
.meas tran vdout1_66ck5 FIND v(dout1_66) AT=30.025n

* CHECK dout1_67 Vdout1_67ck5 = 0.9 time = 30
.meas tran vdout1_67ck5 FIND v(dout1_67) AT=30.025n

* CHECK dout1_68 Vdout1_68ck5 = 0.9 time = 30
.meas tran vdout1_68ck5 FIND v(dout1_68) AT=30.025n

* CHECK dout1_69 Vdout1_69ck5 = 0.9 time = 30
.meas tran vdout1_69ck5 FIND v(dout1_69) AT=30.025n

* CHECK dout1_70 Vdout1_70ck5 = 0.9 time = 30
.meas tran vdout1_70ck5 FIND v(dout1_70) AT=30.025n

* CHECK dout1_71 Vdout1_71ck5 = 0.9 time = 30
.meas tran vdout1_71ck5 FIND v(dout1_71) AT=30.025n

* CHECK dout1_72 Vdout1_72ck5 = 0 time = 30
.meas tran vdout1_72ck5 FIND v(dout1_72) AT=30.025n

* CHECK dout1_73 Vdout1_73ck5 = 0.9 time = 30
.meas tran vdout1_73ck5 FIND v(dout1_73) AT=30.025n

* CHECK dout1_74 Vdout1_74ck5 = 0.9 time = 30
.meas tran vdout1_74ck5 FIND v(dout1_74) AT=30.025n

* CHECK dout1_75 Vdout1_75ck5 = 0.9 time = 30
.meas tran vdout1_75ck5 FIND v(dout1_75) AT=30.025n

* CHECK dout1_76 Vdout1_76ck5 = 0 time = 30
.meas tran vdout1_76ck5 FIND v(dout1_76) AT=30.025n

* CHECK dout1_77 Vdout1_77ck5 = 0 time = 30
.meas tran vdout1_77ck5 FIND v(dout1_77) AT=30.025n

* CHECK dout1_78 Vdout1_78ck5 = 0.9 time = 30
.meas tran vdout1_78ck5 FIND v(dout1_78) AT=30.025n

* CHECK dout1_79 Vdout1_79ck5 = 0.9 time = 30
.meas tran vdout1_79ck5 FIND v(dout1_79) AT=30.025n

* CHECK dout1_80 Vdout1_80ck5 = 0.9 time = 30
.meas tran vdout1_80ck5 FIND v(dout1_80) AT=30.025n

* CHECK dout1_81 Vdout1_81ck5 = 0 time = 30
.meas tran vdout1_81ck5 FIND v(dout1_81) AT=30.025n

* CHECK dout1_82 Vdout1_82ck5 = 0.9 time = 30
.meas tran vdout1_82ck5 FIND v(dout1_82) AT=30.025n

* CHECK dout1_83 Vdout1_83ck5 = 0.9 time = 30
.meas tran vdout1_83ck5 FIND v(dout1_83) AT=30.025n

* CHECK dout1_84 Vdout1_84ck5 = 0.9 time = 30
.meas tran vdout1_84ck5 FIND v(dout1_84) AT=30.025n

* CHECK dout1_85 Vdout1_85ck5 = 0 time = 30
.meas tran vdout1_85ck5 FIND v(dout1_85) AT=30.025n

* CHECK dout1_86 Vdout1_86ck5 = 0.9 time = 30
.meas tran vdout1_86ck5 FIND v(dout1_86) AT=30.025n

* CHECK dout1_87 Vdout1_87ck5 = 0.9 time = 30
.meas tran vdout1_87ck5 FIND v(dout1_87) AT=30.025n

* CHECK dout1_88 Vdout1_88ck5 = 0 time = 30
.meas tran vdout1_88ck5 FIND v(dout1_88) AT=30.025n

* CHECK dout1_89 Vdout1_89ck5 = 0 time = 30
.meas tran vdout1_89ck5 FIND v(dout1_89) AT=30.025n

* CHECK dout1_90 Vdout1_90ck5 = 0 time = 30
.meas tran vdout1_90ck5 FIND v(dout1_90) AT=30.025n

* CHECK dout1_91 Vdout1_91ck5 = 0 time = 30
.meas tran vdout1_91ck5 FIND v(dout1_91) AT=30.025n

* CHECK dout1_92 Vdout1_92ck5 = 0.9 time = 30
.meas tran vdout1_92ck5 FIND v(dout1_92) AT=30.025n

* CHECK dout1_93 Vdout1_93ck5 = 0 time = 30
.meas tran vdout1_93ck5 FIND v(dout1_93) AT=30.025n

* CHECK dout1_94 Vdout1_94ck5 = 0.9 time = 30
.meas tran vdout1_94ck5 FIND v(dout1_94) AT=30.025n

* CHECK dout1_95 Vdout1_95ck5 = 0 time = 30
.meas tran vdout1_95ck5 FIND v(dout1_95) AT=30.025n

* CHECK dout1_96 Vdout1_96ck5 = 0 time = 30
.meas tran vdout1_96ck5 FIND v(dout1_96) AT=30.025n

* CHECK dout1_97 Vdout1_97ck5 = 0.9 time = 30
.meas tran vdout1_97ck5 FIND v(dout1_97) AT=30.025n

* CHECK dout1_98 Vdout1_98ck5 = 0.9 time = 30
.meas tran vdout1_98ck5 FIND v(dout1_98) AT=30.025n

* CHECK dout1_99 Vdout1_99ck5 = 0.9 time = 30
.meas tran vdout1_99ck5 FIND v(dout1_99) AT=30.025n

* CHECK dout1_100 Vdout1_100ck5 = 0.9 time = 30
.meas tran vdout1_100ck5 FIND v(dout1_100) AT=30.025n

* CHECK dout1_101 Vdout1_101ck5 = 0 time = 30
.meas tran vdout1_101ck5 FIND v(dout1_101) AT=30.025n

* CHECK dout1_102 Vdout1_102ck5 = 0.9 time = 30
.meas tran vdout1_102ck5 FIND v(dout1_102) AT=30.025n

* CHECK dout1_103 Vdout1_103ck5 = 0 time = 30
.meas tran vdout1_103ck5 FIND v(dout1_103) AT=30.025n

* CHECK dout1_104 Vdout1_104ck5 = 0 time = 30
.meas tran vdout1_104ck5 FIND v(dout1_104) AT=30.025n

* CHECK dout1_105 Vdout1_105ck5 = 0 time = 30
.meas tran vdout1_105ck5 FIND v(dout1_105) AT=30.025n

* CHECK dout1_106 Vdout1_106ck5 = 0 time = 30
.meas tran vdout1_106ck5 FIND v(dout1_106) AT=30.025n

* CHECK dout1_107 Vdout1_107ck5 = 0 time = 30
.meas tran vdout1_107ck5 FIND v(dout1_107) AT=30.025n

* CHECK dout1_108 Vdout1_108ck5 = 0.9 time = 30
.meas tran vdout1_108ck5 FIND v(dout1_108) AT=30.025n

* CHECK dout1_109 Vdout1_109ck5 = 0.9 time = 30
.meas tran vdout1_109ck5 FIND v(dout1_109) AT=30.025n

* CHECK dout1_110 Vdout1_110ck5 = 0.9 time = 30
.meas tran vdout1_110ck5 FIND v(dout1_110) AT=30.025n

* CHECK dout1_111 Vdout1_111ck5 = 0.9 time = 30
.meas tran vdout1_111ck5 FIND v(dout1_111) AT=30.025n

* CHECK dout1_112 Vdout1_112ck5 = 0 time = 30
.meas tran vdout1_112ck5 FIND v(dout1_112) AT=30.025n

* CHECK dout1_113 Vdout1_113ck5 = 0 time = 30
.meas tran vdout1_113ck5 FIND v(dout1_113) AT=30.025n

* CHECK dout1_114 Vdout1_114ck5 = 0.9 time = 30
.meas tran vdout1_114ck5 FIND v(dout1_114) AT=30.025n

* CHECK dout1_115 Vdout1_115ck5 = 0.9 time = 30
.meas tran vdout1_115ck5 FIND v(dout1_115) AT=30.025n

* CHECK dout1_116 Vdout1_116ck5 = 0 time = 30
.meas tran vdout1_116ck5 FIND v(dout1_116) AT=30.025n

* CHECK dout1_117 Vdout1_117ck5 = 0 time = 30
.meas tran vdout1_117ck5 FIND v(dout1_117) AT=30.025n

* CHECK dout1_118 Vdout1_118ck5 = 0.9 time = 30
.meas tran vdout1_118ck5 FIND v(dout1_118) AT=30.025n

* CHECK dout1_119 Vdout1_119ck5 = 0 time = 30
.meas tran vdout1_119ck5 FIND v(dout1_119) AT=30.025n

* CHECK dout1_0 Vdout1_0ck6 = 0.9 time = 35
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=35.025n

* CHECK dout1_1 Vdout1_1ck6 = 0.9 time = 35
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=35.025n

* CHECK dout1_2 Vdout1_2ck6 = 0 time = 35
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=35.025n

* CHECK dout1_3 Vdout1_3ck6 = 0 time = 35
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=35.025n

* CHECK dout1_4 Vdout1_4ck6 = 0.9 time = 35
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=35.025n

* CHECK dout1_5 Vdout1_5ck6 = 0 time = 35
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=35.025n

* CHECK dout1_6 Vdout1_6ck6 = 0.9 time = 35
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=35.025n

* CHECK dout1_7 Vdout1_7ck6 = 0.9 time = 35
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=35.025n

* CHECK dout1_8 Vdout1_8ck6 = 0.9 time = 35
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=35.025n

* CHECK dout1_9 Vdout1_9ck6 = 0.9 time = 35
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=35.025n

* CHECK dout1_10 Vdout1_10ck6 = 0 time = 35
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=35.025n

* CHECK dout1_11 Vdout1_11ck6 = 0.9 time = 35
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=35.025n

* CHECK dout1_12 Vdout1_12ck6 = 0.9 time = 35
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=35.025n

* CHECK dout1_13 Vdout1_13ck6 = 0 time = 35
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=35.025n

* CHECK dout1_14 Vdout1_14ck6 = 0.9 time = 35
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=35.025n

* CHECK dout1_15 Vdout1_15ck6 = 0.9 time = 35
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=35.025n

* CHECK dout1_16 Vdout1_16ck6 = 0 time = 35
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=35.025n

* CHECK dout1_17 Vdout1_17ck6 = 0.9 time = 35
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=35.025n

* CHECK dout1_18 Vdout1_18ck6 = 0 time = 35
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=35.025n

* CHECK dout1_19 Vdout1_19ck6 = 0.9 time = 35
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=35.025n

* CHECK dout1_20 Vdout1_20ck6 = 0.9 time = 35
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=35.025n

* CHECK dout1_21 Vdout1_21ck6 = 0.9 time = 35
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=35.025n

* CHECK dout1_22 Vdout1_22ck6 = 0 time = 35
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=35.025n

* CHECK dout1_23 Vdout1_23ck6 = 0 time = 35
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=35.025n

* CHECK dout1_24 Vdout1_24ck6 = 0.9 time = 35
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=35.025n

* CHECK dout1_25 Vdout1_25ck6 = 0.9 time = 35
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=35.025n

* CHECK dout1_26 Vdout1_26ck6 = 0 time = 35
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=35.025n

* CHECK dout1_27 Vdout1_27ck6 = 0.9 time = 35
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=35.025n

* CHECK dout1_28 Vdout1_28ck6 = 0 time = 35
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=35.025n

* CHECK dout1_29 Vdout1_29ck6 = 0.9 time = 35
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=35.025n

* CHECK dout1_30 Vdout1_30ck6 = 0 time = 35
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=35.025n

* CHECK dout1_31 Vdout1_31ck6 = 0 time = 35
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=35.025n

* CHECK dout1_32 Vdout1_32ck6 = 0.9 time = 35
.meas tran vdout1_32ck6 FIND v(dout1_32) AT=35.025n

* CHECK dout1_33 Vdout1_33ck6 = 0 time = 35
.meas tran vdout1_33ck6 FIND v(dout1_33) AT=35.025n

* CHECK dout1_34 Vdout1_34ck6 = 0 time = 35
.meas tran vdout1_34ck6 FIND v(dout1_34) AT=35.025n

* CHECK dout1_35 Vdout1_35ck6 = 0.9 time = 35
.meas tran vdout1_35ck6 FIND v(dout1_35) AT=35.025n

* CHECK dout1_36 Vdout1_36ck6 = 0 time = 35
.meas tran vdout1_36ck6 FIND v(dout1_36) AT=35.025n

* CHECK dout1_37 Vdout1_37ck6 = 0 time = 35
.meas tran vdout1_37ck6 FIND v(dout1_37) AT=35.025n

* CHECK dout1_38 Vdout1_38ck6 = 0.9 time = 35
.meas tran vdout1_38ck6 FIND v(dout1_38) AT=35.025n

* CHECK dout1_39 Vdout1_39ck6 = 0 time = 35
.meas tran vdout1_39ck6 FIND v(dout1_39) AT=35.025n

* CHECK dout1_40 Vdout1_40ck6 = 0.9 time = 35
.meas tran vdout1_40ck6 FIND v(dout1_40) AT=35.025n

* CHECK dout1_41 Vdout1_41ck6 = 0.9 time = 35
.meas tran vdout1_41ck6 FIND v(dout1_41) AT=35.025n

* CHECK dout1_42 Vdout1_42ck6 = 0.9 time = 35
.meas tran vdout1_42ck6 FIND v(dout1_42) AT=35.025n

* CHECK dout1_43 Vdout1_43ck6 = 0 time = 35
.meas tran vdout1_43ck6 FIND v(dout1_43) AT=35.025n

* CHECK dout1_44 Vdout1_44ck6 = 0.9 time = 35
.meas tran vdout1_44ck6 FIND v(dout1_44) AT=35.025n

* CHECK dout1_45 Vdout1_45ck6 = 0 time = 35
.meas tran vdout1_45ck6 FIND v(dout1_45) AT=35.025n

* CHECK dout1_46 Vdout1_46ck6 = 0.9 time = 35
.meas tran vdout1_46ck6 FIND v(dout1_46) AT=35.025n

* CHECK dout1_47 Vdout1_47ck6 = 0 time = 35
.meas tran vdout1_47ck6 FIND v(dout1_47) AT=35.025n

* CHECK dout1_48 Vdout1_48ck6 = 0 time = 35
.meas tran vdout1_48ck6 FIND v(dout1_48) AT=35.025n

* CHECK dout1_49 Vdout1_49ck6 = 0.9 time = 35
.meas tran vdout1_49ck6 FIND v(dout1_49) AT=35.025n

* CHECK dout1_50 Vdout1_50ck6 = 0 time = 35
.meas tran vdout1_50ck6 FIND v(dout1_50) AT=35.025n

* CHECK dout1_51 Vdout1_51ck6 = 0.9 time = 35
.meas tran vdout1_51ck6 FIND v(dout1_51) AT=35.025n

* CHECK dout1_52 Vdout1_52ck6 = 0 time = 35
.meas tran vdout1_52ck6 FIND v(dout1_52) AT=35.025n

* CHECK dout1_53 Vdout1_53ck6 = 0.9 time = 35
.meas tran vdout1_53ck6 FIND v(dout1_53) AT=35.025n

* CHECK dout1_54 Vdout1_54ck6 = 0.9 time = 35
.meas tran vdout1_54ck6 FIND v(dout1_54) AT=35.025n

* CHECK dout1_55 Vdout1_55ck6 = 0.9 time = 35
.meas tran vdout1_55ck6 FIND v(dout1_55) AT=35.025n

* CHECK dout1_56 Vdout1_56ck6 = 0.9 time = 35
.meas tran vdout1_56ck6 FIND v(dout1_56) AT=35.025n

* CHECK dout1_57 Vdout1_57ck6 = 0.9 time = 35
.meas tran vdout1_57ck6 FIND v(dout1_57) AT=35.025n

* CHECK dout1_58 Vdout1_58ck6 = 0.9 time = 35
.meas tran vdout1_58ck6 FIND v(dout1_58) AT=35.025n

* CHECK dout1_59 Vdout1_59ck6 = 0 time = 35
.meas tran vdout1_59ck6 FIND v(dout1_59) AT=35.025n

* CHECK dout1_60 Vdout1_60ck6 = 0 time = 35
.meas tran vdout1_60ck6 FIND v(dout1_60) AT=35.025n

* CHECK dout1_61 Vdout1_61ck6 = 0.9 time = 35
.meas tran vdout1_61ck6 FIND v(dout1_61) AT=35.025n

* CHECK dout1_62 Vdout1_62ck6 = 0 time = 35
.meas tran vdout1_62ck6 FIND v(dout1_62) AT=35.025n

* CHECK dout1_63 Vdout1_63ck6 = 0 time = 35
.meas tran vdout1_63ck6 FIND v(dout1_63) AT=35.025n

* CHECK dout1_64 Vdout1_64ck6 = 0 time = 35
.meas tran vdout1_64ck6 FIND v(dout1_64) AT=35.025n

* CHECK dout1_65 Vdout1_65ck6 = 0 time = 35
.meas tran vdout1_65ck6 FIND v(dout1_65) AT=35.025n

* CHECK dout1_66 Vdout1_66ck6 = 0.9 time = 35
.meas tran vdout1_66ck6 FIND v(dout1_66) AT=35.025n

* CHECK dout1_67 Vdout1_67ck6 = 0 time = 35
.meas tran vdout1_67ck6 FIND v(dout1_67) AT=35.025n

* CHECK dout1_68 Vdout1_68ck6 = 0.9 time = 35
.meas tran vdout1_68ck6 FIND v(dout1_68) AT=35.025n

* CHECK dout1_69 Vdout1_69ck6 = 0.9 time = 35
.meas tran vdout1_69ck6 FIND v(dout1_69) AT=35.025n

* CHECK dout1_70 Vdout1_70ck6 = 0 time = 35
.meas tran vdout1_70ck6 FIND v(dout1_70) AT=35.025n

* CHECK dout1_71 Vdout1_71ck6 = 0 time = 35
.meas tran vdout1_71ck6 FIND v(dout1_71) AT=35.025n

* CHECK dout1_72 Vdout1_72ck6 = 0.9 time = 35
.meas tran vdout1_72ck6 FIND v(dout1_72) AT=35.025n

* CHECK dout1_73 Vdout1_73ck6 = 0.9 time = 35
.meas tran vdout1_73ck6 FIND v(dout1_73) AT=35.025n

* CHECK dout1_74 Vdout1_74ck6 = 0 time = 35
.meas tran vdout1_74ck6 FIND v(dout1_74) AT=35.025n

* CHECK dout1_75 Vdout1_75ck6 = 0.9 time = 35
.meas tran vdout1_75ck6 FIND v(dout1_75) AT=35.025n

* CHECK dout1_76 Vdout1_76ck6 = 0.9 time = 35
.meas tran vdout1_76ck6 FIND v(dout1_76) AT=35.025n

* CHECK dout1_77 Vdout1_77ck6 = 0.9 time = 35
.meas tran vdout1_77ck6 FIND v(dout1_77) AT=35.025n

* CHECK dout1_78 Vdout1_78ck6 = 0.9 time = 35
.meas tran vdout1_78ck6 FIND v(dout1_78) AT=35.025n

* CHECK dout1_79 Vdout1_79ck6 = 0.9 time = 35
.meas tran vdout1_79ck6 FIND v(dout1_79) AT=35.025n

* CHECK dout1_80 Vdout1_80ck6 = 0 time = 35
.meas tran vdout1_80ck6 FIND v(dout1_80) AT=35.025n

* CHECK dout1_81 Vdout1_81ck6 = 0.9 time = 35
.meas tran vdout1_81ck6 FIND v(dout1_81) AT=35.025n

* CHECK dout1_82 Vdout1_82ck6 = 0.9 time = 35
.meas tran vdout1_82ck6 FIND v(dout1_82) AT=35.025n

* CHECK dout1_83 Vdout1_83ck6 = 0 time = 35
.meas tran vdout1_83ck6 FIND v(dout1_83) AT=35.025n

* CHECK dout1_84 Vdout1_84ck6 = 0.9 time = 35
.meas tran vdout1_84ck6 FIND v(dout1_84) AT=35.025n

* CHECK dout1_85 Vdout1_85ck6 = 0.9 time = 35
.meas tran vdout1_85ck6 FIND v(dout1_85) AT=35.025n

* CHECK dout1_86 Vdout1_86ck6 = 0.9 time = 35
.meas tran vdout1_86ck6 FIND v(dout1_86) AT=35.025n

* CHECK dout1_87 Vdout1_87ck6 = 0.9 time = 35
.meas tran vdout1_87ck6 FIND v(dout1_87) AT=35.025n

* CHECK dout1_88 Vdout1_88ck6 = 0 time = 35
.meas tran vdout1_88ck6 FIND v(dout1_88) AT=35.025n

* CHECK dout1_89 Vdout1_89ck6 = 0 time = 35
.meas tran vdout1_89ck6 FIND v(dout1_89) AT=35.025n

* CHECK dout1_90 Vdout1_90ck6 = 0 time = 35
.meas tran vdout1_90ck6 FIND v(dout1_90) AT=35.025n

* CHECK dout1_91 Vdout1_91ck6 = 0 time = 35
.meas tran vdout1_91ck6 FIND v(dout1_91) AT=35.025n

* CHECK dout1_92 Vdout1_92ck6 = 0 time = 35
.meas tran vdout1_92ck6 FIND v(dout1_92) AT=35.025n

* CHECK dout1_93 Vdout1_93ck6 = 0.9 time = 35
.meas tran vdout1_93ck6 FIND v(dout1_93) AT=35.025n

* CHECK dout1_94 Vdout1_94ck6 = 0.9 time = 35
.meas tran vdout1_94ck6 FIND v(dout1_94) AT=35.025n

* CHECK dout1_95 Vdout1_95ck6 = 0.9 time = 35
.meas tran vdout1_95ck6 FIND v(dout1_95) AT=35.025n

* CHECK dout1_96 Vdout1_96ck6 = 0.9 time = 35
.meas tran vdout1_96ck6 FIND v(dout1_96) AT=35.025n

* CHECK dout1_97 Vdout1_97ck6 = 0 time = 35
.meas tran vdout1_97ck6 FIND v(dout1_97) AT=35.025n

* CHECK dout1_98 Vdout1_98ck6 = 0.9 time = 35
.meas tran vdout1_98ck6 FIND v(dout1_98) AT=35.025n

* CHECK dout1_99 Vdout1_99ck6 = 0 time = 35
.meas tran vdout1_99ck6 FIND v(dout1_99) AT=35.025n

* CHECK dout1_100 Vdout1_100ck6 = 0.9 time = 35
.meas tran vdout1_100ck6 FIND v(dout1_100) AT=35.025n

* CHECK dout1_101 Vdout1_101ck6 = 0 time = 35
.meas tran vdout1_101ck6 FIND v(dout1_101) AT=35.025n

* CHECK dout1_102 Vdout1_102ck6 = 0 time = 35
.meas tran vdout1_102ck6 FIND v(dout1_102) AT=35.025n

* CHECK dout1_103 Vdout1_103ck6 = 0.9 time = 35
.meas tran vdout1_103ck6 FIND v(dout1_103) AT=35.025n

* CHECK dout1_104 Vdout1_104ck6 = 0 time = 35
.meas tran vdout1_104ck6 FIND v(dout1_104) AT=35.025n

* CHECK dout1_105 Vdout1_105ck6 = 0 time = 35
.meas tran vdout1_105ck6 FIND v(dout1_105) AT=35.025n

* CHECK dout1_106 Vdout1_106ck6 = 0 time = 35
.meas tran vdout1_106ck6 FIND v(dout1_106) AT=35.025n

* CHECK dout1_107 Vdout1_107ck6 = 0 time = 35
.meas tran vdout1_107ck6 FIND v(dout1_107) AT=35.025n

* CHECK dout1_108 Vdout1_108ck6 = 0 time = 35
.meas tran vdout1_108ck6 FIND v(dout1_108) AT=35.025n

* CHECK dout1_109 Vdout1_109ck6 = 0.9 time = 35
.meas tran vdout1_109ck6 FIND v(dout1_109) AT=35.025n

* CHECK dout1_110 Vdout1_110ck6 = 0 time = 35
.meas tran vdout1_110ck6 FIND v(dout1_110) AT=35.025n

* CHECK dout1_111 Vdout1_111ck6 = 0.9 time = 35
.meas tran vdout1_111ck6 FIND v(dout1_111) AT=35.025n

* CHECK dout1_112 Vdout1_112ck6 = 0.9 time = 35
.meas tran vdout1_112ck6 FIND v(dout1_112) AT=35.025n

* CHECK dout1_113 Vdout1_113ck6 = 0 time = 35
.meas tran vdout1_113ck6 FIND v(dout1_113) AT=35.025n

* CHECK dout1_114 Vdout1_114ck6 = 0.9 time = 35
.meas tran vdout1_114ck6 FIND v(dout1_114) AT=35.025n

* CHECK dout1_115 Vdout1_115ck6 = 0.9 time = 35
.meas tran vdout1_115ck6 FIND v(dout1_115) AT=35.025n

* CHECK dout1_116 Vdout1_116ck6 = 0.9 time = 35
.meas tran vdout1_116ck6 FIND v(dout1_116) AT=35.025n

* CHECK dout1_117 Vdout1_117ck6 = 0.9 time = 35
.meas tran vdout1_117ck6 FIND v(dout1_117) AT=35.025n

* CHECK dout1_118 Vdout1_118ck6 = 0.9 time = 35
.meas tran vdout1_118ck6 FIND v(dout1_118) AT=35.025n

* CHECK dout1_119 Vdout1_119ck6 = 0.9 time = 35
.meas tran vdout1_119ck6 FIND v(dout1_119) AT=35.025n

* CHECK dout1_0 Vdout1_0ck8 = 0.9 time = 45
.meas tran vdout1_0ck8 FIND v(dout1_0) AT=45.025n

* CHECK dout1_1 Vdout1_1ck8 = 0 time = 45
.meas tran vdout1_1ck8 FIND v(dout1_1) AT=45.025n

* CHECK dout1_2 Vdout1_2ck8 = 0.9 time = 45
.meas tran vdout1_2ck8 FIND v(dout1_2) AT=45.025n

* CHECK dout1_3 Vdout1_3ck8 = 0 time = 45
.meas tran vdout1_3ck8 FIND v(dout1_3) AT=45.025n

* CHECK dout1_4 Vdout1_4ck8 = 0.9 time = 45
.meas tran vdout1_4ck8 FIND v(dout1_4) AT=45.025n

* CHECK dout1_5 Vdout1_5ck8 = 0 time = 45
.meas tran vdout1_5ck8 FIND v(dout1_5) AT=45.025n

* CHECK dout1_6 Vdout1_6ck8 = 0 time = 45
.meas tran vdout1_6ck8 FIND v(dout1_6) AT=45.025n

* CHECK dout1_7 Vdout1_7ck8 = 0 time = 45
.meas tran vdout1_7ck8 FIND v(dout1_7) AT=45.025n

* CHECK dout1_8 Vdout1_8ck8 = 0.9 time = 45
.meas tran vdout1_8ck8 FIND v(dout1_8) AT=45.025n

* CHECK dout1_9 Vdout1_9ck8 = 0 time = 45
.meas tran vdout1_9ck8 FIND v(dout1_9) AT=45.025n

* CHECK dout1_10 Vdout1_10ck8 = 0.9 time = 45
.meas tran vdout1_10ck8 FIND v(dout1_10) AT=45.025n

* CHECK dout1_11 Vdout1_11ck8 = 0 time = 45
.meas tran vdout1_11ck8 FIND v(dout1_11) AT=45.025n

* CHECK dout1_12 Vdout1_12ck8 = 0.9 time = 45
.meas tran vdout1_12ck8 FIND v(dout1_12) AT=45.025n

* CHECK dout1_13 Vdout1_13ck8 = 0 time = 45
.meas tran vdout1_13ck8 FIND v(dout1_13) AT=45.025n

* CHECK dout1_14 Vdout1_14ck8 = 0.9 time = 45
.meas tran vdout1_14ck8 FIND v(dout1_14) AT=45.025n

* CHECK dout1_15 Vdout1_15ck8 = 0.9 time = 45
.meas tran vdout1_15ck8 FIND v(dout1_15) AT=45.025n

* CHECK dout1_16 Vdout1_16ck8 = 0.9 time = 45
.meas tran vdout1_16ck8 FIND v(dout1_16) AT=45.025n

* CHECK dout1_17 Vdout1_17ck8 = 0 time = 45
.meas tran vdout1_17ck8 FIND v(dout1_17) AT=45.025n

* CHECK dout1_18 Vdout1_18ck8 = 0.9 time = 45
.meas tran vdout1_18ck8 FIND v(dout1_18) AT=45.025n

* CHECK dout1_19 Vdout1_19ck8 = 0.9 time = 45
.meas tran vdout1_19ck8 FIND v(dout1_19) AT=45.025n

* CHECK dout1_20 Vdout1_20ck8 = 0 time = 45
.meas tran vdout1_20ck8 FIND v(dout1_20) AT=45.025n

* CHECK dout1_21 Vdout1_21ck8 = 0.9 time = 45
.meas tran vdout1_21ck8 FIND v(dout1_21) AT=45.025n

* CHECK dout1_22 Vdout1_22ck8 = 0 time = 45
.meas tran vdout1_22ck8 FIND v(dout1_22) AT=45.025n

* CHECK dout1_23 Vdout1_23ck8 = 0 time = 45
.meas tran vdout1_23ck8 FIND v(dout1_23) AT=45.025n

* CHECK dout1_24 Vdout1_24ck8 = 0.9 time = 45
.meas tran vdout1_24ck8 FIND v(dout1_24) AT=45.025n

* CHECK dout1_25 Vdout1_25ck8 = 0 time = 45
.meas tran vdout1_25ck8 FIND v(dout1_25) AT=45.025n

* CHECK dout1_26 Vdout1_26ck8 = 0.9 time = 45
.meas tran vdout1_26ck8 FIND v(dout1_26) AT=45.025n

* CHECK dout1_27 Vdout1_27ck8 = 0.9 time = 45
.meas tran vdout1_27ck8 FIND v(dout1_27) AT=45.025n

* CHECK dout1_28 Vdout1_28ck8 = 0 time = 45
.meas tran vdout1_28ck8 FIND v(dout1_28) AT=45.025n

* CHECK dout1_29 Vdout1_29ck8 = 0 time = 45
.meas tran vdout1_29ck8 FIND v(dout1_29) AT=45.025n

* CHECK dout1_30 Vdout1_30ck8 = 0.9 time = 45
.meas tran vdout1_30ck8 FIND v(dout1_30) AT=45.025n

* CHECK dout1_31 Vdout1_31ck8 = 0 time = 45
.meas tran vdout1_31ck8 FIND v(dout1_31) AT=45.025n

* CHECK dout1_32 Vdout1_32ck8 = 0 time = 45
.meas tran vdout1_32ck8 FIND v(dout1_32) AT=45.025n

* CHECK dout1_33 Vdout1_33ck8 = 0 time = 45
.meas tran vdout1_33ck8 FIND v(dout1_33) AT=45.025n

* CHECK dout1_34 Vdout1_34ck8 = 0.9 time = 45
.meas tran vdout1_34ck8 FIND v(dout1_34) AT=45.025n

* CHECK dout1_35 Vdout1_35ck8 = 0.9 time = 45
.meas tran vdout1_35ck8 FIND v(dout1_35) AT=45.025n

* CHECK dout1_36 Vdout1_36ck8 = 0 time = 45
.meas tran vdout1_36ck8 FIND v(dout1_36) AT=45.025n

* CHECK dout1_37 Vdout1_37ck8 = 0 time = 45
.meas tran vdout1_37ck8 FIND v(dout1_37) AT=45.025n

* CHECK dout1_38 Vdout1_38ck8 = 0.9 time = 45
.meas tran vdout1_38ck8 FIND v(dout1_38) AT=45.025n

* CHECK dout1_39 Vdout1_39ck8 = 0.9 time = 45
.meas tran vdout1_39ck8 FIND v(dout1_39) AT=45.025n

* CHECK dout1_40 Vdout1_40ck8 = 0.9 time = 45
.meas tran vdout1_40ck8 FIND v(dout1_40) AT=45.025n

* CHECK dout1_41 Vdout1_41ck8 = 0.9 time = 45
.meas tran vdout1_41ck8 FIND v(dout1_41) AT=45.025n

* CHECK dout1_42 Vdout1_42ck8 = 0.9 time = 45
.meas tran vdout1_42ck8 FIND v(dout1_42) AT=45.025n

* CHECK dout1_43 Vdout1_43ck8 = 0 time = 45
.meas tran vdout1_43ck8 FIND v(dout1_43) AT=45.025n

* CHECK dout1_44 Vdout1_44ck8 = 0 time = 45
.meas tran vdout1_44ck8 FIND v(dout1_44) AT=45.025n

* CHECK dout1_45 Vdout1_45ck8 = 0.9 time = 45
.meas tran vdout1_45ck8 FIND v(dout1_45) AT=45.025n

* CHECK dout1_46 Vdout1_46ck8 = 0.9 time = 45
.meas tran vdout1_46ck8 FIND v(dout1_46) AT=45.025n

* CHECK dout1_47 Vdout1_47ck8 = 0.9 time = 45
.meas tran vdout1_47ck8 FIND v(dout1_47) AT=45.025n

* CHECK dout1_48 Vdout1_48ck8 = 0 time = 45
.meas tran vdout1_48ck8 FIND v(dout1_48) AT=45.025n

* CHECK dout1_49 Vdout1_49ck8 = 0.9 time = 45
.meas tran vdout1_49ck8 FIND v(dout1_49) AT=45.025n

* CHECK dout1_50 Vdout1_50ck8 = 0.9 time = 45
.meas tran vdout1_50ck8 FIND v(dout1_50) AT=45.025n

* CHECK dout1_51 Vdout1_51ck8 = 0.9 time = 45
.meas tran vdout1_51ck8 FIND v(dout1_51) AT=45.025n

* CHECK dout1_52 Vdout1_52ck8 = 0 time = 45
.meas tran vdout1_52ck8 FIND v(dout1_52) AT=45.025n

* CHECK dout1_53 Vdout1_53ck8 = 0 time = 45
.meas tran vdout1_53ck8 FIND v(dout1_53) AT=45.025n

* CHECK dout1_54 Vdout1_54ck8 = 0.9 time = 45
.meas tran vdout1_54ck8 FIND v(dout1_54) AT=45.025n

* CHECK dout1_55 Vdout1_55ck8 = 0.9 time = 45
.meas tran vdout1_55ck8 FIND v(dout1_55) AT=45.025n

* CHECK dout1_56 Vdout1_56ck8 = 0.9 time = 45
.meas tran vdout1_56ck8 FIND v(dout1_56) AT=45.025n

* CHECK dout1_57 Vdout1_57ck8 = 0.9 time = 45
.meas tran vdout1_57ck8 FIND v(dout1_57) AT=45.025n

* CHECK dout1_58 Vdout1_58ck8 = 0.9 time = 45
.meas tran vdout1_58ck8 FIND v(dout1_58) AT=45.025n

* CHECK dout1_59 Vdout1_59ck8 = 0 time = 45
.meas tran vdout1_59ck8 FIND v(dout1_59) AT=45.025n

* CHECK dout1_60 Vdout1_60ck8 = 0 time = 45
.meas tran vdout1_60ck8 FIND v(dout1_60) AT=45.025n

* CHECK dout1_61 Vdout1_61ck8 = 0.9 time = 45
.meas tran vdout1_61ck8 FIND v(dout1_61) AT=45.025n

* CHECK dout1_62 Vdout1_62ck8 = 0.9 time = 45
.meas tran vdout1_62ck8 FIND v(dout1_62) AT=45.025n

* CHECK dout1_63 Vdout1_63ck8 = 0 time = 45
.meas tran vdout1_63ck8 FIND v(dout1_63) AT=45.025n

* CHECK dout1_64 Vdout1_64ck8 = 0.9 time = 45
.meas tran vdout1_64ck8 FIND v(dout1_64) AT=45.025n

* CHECK dout1_65 Vdout1_65ck8 = 0 time = 45
.meas tran vdout1_65ck8 FIND v(dout1_65) AT=45.025n

* CHECK dout1_66 Vdout1_66ck8 = 0.9 time = 45
.meas tran vdout1_66ck8 FIND v(dout1_66) AT=45.025n

* CHECK dout1_67 Vdout1_67ck8 = 0.9 time = 45
.meas tran vdout1_67ck8 FIND v(dout1_67) AT=45.025n

* CHECK dout1_68 Vdout1_68ck8 = 0.9 time = 45
.meas tran vdout1_68ck8 FIND v(dout1_68) AT=45.025n

* CHECK dout1_69 Vdout1_69ck8 = 0.9 time = 45
.meas tran vdout1_69ck8 FIND v(dout1_69) AT=45.025n

* CHECK dout1_70 Vdout1_70ck8 = 0.9 time = 45
.meas tran vdout1_70ck8 FIND v(dout1_70) AT=45.025n

* CHECK dout1_71 Vdout1_71ck8 = 0.9 time = 45
.meas tran vdout1_71ck8 FIND v(dout1_71) AT=45.025n

* CHECK dout1_72 Vdout1_72ck8 = 0 time = 45
.meas tran vdout1_72ck8 FIND v(dout1_72) AT=45.025n

* CHECK dout1_73 Vdout1_73ck8 = 0.9 time = 45
.meas tran vdout1_73ck8 FIND v(dout1_73) AT=45.025n

* CHECK dout1_74 Vdout1_74ck8 = 0.9 time = 45
.meas tran vdout1_74ck8 FIND v(dout1_74) AT=45.025n

* CHECK dout1_75 Vdout1_75ck8 = 0.9 time = 45
.meas tran vdout1_75ck8 FIND v(dout1_75) AT=45.025n

* CHECK dout1_76 Vdout1_76ck8 = 0 time = 45
.meas tran vdout1_76ck8 FIND v(dout1_76) AT=45.025n

* CHECK dout1_77 Vdout1_77ck8 = 0 time = 45
.meas tran vdout1_77ck8 FIND v(dout1_77) AT=45.025n

* CHECK dout1_78 Vdout1_78ck8 = 0.9 time = 45
.meas tran vdout1_78ck8 FIND v(dout1_78) AT=45.025n

* CHECK dout1_79 Vdout1_79ck8 = 0.9 time = 45
.meas tran vdout1_79ck8 FIND v(dout1_79) AT=45.025n

* CHECK dout1_80 Vdout1_80ck8 = 0.9 time = 45
.meas tran vdout1_80ck8 FIND v(dout1_80) AT=45.025n

* CHECK dout1_81 Vdout1_81ck8 = 0 time = 45
.meas tran vdout1_81ck8 FIND v(dout1_81) AT=45.025n

* CHECK dout1_82 Vdout1_82ck8 = 0.9 time = 45
.meas tran vdout1_82ck8 FIND v(dout1_82) AT=45.025n

* CHECK dout1_83 Vdout1_83ck8 = 0.9 time = 45
.meas tran vdout1_83ck8 FIND v(dout1_83) AT=45.025n

* CHECK dout1_84 Vdout1_84ck8 = 0.9 time = 45
.meas tran vdout1_84ck8 FIND v(dout1_84) AT=45.025n

* CHECK dout1_85 Vdout1_85ck8 = 0 time = 45
.meas tran vdout1_85ck8 FIND v(dout1_85) AT=45.025n

* CHECK dout1_86 Vdout1_86ck8 = 0.9 time = 45
.meas tran vdout1_86ck8 FIND v(dout1_86) AT=45.025n

* CHECK dout1_87 Vdout1_87ck8 = 0.9 time = 45
.meas tran vdout1_87ck8 FIND v(dout1_87) AT=45.025n

* CHECK dout1_88 Vdout1_88ck8 = 0 time = 45
.meas tran vdout1_88ck8 FIND v(dout1_88) AT=45.025n

* CHECK dout1_89 Vdout1_89ck8 = 0 time = 45
.meas tran vdout1_89ck8 FIND v(dout1_89) AT=45.025n

* CHECK dout1_90 Vdout1_90ck8 = 0 time = 45
.meas tran vdout1_90ck8 FIND v(dout1_90) AT=45.025n

* CHECK dout1_91 Vdout1_91ck8 = 0 time = 45
.meas tran vdout1_91ck8 FIND v(dout1_91) AT=45.025n

* CHECK dout1_92 Vdout1_92ck8 = 0.9 time = 45
.meas tran vdout1_92ck8 FIND v(dout1_92) AT=45.025n

* CHECK dout1_93 Vdout1_93ck8 = 0 time = 45
.meas tran vdout1_93ck8 FIND v(dout1_93) AT=45.025n

* CHECK dout1_94 Vdout1_94ck8 = 0.9 time = 45
.meas tran vdout1_94ck8 FIND v(dout1_94) AT=45.025n

* CHECK dout1_95 Vdout1_95ck8 = 0 time = 45
.meas tran vdout1_95ck8 FIND v(dout1_95) AT=45.025n

* CHECK dout1_96 Vdout1_96ck8 = 0 time = 45
.meas tran vdout1_96ck8 FIND v(dout1_96) AT=45.025n

* CHECK dout1_97 Vdout1_97ck8 = 0.9 time = 45
.meas tran vdout1_97ck8 FIND v(dout1_97) AT=45.025n

* CHECK dout1_98 Vdout1_98ck8 = 0.9 time = 45
.meas tran vdout1_98ck8 FIND v(dout1_98) AT=45.025n

* CHECK dout1_99 Vdout1_99ck8 = 0.9 time = 45
.meas tran vdout1_99ck8 FIND v(dout1_99) AT=45.025n

* CHECK dout1_100 Vdout1_100ck8 = 0.9 time = 45
.meas tran vdout1_100ck8 FIND v(dout1_100) AT=45.025n

* CHECK dout1_101 Vdout1_101ck8 = 0 time = 45
.meas tran vdout1_101ck8 FIND v(dout1_101) AT=45.025n

* CHECK dout1_102 Vdout1_102ck8 = 0.9 time = 45
.meas tran vdout1_102ck8 FIND v(dout1_102) AT=45.025n

* CHECK dout1_103 Vdout1_103ck8 = 0 time = 45
.meas tran vdout1_103ck8 FIND v(dout1_103) AT=45.025n

* CHECK dout1_104 Vdout1_104ck8 = 0 time = 45
.meas tran vdout1_104ck8 FIND v(dout1_104) AT=45.025n

* CHECK dout1_105 Vdout1_105ck8 = 0 time = 45
.meas tran vdout1_105ck8 FIND v(dout1_105) AT=45.025n

* CHECK dout1_106 Vdout1_106ck8 = 0 time = 45
.meas tran vdout1_106ck8 FIND v(dout1_106) AT=45.025n

* CHECK dout1_107 Vdout1_107ck8 = 0 time = 45
.meas tran vdout1_107ck8 FIND v(dout1_107) AT=45.025n

* CHECK dout1_108 Vdout1_108ck8 = 0.9 time = 45
.meas tran vdout1_108ck8 FIND v(dout1_108) AT=45.025n

* CHECK dout1_109 Vdout1_109ck8 = 0.9 time = 45
.meas tran vdout1_109ck8 FIND v(dout1_109) AT=45.025n

* CHECK dout1_110 Vdout1_110ck8 = 0.9 time = 45
.meas tran vdout1_110ck8 FIND v(dout1_110) AT=45.025n

* CHECK dout1_111 Vdout1_111ck8 = 0.9 time = 45
.meas tran vdout1_111ck8 FIND v(dout1_111) AT=45.025n

* CHECK dout1_112 Vdout1_112ck8 = 0 time = 45
.meas tran vdout1_112ck8 FIND v(dout1_112) AT=45.025n

* CHECK dout1_113 Vdout1_113ck8 = 0 time = 45
.meas tran vdout1_113ck8 FIND v(dout1_113) AT=45.025n

* CHECK dout1_114 Vdout1_114ck8 = 0.9 time = 45
.meas tran vdout1_114ck8 FIND v(dout1_114) AT=45.025n

* CHECK dout1_115 Vdout1_115ck8 = 0.9 time = 45
.meas tran vdout1_115ck8 FIND v(dout1_115) AT=45.025n

* CHECK dout1_116 Vdout1_116ck8 = 0 time = 45
.meas tran vdout1_116ck8 FIND v(dout1_116) AT=45.025n

* CHECK dout1_117 Vdout1_117ck8 = 0 time = 45
.meas tran vdout1_117ck8 FIND v(dout1_117) AT=45.025n

* CHECK dout1_118 Vdout1_118ck8 = 0.9 time = 45
.meas tran vdout1_118ck8 FIND v(dout1_118) AT=45.025n

* CHECK dout1_119 Vdout1_119ck8 = 0 time = 45
.meas tran vdout1_119ck8 FIND v(dout1_119) AT=45.025n

* CHECK dout1_0 Vdout1_0ck11 = 0.9 time = 60
.meas tran vdout1_0ck11 FIND v(dout1_0) AT=60.025n

* CHECK dout1_1 Vdout1_1ck11 = 0.9 time = 60
.meas tran vdout1_1ck11 FIND v(dout1_1) AT=60.025n

* CHECK dout1_2 Vdout1_2ck11 = 0.9 time = 60
.meas tran vdout1_2ck11 FIND v(dout1_2) AT=60.025n

* CHECK dout1_3 Vdout1_3ck11 = 0 time = 60
.meas tran vdout1_3ck11 FIND v(dout1_3) AT=60.025n

* CHECK dout1_4 Vdout1_4ck11 = 0 time = 60
.meas tran vdout1_4ck11 FIND v(dout1_4) AT=60.025n

* CHECK dout1_5 Vdout1_5ck11 = 0.9 time = 60
.meas tran vdout1_5ck11 FIND v(dout1_5) AT=60.025n

* CHECK dout1_6 Vdout1_6ck11 = 0.9 time = 60
.meas tran vdout1_6ck11 FIND v(dout1_6) AT=60.025n

* CHECK dout1_7 Vdout1_7ck11 = 0.9 time = 60
.meas tran vdout1_7ck11 FIND v(dout1_7) AT=60.025n

* CHECK dout1_8 Vdout1_8ck11 = 0.9 time = 60
.meas tran vdout1_8ck11 FIND v(dout1_8) AT=60.025n

* CHECK dout1_9 Vdout1_9ck11 = 0.9 time = 60
.meas tran vdout1_9ck11 FIND v(dout1_9) AT=60.025n

* CHECK dout1_10 Vdout1_10ck11 = 0.9 time = 60
.meas tran vdout1_10ck11 FIND v(dout1_10) AT=60.025n

* CHECK dout1_11 Vdout1_11ck11 = 0.9 time = 60
.meas tran vdout1_11ck11 FIND v(dout1_11) AT=60.025n

* CHECK dout1_12 Vdout1_12ck11 = 0 time = 60
.meas tran vdout1_12ck11 FIND v(dout1_12) AT=60.025n

* CHECK dout1_13 Vdout1_13ck11 = 0 time = 60
.meas tran vdout1_13ck11 FIND v(dout1_13) AT=60.025n

* CHECK dout1_14 Vdout1_14ck11 = 0.9 time = 60
.meas tran vdout1_14ck11 FIND v(dout1_14) AT=60.025n

* CHECK dout1_15 Vdout1_15ck11 = 0.9 time = 60
.meas tran vdout1_15ck11 FIND v(dout1_15) AT=60.025n

* CHECK dout1_16 Vdout1_16ck11 = 0 time = 60
.meas tran vdout1_16ck11 FIND v(dout1_16) AT=60.025n

* CHECK dout1_17 Vdout1_17ck11 = 0.9 time = 60
.meas tran vdout1_17ck11 FIND v(dout1_17) AT=60.025n

* CHECK dout1_18 Vdout1_18ck11 = 0 time = 60
.meas tran vdout1_18ck11 FIND v(dout1_18) AT=60.025n

* CHECK dout1_19 Vdout1_19ck11 = 0 time = 60
.meas tran vdout1_19ck11 FIND v(dout1_19) AT=60.025n

* CHECK dout1_20 Vdout1_20ck11 = 0.9 time = 60
.meas tran vdout1_20ck11 FIND v(dout1_20) AT=60.025n

* CHECK dout1_21 Vdout1_21ck11 = 0.9 time = 60
.meas tran vdout1_21ck11 FIND v(dout1_21) AT=60.025n

* CHECK dout1_22 Vdout1_22ck11 = 0.9 time = 60
.meas tran vdout1_22ck11 FIND v(dout1_22) AT=60.025n

* CHECK dout1_23 Vdout1_23ck11 = 0 time = 60
.meas tran vdout1_23ck11 FIND v(dout1_23) AT=60.025n

* CHECK dout1_24 Vdout1_24ck11 = 0.9 time = 60
.meas tran vdout1_24ck11 FIND v(dout1_24) AT=60.025n

* CHECK dout1_25 Vdout1_25ck11 = 0 time = 60
.meas tran vdout1_25ck11 FIND v(dout1_25) AT=60.025n

* CHECK dout1_26 Vdout1_26ck11 = 0 time = 60
.meas tran vdout1_26ck11 FIND v(dout1_26) AT=60.025n

* CHECK dout1_27 Vdout1_27ck11 = 0.9 time = 60
.meas tran vdout1_27ck11 FIND v(dout1_27) AT=60.025n

* CHECK dout1_28 Vdout1_28ck11 = 0 time = 60
.meas tran vdout1_28ck11 FIND v(dout1_28) AT=60.025n

* CHECK dout1_29 Vdout1_29ck11 = 0 time = 60
.meas tran vdout1_29ck11 FIND v(dout1_29) AT=60.025n

* CHECK dout1_30 Vdout1_30ck11 = 0 time = 60
.meas tran vdout1_30ck11 FIND v(dout1_30) AT=60.025n

* CHECK dout1_31 Vdout1_31ck11 = 0 time = 60
.meas tran vdout1_31ck11 FIND v(dout1_31) AT=60.025n

* CHECK dout1_32 Vdout1_32ck11 = 0.9 time = 60
.meas tran vdout1_32ck11 FIND v(dout1_32) AT=60.025n

* CHECK dout1_33 Vdout1_33ck11 = 0 time = 60
.meas tran vdout1_33ck11 FIND v(dout1_33) AT=60.025n

* CHECK dout1_34 Vdout1_34ck11 = 0 time = 60
.meas tran vdout1_34ck11 FIND v(dout1_34) AT=60.025n

* CHECK dout1_35 Vdout1_35ck11 = 0.9 time = 60
.meas tran vdout1_35ck11 FIND v(dout1_35) AT=60.025n

* CHECK dout1_36 Vdout1_36ck11 = 0.9 time = 60
.meas tran vdout1_36ck11 FIND v(dout1_36) AT=60.025n

* CHECK dout1_37 Vdout1_37ck11 = 0.9 time = 60
.meas tran vdout1_37ck11 FIND v(dout1_37) AT=60.025n

* CHECK dout1_38 Vdout1_38ck11 = 0 time = 60
.meas tran vdout1_38ck11 FIND v(dout1_38) AT=60.025n

* CHECK dout1_39 Vdout1_39ck11 = 0.9 time = 60
.meas tran vdout1_39ck11 FIND v(dout1_39) AT=60.025n

* CHECK dout1_40 Vdout1_40ck11 = 0 time = 60
.meas tran vdout1_40ck11 FIND v(dout1_40) AT=60.025n

* CHECK dout1_41 Vdout1_41ck11 = 0 time = 60
.meas tran vdout1_41ck11 FIND v(dout1_41) AT=60.025n

* CHECK dout1_42 Vdout1_42ck11 = 0 time = 60
.meas tran vdout1_42ck11 FIND v(dout1_42) AT=60.025n

* CHECK dout1_43 Vdout1_43ck11 = 0.9 time = 60
.meas tran vdout1_43ck11 FIND v(dout1_43) AT=60.025n

* CHECK dout1_44 Vdout1_44ck11 = 0 time = 60
.meas tran vdout1_44ck11 FIND v(dout1_44) AT=60.025n

* CHECK dout1_45 Vdout1_45ck11 = 0 time = 60
.meas tran vdout1_45ck11 FIND v(dout1_45) AT=60.025n

* CHECK dout1_46 Vdout1_46ck11 = 0 time = 60
.meas tran vdout1_46ck11 FIND v(dout1_46) AT=60.025n

* CHECK dout1_47 Vdout1_47ck11 = 0 time = 60
.meas tran vdout1_47ck11 FIND v(dout1_47) AT=60.025n

* CHECK dout1_48 Vdout1_48ck11 = 0 time = 60
.meas tran vdout1_48ck11 FIND v(dout1_48) AT=60.025n

* CHECK dout1_49 Vdout1_49ck11 = 0 time = 60
.meas tran vdout1_49ck11 FIND v(dout1_49) AT=60.025n

* CHECK dout1_50 Vdout1_50ck11 = 0.9 time = 60
.meas tran vdout1_50ck11 FIND v(dout1_50) AT=60.025n

* CHECK dout1_51 Vdout1_51ck11 = 0 time = 60
.meas tran vdout1_51ck11 FIND v(dout1_51) AT=60.025n

* CHECK dout1_52 Vdout1_52ck11 = 0.9 time = 60
.meas tran vdout1_52ck11 FIND v(dout1_52) AT=60.025n

* CHECK dout1_53 Vdout1_53ck11 = 0 time = 60
.meas tran vdout1_53ck11 FIND v(dout1_53) AT=60.025n

* CHECK dout1_54 Vdout1_54ck11 = 0.9 time = 60
.meas tran vdout1_54ck11 FIND v(dout1_54) AT=60.025n

* CHECK dout1_55 Vdout1_55ck11 = 0.9 time = 60
.meas tran vdout1_55ck11 FIND v(dout1_55) AT=60.025n

* CHECK dout1_56 Vdout1_56ck11 = 0.9 time = 60
.meas tran vdout1_56ck11 FIND v(dout1_56) AT=60.025n

* CHECK dout1_57 Vdout1_57ck11 = 0 time = 60
.meas tran vdout1_57ck11 FIND v(dout1_57) AT=60.025n

* CHECK dout1_58 Vdout1_58ck11 = 0 time = 60
.meas tran vdout1_58ck11 FIND v(dout1_58) AT=60.025n

* CHECK dout1_59 Vdout1_59ck11 = 0 time = 60
.meas tran vdout1_59ck11 FIND v(dout1_59) AT=60.025n

* CHECK dout1_60 Vdout1_60ck11 = 0 time = 60
.meas tran vdout1_60ck11 FIND v(dout1_60) AT=60.025n

* CHECK dout1_61 Vdout1_61ck11 = 0 time = 60
.meas tran vdout1_61ck11 FIND v(dout1_61) AT=60.025n

* CHECK dout1_62 Vdout1_62ck11 = 0.9 time = 60
.meas tran vdout1_62ck11 FIND v(dout1_62) AT=60.025n

* CHECK dout1_63 Vdout1_63ck11 = 0.9 time = 60
.meas tran vdout1_63ck11 FIND v(dout1_63) AT=60.025n

* CHECK dout1_64 Vdout1_64ck11 = 0.9 time = 60
.meas tran vdout1_64ck11 FIND v(dout1_64) AT=60.025n

* CHECK dout1_65 Vdout1_65ck11 = 0 time = 60
.meas tran vdout1_65ck11 FIND v(dout1_65) AT=60.025n

* CHECK dout1_66 Vdout1_66ck11 = 0 time = 60
.meas tran vdout1_66ck11 FIND v(dout1_66) AT=60.025n

* CHECK dout1_67 Vdout1_67ck11 = 0 time = 60
.meas tran vdout1_67ck11 FIND v(dout1_67) AT=60.025n

* CHECK dout1_68 Vdout1_68ck11 = 0 time = 60
.meas tran vdout1_68ck11 FIND v(dout1_68) AT=60.025n

* CHECK dout1_69 Vdout1_69ck11 = 0 time = 60
.meas tran vdout1_69ck11 FIND v(dout1_69) AT=60.025n

* CHECK dout1_70 Vdout1_70ck11 = 0 time = 60
.meas tran vdout1_70ck11 FIND v(dout1_70) AT=60.025n

* CHECK dout1_71 Vdout1_71ck11 = 0 time = 60
.meas tran vdout1_71ck11 FIND v(dout1_71) AT=60.025n

* CHECK dout1_72 Vdout1_72ck11 = 0 time = 60
.meas tran vdout1_72ck11 FIND v(dout1_72) AT=60.025n

* CHECK dout1_73 Vdout1_73ck11 = 0.9 time = 60
.meas tran vdout1_73ck11 FIND v(dout1_73) AT=60.025n

* CHECK dout1_74 Vdout1_74ck11 = 0 time = 60
.meas tran vdout1_74ck11 FIND v(dout1_74) AT=60.025n

* CHECK dout1_75 Vdout1_75ck11 = 0 time = 60
.meas tran vdout1_75ck11 FIND v(dout1_75) AT=60.025n

* CHECK dout1_76 Vdout1_76ck11 = 0 time = 60
.meas tran vdout1_76ck11 FIND v(dout1_76) AT=60.025n

* CHECK dout1_77 Vdout1_77ck11 = 0 time = 60
.meas tran vdout1_77ck11 FIND v(dout1_77) AT=60.025n

* CHECK dout1_78 Vdout1_78ck11 = 0.9 time = 60
.meas tran vdout1_78ck11 FIND v(dout1_78) AT=60.025n

* CHECK dout1_79 Vdout1_79ck11 = 0.9 time = 60
.meas tran vdout1_79ck11 FIND v(dout1_79) AT=60.025n

* CHECK dout1_80 Vdout1_80ck11 = 0.9 time = 60
.meas tran vdout1_80ck11 FIND v(dout1_80) AT=60.025n

* CHECK dout1_81 Vdout1_81ck11 = 0 time = 60
.meas tran vdout1_81ck11 FIND v(dout1_81) AT=60.025n

* CHECK dout1_82 Vdout1_82ck11 = 0.9 time = 60
.meas tran vdout1_82ck11 FIND v(dout1_82) AT=60.025n

* CHECK dout1_83 Vdout1_83ck11 = 0 time = 60
.meas tran vdout1_83ck11 FIND v(dout1_83) AT=60.025n

* CHECK dout1_84 Vdout1_84ck11 = 0 time = 60
.meas tran vdout1_84ck11 FIND v(dout1_84) AT=60.025n

* CHECK dout1_85 Vdout1_85ck11 = 0.9 time = 60
.meas tran vdout1_85ck11 FIND v(dout1_85) AT=60.025n

* CHECK dout1_86 Vdout1_86ck11 = 0.9 time = 60
.meas tran vdout1_86ck11 FIND v(dout1_86) AT=60.025n

* CHECK dout1_87 Vdout1_87ck11 = 0.9 time = 60
.meas tran vdout1_87ck11 FIND v(dout1_87) AT=60.025n

* CHECK dout1_88 Vdout1_88ck11 = 0 time = 60
.meas tran vdout1_88ck11 FIND v(dout1_88) AT=60.025n

* CHECK dout1_89 Vdout1_89ck11 = 0 time = 60
.meas tran vdout1_89ck11 FIND v(dout1_89) AT=60.025n

* CHECK dout1_90 Vdout1_90ck11 = 0 time = 60
.meas tran vdout1_90ck11 FIND v(dout1_90) AT=60.025n

* CHECK dout1_91 Vdout1_91ck11 = 0 time = 60
.meas tran vdout1_91ck11 FIND v(dout1_91) AT=60.025n

* CHECK dout1_92 Vdout1_92ck11 = 0 time = 60
.meas tran vdout1_92ck11 FIND v(dout1_92) AT=60.025n

* CHECK dout1_93 Vdout1_93ck11 = 0 time = 60
.meas tran vdout1_93ck11 FIND v(dout1_93) AT=60.025n

* CHECK dout1_94 Vdout1_94ck11 = 0 time = 60
.meas tran vdout1_94ck11 FIND v(dout1_94) AT=60.025n

* CHECK dout1_95 Vdout1_95ck11 = 0 time = 60
.meas tran vdout1_95ck11 FIND v(dout1_95) AT=60.025n

* CHECK dout1_96 Vdout1_96ck11 = 0 time = 60
.meas tran vdout1_96ck11 FIND v(dout1_96) AT=60.025n

* CHECK dout1_97 Vdout1_97ck11 = 0 time = 60
.meas tran vdout1_97ck11 FIND v(dout1_97) AT=60.025n

* CHECK dout1_98 Vdout1_98ck11 = 0 time = 60
.meas tran vdout1_98ck11 FIND v(dout1_98) AT=60.025n

* CHECK dout1_99 Vdout1_99ck11 = 0.9 time = 60
.meas tran vdout1_99ck11 FIND v(dout1_99) AT=60.025n

* CHECK dout1_100 Vdout1_100ck11 = 0 time = 60
.meas tran vdout1_100ck11 FIND v(dout1_100) AT=60.025n

* CHECK dout1_101 Vdout1_101ck11 = 0.9 time = 60
.meas tran vdout1_101ck11 FIND v(dout1_101) AT=60.025n

* CHECK dout1_102 Vdout1_102ck11 = 0 time = 60
.meas tran vdout1_102ck11 FIND v(dout1_102) AT=60.025n

* CHECK dout1_103 Vdout1_103ck11 = 0 time = 60
.meas tran vdout1_103ck11 FIND v(dout1_103) AT=60.025n

* CHECK dout1_104 Vdout1_104ck11 = 0 time = 60
.meas tran vdout1_104ck11 FIND v(dout1_104) AT=60.025n

* CHECK dout1_105 Vdout1_105ck11 = 0 time = 60
.meas tran vdout1_105ck11 FIND v(dout1_105) AT=60.025n

* CHECK dout1_106 Vdout1_106ck11 = 0.9 time = 60
.meas tran vdout1_106ck11 FIND v(dout1_106) AT=60.025n

* CHECK dout1_107 Vdout1_107ck11 = 0 time = 60
.meas tran vdout1_107ck11 FIND v(dout1_107) AT=60.025n

* CHECK dout1_108 Vdout1_108ck11 = 0 time = 60
.meas tran vdout1_108ck11 FIND v(dout1_108) AT=60.025n

* CHECK dout1_109 Vdout1_109ck11 = 0.9 time = 60
.meas tran vdout1_109ck11 FIND v(dout1_109) AT=60.025n

* CHECK dout1_110 Vdout1_110ck11 = 0 time = 60
.meas tran vdout1_110ck11 FIND v(dout1_110) AT=60.025n

* CHECK dout1_111 Vdout1_111ck11 = 0 time = 60
.meas tran vdout1_111ck11 FIND v(dout1_111) AT=60.025n

* CHECK dout1_112 Vdout1_112ck11 = 0 time = 60
.meas tran vdout1_112ck11 FIND v(dout1_112) AT=60.025n

* CHECK dout1_113 Vdout1_113ck11 = 0.9 time = 60
.meas tran vdout1_113ck11 FIND v(dout1_113) AT=60.025n

* CHECK dout1_114 Vdout1_114ck11 = 0.9 time = 60
.meas tran vdout1_114ck11 FIND v(dout1_114) AT=60.025n

* CHECK dout1_115 Vdout1_115ck11 = 0 time = 60
.meas tran vdout1_115ck11 FIND v(dout1_115) AT=60.025n

* CHECK dout1_116 Vdout1_116ck11 = 0 time = 60
.meas tran vdout1_116ck11 FIND v(dout1_116) AT=60.025n

* CHECK dout1_117 Vdout1_117ck11 = 0 time = 60
.meas tran vdout1_117ck11 FIND v(dout1_117) AT=60.025n

* CHECK dout1_118 Vdout1_118ck11 = 0 time = 60
.meas tran vdout1_118ck11 FIND v(dout1_118) AT=60.025n

* CHECK dout1_119 Vdout1_119ck11 = 0 time = 60
.meas tran vdout1_119ck11 FIND v(dout1_119) AT=60.025n

* CHECK dout1_0 Vdout1_0ck15 = 0 time = 80
.meas tran vdout1_0ck15 FIND v(dout1_0) AT=80.025n

* CHECK dout1_1 Vdout1_1ck15 = 0.9 time = 80
.meas tran vdout1_1ck15 FIND v(dout1_1) AT=80.025n

* CHECK dout1_2 Vdout1_2ck15 = 0.9 time = 80
.meas tran vdout1_2ck15 FIND v(dout1_2) AT=80.025n

* CHECK dout1_3 Vdout1_3ck15 = 0.9 time = 80
.meas tran vdout1_3ck15 FIND v(dout1_3) AT=80.025n

* CHECK dout1_4 Vdout1_4ck15 = 0.9 time = 80
.meas tran vdout1_4ck15 FIND v(dout1_4) AT=80.025n

* CHECK dout1_5 Vdout1_5ck15 = 0 time = 80
.meas tran vdout1_5ck15 FIND v(dout1_5) AT=80.025n

* CHECK dout1_6 Vdout1_6ck15 = 0.9 time = 80
.meas tran vdout1_6ck15 FIND v(dout1_6) AT=80.025n

* CHECK dout1_7 Vdout1_7ck15 = 0.9 time = 80
.meas tran vdout1_7ck15 FIND v(dout1_7) AT=80.025n

* CHECK dout1_8 Vdout1_8ck15 = 0 time = 80
.meas tran vdout1_8ck15 FIND v(dout1_8) AT=80.025n

* CHECK dout1_9 Vdout1_9ck15 = 0 time = 80
.meas tran vdout1_9ck15 FIND v(dout1_9) AT=80.025n

* CHECK dout1_10 Vdout1_10ck15 = 0 time = 80
.meas tran vdout1_10ck15 FIND v(dout1_10) AT=80.025n

* CHECK dout1_11 Vdout1_11ck15 = 0 time = 80
.meas tran vdout1_11ck15 FIND v(dout1_11) AT=80.025n

* CHECK dout1_12 Vdout1_12ck15 = 0 time = 80
.meas tran vdout1_12ck15 FIND v(dout1_12) AT=80.025n

* CHECK dout1_13 Vdout1_13ck15 = 0.9 time = 80
.meas tran vdout1_13ck15 FIND v(dout1_13) AT=80.025n

* CHECK dout1_14 Vdout1_14ck15 = 0.9 time = 80
.meas tran vdout1_14ck15 FIND v(dout1_14) AT=80.025n

* CHECK dout1_15 Vdout1_15ck15 = 0 time = 80
.meas tran vdout1_15ck15 FIND v(dout1_15) AT=80.025n

* CHECK dout1_16 Vdout1_16ck15 = 0.9 time = 80
.meas tran vdout1_16ck15 FIND v(dout1_16) AT=80.025n

* CHECK dout1_17 Vdout1_17ck15 = 0 time = 80
.meas tran vdout1_17ck15 FIND v(dout1_17) AT=80.025n

* CHECK dout1_18 Vdout1_18ck15 = 0.9 time = 80
.meas tran vdout1_18ck15 FIND v(dout1_18) AT=80.025n

* CHECK dout1_19 Vdout1_19ck15 = 0.9 time = 80
.meas tran vdout1_19ck15 FIND v(dout1_19) AT=80.025n

* CHECK dout1_20 Vdout1_20ck15 = 0.9 time = 80
.meas tran vdout1_20ck15 FIND v(dout1_20) AT=80.025n

* CHECK dout1_21 Vdout1_21ck15 = 0.9 time = 80
.meas tran vdout1_21ck15 FIND v(dout1_21) AT=80.025n

* CHECK dout1_22 Vdout1_22ck15 = 0.9 time = 80
.meas tran vdout1_22ck15 FIND v(dout1_22) AT=80.025n

* CHECK dout1_23 Vdout1_23ck15 = 0.9 time = 80
.meas tran vdout1_23ck15 FIND v(dout1_23) AT=80.025n

* CHECK dout1_24 Vdout1_24ck15 = 0.9 time = 80
.meas tran vdout1_24ck15 FIND v(dout1_24) AT=80.025n

* CHECK dout1_25 Vdout1_25ck15 = 0 time = 80
.meas tran vdout1_25ck15 FIND v(dout1_25) AT=80.025n

* CHECK dout1_26 Vdout1_26ck15 = 0.9 time = 80
.meas tran vdout1_26ck15 FIND v(dout1_26) AT=80.025n

* CHECK dout1_27 Vdout1_27ck15 = 0 time = 80
.meas tran vdout1_27ck15 FIND v(dout1_27) AT=80.025n

* CHECK dout1_28 Vdout1_28ck15 = 0 time = 80
.meas tran vdout1_28ck15 FIND v(dout1_28) AT=80.025n

* CHECK dout1_29 Vdout1_29ck15 = 0 time = 80
.meas tran vdout1_29ck15 FIND v(dout1_29) AT=80.025n

* CHECK dout1_30 Vdout1_30ck15 = 0.9 time = 80
.meas tran vdout1_30ck15 FIND v(dout1_30) AT=80.025n

* CHECK dout1_31 Vdout1_31ck15 = 0.9 time = 80
.meas tran vdout1_31ck15 FIND v(dout1_31) AT=80.025n

* CHECK dout1_32 Vdout1_32ck15 = 0 time = 80
.meas tran vdout1_32ck15 FIND v(dout1_32) AT=80.025n

* CHECK dout1_33 Vdout1_33ck15 = 0.9 time = 80
.meas tran vdout1_33ck15 FIND v(dout1_33) AT=80.025n

* CHECK dout1_34 Vdout1_34ck15 = 0.9 time = 80
.meas tran vdout1_34ck15 FIND v(dout1_34) AT=80.025n

* CHECK dout1_35 Vdout1_35ck15 = 0.9 time = 80
.meas tran vdout1_35ck15 FIND v(dout1_35) AT=80.025n

* CHECK dout1_36 Vdout1_36ck15 = 0.9 time = 80
.meas tran vdout1_36ck15 FIND v(dout1_36) AT=80.025n

* CHECK dout1_37 Vdout1_37ck15 = 0.9 time = 80
.meas tran vdout1_37ck15 FIND v(dout1_37) AT=80.025n

* CHECK dout1_38 Vdout1_38ck15 = 0 time = 80
.meas tran vdout1_38ck15 FIND v(dout1_38) AT=80.025n

* CHECK dout1_39 Vdout1_39ck15 = 0 time = 80
.meas tran vdout1_39ck15 FIND v(dout1_39) AT=80.025n

* CHECK dout1_40 Vdout1_40ck15 = 0.9 time = 80
.meas tran vdout1_40ck15 FIND v(dout1_40) AT=80.025n

* CHECK dout1_41 Vdout1_41ck15 = 0.9 time = 80
.meas tran vdout1_41ck15 FIND v(dout1_41) AT=80.025n

* CHECK dout1_42 Vdout1_42ck15 = 0.9 time = 80
.meas tran vdout1_42ck15 FIND v(dout1_42) AT=80.025n

* CHECK dout1_43 Vdout1_43ck15 = 0.9 time = 80
.meas tran vdout1_43ck15 FIND v(dout1_43) AT=80.025n

* CHECK dout1_44 Vdout1_44ck15 = 0 time = 80
.meas tran vdout1_44ck15 FIND v(dout1_44) AT=80.025n

* CHECK dout1_45 Vdout1_45ck15 = 0.9 time = 80
.meas tran vdout1_45ck15 FIND v(dout1_45) AT=80.025n

* CHECK dout1_46 Vdout1_46ck15 = 0.9 time = 80
.meas tran vdout1_46ck15 FIND v(dout1_46) AT=80.025n

* CHECK dout1_47 Vdout1_47ck15 = 0.9 time = 80
.meas tran vdout1_47ck15 FIND v(dout1_47) AT=80.025n

* CHECK dout1_48 Vdout1_48ck15 = 0 time = 80
.meas tran vdout1_48ck15 FIND v(dout1_48) AT=80.025n

* CHECK dout1_49 Vdout1_49ck15 = 0 time = 80
.meas tran vdout1_49ck15 FIND v(dout1_49) AT=80.025n

* CHECK dout1_50 Vdout1_50ck15 = 0 time = 80
.meas tran vdout1_50ck15 FIND v(dout1_50) AT=80.025n

* CHECK dout1_51 Vdout1_51ck15 = 0 time = 80
.meas tran vdout1_51ck15 FIND v(dout1_51) AT=80.025n

* CHECK dout1_52 Vdout1_52ck15 = 0 time = 80
.meas tran vdout1_52ck15 FIND v(dout1_52) AT=80.025n

* CHECK dout1_53 Vdout1_53ck15 = 0.9 time = 80
.meas tran vdout1_53ck15 FIND v(dout1_53) AT=80.025n

* CHECK dout1_54 Vdout1_54ck15 = 0 time = 80
.meas tran vdout1_54ck15 FIND v(dout1_54) AT=80.025n

* CHECK dout1_55 Vdout1_55ck15 = 0.9 time = 80
.meas tran vdout1_55ck15 FIND v(dout1_55) AT=80.025n

* CHECK dout1_56 Vdout1_56ck15 = 0.9 time = 80
.meas tran vdout1_56ck15 FIND v(dout1_56) AT=80.025n

* CHECK dout1_57 Vdout1_57ck15 = 0.9 time = 80
.meas tran vdout1_57ck15 FIND v(dout1_57) AT=80.025n

* CHECK dout1_58 Vdout1_58ck15 = 0.9 time = 80
.meas tran vdout1_58ck15 FIND v(dout1_58) AT=80.025n

* CHECK dout1_59 Vdout1_59ck15 = 0 time = 80
.meas tran vdout1_59ck15 FIND v(dout1_59) AT=80.025n

* CHECK dout1_60 Vdout1_60ck15 = 0 time = 80
.meas tran vdout1_60ck15 FIND v(dout1_60) AT=80.025n

* CHECK dout1_61 Vdout1_61ck15 = 0 time = 80
.meas tran vdout1_61ck15 FIND v(dout1_61) AT=80.025n

* CHECK dout1_62 Vdout1_62ck15 = 0 time = 80
.meas tran vdout1_62ck15 FIND v(dout1_62) AT=80.025n

* CHECK dout1_63 Vdout1_63ck15 = 0.9 time = 80
.meas tran vdout1_63ck15 FIND v(dout1_63) AT=80.025n

* CHECK dout1_64 Vdout1_64ck15 = 0.9 time = 80
.meas tran vdout1_64ck15 FIND v(dout1_64) AT=80.025n

* CHECK dout1_65 Vdout1_65ck15 = 0.9 time = 80
.meas tran vdout1_65ck15 FIND v(dout1_65) AT=80.025n

* CHECK dout1_66 Vdout1_66ck15 = 0.9 time = 80
.meas tran vdout1_66ck15 FIND v(dout1_66) AT=80.025n

* CHECK dout1_67 Vdout1_67ck15 = 0.9 time = 80
.meas tran vdout1_67ck15 FIND v(dout1_67) AT=80.025n

* CHECK dout1_68 Vdout1_68ck15 = 0 time = 80
.meas tran vdout1_68ck15 FIND v(dout1_68) AT=80.025n

* CHECK dout1_69 Vdout1_69ck15 = 0 time = 80
.meas tran vdout1_69ck15 FIND v(dout1_69) AT=80.025n

* CHECK dout1_70 Vdout1_70ck15 = 0 time = 80
.meas tran vdout1_70ck15 FIND v(dout1_70) AT=80.025n

* CHECK dout1_71 Vdout1_71ck15 = 0.9 time = 80
.meas tran vdout1_71ck15 FIND v(dout1_71) AT=80.025n

* CHECK dout1_72 Vdout1_72ck15 = 0 time = 80
.meas tran vdout1_72ck15 FIND v(dout1_72) AT=80.025n

* CHECK dout1_73 Vdout1_73ck15 = 0.9 time = 80
.meas tran vdout1_73ck15 FIND v(dout1_73) AT=80.025n

* CHECK dout1_74 Vdout1_74ck15 = 0 time = 80
.meas tran vdout1_74ck15 FIND v(dout1_74) AT=80.025n

* CHECK dout1_75 Vdout1_75ck15 = 0 time = 80
.meas tran vdout1_75ck15 FIND v(dout1_75) AT=80.025n

* CHECK dout1_76 Vdout1_76ck15 = 0 time = 80
.meas tran vdout1_76ck15 FIND v(dout1_76) AT=80.025n

* CHECK dout1_77 Vdout1_77ck15 = 0 time = 80
.meas tran vdout1_77ck15 FIND v(dout1_77) AT=80.025n

* CHECK dout1_78 Vdout1_78ck15 = 0.9 time = 80
.meas tran vdout1_78ck15 FIND v(dout1_78) AT=80.025n

* CHECK dout1_79 Vdout1_79ck15 = 0.9 time = 80
.meas tran vdout1_79ck15 FIND v(dout1_79) AT=80.025n

* CHECK dout1_80 Vdout1_80ck15 = 0 time = 80
.meas tran vdout1_80ck15 FIND v(dout1_80) AT=80.025n

* CHECK dout1_81 Vdout1_81ck15 = 0 time = 80
.meas tran vdout1_81ck15 FIND v(dout1_81) AT=80.025n

* CHECK dout1_82 Vdout1_82ck15 = 0.9 time = 80
.meas tran vdout1_82ck15 FIND v(dout1_82) AT=80.025n

* CHECK dout1_83 Vdout1_83ck15 = 0 time = 80
.meas tran vdout1_83ck15 FIND v(dout1_83) AT=80.025n

* CHECK dout1_84 Vdout1_84ck15 = 0.9 time = 80
.meas tran vdout1_84ck15 FIND v(dout1_84) AT=80.025n

* CHECK dout1_85 Vdout1_85ck15 = 0.9 time = 80
.meas tran vdout1_85ck15 FIND v(dout1_85) AT=80.025n

* CHECK dout1_86 Vdout1_86ck15 = 0.9 time = 80
.meas tran vdout1_86ck15 FIND v(dout1_86) AT=80.025n

* CHECK dout1_87 Vdout1_87ck15 = 0 time = 80
.meas tran vdout1_87ck15 FIND v(dout1_87) AT=80.025n

* CHECK dout1_88 Vdout1_88ck15 = 0.9 time = 80
.meas tran vdout1_88ck15 FIND v(dout1_88) AT=80.025n

* CHECK dout1_89 Vdout1_89ck15 = 0 time = 80
.meas tran vdout1_89ck15 FIND v(dout1_89) AT=80.025n

* CHECK dout1_90 Vdout1_90ck15 = 0 time = 80
.meas tran vdout1_90ck15 FIND v(dout1_90) AT=80.025n

* CHECK dout1_91 Vdout1_91ck15 = 0.9 time = 80
.meas tran vdout1_91ck15 FIND v(dout1_91) AT=80.025n

* CHECK dout1_92 Vdout1_92ck15 = 0 time = 80
.meas tran vdout1_92ck15 FIND v(dout1_92) AT=80.025n

* CHECK dout1_93 Vdout1_93ck15 = 0.9 time = 80
.meas tran vdout1_93ck15 FIND v(dout1_93) AT=80.025n

* CHECK dout1_94 Vdout1_94ck15 = 0.9 time = 80
.meas tran vdout1_94ck15 FIND v(dout1_94) AT=80.025n

* CHECK dout1_95 Vdout1_95ck15 = 0 time = 80
.meas tran vdout1_95ck15 FIND v(dout1_95) AT=80.025n

* CHECK dout1_96 Vdout1_96ck15 = 0.9 time = 80
.meas tran vdout1_96ck15 FIND v(dout1_96) AT=80.025n

* CHECK dout1_97 Vdout1_97ck15 = 0.9 time = 80
.meas tran vdout1_97ck15 FIND v(dout1_97) AT=80.025n

* CHECK dout1_98 Vdout1_98ck15 = 0 time = 80
.meas tran vdout1_98ck15 FIND v(dout1_98) AT=80.025n

* CHECK dout1_99 Vdout1_99ck15 = 0.9 time = 80
.meas tran vdout1_99ck15 FIND v(dout1_99) AT=80.025n

* CHECK dout1_100 Vdout1_100ck15 = 0.9 time = 80
.meas tran vdout1_100ck15 FIND v(dout1_100) AT=80.025n

* CHECK dout1_101 Vdout1_101ck15 = 0 time = 80
.meas tran vdout1_101ck15 FIND v(dout1_101) AT=80.025n

* CHECK dout1_102 Vdout1_102ck15 = 0 time = 80
.meas tran vdout1_102ck15 FIND v(dout1_102) AT=80.025n

* CHECK dout1_103 Vdout1_103ck15 = 0.9 time = 80
.meas tran vdout1_103ck15 FIND v(dout1_103) AT=80.025n

* CHECK dout1_104 Vdout1_104ck15 = 0.9 time = 80
.meas tran vdout1_104ck15 FIND v(dout1_104) AT=80.025n

* CHECK dout1_105 Vdout1_105ck15 = 0.9 time = 80
.meas tran vdout1_105ck15 FIND v(dout1_105) AT=80.025n

* CHECK dout1_106 Vdout1_106ck15 = 0.9 time = 80
.meas tran vdout1_106ck15 FIND v(dout1_106) AT=80.025n

* CHECK dout1_107 Vdout1_107ck15 = 0 time = 80
.meas tran vdout1_107ck15 FIND v(dout1_107) AT=80.025n

* CHECK dout1_108 Vdout1_108ck15 = 0 time = 80
.meas tran vdout1_108ck15 FIND v(dout1_108) AT=80.025n

* CHECK dout1_109 Vdout1_109ck15 = 0 time = 80
.meas tran vdout1_109ck15 FIND v(dout1_109) AT=80.025n

* CHECK dout1_110 Vdout1_110ck15 = 0.9 time = 80
.meas tran vdout1_110ck15 FIND v(dout1_110) AT=80.025n

* CHECK dout1_111 Vdout1_111ck15 = 0.9 time = 80
.meas tran vdout1_111ck15 FIND v(dout1_111) AT=80.025n

* CHECK dout1_112 Vdout1_112ck15 = 0.9 time = 80
.meas tran vdout1_112ck15 FIND v(dout1_112) AT=80.025n

* CHECK dout1_113 Vdout1_113ck15 = 0 time = 80
.meas tran vdout1_113ck15 FIND v(dout1_113) AT=80.025n

* CHECK dout1_114 Vdout1_114ck15 = 0.9 time = 80
.meas tran vdout1_114ck15 FIND v(dout1_114) AT=80.025n

* CHECK dout1_115 Vdout1_115ck15 = 0 time = 80
.meas tran vdout1_115ck15 FIND v(dout1_115) AT=80.025n

* CHECK dout1_116 Vdout1_116ck15 = 0 time = 80
.meas tran vdout1_116ck15 FIND v(dout1_116) AT=80.025n

* CHECK dout1_117 Vdout1_117ck15 = 0 time = 80
.meas tran vdout1_117ck15 FIND v(dout1_117) AT=80.025n

* CHECK dout1_118 Vdout1_118ck15 = 0.9 time = 80
.meas tran vdout1_118ck15 FIND v(dout1_118) AT=80.025n

* CHECK dout1_119 Vdout1_119ck15 = 0 time = 80
.meas tran vdout1_119ck15 FIND v(dout1_119) AT=80.025n

* CHECK dout1_0 Vdout1_0ck19 = 0 time = 100
.meas tran vdout1_0ck19 FIND v(dout1_0) AT=100.025n

* CHECK dout1_1 Vdout1_1ck19 = 0.9 time = 100
.meas tran vdout1_1ck19 FIND v(dout1_1) AT=100.025n

* CHECK dout1_2 Vdout1_2ck19 = 0.9 time = 100
.meas tran vdout1_2ck19 FIND v(dout1_2) AT=100.025n

* CHECK dout1_3 Vdout1_3ck19 = 0.9 time = 100
.meas tran vdout1_3ck19 FIND v(dout1_3) AT=100.025n

* CHECK dout1_4 Vdout1_4ck19 = 0.9 time = 100
.meas tran vdout1_4ck19 FIND v(dout1_4) AT=100.025n

* CHECK dout1_5 Vdout1_5ck19 = 0 time = 100
.meas tran vdout1_5ck19 FIND v(dout1_5) AT=100.025n

* CHECK dout1_6 Vdout1_6ck19 = 0.9 time = 100
.meas tran vdout1_6ck19 FIND v(dout1_6) AT=100.025n

* CHECK dout1_7 Vdout1_7ck19 = 0.9 time = 100
.meas tran vdout1_7ck19 FIND v(dout1_7) AT=100.025n

* CHECK dout1_8 Vdout1_8ck19 = 0 time = 100
.meas tran vdout1_8ck19 FIND v(dout1_8) AT=100.025n

* CHECK dout1_9 Vdout1_9ck19 = 0 time = 100
.meas tran vdout1_9ck19 FIND v(dout1_9) AT=100.025n

* CHECK dout1_10 Vdout1_10ck19 = 0 time = 100
.meas tran vdout1_10ck19 FIND v(dout1_10) AT=100.025n

* CHECK dout1_11 Vdout1_11ck19 = 0 time = 100
.meas tran vdout1_11ck19 FIND v(dout1_11) AT=100.025n

* CHECK dout1_12 Vdout1_12ck19 = 0 time = 100
.meas tran vdout1_12ck19 FIND v(dout1_12) AT=100.025n

* CHECK dout1_13 Vdout1_13ck19 = 0.9 time = 100
.meas tran vdout1_13ck19 FIND v(dout1_13) AT=100.025n

* CHECK dout1_14 Vdout1_14ck19 = 0.9 time = 100
.meas tran vdout1_14ck19 FIND v(dout1_14) AT=100.025n

* CHECK dout1_15 Vdout1_15ck19 = 0 time = 100
.meas tran vdout1_15ck19 FIND v(dout1_15) AT=100.025n

* CHECK dout1_16 Vdout1_16ck19 = 0.9 time = 100
.meas tran vdout1_16ck19 FIND v(dout1_16) AT=100.025n

* CHECK dout1_17 Vdout1_17ck19 = 0 time = 100
.meas tran vdout1_17ck19 FIND v(dout1_17) AT=100.025n

* CHECK dout1_18 Vdout1_18ck19 = 0.9 time = 100
.meas tran vdout1_18ck19 FIND v(dout1_18) AT=100.025n

* CHECK dout1_19 Vdout1_19ck19 = 0.9 time = 100
.meas tran vdout1_19ck19 FIND v(dout1_19) AT=100.025n

* CHECK dout1_20 Vdout1_20ck19 = 0.9 time = 100
.meas tran vdout1_20ck19 FIND v(dout1_20) AT=100.025n

* CHECK dout1_21 Vdout1_21ck19 = 0.9 time = 100
.meas tran vdout1_21ck19 FIND v(dout1_21) AT=100.025n

* CHECK dout1_22 Vdout1_22ck19 = 0.9 time = 100
.meas tran vdout1_22ck19 FIND v(dout1_22) AT=100.025n

* CHECK dout1_23 Vdout1_23ck19 = 0.9 time = 100
.meas tran vdout1_23ck19 FIND v(dout1_23) AT=100.025n

* CHECK dout1_24 Vdout1_24ck19 = 0.9 time = 100
.meas tran vdout1_24ck19 FIND v(dout1_24) AT=100.025n

* CHECK dout1_25 Vdout1_25ck19 = 0 time = 100
.meas tran vdout1_25ck19 FIND v(dout1_25) AT=100.025n

* CHECK dout1_26 Vdout1_26ck19 = 0.9 time = 100
.meas tran vdout1_26ck19 FIND v(dout1_26) AT=100.025n

* CHECK dout1_27 Vdout1_27ck19 = 0 time = 100
.meas tran vdout1_27ck19 FIND v(dout1_27) AT=100.025n

* CHECK dout1_28 Vdout1_28ck19 = 0 time = 100
.meas tran vdout1_28ck19 FIND v(dout1_28) AT=100.025n

* CHECK dout1_29 Vdout1_29ck19 = 0 time = 100
.meas tran vdout1_29ck19 FIND v(dout1_29) AT=100.025n

* CHECK dout1_30 Vdout1_30ck19 = 0.9 time = 100
.meas tran vdout1_30ck19 FIND v(dout1_30) AT=100.025n

* CHECK dout1_31 Vdout1_31ck19 = 0.9 time = 100
.meas tran vdout1_31ck19 FIND v(dout1_31) AT=100.025n

* CHECK dout1_32 Vdout1_32ck19 = 0 time = 100
.meas tran vdout1_32ck19 FIND v(dout1_32) AT=100.025n

* CHECK dout1_33 Vdout1_33ck19 = 0.9 time = 100
.meas tran vdout1_33ck19 FIND v(dout1_33) AT=100.025n

* CHECK dout1_34 Vdout1_34ck19 = 0.9 time = 100
.meas tran vdout1_34ck19 FIND v(dout1_34) AT=100.025n

* CHECK dout1_35 Vdout1_35ck19 = 0.9 time = 100
.meas tran vdout1_35ck19 FIND v(dout1_35) AT=100.025n

* CHECK dout1_36 Vdout1_36ck19 = 0.9 time = 100
.meas tran vdout1_36ck19 FIND v(dout1_36) AT=100.025n

* CHECK dout1_37 Vdout1_37ck19 = 0.9 time = 100
.meas tran vdout1_37ck19 FIND v(dout1_37) AT=100.025n

* CHECK dout1_38 Vdout1_38ck19 = 0 time = 100
.meas tran vdout1_38ck19 FIND v(dout1_38) AT=100.025n

* CHECK dout1_39 Vdout1_39ck19 = 0 time = 100
.meas tran vdout1_39ck19 FIND v(dout1_39) AT=100.025n

* CHECK dout1_40 Vdout1_40ck19 = 0.9 time = 100
.meas tran vdout1_40ck19 FIND v(dout1_40) AT=100.025n

* CHECK dout1_41 Vdout1_41ck19 = 0.9 time = 100
.meas tran vdout1_41ck19 FIND v(dout1_41) AT=100.025n

* CHECK dout1_42 Vdout1_42ck19 = 0.9 time = 100
.meas tran vdout1_42ck19 FIND v(dout1_42) AT=100.025n

* CHECK dout1_43 Vdout1_43ck19 = 0.9 time = 100
.meas tran vdout1_43ck19 FIND v(dout1_43) AT=100.025n

* CHECK dout1_44 Vdout1_44ck19 = 0 time = 100
.meas tran vdout1_44ck19 FIND v(dout1_44) AT=100.025n

* CHECK dout1_45 Vdout1_45ck19 = 0.9 time = 100
.meas tran vdout1_45ck19 FIND v(dout1_45) AT=100.025n

* CHECK dout1_46 Vdout1_46ck19 = 0.9 time = 100
.meas tran vdout1_46ck19 FIND v(dout1_46) AT=100.025n

* CHECK dout1_47 Vdout1_47ck19 = 0.9 time = 100
.meas tran vdout1_47ck19 FIND v(dout1_47) AT=100.025n

* CHECK dout1_48 Vdout1_48ck19 = 0 time = 100
.meas tran vdout1_48ck19 FIND v(dout1_48) AT=100.025n

* CHECK dout1_49 Vdout1_49ck19 = 0 time = 100
.meas tran vdout1_49ck19 FIND v(dout1_49) AT=100.025n

* CHECK dout1_50 Vdout1_50ck19 = 0 time = 100
.meas tran vdout1_50ck19 FIND v(dout1_50) AT=100.025n

* CHECK dout1_51 Vdout1_51ck19 = 0 time = 100
.meas tran vdout1_51ck19 FIND v(dout1_51) AT=100.025n

* CHECK dout1_52 Vdout1_52ck19 = 0 time = 100
.meas tran vdout1_52ck19 FIND v(dout1_52) AT=100.025n

* CHECK dout1_53 Vdout1_53ck19 = 0.9 time = 100
.meas tran vdout1_53ck19 FIND v(dout1_53) AT=100.025n

* CHECK dout1_54 Vdout1_54ck19 = 0 time = 100
.meas tran vdout1_54ck19 FIND v(dout1_54) AT=100.025n

* CHECK dout1_55 Vdout1_55ck19 = 0.9 time = 100
.meas tran vdout1_55ck19 FIND v(dout1_55) AT=100.025n

* CHECK dout1_56 Vdout1_56ck19 = 0.9 time = 100
.meas tran vdout1_56ck19 FIND v(dout1_56) AT=100.025n

* CHECK dout1_57 Vdout1_57ck19 = 0.9 time = 100
.meas tran vdout1_57ck19 FIND v(dout1_57) AT=100.025n

* CHECK dout1_58 Vdout1_58ck19 = 0.9 time = 100
.meas tran vdout1_58ck19 FIND v(dout1_58) AT=100.025n

* CHECK dout1_59 Vdout1_59ck19 = 0 time = 100
.meas tran vdout1_59ck19 FIND v(dout1_59) AT=100.025n

* CHECK dout1_60 Vdout1_60ck19 = 0 time = 100
.meas tran vdout1_60ck19 FIND v(dout1_60) AT=100.025n

* CHECK dout1_61 Vdout1_61ck19 = 0 time = 100
.meas tran vdout1_61ck19 FIND v(dout1_61) AT=100.025n

* CHECK dout1_62 Vdout1_62ck19 = 0 time = 100
.meas tran vdout1_62ck19 FIND v(dout1_62) AT=100.025n

* CHECK dout1_63 Vdout1_63ck19 = 0.9 time = 100
.meas tran vdout1_63ck19 FIND v(dout1_63) AT=100.025n

* CHECK dout1_64 Vdout1_64ck19 = 0.9 time = 100
.meas tran vdout1_64ck19 FIND v(dout1_64) AT=100.025n

* CHECK dout1_65 Vdout1_65ck19 = 0.9 time = 100
.meas tran vdout1_65ck19 FIND v(dout1_65) AT=100.025n

* CHECK dout1_66 Vdout1_66ck19 = 0.9 time = 100
.meas tran vdout1_66ck19 FIND v(dout1_66) AT=100.025n

* CHECK dout1_67 Vdout1_67ck19 = 0.9 time = 100
.meas tran vdout1_67ck19 FIND v(dout1_67) AT=100.025n

* CHECK dout1_68 Vdout1_68ck19 = 0 time = 100
.meas tran vdout1_68ck19 FIND v(dout1_68) AT=100.025n

* CHECK dout1_69 Vdout1_69ck19 = 0 time = 100
.meas tran vdout1_69ck19 FIND v(dout1_69) AT=100.025n

* CHECK dout1_70 Vdout1_70ck19 = 0 time = 100
.meas tran vdout1_70ck19 FIND v(dout1_70) AT=100.025n

* CHECK dout1_71 Vdout1_71ck19 = 0.9 time = 100
.meas tran vdout1_71ck19 FIND v(dout1_71) AT=100.025n

* CHECK dout1_72 Vdout1_72ck19 = 0 time = 100
.meas tran vdout1_72ck19 FIND v(dout1_72) AT=100.025n

* CHECK dout1_73 Vdout1_73ck19 = 0.9 time = 100
.meas tran vdout1_73ck19 FIND v(dout1_73) AT=100.025n

* CHECK dout1_74 Vdout1_74ck19 = 0 time = 100
.meas tran vdout1_74ck19 FIND v(dout1_74) AT=100.025n

* CHECK dout1_75 Vdout1_75ck19 = 0 time = 100
.meas tran vdout1_75ck19 FIND v(dout1_75) AT=100.025n

* CHECK dout1_76 Vdout1_76ck19 = 0 time = 100
.meas tran vdout1_76ck19 FIND v(dout1_76) AT=100.025n

* CHECK dout1_77 Vdout1_77ck19 = 0 time = 100
.meas tran vdout1_77ck19 FIND v(dout1_77) AT=100.025n

* CHECK dout1_78 Vdout1_78ck19 = 0.9 time = 100
.meas tran vdout1_78ck19 FIND v(dout1_78) AT=100.025n

* CHECK dout1_79 Vdout1_79ck19 = 0.9 time = 100
.meas tran vdout1_79ck19 FIND v(dout1_79) AT=100.025n

* CHECK dout1_80 Vdout1_80ck19 = 0 time = 100
.meas tran vdout1_80ck19 FIND v(dout1_80) AT=100.025n

* CHECK dout1_81 Vdout1_81ck19 = 0 time = 100
.meas tran vdout1_81ck19 FIND v(dout1_81) AT=100.025n

* CHECK dout1_82 Vdout1_82ck19 = 0.9 time = 100
.meas tran vdout1_82ck19 FIND v(dout1_82) AT=100.025n

* CHECK dout1_83 Vdout1_83ck19 = 0 time = 100
.meas tran vdout1_83ck19 FIND v(dout1_83) AT=100.025n

* CHECK dout1_84 Vdout1_84ck19 = 0.9 time = 100
.meas tran vdout1_84ck19 FIND v(dout1_84) AT=100.025n

* CHECK dout1_85 Vdout1_85ck19 = 0.9 time = 100
.meas tran vdout1_85ck19 FIND v(dout1_85) AT=100.025n

* CHECK dout1_86 Vdout1_86ck19 = 0.9 time = 100
.meas tran vdout1_86ck19 FIND v(dout1_86) AT=100.025n

* CHECK dout1_87 Vdout1_87ck19 = 0 time = 100
.meas tran vdout1_87ck19 FIND v(dout1_87) AT=100.025n

* CHECK dout1_88 Vdout1_88ck19 = 0.9 time = 100
.meas tran vdout1_88ck19 FIND v(dout1_88) AT=100.025n

* CHECK dout1_89 Vdout1_89ck19 = 0 time = 100
.meas tran vdout1_89ck19 FIND v(dout1_89) AT=100.025n

* CHECK dout1_90 Vdout1_90ck19 = 0 time = 100
.meas tran vdout1_90ck19 FIND v(dout1_90) AT=100.025n

* CHECK dout1_91 Vdout1_91ck19 = 0.9 time = 100
.meas tran vdout1_91ck19 FIND v(dout1_91) AT=100.025n

* CHECK dout1_92 Vdout1_92ck19 = 0 time = 100
.meas tran vdout1_92ck19 FIND v(dout1_92) AT=100.025n

* CHECK dout1_93 Vdout1_93ck19 = 0.9 time = 100
.meas tran vdout1_93ck19 FIND v(dout1_93) AT=100.025n

* CHECK dout1_94 Vdout1_94ck19 = 0.9 time = 100
.meas tran vdout1_94ck19 FIND v(dout1_94) AT=100.025n

* CHECK dout1_95 Vdout1_95ck19 = 0 time = 100
.meas tran vdout1_95ck19 FIND v(dout1_95) AT=100.025n

* CHECK dout1_96 Vdout1_96ck19 = 0.9 time = 100
.meas tran vdout1_96ck19 FIND v(dout1_96) AT=100.025n

* CHECK dout1_97 Vdout1_97ck19 = 0.9 time = 100
.meas tran vdout1_97ck19 FIND v(dout1_97) AT=100.025n

* CHECK dout1_98 Vdout1_98ck19 = 0 time = 100
.meas tran vdout1_98ck19 FIND v(dout1_98) AT=100.025n

* CHECK dout1_99 Vdout1_99ck19 = 0.9 time = 100
.meas tran vdout1_99ck19 FIND v(dout1_99) AT=100.025n

* CHECK dout1_100 Vdout1_100ck19 = 0.9 time = 100
.meas tran vdout1_100ck19 FIND v(dout1_100) AT=100.025n

* CHECK dout1_101 Vdout1_101ck19 = 0 time = 100
.meas tran vdout1_101ck19 FIND v(dout1_101) AT=100.025n

* CHECK dout1_102 Vdout1_102ck19 = 0 time = 100
.meas tran vdout1_102ck19 FIND v(dout1_102) AT=100.025n

* CHECK dout1_103 Vdout1_103ck19 = 0.9 time = 100
.meas tran vdout1_103ck19 FIND v(dout1_103) AT=100.025n

* CHECK dout1_104 Vdout1_104ck19 = 0.9 time = 100
.meas tran vdout1_104ck19 FIND v(dout1_104) AT=100.025n

* CHECK dout1_105 Vdout1_105ck19 = 0.9 time = 100
.meas tran vdout1_105ck19 FIND v(dout1_105) AT=100.025n

* CHECK dout1_106 Vdout1_106ck19 = 0.9 time = 100
.meas tran vdout1_106ck19 FIND v(dout1_106) AT=100.025n

* CHECK dout1_107 Vdout1_107ck19 = 0 time = 100
.meas tran vdout1_107ck19 FIND v(dout1_107) AT=100.025n

* CHECK dout1_108 Vdout1_108ck19 = 0 time = 100
.meas tran vdout1_108ck19 FIND v(dout1_108) AT=100.025n

* CHECK dout1_109 Vdout1_109ck19 = 0 time = 100
.meas tran vdout1_109ck19 FIND v(dout1_109) AT=100.025n

* CHECK dout1_110 Vdout1_110ck19 = 0.9 time = 100
.meas tran vdout1_110ck19 FIND v(dout1_110) AT=100.025n

* CHECK dout1_111 Vdout1_111ck19 = 0.9 time = 100
.meas tran vdout1_111ck19 FIND v(dout1_111) AT=100.025n

* CHECK dout1_112 Vdout1_112ck19 = 0.9 time = 100
.meas tran vdout1_112ck19 FIND v(dout1_112) AT=100.025n

* CHECK dout1_113 Vdout1_113ck19 = 0 time = 100
.meas tran vdout1_113ck19 FIND v(dout1_113) AT=100.025n

* CHECK dout1_114 Vdout1_114ck19 = 0.9 time = 100
.meas tran vdout1_114ck19 FIND v(dout1_114) AT=100.025n

* CHECK dout1_115 Vdout1_115ck19 = 0 time = 100
.meas tran vdout1_115ck19 FIND v(dout1_115) AT=100.025n

* CHECK dout1_116 Vdout1_116ck19 = 0 time = 100
.meas tran vdout1_116ck19 FIND v(dout1_116) AT=100.025n

* CHECK dout1_117 Vdout1_117ck19 = 0 time = 100
.meas tran vdout1_117ck19 FIND v(dout1_117) AT=100.025n

* CHECK dout1_118 Vdout1_118ck19 = 0.9 time = 100
.meas tran vdout1_118ck19 FIND v(dout1_118) AT=100.025n

* CHECK dout1_119 Vdout1_119ck19 = 0 time = 100
.meas tran vdout1_119ck19 FIND v(dout1_119) AT=100.025n

* CHECK dout1_0 Vdout1_0ck24 = 0.9 time = 125
.meas tran vdout1_0ck24 FIND v(dout1_0) AT=125.025n

* CHECK dout1_1 Vdout1_1ck24 = 0.9 time = 125
.meas tran vdout1_1ck24 FIND v(dout1_1) AT=125.025n

* CHECK dout1_2 Vdout1_2ck24 = 0 time = 125
.meas tran vdout1_2ck24 FIND v(dout1_2) AT=125.025n

* CHECK dout1_3 Vdout1_3ck24 = 0.9 time = 125
.meas tran vdout1_3ck24 FIND v(dout1_3) AT=125.025n

* CHECK dout1_4 Vdout1_4ck24 = 0 time = 125
.meas tran vdout1_4ck24 FIND v(dout1_4) AT=125.025n

* CHECK dout1_5 Vdout1_5ck24 = 0 time = 125
.meas tran vdout1_5ck24 FIND v(dout1_5) AT=125.025n

* CHECK dout1_6 Vdout1_6ck24 = 0.9 time = 125
.meas tran vdout1_6ck24 FIND v(dout1_6) AT=125.025n

* CHECK dout1_7 Vdout1_7ck24 = 0.9 time = 125
.meas tran vdout1_7ck24 FIND v(dout1_7) AT=125.025n

* CHECK dout1_8 Vdout1_8ck24 = 0 time = 125
.meas tran vdout1_8ck24 FIND v(dout1_8) AT=125.025n

* CHECK dout1_9 Vdout1_9ck24 = 0 time = 125
.meas tran vdout1_9ck24 FIND v(dout1_9) AT=125.025n

* CHECK dout1_10 Vdout1_10ck24 = 0 time = 125
.meas tran vdout1_10ck24 FIND v(dout1_10) AT=125.025n

* CHECK dout1_11 Vdout1_11ck24 = 0.9 time = 125
.meas tran vdout1_11ck24 FIND v(dout1_11) AT=125.025n

* CHECK dout1_12 Vdout1_12ck24 = 0.9 time = 125
.meas tran vdout1_12ck24 FIND v(dout1_12) AT=125.025n

* CHECK dout1_13 Vdout1_13ck24 = 0 time = 125
.meas tran vdout1_13ck24 FIND v(dout1_13) AT=125.025n

* CHECK dout1_14 Vdout1_14ck24 = 0.9 time = 125
.meas tran vdout1_14ck24 FIND v(dout1_14) AT=125.025n

* CHECK dout1_15 Vdout1_15ck24 = 0 time = 125
.meas tran vdout1_15ck24 FIND v(dout1_15) AT=125.025n

* CHECK dout1_16 Vdout1_16ck24 = 0 time = 125
.meas tran vdout1_16ck24 FIND v(dout1_16) AT=125.025n

* CHECK dout1_17 Vdout1_17ck24 = 0.9 time = 125
.meas tran vdout1_17ck24 FIND v(dout1_17) AT=125.025n

* CHECK dout1_18 Vdout1_18ck24 = 0.9 time = 125
.meas tran vdout1_18ck24 FIND v(dout1_18) AT=125.025n

* CHECK dout1_19 Vdout1_19ck24 = 0 time = 125
.meas tran vdout1_19ck24 FIND v(dout1_19) AT=125.025n

* CHECK dout1_20 Vdout1_20ck24 = 0 time = 125
.meas tran vdout1_20ck24 FIND v(dout1_20) AT=125.025n

* CHECK dout1_21 Vdout1_21ck24 = 0.9 time = 125
.meas tran vdout1_21ck24 FIND v(dout1_21) AT=125.025n

* CHECK dout1_22 Vdout1_22ck24 = 0.9 time = 125
.meas tran vdout1_22ck24 FIND v(dout1_22) AT=125.025n

* CHECK dout1_23 Vdout1_23ck24 = 0.9 time = 125
.meas tran vdout1_23ck24 FIND v(dout1_23) AT=125.025n

* CHECK dout1_24 Vdout1_24ck24 = 0 time = 125
.meas tran vdout1_24ck24 FIND v(dout1_24) AT=125.025n

* CHECK dout1_25 Vdout1_25ck24 = 0 time = 125
.meas tran vdout1_25ck24 FIND v(dout1_25) AT=125.025n

* CHECK dout1_26 Vdout1_26ck24 = 0.9 time = 125
.meas tran vdout1_26ck24 FIND v(dout1_26) AT=125.025n

* CHECK dout1_27 Vdout1_27ck24 = 0.9 time = 125
.meas tran vdout1_27ck24 FIND v(dout1_27) AT=125.025n

* CHECK dout1_28 Vdout1_28ck24 = 0 time = 125
.meas tran vdout1_28ck24 FIND v(dout1_28) AT=125.025n

* CHECK dout1_29 Vdout1_29ck24 = 0 time = 125
.meas tran vdout1_29ck24 FIND v(dout1_29) AT=125.025n

* CHECK dout1_30 Vdout1_30ck24 = 0.9 time = 125
.meas tran vdout1_30ck24 FIND v(dout1_30) AT=125.025n

* CHECK dout1_31 Vdout1_31ck24 = 0.9 time = 125
.meas tran vdout1_31ck24 FIND v(dout1_31) AT=125.025n

* CHECK dout1_32 Vdout1_32ck24 = 0.9 time = 125
.meas tran vdout1_32ck24 FIND v(dout1_32) AT=125.025n

* CHECK dout1_33 Vdout1_33ck24 = 0.9 time = 125
.meas tran vdout1_33ck24 FIND v(dout1_33) AT=125.025n

* CHECK dout1_34 Vdout1_34ck24 = 0.9 time = 125
.meas tran vdout1_34ck24 FIND v(dout1_34) AT=125.025n

* CHECK dout1_35 Vdout1_35ck24 = 0.9 time = 125
.meas tran vdout1_35ck24 FIND v(dout1_35) AT=125.025n

* CHECK dout1_36 Vdout1_36ck24 = 0.9 time = 125
.meas tran vdout1_36ck24 FIND v(dout1_36) AT=125.025n

* CHECK dout1_37 Vdout1_37ck24 = 0.9 time = 125
.meas tran vdout1_37ck24 FIND v(dout1_37) AT=125.025n

* CHECK dout1_38 Vdout1_38ck24 = 0 time = 125
.meas tran vdout1_38ck24 FIND v(dout1_38) AT=125.025n

* CHECK dout1_39 Vdout1_39ck24 = 0.9 time = 125
.meas tran vdout1_39ck24 FIND v(dout1_39) AT=125.025n

* CHECK dout1_40 Vdout1_40ck24 = 0 time = 125
.meas tran vdout1_40ck24 FIND v(dout1_40) AT=125.025n

* CHECK dout1_41 Vdout1_41ck24 = 0.9 time = 125
.meas tran vdout1_41ck24 FIND v(dout1_41) AT=125.025n

* CHECK dout1_42 Vdout1_42ck24 = 0 time = 125
.meas tran vdout1_42ck24 FIND v(dout1_42) AT=125.025n

* CHECK dout1_43 Vdout1_43ck24 = 0.9 time = 125
.meas tran vdout1_43ck24 FIND v(dout1_43) AT=125.025n

* CHECK dout1_44 Vdout1_44ck24 = 0.9 time = 125
.meas tran vdout1_44ck24 FIND v(dout1_44) AT=125.025n

* CHECK dout1_45 Vdout1_45ck24 = 0.9 time = 125
.meas tran vdout1_45ck24 FIND v(dout1_45) AT=125.025n

* CHECK dout1_46 Vdout1_46ck24 = 0.9 time = 125
.meas tran vdout1_46ck24 FIND v(dout1_46) AT=125.025n

* CHECK dout1_47 Vdout1_47ck24 = 0 time = 125
.meas tran vdout1_47ck24 FIND v(dout1_47) AT=125.025n

* CHECK dout1_48 Vdout1_48ck24 = 0 time = 125
.meas tran vdout1_48ck24 FIND v(dout1_48) AT=125.025n

* CHECK dout1_49 Vdout1_49ck24 = 0 time = 125
.meas tran vdout1_49ck24 FIND v(dout1_49) AT=125.025n

* CHECK dout1_50 Vdout1_50ck24 = 0.9 time = 125
.meas tran vdout1_50ck24 FIND v(dout1_50) AT=125.025n

* CHECK dout1_51 Vdout1_51ck24 = 0.9 time = 125
.meas tran vdout1_51ck24 FIND v(dout1_51) AT=125.025n

* CHECK dout1_52 Vdout1_52ck24 = 0 time = 125
.meas tran vdout1_52ck24 FIND v(dout1_52) AT=125.025n

* CHECK dout1_53 Vdout1_53ck24 = 0.9 time = 125
.meas tran vdout1_53ck24 FIND v(dout1_53) AT=125.025n

* CHECK dout1_54 Vdout1_54ck24 = 0 time = 125
.meas tran vdout1_54ck24 FIND v(dout1_54) AT=125.025n

* CHECK dout1_55 Vdout1_55ck24 = 0.9 time = 125
.meas tran vdout1_55ck24 FIND v(dout1_55) AT=125.025n

* CHECK dout1_56 Vdout1_56ck24 = 0 time = 125
.meas tran vdout1_56ck24 FIND v(dout1_56) AT=125.025n

* CHECK dout1_57 Vdout1_57ck24 = 0 time = 125
.meas tran vdout1_57ck24 FIND v(dout1_57) AT=125.025n

* CHECK dout1_58 Vdout1_58ck24 = 0.9 time = 125
.meas tran vdout1_58ck24 FIND v(dout1_58) AT=125.025n

* CHECK dout1_59 Vdout1_59ck24 = 0 time = 125
.meas tran vdout1_59ck24 FIND v(dout1_59) AT=125.025n

* CHECK dout1_60 Vdout1_60ck24 = 0.9 time = 125
.meas tran vdout1_60ck24 FIND v(dout1_60) AT=125.025n

* CHECK dout1_61 Vdout1_61ck24 = 0.9 time = 125
.meas tran vdout1_61ck24 FIND v(dout1_61) AT=125.025n

* CHECK dout1_62 Vdout1_62ck24 = 0 time = 125
.meas tran vdout1_62ck24 FIND v(dout1_62) AT=125.025n

* CHECK dout1_63 Vdout1_63ck24 = 0.9 time = 125
.meas tran vdout1_63ck24 FIND v(dout1_63) AT=125.025n

* CHECK dout1_64 Vdout1_64ck24 = 0 time = 125
.meas tran vdout1_64ck24 FIND v(dout1_64) AT=125.025n

* CHECK dout1_65 Vdout1_65ck24 = 0.9 time = 125
.meas tran vdout1_65ck24 FIND v(dout1_65) AT=125.025n

* CHECK dout1_66 Vdout1_66ck24 = 0.9 time = 125
.meas tran vdout1_66ck24 FIND v(dout1_66) AT=125.025n

* CHECK dout1_67 Vdout1_67ck24 = 0 time = 125
.meas tran vdout1_67ck24 FIND v(dout1_67) AT=125.025n

* CHECK dout1_68 Vdout1_68ck24 = 0 time = 125
.meas tran vdout1_68ck24 FIND v(dout1_68) AT=125.025n

* CHECK dout1_69 Vdout1_69ck24 = 0 time = 125
.meas tran vdout1_69ck24 FIND v(dout1_69) AT=125.025n

* CHECK dout1_70 Vdout1_70ck24 = 0.9 time = 125
.meas tran vdout1_70ck24 FIND v(dout1_70) AT=125.025n

* CHECK dout1_71 Vdout1_71ck24 = 0.9 time = 125
.meas tran vdout1_71ck24 FIND v(dout1_71) AT=125.025n

* CHECK dout1_72 Vdout1_72ck24 = 0 time = 125
.meas tran vdout1_72ck24 FIND v(dout1_72) AT=125.025n

* CHECK dout1_73 Vdout1_73ck24 = 0 time = 125
.meas tran vdout1_73ck24 FIND v(dout1_73) AT=125.025n

* CHECK dout1_74 Vdout1_74ck24 = 0.9 time = 125
.meas tran vdout1_74ck24 FIND v(dout1_74) AT=125.025n

* CHECK dout1_75 Vdout1_75ck24 = 0.9 time = 125
.meas tran vdout1_75ck24 FIND v(dout1_75) AT=125.025n

* CHECK dout1_76 Vdout1_76ck24 = 0 time = 125
.meas tran vdout1_76ck24 FIND v(dout1_76) AT=125.025n

* CHECK dout1_77 Vdout1_77ck24 = 0.9 time = 125
.meas tran vdout1_77ck24 FIND v(dout1_77) AT=125.025n

* CHECK dout1_78 Vdout1_78ck24 = 0.9 time = 125
.meas tran vdout1_78ck24 FIND v(dout1_78) AT=125.025n

* CHECK dout1_79 Vdout1_79ck24 = 0 time = 125
.meas tran vdout1_79ck24 FIND v(dout1_79) AT=125.025n

* CHECK dout1_80 Vdout1_80ck24 = 0 time = 125
.meas tran vdout1_80ck24 FIND v(dout1_80) AT=125.025n

* CHECK dout1_81 Vdout1_81ck24 = 0.9 time = 125
.meas tran vdout1_81ck24 FIND v(dout1_81) AT=125.025n

* CHECK dout1_82 Vdout1_82ck24 = 0 time = 125
.meas tran vdout1_82ck24 FIND v(dout1_82) AT=125.025n

* CHECK dout1_83 Vdout1_83ck24 = 0 time = 125
.meas tran vdout1_83ck24 FIND v(dout1_83) AT=125.025n

* CHECK dout1_84 Vdout1_84ck24 = 0 time = 125
.meas tran vdout1_84ck24 FIND v(dout1_84) AT=125.025n

* CHECK dout1_85 Vdout1_85ck24 = 0 time = 125
.meas tran vdout1_85ck24 FIND v(dout1_85) AT=125.025n

* CHECK dout1_86 Vdout1_86ck24 = 0 time = 125
.meas tran vdout1_86ck24 FIND v(dout1_86) AT=125.025n

* CHECK dout1_87 Vdout1_87ck24 = 0.9 time = 125
.meas tran vdout1_87ck24 FIND v(dout1_87) AT=125.025n

* CHECK dout1_88 Vdout1_88ck24 = 0.9 time = 125
.meas tran vdout1_88ck24 FIND v(dout1_88) AT=125.025n

* CHECK dout1_89 Vdout1_89ck24 = 0 time = 125
.meas tran vdout1_89ck24 FIND v(dout1_89) AT=125.025n

* CHECK dout1_90 Vdout1_90ck24 = 0.9 time = 125
.meas tran vdout1_90ck24 FIND v(dout1_90) AT=125.025n

* CHECK dout1_91 Vdout1_91ck24 = 0.9 time = 125
.meas tran vdout1_91ck24 FIND v(dout1_91) AT=125.025n

* CHECK dout1_92 Vdout1_92ck24 = 0 time = 125
.meas tran vdout1_92ck24 FIND v(dout1_92) AT=125.025n

* CHECK dout1_93 Vdout1_93ck24 = 0 time = 125
.meas tran vdout1_93ck24 FIND v(dout1_93) AT=125.025n

* CHECK dout1_94 Vdout1_94ck24 = 0 time = 125
.meas tran vdout1_94ck24 FIND v(dout1_94) AT=125.025n

* CHECK dout1_95 Vdout1_95ck24 = 0.9 time = 125
.meas tran vdout1_95ck24 FIND v(dout1_95) AT=125.025n

* CHECK dout1_96 Vdout1_96ck24 = 0 time = 125
.meas tran vdout1_96ck24 FIND v(dout1_96) AT=125.025n

* CHECK dout1_97 Vdout1_97ck24 = 0.9 time = 125
.meas tran vdout1_97ck24 FIND v(dout1_97) AT=125.025n

* CHECK dout1_98 Vdout1_98ck24 = 0 time = 125
.meas tran vdout1_98ck24 FIND v(dout1_98) AT=125.025n

* CHECK dout1_99 Vdout1_99ck24 = 0.9 time = 125
.meas tran vdout1_99ck24 FIND v(dout1_99) AT=125.025n

* CHECK dout1_100 Vdout1_100ck24 = 0.9 time = 125
.meas tran vdout1_100ck24 FIND v(dout1_100) AT=125.025n

* CHECK dout1_101 Vdout1_101ck24 = 0.9 time = 125
.meas tran vdout1_101ck24 FIND v(dout1_101) AT=125.025n

* CHECK dout1_102 Vdout1_102ck24 = 0.9 time = 125
.meas tran vdout1_102ck24 FIND v(dout1_102) AT=125.025n

* CHECK dout1_103 Vdout1_103ck24 = 0 time = 125
.meas tran vdout1_103ck24 FIND v(dout1_103) AT=125.025n

* CHECK dout1_104 Vdout1_104ck24 = 0 time = 125
.meas tran vdout1_104ck24 FIND v(dout1_104) AT=125.025n

* CHECK dout1_105 Vdout1_105ck24 = 0.9 time = 125
.meas tran vdout1_105ck24 FIND v(dout1_105) AT=125.025n

* CHECK dout1_106 Vdout1_106ck24 = 0.9 time = 125
.meas tran vdout1_106ck24 FIND v(dout1_106) AT=125.025n

* CHECK dout1_107 Vdout1_107ck24 = 0.9 time = 125
.meas tran vdout1_107ck24 FIND v(dout1_107) AT=125.025n

* CHECK dout1_108 Vdout1_108ck24 = 0.9 time = 125
.meas tran vdout1_108ck24 FIND v(dout1_108) AT=125.025n

* CHECK dout1_109 Vdout1_109ck24 = 0.9 time = 125
.meas tran vdout1_109ck24 FIND v(dout1_109) AT=125.025n

* CHECK dout1_110 Vdout1_110ck24 = 0 time = 125
.meas tran vdout1_110ck24 FIND v(dout1_110) AT=125.025n

* CHECK dout1_111 Vdout1_111ck24 = 0 time = 125
.meas tran vdout1_111ck24 FIND v(dout1_111) AT=125.025n

* CHECK dout1_112 Vdout1_112ck24 = 0.9 time = 125
.meas tran vdout1_112ck24 FIND v(dout1_112) AT=125.025n

* CHECK dout1_113 Vdout1_113ck24 = 0 time = 125
.meas tran vdout1_113ck24 FIND v(dout1_113) AT=125.025n

* CHECK dout1_114 Vdout1_114ck24 = 0.9 time = 125
.meas tran vdout1_114ck24 FIND v(dout1_114) AT=125.025n

* CHECK dout1_115 Vdout1_115ck24 = 0.9 time = 125
.meas tran vdout1_115ck24 FIND v(dout1_115) AT=125.025n

* CHECK dout1_116 Vdout1_116ck24 = 0 time = 125
.meas tran vdout1_116ck24 FIND v(dout1_116) AT=125.025n

* CHECK dout1_117 Vdout1_117ck24 = 0.9 time = 125
.meas tran vdout1_117ck24 FIND v(dout1_117) AT=125.025n

* CHECK dout1_118 Vdout1_118ck24 = 0 time = 125
.meas tran vdout1_118ck24 FIND v(dout1_118) AT=125.025n

* CHECK dout1_119 Vdout1_119ck24 = 0 time = 125
.meas tran vdout1_119ck24 FIND v(dout1_119) AT=125.025n

* CHECK dout1_0 Vdout1_0ck25 = 0.9 time = 130
.meas tran vdout1_0ck25 FIND v(dout1_0) AT=130.025n

* CHECK dout1_1 Vdout1_1ck25 = 0.9 time = 130
.meas tran vdout1_1ck25 FIND v(dout1_1) AT=130.025n

* CHECK dout1_2 Vdout1_2ck25 = 0.9 time = 130
.meas tran vdout1_2ck25 FIND v(dout1_2) AT=130.025n

* CHECK dout1_3 Vdout1_3ck25 = 0 time = 130
.meas tran vdout1_3ck25 FIND v(dout1_3) AT=130.025n

* CHECK dout1_4 Vdout1_4ck25 = 0.9 time = 130
.meas tran vdout1_4ck25 FIND v(dout1_4) AT=130.025n

* CHECK dout1_5 Vdout1_5ck25 = 0.9 time = 130
.meas tran vdout1_5ck25 FIND v(dout1_5) AT=130.025n

* CHECK dout1_6 Vdout1_6ck25 = 0.9 time = 130
.meas tran vdout1_6ck25 FIND v(dout1_6) AT=130.025n

* CHECK dout1_7 Vdout1_7ck25 = 0.9 time = 130
.meas tran vdout1_7ck25 FIND v(dout1_7) AT=130.025n

* CHECK dout1_8 Vdout1_8ck25 = 0 time = 130
.meas tran vdout1_8ck25 FIND v(dout1_8) AT=130.025n

* CHECK dout1_9 Vdout1_9ck25 = 0 time = 130
.meas tran vdout1_9ck25 FIND v(dout1_9) AT=130.025n

* CHECK dout1_10 Vdout1_10ck25 = 0 time = 130
.meas tran vdout1_10ck25 FIND v(dout1_10) AT=130.025n

* CHECK dout1_11 Vdout1_11ck25 = 0 time = 130
.meas tran vdout1_11ck25 FIND v(dout1_11) AT=130.025n

* CHECK dout1_12 Vdout1_12ck25 = 0.9 time = 130
.meas tran vdout1_12ck25 FIND v(dout1_12) AT=130.025n

* CHECK dout1_13 Vdout1_13ck25 = 0 time = 130
.meas tran vdout1_13ck25 FIND v(dout1_13) AT=130.025n

* CHECK dout1_14 Vdout1_14ck25 = 0 time = 130
.meas tran vdout1_14ck25 FIND v(dout1_14) AT=130.025n

* CHECK dout1_15 Vdout1_15ck25 = 0 time = 130
.meas tran vdout1_15ck25 FIND v(dout1_15) AT=130.025n

* CHECK dout1_16 Vdout1_16ck25 = 0 time = 130
.meas tran vdout1_16ck25 FIND v(dout1_16) AT=130.025n

* CHECK dout1_17 Vdout1_17ck25 = 0.9 time = 130
.meas tran vdout1_17ck25 FIND v(dout1_17) AT=130.025n

* CHECK dout1_18 Vdout1_18ck25 = 0 time = 130
.meas tran vdout1_18ck25 FIND v(dout1_18) AT=130.025n

* CHECK dout1_19 Vdout1_19ck25 = 0 time = 130
.meas tran vdout1_19ck25 FIND v(dout1_19) AT=130.025n

* CHECK dout1_20 Vdout1_20ck25 = 0.9 time = 130
.meas tran vdout1_20ck25 FIND v(dout1_20) AT=130.025n

* CHECK dout1_21 Vdout1_21ck25 = 0 time = 130
.meas tran vdout1_21ck25 FIND v(dout1_21) AT=130.025n

* CHECK dout1_22 Vdout1_22ck25 = 0.9 time = 130
.meas tran vdout1_22ck25 FIND v(dout1_22) AT=130.025n

* CHECK dout1_23 Vdout1_23ck25 = 0 time = 130
.meas tran vdout1_23ck25 FIND v(dout1_23) AT=130.025n

* CHECK dout1_24 Vdout1_24ck25 = 0.9 time = 130
.meas tran vdout1_24ck25 FIND v(dout1_24) AT=130.025n

* CHECK dout1_25 Vdout1_25ck25 = 0.9 time = 130
.meas tran vdout1_25ck25 FIND v(dout1_25) AT=130.025n

* CHECK dout1_26 Vdout1_26ck25 = 0.9 time = 130
.meas tran vdout1_26ck25 FIND v(dout1_26) AT=130.025n

* CHECK dout1_27 Vdout1_27ck25 = 0.9 time = 130
.meas tran vdout1_27ck25 FIND v(dout1_27) AT=130.025n

* CHECK dout1_28 Vdout1_28ck25 = 0.9 time = 130
.meas tran vdout1_28ck25 FIND v(dout1_28) AT=130.025n

* CHECK dout1_29 Vdout1_29ck25 = 0.9 time = 130
.meas tran vdout1_29ck25 FIND v(dout1_29) AT=130.025n

* CHECK dout1_30 Vdout1_30ck25 = 0 time = 130
.meas tran vdout1_30ck25 FIND v(dout1_30) AT=130.025n

* CHECK dout1_31 Vdout1_31ck25 = 0 time = 130
.meas tran vdout1_31ck25 FIND v(dout1_31) AT=130.025n

* CHECK dout1_32 Vdout1_32ck25 = 0 time = 130
.meas tran vdout1_32ck25 FIND v(dout1_32) AT=130.025n

* CHECK dout1_33 Vdout1_33ck25 = 0.9 time = 130
.meas tran vdout1_33ck25 FIND v(dout1_33) AT=130.025n

* CHECK dout1_34 Vdout1_34ck25 = 0.9 time = 130
.meas tran vdout1_34ck25 FIND v(dout1_34) AT=130.025n

* CHECK dout1_35 Vdout1_35ck25 = 0 time = 130
.meas tran vdout1_35ck25 FIND v(dout1_35) AT=130.025n

* CHECK dout1_36 Vdout1_36ck25 = 0.9 time = 130
.meas tran vdout1_36ck25 FIND v(dout1_36) AT=130.025n

* CHECK dout1_37 Vdout1_37ck25 = 0.9 time = 130
.meas tran vdout1_37ck25 FIND v(dout1_37) AT=130.025n

* CHECK dout1_38 Vdout1_38ck25 = 0.9 time = 130
.meas tran vdout1_38ck25 FIND v(dout1_38) AT=130.025n

* CHECK dout1_39 Vdout1_39ck25 = 0 time = 130
.meas tran vdout1_39ck25 FIND v(dout1_39) AT=130.025n

* CHECK dout1_40 Vdout1_40ck25 = 0.9 time = 130
.meas tran vdout1_40ck25 FIND v(dout1_40) AT=130.025n

* CHECK dout1_41 Vdout1_41ck25 = 0 time = 130
.meas tran vdout1_41ck25 FIND v(dout1_41) AT=130.025n

* CHECK dout1_42 Vdout1_42ck25 = 0.9 time = 130
.meas tran vdout1_42ck25 FIND v(dout1_42) AT=130.025n

* CHECK dout1_43 Vdout1_43ck25 = 0 time = 130
.meas tran vdout1_43ck25 FIND v(dout1_43) AT=130.025n

* CHECK dout1_44 Vdout1_44ck25 = 0.9 time = 130
.meas tran vdout1_44ck25 FIND v(dout1_44) AT=130.025n

* CHECK dout1_45 Vdout1_45ck25 = 0.9 time = 130
.meas tran vdout1_45ck25 FIND v(dout1_45) AT=130.025n

* CHECK dout1_46 Vdout1_46ck25 = 0.9 time = 130
.meas tran vdout1_46ck25 FIND v(dout1_46) AT=130.025n

* CHECK dout1_47 Vdout1_47ck25 = 0.9 time = 130
.meas tran vdout1_47ck25 FIND v(dout1_47) AT=130.025n

* CHECK dout1_48 Vdout1_48ck25 = 0.9 time = 130
.meas tran vdout1_48ck25 FIND v(dout1_48) AT=130.025n

* CHECK dout1_49 Vdout1_49ck25 = 0.9 time = 130
.meas tran vdout1_49ck25 FIND v(dout1_49) AT=130.025n

* CHECK dout1_50 Vdout1_50ck25 = 0 time = 130
.meas tran vdout1_50ck25 FIND v(dout1_50) AT=130.025n

* CHECK dout1_51 Vdout1_51ck25 = 0 time = 130
.meas tran vdout1_51ck25 FIND v(dout1_51) AT=130.025n

* CHECK dout1_52 Vdout1_52ck25 = 0.9 time = 130
.meas tran vdout1_52ck25 FIND v(dout1_52) AT=130.025n

* CHECK dout1_53 Vdout1_53ck25 = 0 time = 130
.meas tran vdout1_53ck25 FIND v(dout1_53) AT=130.025n

* CHECK dout1_54 Vdout1_54ck25 = 0.9 time = 130
.meas tran vdout1_54ck25 FIND v(dout1_54) AT=130.025n

* CHECK dout1_55 Vdout1_55ck25 = 0 time = 130
.meas tran vdout1_55ck25 FIND v(dout1_55) AT=130.025n

* CHECK dout1_56 Vdout1_56ck25 = 0.9 time = 130
.meas tran vdout1_56ck25 FIND v(dout1_56) AT=130.025n

* CHECK dout1_57 Vdout1_57ck25 = 0.9 time = 130
.meas tran vdout1_57ck25 FIND v(dout1_57) AT=130.025n

* CHECK dout1_58 Vdout1_58ck25 = 0.9 time = 130
.meas tran vdout1_58ck25 FIND v(dout1_58) AT=130.025n

* CHECK dout1_59 Vdout1_59ck25 = 0 time = 130
.meas tran vdout1_59ck25 FIND v(dout1_59) AT=130.025n

* CHECK dout1_60 Vdout1_60ck25 = 0.9 time = 130
.meas tran vdout1_60ck25 FIND v(dout1_60) AT=130.025n

* CHECK dout1_61 Vdout1_61ck25 = 0.9 time = 130
.meas tran vdout1_61ck25 FIND v(dout1_61) AT=130.025n

* CHECK dout1_62 Vdout1_62ck25 = 0.9 time = 130
.meas tran vdout1_62ck25 FIND v(dout1_62) AT=130.025n

* CHECK dout1_63 Vdout1_63ck25 = 0.9 time = 130
.meas tran vdout1_63ck25 FIND v(dout1_63) AT=130.025n

* CHECK dout1_64 Vdout1_64ck25 = 0 time = 130
.meas tran vdout1_64ck25 FIND v(dout1_64) AT=130.025n

* CHECK dout1_65 Vdout1_65ck25 = 0 time = 130
.meas tran vdout1_65ck25 FIND v(dout1_65) AT=130.025n

* CHECK dout1_66 Vdout1_66ck25 = 0.9 time = 130
.meas tran vdout1_66ck25 FIND v(dout1_66) AT=130.025n

* CHECK dout1_67 Vdout1_67ck25 = 0 time = 130
.meas tran vdout1_67ck25 FIND v(dout1_67) AT=130.025n

* CHECK dout1_68 Vdout1_68ck25 = 0.9 time = 130
.meas tran vdout1_68ck25 FIND v(dout1_68) AT=130.025n

* CHECK dout1_69 Vdout1_69ck25 = 0.9 time = 130
.meas tran vdout1_69ck25 FIND v(dout1_69) AT=130.025n

* CHECK dout1_70 Vdout1_70ck25 = 0.9 time = 130
.meas tran vdout1_70ck25 FIND v(dout1_70) AT=130.025n

* CHECK dout1_71 Vdout1_71ck25 = 0.9 time = 130
.meas tran vdout1_71ck25 FIND v(dout1_71) AT=130.025n

* CHECK dout1_72 Vdout1_72ck25 = 0.9 time = 130
.meas tran vdout1_72ck25 FIND v(dout1_72) AT=130.025n

* CHECK dout1_73 Vdout1_73ck25 = 0 time = 130
.meas tran vdout1_73ck25 FIND v(dout1_73) AT=130.025n

* CHECK dout1_74 Vdout1_74ck25 = 0 time = 130
.meas tran vdout1_74ck25 FIND v(dout1_74) AT=130.025n

* CHECK dout1_75 Vdout1_75ck25 = 0.9 time = 130
.meas tran vdout1_75ck25 FIND v(dout1_75) AT=130.025n

* CHECK dout1_76 Vdout1_76ck25 = 0.9 time = 130
.meas tran vdout1_76ck25 FIND v(dout1_76) AT=130.025n

* CHECK dout1_77 Vdout1_77ck25 = 0 time = 130
.meas tran vdout1_77ck25 FIND v(dout1_77) AT=130.025n

* CHECK dout1_78 Vdout1_78ck25 = 0.9 time = 130
.meas tran vdout1_78ck25 FIND v(dout1_78) AT=130.025n

* CHECK dout1_79 Vdout1_79ck25 = 0.9 time = 130
.meas tran vdout1_79ck25 FIND v(dout1_79) AT=130.025n

* CHECK dout1_80 Vdout1_80ck25 = 0 time = 130
.meas tran vdout1_80ck25 FIND v(dout1_80) AT=130.025n

* CHECK dout1_81 Vdout1_81ck25 = 0.9 time = 130
.meas tran vdout1_81ck25 FIND v(dout1_81) AT=130.025n

* CHECK dout1_82 Vdout1_82ck25 = 0 time = 130
.meas tran vdout1_82ck25 FIND v(dout1_82) AT=130.025n

* CHECK dout1_83 Vdout1_83ck25 = 0 time = 130
.meas tran vdout1_83ck25 FIND v(dout1_83) AT=130.025n

* CHECK dout1_84 Vdout1_84ck25 = 0.9 time = 130
.meas tran vdout1_84ck25 FIND v(dout1_84) AT=130.025n

* CHECK dout1_85 Vdout1_85ck25 = 0.9 time = 130
.meas tran vdout1_85ck25 FIND v(dout1_85) AT=130.025n

* CHECK dout1_86 Vdout1_86ck25 = 0.9 time = 130
.meas tran vdout1_86ck25 FIND v(dout1_86) AT=130.025n

* CHECK dout1_87 Vdout1_87ck25 = 0.9 time = 130
.meas tran vdout1_87ck25 FIND v(dout1_87) AT=130.025n

* CHECK dout1_88 Vdout1_88ck25 = 0 time = 130
.meas tran vdout1_88ck25 FIND v(dout1_88) AT=130.025n

* CHECK dout1_89 Vdout1_89ck25 = 0 time = 130
.meas tran vdout1_89ck25 FIND v(dout1_89) AT=130.025n

* CHECK dout1_90 Vdout1_90ck25 = 0 time = 130
.meas tran vdout1_90ck25 FIND v(dout1_90) AT=130.025n

* CHECK dout1_91 Vdout1_91ck25 = 0.9 time = 130
.meas tran vdout1_91ck25 FIND v(dout1_91) AT=130.025n

* CHECK dout1_92 Vdout1_92ck25 = 0.9 time = 130
.meas tran vdout1_92ck25 FIND v(dout1_92) AT=130.025n

* CHECK dout1_93 Vdout1_93ck25 = 0.9 time = 130
.meas tran vdout1_93ck25 FIND v(dout1_93) AT=130.025n

* CHECK dout1_94 Vdout1_94ck25 = 0.9 time = 130
.meas tran vdout1_94ck25 FIND v(dout1_94) AT=130.025n

* CHECK dout1_95 Vdout1_95ck25 = 0 time = 130
.meas tran vdout1_95ck25 FIND v(dout1_95) AT=130.025n

* CHECK dout1_96 Vdout1_96ck25 = 0 time = 130
.meas tran vdout1_96ck25 FIND v(dout1_96) AT=130.025n

* CHECK dout1_97 Vdout1_97ck25 = 0.9 time = 130
.meas tran vdout1_97ck25 FIND v(dout1_97) AT=130.025n

* CHECK dout1_98 Vdout1_98ck25 = 0.9 time = 130
.meas tran vdout1_98ck25 FIND v(dout1_98) AT=130.025n

* CHECK dout1_99 Vdout1_99ck25 = 0 time = 130
.meas tran vdout1_99ck25 FIND v(dout1_99) AT=130.025n

* CHECK dout1_100 Vdout1_100ck25 = 0.9 time = 130
.meas tran vdout1_100ck25 FIND v(dout1_100) AT=130.025n

* CHECK dout1_101 Vdout1_101ck25 = 0.9 time = 130
.meas tran vdout1_101ck25 FIND v(dout1_101) AT=130.025n

* CHECK dout1_102 Vdout1_102ck25 = 0.9 time = 130
.meas tran vdout1_102ck25 FIND v(dout1_102) AT=130.025n

* CHECK dout1_103 Vdout1_103ck25 = 0.9 time = 130
.meas tran vdout1_103ck25 FIND v(dout1_103) AT=130.025n

* CHECK dout1_104 Vdout1_104ck25 = 0.9 time = 130
.meas tran vdout1_104ck25 FIND v(dout1_104) AT=130.025n

* CHECK dout1_105 Vdout1_105ck25 = 0 time = 130
.meas tran vdout1_105ck25 FIND v(dout1_105) AT=130.025n

* CHECK dout1_106 Vdout1_106ck25 = 0 time = 130
.meas tran vdout1_106ck25 FIND v(dout1_106) AT=130.025n

* CHECK dout1_107 Vdout1_107ck25 = 0.9 time = 130
.meas tran vdout1_107ck25 FIND v(dout1_107) AT=130.025n

* CHECK dout1_108 Vdout1_108ck25 = 0 time = 130
.meas tran vdout1_108ck25 FIND v(dout1_108) AT=130.025n

* CHECK dout1_109 Vdout1_109ck25 = 0 time = 130
.meas tran vdout1_109ck25 FIND v(dout1_109) AT=130.025n

* CHECK dout1_110 Vdout1_110ck25 = 0.9 time = 130
.meas tran vdout1_110ck25 FIND v(dout1_110) AT=130.025n

* CHECK dout1_111 Vdout1_111ck25 = 0.9 time = 130
.meas tran vdout1_111ck25 FIND v(dout1_111) AT=130.025n

* CHECK dout1_112 Vdout1_112ck25 = 0.9 time = 130
.meas tran vdout1_112ck25 FIND v(dout1_112) AT=130.025n

* CHECK dout1_113 Vdout1_113ck25 = 0.9 time = 130
.meas tran vdout1_113ck25 FIND v(dout1_113) AT=130.025n

* CHECK dout1_114 Vdout1_114ck25 = 0 time = 130
.meas tran vdout1_114ck25 FIND v(dout1_114) AT=130.025n

* CHECK dout1_115 Vdout1_115ck25 = 0 time = 130
.meas tran vdout1_115ck25 FIND v(dout1_115) AT=130.025n

* CHECK dout1_116 Vdout1_116ck25 = 0 time = 130
.meas tran vdout1_116ck25 FIND v(dout1_116) AT=130.025n

* CHECK dout1_117 Vdout1_117ck25 = 0 time = 130
.meas tran vdout1_117ck25 FIND v(dout1_117) AT=130.025n

* CHECK dout1_118 Vdout1_118ck25 = 0 time = 130
.meas tran vdout1_118ck25 FIND v(dout1_118) AT=130.025n

* CHECK dout1_119 Vdout1_119ck25 = 0.9 time = 130
.meas tran vdout1_119ck25 FIND v(dout1_119) AT=130.025n

* CHECK dout1_0 Vdout1_0ck26 = 0.9 time = 135
.meas tran vdout1_0ck26 FIND v(dout1_0) AT=135.025n

* CHECK dout1_1 Vdout1_1ck26 = 0.9 time = 135
.meas tran vdout1_1ck26 FIND v(dout1_1) AT=135.025n

* CHECK dout1_2 Vdout1_2ck26 = 0.9 time = 135
.meas tran vdout1_2ck26 FIND v(dout1_2) AT=135.025n

* CHECK dout1_3 Vdout1_3ck26 = 0 time = 135
.meas tran vdout1_3ck26 FIND v(dout1_3) AT=135.025n

* CHECK dout1_4 Vdout1_4ck26 = 0.9 time = 135
.meas tran vdout1_4ck26 FIND v(dout1_4) AT=135.025n

* CHECK dout1_5 Vdout1_5ck26 = 0.9 time = 135
.meas tran vdout1_5ck26 FIND v(dout1_5) AT=135.025n

* CHECK dout1_6 Vdout1_6ck26 = 0.9 time = 135
.meas tran vdout1_6ck26 FIND v(dout1_6) AT=135.025n

* CHECK dout1_7 Vdout1_7ck26 = 0.9 time = 135
.meas tran vdout1_7ck26 FIND v(dout1_7) AT=135.025n

* CHECK dout1_8 Vdout1_8ck26 = 0 time = 135
.meas tran vdout1_8ck26 FIND v(dout1_8) AT=135.025n

* CHECK dout1_9 Vdout1_9ck26 = 0 time = 135
.meas tran vdout1_9ck26 FIND v(dout1_9) AT=135.025n

* CHECK dout1_10 Vdout1_10ck26 = 0 time = 135
.meas tran vdout1_10ck26 FIND v(dout1_10) AT=135.025n

* CHECK dout1_11 Vdout1_11ck26 = 0 time = 135
.meas tran vdout1_11ck26 FIND v(dout1_11) AT=135.025n

* CHECK dout1_12 Vdout1_12ck26 = 0.9 time = 135
.meas tran vdout1_12ck26 FIND v(dout1_12) AT=135.025n

* CHECK dout1_13 Vdout1_13ck26 = 0 time = 135
.meas tran vdout1_13ck26 FIND v(dout1_13) AT=135.025n

* CHECK dout1_14 Vdout1_14ck26 = 0 time = 135
.meas tran vdout1_14ck26 FIND v(dout1_14) AT=135.025n

* CHECK dout1_15 Vdout1_15ck26 = 0 time = 135
.meas tran vdout1_15ck26 FIND v(dout1_15) AT=135.025n

* CHECK dout1_16 Vdout1_16ck26 = 0 time = 135
.meas tran vdout1_16ck26 FIND v(dout1_16) AT=135.025n

* CHECK dout1_17 Vdout1_17ck26 = 0.9 time = 135
.meas tran vdout1_17ck26 FIND v(dout1_17) AT=135.025n

* CHECK dout1_18 Vdout1_18ck26 = 0 time = 135
.meas tran vdout1_18ck26 FIND v(dout1_18) AT=135.025n

* CHECK dout1_19 Vdout1_19ck26 = 0 time = 135
.meas tran vdout1_19ck26 FIND v(dout1_19) AT=135.025n

* CHECK dout1_20 Vdout1_20ck26 = 0.9 time = 135
.meas tran vdout1_20ck26 FIND v(dout1_20) AT=135.025n

* CHECK dout1_21 Vdout1_21ck26 = 0 time = 135
.meas tran vdout1_21ck26 FIND v(dout1_21) AT=135.025n

* CHECK dout1_22 Vdout1_22ck26 = 0.9 time = 135
.meas tran vdout1_22ck26 FIND v(dout1_22) AT=135.025n

* CHECK dout1_23 Vdout1_23ck26 = 0 time = 135
.meas tran vdout1_23ck26 FIND v(dout1_23) AT=135.025n

* CHECK dout1_24 Vdout1_24ck26 = 0.9 time = 135
.meas tran vdout1_24ck26 FIND v(dout1_24) AT=135.025n

* CHECK dout1_25 Vdout1_25ck26 = 0.9 time = 135
.meas tran vdout1_25ck26 FIND v(dout1_25) AT=135.025n

* CHECK dout1_26 Vdout1_26ck26 = 0.9 time = 135
.meas tran vdout1_26ck26 FIND v(dout1_26) AT=135.025n

* CHECK dout1_27 Vdout1_27ck26 = 0.9 time = 135
.meas tran vdout1_27ck26 FIND v(dout1_27) AT=135.025n

* CHECK dout1_28 Vdout1_28ck26 = 0.9 time = 135
.meas tran vdout1_28ck26 FIND v(dout1_28) AT=135.025n

* CHECK dout1_29 Vdout1_29ck26 = 0.9 time = 135
.meas tran vdout1_29ck26 FIND v(dout1_29) AT=135.025n

* CHECK dout1_30 Vdout1_30ck26 = 0 time = 135
.meas tran vdout1_30ck26 FIND v(dout1_30) AT=135.025n

* CHECK dout1_31 Vdout1_31ck26 = 0 time = 135
.meas tran vdout1_31ck26 FIND v(dout1_31) AT=135.025n

* CHECK dout1_32 Vdout1_32ck26 = 0 time = 135
.meas tran vdout1_32ck26 FIND v(dout1_32) AT=135.025n

* CHECK dout1_33 Vdout1_33ck26 = 0.9 time = 135
.meas tran vdout1_33ck26 FIND v(dout1_33) AT=135.025n

* CHECK dout1_34 Vdout1_34ck26 = 0.9 time = 135
.meas tran vdout1_34ck26 FIND v(dout1_34) AT=135.025n

* CHECK dout1_35 Vdout1_35ck26 = 0 time = 135
.meas tran vdout1_35ck26 FIND v(dout1_35) AT=135.025n

* CHECK dout1_36 Vdout1_36ck26 = 0.9 time = 135
.meas tran vdout1_36ck26 FIND v(dout1_36) AT=135.025n

* CHECK dout1_37 Vdout1_37ck26 = 0.9 time = 135
.meas tran vdout1_37ck26 FIND v(dout1_37) AT=135.025n

* CHECK dout1_38 Vdout1_38ck26 = 0.9 time = 135
.meas tran vdout1_38ck26 FIND v(dout1_38) AT=135.025n

* CHECK dout1_39 Vdout1_39ck26 = 0 time = 135
.meas tran vdout1_39ck26 FIND v(dout1_39) AT=135.025n

* CHECK dout1_40 Vdout1_40ck26 = 0.9 time = 135
.meas tran vdout1_40ck26 FIND v(dout1_40) AT=135.025n

* CHECK dout1_41 Vdout1_41ck26 = 0 time = 135
.meas tran vdout1_41ck26 FIND v(dout1_41) AT=135.025n

* CHECK dout1_42 Vdout1_42ck26 = 0.9 time = 135
.meas tran vdout1_42ck26 FIND v(dout1_42) AT=135.025n

* CHECK dout1_43 Vdout1_43ck26 = 0 time = 135
.meas tran vdout1_43ck26 FIND v(dout1_43) AT=135.025n

* CHECK dout1_44 Vdout1_44ck26 = 0.9 time = 135
.meas tran vdout1_44ck26 FIND v(dout1_44) AT=135.025n

* CHECK dout1_45 Vdout1_45ck26 = 0.9 time = 135
.meas tran vdout1_45ck26 FIND v(dout1_45) AT=135.025n

* CHECK dout1_46 Vdout1_46ck26 = 0.9 time = 135
.meas tran vdout1_46ck26 FIND v(dout1_46) AT=135.025n

* CHECK dout1_47 Vdout1_47ck26 = 0.9 time = 135
.meas tran vdout1_47ck26 FIND v(dout1_47) AT=135.025n

* CHECK dout1_48 Vdout1_48ck26 = 0.9 time = 135
.meas tran vdout1_48ck26 FIND v(dout1_48) AT=135.025n

* CHECK dout1_49 Vdout1_49ck26 = 0.9 time = 135
.meas tran vdout1_49ck26 FIND v(dout1_49) AT=135.025n

* CHECK dout1_50 Vdout1_50ck26 = 0 time = 135
.meas tran vdout1_50ck26 FIND v(dout1_50) AT=135.025n

* CHECK dout1_51 Vdout1_51ck26 = 0 time = 135
.meas tran vdout1_51ck26 FIND v(dout1_51) AT=135.025n

* CHECK dout1_52 Vdout1_52ck26 = 0.9 time = 135
.meas tran vdout1_52ck26 FIND v(dout1_52) AT=135.025n

* CHECK dout1_53 Vdout1_53ck26 = 0 time = 135
.meas tran vdout1_53ck26 FIND v(dout1_53) AT=135.025n

* CHECK dout1_54 Vdout1_54ck26 = 0.9 time = 135
.meas tran vdout1_54ck26 FIND v(dout1_54) AT=135.025n

* CHECK dout1_55 Vdout1_55ck26 = 0 time = 135
.meas tran vdout1_55ck26 FIND v(dout1_55) AT=135.025n

* CHECK dout1_56 Vdout1_56ck26 = 0.9 time = 135
.meas tran vdout1_56ck26 FIND v(dout1_56) AT=135.025n

* CHECK dout1_57 Vdout1_57ck26 = 0.9 time = 135
.meas tran vdout1_57ck26 FIND v(dout1_57) AT=135.025n

* CHECK dout1_58 Vdout1_58ck26 = 0.9 time = 135
.meas tran vdout1_58ck26 FIND v(dout1_58) AT=135.025n

* CHECK dout1_59 Vdout1_59ck26 = 0 time = 135
.meas tran vdout1_59ck26 FIND v(dout1_59) AT=135.025n

* CHECK dout1_60 Vdout1_60ck26 = 0.9 time = 135
.meas tran vdout1_60ck26 FIND v(dout1_60) AT=135.025n

* CHECK dout1_61 Vdout1_61ck26 = 0.9 time = 135
.meas tran vdout1_61ck26 FIND v(dout1_61) AT=135.025n

* CHECK dout1_62 Vdout1_62ck26 = 0.9 time = 135
.meas tran vdout1_62ck26 FIND v(dout1_62) AT=135.025n

* CHECK dout1_63 Vdout1_63ck26 = 0.9 time = 135
.meas tran vdout1_63ck26 FIND v(dout1_63) AT=135.025n

* CHECK dout1_64 Vdout1_64ck26 = 0 time = 135
.meas tran vdout1_64ck26 FIND v(dout1_64) AT=135.025n

* CHECK dout1_65 Vdout1_65ck26 = 0 time = 135
.meas tran vdout1_65ck26 FIND v(dout1_65) AT=135.025n

* CHECK dout1_66 Vdout1_66ck26 = 0.9 time = 135
.meas tran vdout1_66ck26 FIND v(dout1_66) AT=135.025n

* CHECK dout1_67 Vdout1_67ck26 = 0 time = 135
.meas tran vdout1_67ck26 FIND v(dout1_67) AT=135.025n

* CHECK dout1_68 Vdout1_68ck26 = 0.9 time = 135
.meas tran vdout1_68ck26 FIND v(dout1_68) AT=135.025n

* CHECK dout1_69 Vdout1_69ck26 = 0.9 time = 135
.meas tran vdout1_69ck26 FIND v(dout1_69) AT=135.025n

* CHECK dout1_70 Vdout1_70ck26 = 0.9 time = 135
.meas tran vdout1_70ck26 FIND v(dout1_70) AT=135.025n

* CHECK dout1_71 Vdout1_71ck26 = 0.9 time = 135
.meas tran vdout1_71ck26 FIND v(dout1_71) AT=135.025n

* CHECK dout1_72 Vdout1_72ck26 = 0.9 time = 135
.meas tran vdout1_72ck26 FIND v(dout1_72) AT=135.025n

* CHECK dout1_73 Vdout1_73ck26 = 0 time = 135
.meas tran vdout1_73ck26 FIND v(dout1_73) AT=135.025n

* CHECK dout1_74 Vdout1_74ck26 = 0 time = 135
.meas tran vdout1_74ck26 FIND v(dout1_74) AT=135.025n

* CHECK dout1_75 Vdout1_75ck26 = 0.9 time = 135
.meas tran vdout1_75ck26 FIND v(dout1_75) AT=135.025n

* CHECK dout1_76 Vdout1_76ck26 = 0.9 time = 135
.meas tran vdout1_76ck26 FIND v(dout1_76) AT=135.025n

* CHECK dout1_77 Vdout1_77ck26 = 0 time = 135
.meas tran vdout1_77ck26 FIND v(dout1_77) AT=135.025n

* CHECK dout1_78 Vdout1_78ck26 = 0.9 time = 135
.meas tran vdout1_78ck26 FIND v(dout1_78) AT=135.025n

* CHECK dout1_79 Vdout1_79ck26 = 0.9 time = 135
.meas tran vdout1_79ck26 FIND v(dout1_79) AT=135.025n

* CHECK dout1_80 Vdout1_80ck26 = 0 time = 135
.meas tran vdout1_80ck26 FIND v(dout1_80) AT=135.025n

* CHECK dout1_81 Vdout1_81ck26 = 0.9 time = 135
.meas tran vdout1_81ck26 FIND v(dout1_81) AT=135.025n

* CHECK dout1_82 Vdout1_82ck26 = 0 time = 135
.meas tran vdout1_82ck26 FIND v(dout1_82) AT=135.025n

* CHECK dout1_83 Vdout1_83ck26 = 0 time = 135
.meas tran vdout1_83ck26 FIND v(dout1_83) AT=135.025n

* CHECK dout1_84 Vdout1_84ck26 = 0.9 time = 135
.meas tran vdout1_84ck26 FIND v(dout1_84) AT=135.025n

* CHECK dout1_85 Vdout1_85ck26 = 0.9 time = 135
.meas tran vdout1_85ck26 FIND v(dout1_85) AT=135.025n

* CHECK dout1_86 Vdout1_86ck26 = 0.9 time = 135
.meas tran vdout1_86ck26 FIND v(dout1_86) AT=135.025n

* CHECK dout1_87 Vdout1_87ck26 = 0.9 time = 135
.meas tran vdout1_87ck26 FIND v(dout1_87) AT=135.025n

* CHECK dout1_88 Vdout1_88ck26 = 0 time = 135
.meas tran vdout1_88ck26 FIND v(dout1_88) AT=135.025n

* CHECK dout1_89 Vdout1_89ck26 = 0 time = 135
.meas tran vdout1_89ck26 FIND v(dout1_89) AT=135.025n

* CHECK dout1_90 Vdout1_90ck26 = 0 time = 135
.meas tran vdout1_90ck26 FIND v(dout1_90) AT=135.025n

* CHECK dout1_91 Vdout1_91ck26 = 0.9 time = 135
.meas tran vdout1_91ck26 FIND v(dout1_91) AT=135.025n

* CHECK dout1_92 Vdout1_92ck26 = 0.9 time = 135
.meas tran vdout1_92ck26 FIND v(dout1_92) AT=135.025n

* CHECK dout1_93 Vdout1_93ck26 = 0.9 time = 135
.meas tran vdout1_93ck26 FIND v(dout1_93) AT=135.025n

* CHECK dout1_94 Vdout1_94ck26 = 0.9 time = 135
.meas tran vdout1_94ck26 FIND v(dout1_94) AT=135.025n

* CHECK dout1_95 Vdout1_95ck26 = 0 time = 135
.meas tran vdout1_95ck26 FIND v(dout1_95) AT=135.025n

* CHECK dout1_96 Vdout1_96ck26 = 0 time = 135
.meas tran vdout1_96ck26 FIND v(dout1_96) AT=135.025n

* CHECK dout1_97 Vdout1_97ck26 = 0.9 time = 135
.meas tran vdout1_97ck26 FIND v(dout1_97) AT=135.025n

* CHECK dout1_98 Vdout1_98ck26 = 0.9 time = 135
.meas tran vdout1_98ck26 FIND v(dout1_98) AT=135.025n

* CHECK dout1_99 Vdout1_99ck26 = 0 time = 135
.meas tran vdout1_99ck26 FIND v(dout1_99) AT=135.025n

* CHECK dout1_100 Vdout1_100ck26 = 0.9 time = 135
.meas tran vdout1_100ck26 FIND v(dout1_100) AT=135.025n

* CHECK dout1_101 Vdout1_101ck26 = 0.9 time = 135
.meas tran vdout1_101ck26 FIND v(dout1_101) AT=135.025n

* CHECK dout1_102 Vdout1_102ck26 = 0.9 time = 135
.meas tran vdout1_102ck26 FIND v(dout1_102) AT=135.025n

* CHECK dout1_103 Vdout1_103ck26 = 0.9 time = 135
.meas tran vdout1_103ck26 FIND v(dout1_103) AT=135.025n

* CHECK dout1_104 Vdout1_104ck26 = 0.9 time = 135
.meas tran vdout1_104ck26 FIND v(dout1_104) AT=135.025n

* CHECK dout1_105 Vdout1_105ck26 = 0 time = 135
.meas tran vdout1_105ck26 FIND v(dout1_105) AT=135.025n

* CHECK dout1_106 Vdout1_106ck26 = 0 time = 135
.meas tran vdout1_106ck26 FIND v(dout1_106) AT=135.025n

* CHECK dout1_107 Vdout1_107ck26 = 0.9 time = 135
.meas tran vdout1_107ck26 FIND v(dout1_107) AT=135.025n

* CHECK dout1_108 Vdout1_108ck26 = 0 time = 135
.meas tran vdout1_108ck26 FIND v(dout1_108) AT=135.025n

* CHECK dout1_109 Vdout1_109ck26 = 0 time = 135
.meas tran vdout1_109ck26 FIND v(dout1_109) AT=135.025n

* CHECK dout1_110 Vdout1_110ck26 = 0.9 time = 135
.meas tran vdout1_110ck26 FIND v(dout1_110) AT=135.025n

* CHECK dout1_111 Vdout1_111ck26 = 0.9 time = 135
.meas tran vdout1_111ck26 FIND v(dout1_111) AT=135.025n

* CHECK dout1_112 Vdout1_112ck26 = 0.9 time = 135
.meas tran vdout1_112ck26 FIND v(dout1_112) AT=135.025n

* CHECK dout1_113 Vdout1_113ck26 = 0.9 time = 135
.meas tran vdout1_113ck26 FIND v(dout1_113) AT=135.025n

* CHECK dout1_114 Vdout1_114ck26 = 0 time = 135
.meas tran vdout1_114ck26 FIND v(dout1_114) AT=135.025n

* CHECK dout1_115 Vdout1_115ck26 = 0 time = 135
.meas tran vdout1_115ck26 FIND v(dout1_115) AT=135.025n

* CHECK dout1_116 Vdout1_116ck26 = 0 time = 135
.meas tran vdout1_116ck26 FIND v(dout1_116) AT=135.025n

* CHECK dout1_117 Vdout1_117ck26 = 0 time = 135
.meas tran vdout1_117ck26 FIND v(dout1_117) AT=135.025n

* CHECK dout1_118 Vdout1_118ck26 = 0 time = 135
.meas tran vdout1_118ck26 FIND v(dout1_118) AT=135.025n

* CHECK dout1_119 Vdout1_119ck26 = 0.9 time = 135
.meas tran vdout1_119ck26 FIND v(dout1_119) AT=135.025n

* CHECK dout1_0 Vdout1_0ck29 = 0 time = 150
.meas tran vdout1_0ck29 FIND v(dout1_0) AT=150.025n

* CHECK dout1_1 Vdout1_1ck29 = 0 time = 150
.meas tran vdout1_1ck29 FIND v(dout1_1) AT=150.025n

* CHECK dout1_2 Vdout1_2ck29 = 0.9 time = 150
.meas tran vdout1_2ck29 FIND v(dout1_2) AT=150.025n

* CHECK dout1_3 Vdout1_3ck29 = 0 time = 150
.meas tran vdout1_3ck29 FIND v(dout1_3) AT=150.025n

* CHECK dout1_4 Vdout1_4ck29 = 0 time = 150
.meas tran vdout1_4ck29 FIND v(dout1_4) AT=150.025n

* CHECK dout1_5 Vdout1_5ck29 = 0.9 time = 150
.meas tran vdout1_5ck29 FIND v(dout1_5) AT=150.025n

* CHECK dout1_6 Vdout1_6ck29 = 0.9 time = 150
.meas tran vdout1_6ck29 FIND v(dout1_6) AT=150.025n

* CHECK dout1_7 Vdout1_7ck29 = 0 time = 150
.meas tran vdout1_7ck29 FIND v(dout1_7) AT=150.025n

* CHECK dout1_8 Vdout1_8ck29 = 0.9 time = 150
.meas tran vdout1_8ck29 FIND v(dout1_8) AT=150.025n

* CHECK dout1_9 Vdout1_9ck29 = 0.9 time = 150
.meas tran vdout1_9ck29 FIND v(dout1_9) AT=150.025n

* CHECK dout1_10 Vdout1_10ck29 = 0 time = 150
.meas tran vdout1_10ck29 FIND v(dout1_10) AT=150.025n

* CHECK dout1_11 Vdout1_11ck29 = 0 time = 150
.meas tran vdout1_11ck29 FIND v(dout1_11) AT=150.025n

* CHECK dout1_12 Vdout1_12ck29 = 0 time = 150
.meas tran vdout1_12ck29 FIND v(dout1_12) AT=150.025n

* CHECK dout1_13 Vdout1_13ck29 = 0.9 time = 150
.meas tran vdout1_13ck29 FIND v(dout1_13) AT=150.025n

* CHECK dout1_14 Vdout1_14ck29 = 0.9 time = 150
.meas tran vdout1_14ck29 FIND v(dout1_14) AT=150.025n

* CHECK dout1_15 Vdout1_15ck29 = 0.9 time = 150
.meas tran vdout1_15ck29 FIND v(dout1_15) AT=150.025n

* CHECK dout1_16 Vdout1_16ck29 = 0 time = 150
.meas tran vdout1_16ck29 FIND v(dout1_16) AT=150.025n

* CHECK dout1_17 Vdout1_17ck29 = 0 time = 150
.meas tran vdout1_17ck29 FIND v(dout1_17) AT=150.025n

* CHECK dout1_18 Vdout1_18ck29 = 0.9 time = 150
.meas tran vdout1_18ck29 FIND v(dout1_18) AT=150.025n

* CHECK dout1_19 Vdout1_19ck29 = 0 time = 150
.meas tran vdout1_19ck29 FIND v(dout1_19) AT=150.025n

* CHECK dout1_20 Vdout1_20ck29 = 0.9 time = 150
.meas tran vdout1_20ck29 FIND v(dout1_20) AT=150.025n

* CHECK dout1_21 Vdout1_21ck29 = 0.9 time = 150
.meas tran vdout1_21ck29 FIND v(dout1_21) AT=150.025n

* CHECK dout1_22 Vdout1_22ck29 = 0.9 time = 150
.meas tran vdout1_22ck29 FIND v(dout1_22) AT=150.025n

* CHECK dout1_23 Vdout1_23ck29 = 0.9 time = 150
.meas tran vdout1_23ck29 FIND v(dout1_23) AT=150.025n

* CHECK dout1_24 Vdout1_24ck29 = 0 time = 150
.meas tran vdout1_24ck29 FIND v(dout1_24) AT=150.025n

* CHECK dout1_25 Vdout1_25ck29 = 0 time = 150
.meas tran vdout1_25ck29 FIND v(dout1_25) AT=150.025n

* CHECK dout1_26 Vdout1_26ck29 = 0 time = 150
.meas tran vdout1_26ck29 FIND v(dout1_26) AT=150.025n

* CHECK dout1_27 Vdout1_27ck29 = 0 time = 150
.meas tran vdout1_27ck29 FIND v(dout1_27) AT=150.025n

* CHECK dout1_28 Vdout1_28ck29 = 0.9 time = 150
.meas tran vdout1_28ck29 FIND v(dout1_28) AT=150.025n

* CHECK dout1_29 Vdout1_29ck29 = 0.9 time = 150
.meas tran vdout1_29ck29 FIND v(dout1_29) AT=150.025n

* CHECK dout1_30 Vdout1_30ck29 = 0 time = 150
.meas tran vdout1_30ck29 FIND v(dout1_30) AT=150.025n

* CHECK dout1_31 Vdout1_31ck29 = 0.9 time = 150
.meas tran vdout1_31ck29 FIND v(dout1_31) AT=150.025n

* CHECK dout1_32 Vdout1_32ck29 = 0 time = 150
.meas tran vdout1_32ck29 FIND v(dout1_32) AT=150.025n

* CHECK dout1_33 Vdout1_33ck29 = 0.9 time = 150
.meas tran vdout1_33ck29 FIND v(dout1_33) AT=150.025n

* CHECK dout1_34 Vdout1_34ck29 = 0 time = 150
.meas tran vdout1_34ck29 FIND v(dout1_34) AT=150.025n

* CHECK dout1_35 Vdout1_35ck29 = 0 time = 150
.meas tran vdout1_35ck29 FIND v(dout1_35) AT=150.025n

* CHECK dout1_36 Vdout1_36ck29 = 0 time = 150
.meas tran vdout1_36ck29 FIND v(dout1_36) AT=150.025n

* CHECK dout1_37 Vdout1_37ck29 = 0.9 time = 150
.meas tran vdout1_37ck29 FIND v(dout1_37) AT=150.025n

* CHECK dout1_38 Vdout1_38ck29 = 0.9 time = 150
.meas tran vdout1_38ck29 FIND v(dout1_38) AT=150.025n

* CHECK dout1_39 Vdout1_39ck29 = 0 time = 150
.meas tran vdout1_39ck29 FIND v(dout1_39) AT=150.025n

* CHECK dout1_40 Vdout1_40ck29 = 0 time = 150
.meas tran vdout1_40ck29 FIND v(dout1_40) AT=150.025n

* CHECK dout1_41 Vdout1_41ck29 = 0.9 time = 150
.meas tran vdout1_41ck29 FIND v(dout1_41) AT=150.025n

* CHECK dout1_42 Vdout1_42ck29 = 0 time = 150
.meas tran vdout1_42ck29 FIND v(dout1_42) AT=150.025n

* CHECK dout1_43 Vdout1_43ck29 = 0 time = 150
.meas tran vdout1_43ck29 FIND v(dout1_43) AT=150.025n

* CHECK dout1_44 Vdout1_44ck29 = 0.9 time = 150
.meas tran vdout1_44ck29 FIND v(dout1_44) AT=150.025n

* CHECK dout1_45 Vdout1_45ck29 = 0.9 time = 150
.meas tran vdout1_45ck29 FIND v(dout1_45) AT=150.025n

* CHECK dout1_46 Vdout1_46ck29 = 0.9 time = 150
.meas tran vdout1_46ck29 FIND v(dout1_46) AT=150.025n

* CHECK dout1_47 Vdout1_47ck29 = 0.9 time = 150
.meas tran vdout1_47ck29 FIND v(dout1_47) AT=150.025n

* CHECK dout1_48 Vdout1_48ck29 = 0 time = 150
.meas tran vdout1_48ck29 FIND v(dout1_48) AT=150.025n

* CHECK dout1_49 Vdout1_49ck29 = 0.9 time = 150
.meas tran vdout1_49ck29 FIND v(dout1_49) AT=150.025n

* CHECK dout1_50 Vdout1_50ck29 = 0 time = 150
.meas tran vdout1_50ck29 FIND v(dout1_50) AT=150.025n

* CHECK dout1_51 Vdout1_51ck29 = 0.9 time = 150
.meas tran vdout1_51ck29 FIND v(dout1_51) AT=150.025n

* CHECK dout1_52 Vdout1_52ck29 = 0.9 time = 150
.meas tran vdout1_52ck29 FIND v(dout1_52) AT=150.025n

* CHECK dout1_53 Vdout1_53ck29 = 0.9 time = 150
.meas tran vdout1_53ck29 FIND v(dout1_53) AT=150.025n

* CHECK dout1_54 Vdout1_54ck29 = 0 time = 150
.meas tran vdout1_54ck29 FIND v(dout1_54) AT=150.025n

* CHECK dout1_55 Vdout1_55ck29 = 0.9 time = 150
.meas tran vdout1_55ck29 FIND v(dout1_55) AT=150.025n

* CHECK dout1_56 Vdout1_56ck29 = 0 time = 150
.meas tran vdout1_56ck29 FIND v(dout1_56) AT=150.025n

* CHECK dout1_57 Vdout1_57ck29 = 0 time = 150
.meas tran vdout1_57ck29 FIND v(dout1_57) AT=150.025n

* CHECK dout1_58 Vdout1_58ck29 = 0 time = 150
.meas tran vdout1_58ck29 FIND v(dout1_58) AT=150.025n

* CHECK dout1_59 Vdout1_59ck29 = 0 time = 150
.meas tran vdout1_59ck29 FIND v(dout1_59) AT=150.025n

* CHECK dout1_60 Vdout1_60ck29 = 0 time = 150
.meas tran vdout1_60ck29 FIND v(dout1_60) AT=150.025n

* CHECK dout1_61 Vdout1_61ck29 = 0 time = 150
.meas tran vdout1_61ck29 FIND v(dout1_61) AT=150.025n

* CHECK dout1_62 Vdout1_62ck29 = 0.9 time = 150
.meas tran vdout1_62ck29 FIND v(dout1_62) AT=150.025n

* CHECK dout1_63 Vdout1_63ck29 = 0.9 time = 150
.meas tran vdout1_63ck29 FIND v(dout1_63) AT=150.025n

* CHECK dout1_64 Vdout1_64ck29 = 0 time = 150
.meas tran vdout1_64ck29 FIND v(dout1_64) AT=150.025n

* CHECK dout1_65 Vdout1_65ck29 = 0.9 time = 150
.meas tran vdout1_65ck29 FIND v(dout1_65) AT=150.025n

* CHECK dout1_66 Vdout1_66ck29 = 0 time = 150
.meas tran vdout1_66ck29 FIND v(dout1_66) AT=150.025n

* CHECK dout1_67 Vdout1_67ck29 = 0.9 time = 150
.meas tran vdout1_67ck29 FIND v(dout1_67) AT=150.025n

* CHECK dout1_68 Vdout1_68ck29 = 0 time = 150
.meas tran vdout1_68ck29 FIND v(dout1_68) AT=150.025n

* CHECK dout1_69 Vdout1_69ck29 = 0.9 time = 150
.meas tran vdout1_69ck29 FIND v(dout1_69) AT=150.025n

* CHECK dout1_70 Vdout1_70ck29 = 0.9 time = 150
.meas tran vdout1_70ck29 FIND v(dout1_70) AT=150.025n

* CHECK dout1_71 Vdout1_71ck29 = 0 time = 150
.meas tran vdout1_71ck29 FIND v(dout1_71) AT=150.025n

* CHECK dout1_72 Vdout1_72ck29 = 0.9 time = 150
.meas tran vdout1_72ck29 FIND v(dout1_72) AT=150.025n

* CHECK dout1_73 Vdout1_73ck29 = 0.9 time = 150
.meas tran vdout1_73ck29 FIND v(dout1_73) AT=150.025n

* CHECK dout1_74 Vdout1_74ck29 = 0.9 time = 150
.meas tran vdout1_74ck29 FIND v(dout1_74) AT=150.025n

* CHECK dout1_75 Vdout1_75ck29 = 0.9 time = 150
.meas tran vdout1_75ck29 FIND v(dout1_75) AT=150.025n

* CHECK dout1_76 Vdout1_76ck29 = 0 time = 150
.meas tran vdout1_76ck29 FIND v(dout1_76) AT=150.025n

* CHECK dout1_77 Vdout1_77ck29 = 0.9 time = 150
.meas tran vdout1_77ck29 FIND v(dout1_77) AT=150.025n

* CHECK dout1_78 Vdout1_78ck29 = 0 time = 150
.meas tran vdout1_78ck29 FIND v(dout1_78) AT=150.025n

* CHECK dout1_79 Vdout1_79ck29 = 0.9 time = 150
.meas tran vdout1_79ck29 FIND v(dout1_79) AT=150.025n

* CHECK dout1_80 Vdout1_80ck29 = 0 time = 150
.meas tran vdout1_80ck29 FIND v(dout1_80) AT=150.025n

* CHECK dout1_81 Vdout1_81ck29 = 0.9 time = 150
.meas tran vdout1_81ck29 FIND v(dout1_81) AT=150.025n

* CHECK dout1_82 Vdout1_82ck29 = 0.9 time = 150
.meas tran vdout1_82ck29 FIND v(dout1_82) AT=150.025n

* CHECK dout1_83 Vdout1_83ck29 = 0 time = 150
.meas tran vdout1_83ck29 FIND v(dout1_83) AT=150.025n

* CHECK dout1_84 Vdout1_84ck29 = 0 time = 150
.meas tran vdout1_84ck29 FIND v(dout1_84) AT=150.025n

* CHECK dout1_85 Vdout1_85ck29 = 0.9 time = 150
.meas tran vdout1_85ck29 FIND v(dout1_85) AT=150.025n

* CHECK dout1_86 Vdout1_86ck29 = 0.9 time = 150
.meas tran vdout1_86ck29 FIND v(dout1_86) AT=150.025n

* CHECK dout1_87 Vdout1_87ck29 = 0 time = 150
.meas tran vdout1_87ck29 FIND v(dout1_87) AT=150.025n

* CHECK dout1_88 Vdout1_88ck29 = 0.9 time = 150
.meas tran vdout1_88ck29 FIND v(dout1_88) AT=150.025n

* CHECK dout1_89 Vdout1_89ck29 = 0.9 time = 150
.meas tran vdout1_89ck29 FIND v(dout1_89) AT=150.025n

* CHECK dout1_90 Vdout1_90ck29 = 0 time = 150
.meas tran vdout1_90ck29 FIND v(dout1_90) AT=150.025n

* CHECK dout1_91 Vdout1_91ck29 = 0.9 time = 150
.meas tran vdout1_91ck29 FIND v(dout1_91) AT=150.025n

* CHECK dout1_92 Vdout1_92ck29 = 0 time = 150
.meas tran vdout1_92ck29 FIND v(dout1_92) AT=150.025n

* CHECK dout1_93 Vdout1_93ck29 = 0.9 time = 150
.meas tran vdout1_93ck29 FIND v(dout1_93) AT=150.025n

* CHECK dout1_94 Vdout1_94ck29 = 0 time = 150
.meas tran vdout1_94ck29 FIND v(dout1_94) AT=150.025n

* CHECK dout1_95 Vdout1_95ck29 = 0 time = 150
.meas tran vdout1_95ck29 FIND v(dout1_95) AT=150.025n

* CHECK dout1_96 Vdout1_96ck29 = 0.9 time = 150
.meas tran vdout1_96ck29 FIND v(dout1_96) AT=150.025n

* CHECK dout1_97 Vdout1_97ck29 = 0 time = 150
.meas tran vdout1_97ck29 FIND v(dout1_97) AT=150.025n

* CHECK dout1_98 Vdout1_98ck29 = 0 time = 150
.meas tran vdout1_98ck29 FIND v(dout1_98) AT=150.025n

* CHECK dout1_99 Vdout1_99ck29 = 0 time = 150
.meas tran vdout1_99ck29 FIND v(dout1_99) AT=150.025n

* CHECK dout1_100 Vdout1_100ck29 = 0 time = 150
.meas tran vdout1_100ck29 FIND v(dout1_100) AT=150.025n

* CHECK dout1_101 Vdout1_101ck29 = 0.9 time = 150
.meas tran vdout1_101ck29 FIND v(dout1_101) AT=150.025n

* CHECK dout1_102 Vdout1_102ck29 = 0.9 time = 150
.meas tran vdout1_102ck29 FIND v(dout1_102) AT=150.025n

* CHECK dout1_103 Vdout1_103ck29 = 0 time = 150
.meas tran vdout1_103ck29 FIND v(dout1_103) AT=150.025n

* CHECK dout1_104 Vdout1_104ck29 = 0 time = 150
.meas tran vdout1_104ck29 FIND v(dout1_104) AT=150.025n

* CHECK dout1_105 Vdout1_105ck29 = 0 time = 150
.meas tran vdout1_105ck29 FIND v(dout1_105) AT=150.025n

* CHECK dout1_106 Vdout1_106ck29 = 0 time = 150
.meas tran vdout1_106ck29 FIND v(dout1_106) AT=150.025n

* CHECK dout1_107 Vdout1_107ck29 = 0.9 time = 150
.meas tran vdout1_107ck29 FIND v(dout1_107) AT=150.025n

* CHECK dout1_108 Vdout1_108ck29 = 0.9 time = 150
.meas tran vdout1_108ck29 FIND v(dout1_108) AT=150.025n

* CHECK dout1_109 Vdout1_109ck29 = 0 time = 150
.meas tran vdout1_109ck29 FIND v(dout1_109) AT=150.025n

* CHECK dout1_110 Vdout1_110ck29 = 0 time = 150
.meas tran vdout1_110ck29 FIND v(dout1_110) AT=150.025n

* CHECK dout1_111 Vdout1_111ck29 = 0.9 time = 150
.meas tran vdout1_111ck29 FIND v(dout1_111) AT=150.025n

* CHECK dout1_112 Vdout1_112ck29 = 0 time = 150
.meas tran vdout1_112ck29 FIND v(dout1_112) AT=150.025n

* CHECK dout1_113 Vdout1_113ck29 = 0 time = 150
.meas tran vdout1_113ck29 FIND v(dout1_113) AT=150.025n

* CHECK dout1_114 Vdout1_114ck29 = 0.9 time = 150
.meas tran vdout1_114ck29 FIND v(dout1_114) AT=150.025n

* CHECK dout1_115 Vdout1_115ck29 = 0.9 time = 150
.meas tran vdout1_115ck29 FIND v(dout1_115) AT=150.025n

* CHECK dout1_116 Vdout1_116ck29 = 0 time = 150
.meas tran vdout1_116ck29 FIND v(dout1_116) AT=150.025n

* CHECK dout1_117 Vdout1_117ck29 = 0.9 time = 150
.meas tran vdout1_117ck29 FIND v(dout1_117) AT=150.025n

* CHECK dout1_118 Vdout1_118ck29 = 0.9 time = 150
.meas tran vdout1_118ck29 FIND v(dout1_118) AT=150.025n

* CHECK dout1_119 Vdout1_119ck29 = 0 time = 150
.meas tran vdout1_119ck29 FIND v(dout1_119) AT=150.025n

* CHECK dout1_0 Vdout1_0ck31 = 0 time = 160
.meas tran vdout1_0ck31 FIND v(dout1_0) AT=160.025n

* CHECK dout1_1 Vdout1_1ck31 = 0.9 time = 160
.meas tran vdout1_1ck31 FIND v(dout1_1) AT=160.025n

* CHECK dout1_2 Vdout1_2ck31 = 0.9 time = 160
.meas tran vdout1_2ck31 FIND v(dout1_2) AT=160.025n

* CHECK dout1_3 Vdout1_3ck31 = 0 time = 160
.meas tran vdout1_3ck31 FIND v(dout1_3) AT=160.025n

* CHECK dout1_4 Vdout1_4ck31 = 0 time = 160
.meas tran vdout1_4ck31 FIND v(dout1_4) AT=160.025n

* CHECK dout1_5 Vdout1_5ck31 = 0.9 time = 160
.meas tran vdout1_5ck31 FIND v(dout1_5) AT=160.025n

* CHECK dout1_6 Vdout1_6ck31 = 0.9 time = 160
.meas tran vdout1_6ck31 FIND v(dout1_6) AT=160.025n

* CHECK dout1_7 Vdout1_7ck31 = 0 time = 160
.meas tran vdout1_7ck31 FIND v(dout1_7) AT=160.025n

* CHECK dout1_8 Vdout1_8ck31 = 0.9 time = 160
.meas tran vdout1_8ck31 FIND v(dout1_8) AT=160.025n

* CHECK dout1_9 Vdout1_9ck31 = 0 time = 160
.meas tran vdout1_9ck31 FIND v(dout1_9) AT=160.025n

* CHECK dout1_10 Vdout1_10ck31 = 0 time = 160
.meas tran vdout1_10ck31 FIND v(dout1_10) AT=160.025n

* CHECK dout1_11 Vdout1_11ck31 = 0.9 time = 160
.meas tran vdout1_11ck31 FIND v(dout1_11) AT=160.025n

* CHECK dout1_12 Vdout1_12ck31 = 0 time = 160
.meas tran vdout1_12ck31 FIND v(dout1_12) AT=160.025n

* CHECK dout1_13 Vdout1_13ck31 = 0 time = 160
.meas tran vdout1_13ck31 FIND v(dout1_13) AT=160.025n

* CHECK dout1_14 Vdout1_14ck31 = 0.9 time = 160
.meas tran vdout1_14ck31 FIND v(dout1_14) AT=160.025n

* CHECK dout1_15 Vdout1_15ck31 = 0.9 time = 160
.meas tran vdout1_15ck31 FIND v(dout1_15) AT=160.025n

* CHECK dout1_16 Vdout1_16ck31 = 0.9 time = 160
.meas tran vdout1_16ck31 FIND v(dout1_16) AT=160.025n

* CHECK dout1_17 Vdout1_17ck31 = 0 time = 160
.meas tran vdout1_17ck31 FIND v(dout1_17) AT=160.025n

* CHECK dout1_18 Vdout1_18ck31 = 0 time = 160
.meas tran vdout1_18ck31 FIND v(dout1_18) AT=160.025n

* CHECK dout1_19 Vdout1_19ck31 = 0.9 time = 160
.meas tran vdout1_19ck31 FIND v(dout1_19) AT=160.025n

* CHECK dout1_20 Vdout1_20ck31 = 0.9 time = 160
.meas tran vdout1_20ck31 FIND v(dout1_20) AT=160.025n

* CHECK dout1_21 Vdout1_21ck31 = 0 time = 160
.meas tran vdout1_21ck31 FIND v(dout1_21) AT=160.025n

* CHECK dout1_22 Vdout1_22ck31 = 0 time = 160
.meas tran vdout1_22ck31 FIND v(dout1_22) AT=160.025n

* CHECK dout1_23 Vdout1_23ck31 = 0.9 time = 160
.meas tran vdout1_23ck31 FIND v(dout1_23) AT=160.025n

* CHECK dout1_24 Vdout1_24ck31 = 0 time = 160
.meas tran vdout1_24ck31 FIND v(dout1_24) AT=160.025n

* CHECK dout1_25 Vdout1_25ck31 = 0.9 time = 160
.meas tran vdout1_25ck31 FIND v(dout1_25) AT=160.025n

* CHECK dout1_26 Vdout1_26ck31 = 0 time = 160
.meas tran vdout1_26ck31 FIND v(dout1_26) AT=160.025n

* CHECK dout1_27 Vdout1_27ck31 = 0 time = 160
.meas tran vdout1_27ck31 FIND v(dout1_27) AT=160.025n

* CHECK dout1_28 Vdout1_28ck31 = 0.9 time = 160
.meas tran vdout1_28ck31 FIND v(dout1_28) AT=160.025n

* CHECK dout1_29 Vdout1_29ck31 = 0 time = 160
.meas tran vdout1_29ck31 FIND v(dout1_29) AT=160.025n

* CHECK dout1_30 Vdout1_30ck31 = 0 time = 160
.meas tran vdout1_30ck31 FIND v(dout1_30) AT=160.025n

* CHECK dout1_31 Vdout1_31ck31 = 0 time = 160
.meas tran vdout1_31ck31 FIND v(dout1_31) AT=160.025n

* CHECK dout1_32 Vdout1_32ck31 = 0.9 time = 160
.meas tran vdout1_32ck31 FIND v(dout1_32) AT=160.025n

* CHECK dout1_33 Vdout1_33ck31 = 0 time = 160
.meas tran vdout1_33ck31 FIND v(dout1_33) AT=160.025n

* CHECK dout1_34 Vdout1_34ck31 = 0.9 time = 160
.meas tran vdout1_34ck31 FIND v(dout1_34) AT=160.025n

* CHECK dout1_35 Vdout1_35ck31 = 0 time = 160
.meas tran vdout1_35ck31 FIND v(dout1_35) AT=160.025n

* CHECK dout1_36 Vdout1_36ck31 = 0.9 time = 160
.meas tran vdout1_36ck31 FIND v(dout1_36) AT=160.025n

* CHECK dout1_37 Vdout1_37ck31 = 0 time = 160
.meas tran vdout1_37ck31 FIND v(dout1_37) AT=160.025n

* CHECK dout1_38 Vdout1_38ck31 = 0 time = 160
.meas tran vdout1_38ck31 FIND v(dout1_38) AT=160.025n

* CHECK dout1_39 Vdout1_39ck31 = 0 time = 160
.meas tran vdout1_39ck31 FIND v(dout1_39) AT=160.025n

* CHECK dout1_40 Vdout1_40ck31 = 0 time = 160
.meas tran vdout1_40ck31 FIND v(dout1_40) AT=160.025n

* CHECK dout1_41 Vdout1_41ck31 = 0.9 time = 160
.meas tran vdout1_41ck31 FIND v(dout1_41) AT=160.025n

* CHECK dout1_42 Vdout1_42ck31 = 0 time = 160
.meas tran vdout1_42ck31 FIND v(dout1_42) AT=160.025n

* CHECK dout1_43 Vdout1_43ck31 = 0 time = 160
.meas tran vdout1_43ck31 FIND v(dout1_43) AT=160.025n

* CHECK dout1_44 Vdout1_44ck31 = 0 time = 160
.meas tran vdout1_44ck31 FIND v(dout1_44) AT=160.025n

* CHECK dout1_45 Vdout1_45ck31 = 0.9 time = 160
.meas tran vdout1_45ck31 FIND v(dout1_45) AT=160.025n

* CHECK dout1_46 Vdout1_46ck31 = 0 time = 160
.meas tran vdout1_46ck31 FIND v(dout1_46) AT=160.025n

* CHECK dout1_47 Vdout1_47ck31 = 0.9 time = 160
.meas tran vdout1_47ck31 FIND v(dout1_47) AT=160.025n

* CHECK dout1_48 Vdout1_48ck31 = 0 time = 160
.meas tran vdout1_48ck31 FIND v(dout1_48) AT=160.025n

* CHECK dout1_49 Vdout1_49ck31 = 0 time = 160
.meas tran vdout1_49ck31 FIND v(dout1_49) AT=160.025n

* CHECK dout1_50 Vdout1_50ck31 = 0.9 time = 160
.meas tran vdout1_50ck31 FIND v(dout1_50) AT=160.025n

* CHECK dout1_51 Vdout1_51ck31 = 0 time = 160
.meas tran vdout1_51ck31 FIND v(dout1_51) AT=160.025n

* CHECK dout1_52 Vdout1_52ck31 = 0.9 time = 160
.meas tran vdout1_52ck31 FIND v(dout1_52) AT=160.025n

* CHECK dout1_53 Vdout1_53ck31 = 0.9 time = 160
.meas tran vdout1_53ck31 FIND v(dout1_53) AT=160.025n

* CHECK dout1_54 Vdout1_54ck31 = 0 time = 160
.meas tran vdout1_54ck31 FIND v(dout1_54) AT=160.025n

* CHECK dout1_55 Vdout1_55ck31 = 0.9 time = 160
.meas tran vdout1_55ck31 FIND v(dout1_55) AT=160.025n

* CHECK dout1_56 Vdout1_56ck31 = 0.9 time = 160
.meas tran vdout1_56ck31 FIND v(dout1_56) AT=160.025n

* CHECK dout1_57 Vdout1_57ck31 = 0 time = 160
.meas tran vdout1_57ck31 FIND v(dout1_57) AT=160.025n

* CHECK dout1_58 Vdout1_58ck31 = 0 time = 160
.meas tran vdout1_58ck31 FIND v(dout1_58) AT=160.025n

* CHECK dout1_59 Vdout1_59ck31 = 0 time = 160
.meas tran vdout1_59ck31 FIND v(dout1_59) AT=160.025n

* CHECK dout1_60 Vdout1_60ck31 = 0 time = 160
.meas tran vdout1_60ck31 FIND v(dout1_60) AT=160.025n

* CHECK dout1_61 Vdout1_61ck31 = 0.9 time = 160
.meas tran vdout1_61ck31 FIND v(dout1_61) AT=160.025n

* CHECK dout1_62 Vdout1_62ck31 = 0 time = 160
.meas tran vdout1_62ck31 FIND v(dout1_62) AT=160.025n

* CHECK dout1_63 Vdout1_63ck31 = 0 time = 160
.meas tran vdout1_63ck31 FIND v(dout1_63) AT=160.025n

* CHECK dout1_64 Vdout1_64ck31 = 0 time = 160
.meas tran vdout1_64ck31 FIND v(dout1_64) AT=160.025n

* CHECK dout1_65 Vdout1_65ck31 = 0.9 time = 160
.meas tran vdout1_65ck31 FIND v(dout1_65) AT=160.025n

* CHECK dout1_66 Vdout1_66ck31 = 0.9 time = 160
.meas tran vdout1_66ck31 FIND v(dout1_66) AT=160.025n

* CHECK dout1_67 Vdout1_67ck31 = 0 time = 160
.meas tran vdout1_67ck31 FIND v(dout1_67) AT=160.025n

* CHECK dout1_68 Vdout1_68ck31 = 0.9 time = 160
.meas tran vdout1_68ck31 FIND v(dout1_68) AT=160.025n

* CHECK dout1_69 Vdout1_69ck31 = 0.9 time = 160
.meas tran vdout1_69ck31 FIND v(dout1_69) AT=160.025n

* CHECK dout1_70 Vdout1_70ck31 = 0 time = 160
.meas tran vdout1_70ck31 FIND v(dout1_70) AT=160.025n

* CHECK dout1_71 Vdout1_71ck31 = 0 time = 160
.meas tran vdout1_71ck31 FIND v(dout1_71) AT=160.025n

* CHECK dout1_72 Vdout1_72ck31 = 0 time = 160
.meas tran vdout1_72ck31 FIND v(dout1_72) AT=160.025n

* CHECK dout1_73 Vdout1_73ck31 = 0.9 time = 160
.meas tran vdout1_73ck31 FIND v(dout1_73) AT=160.025n

* CHECK dout1_74 Vdout1_74ck31 = 0.9 time = 160
.meas tran vdout1_74ck31 FIND v(dout1_74) AT=160.025n

* CHECK dout1_75 Vdout1_75ck31 = 0 time = 160
.meas tran vdout1_75ck31 FIND v(dout1_75) AT=160.025n

* CHECK dout1_76 Vdout1_76ck31 = 0.9 time = 160
.meas tran vdout1_76ck31 FIND v(dout1_76) AT=160.025n

* CHECK dout1_77 Vdout1_77ck31 = 0 time = 160
.meas tran vdout1_77ck31 FIND v(dout1_77) AT=160.025n

* CHECK dout1_78 Vdout1_78ck31 = 0 time = 160
.meas tran vdout1_78ck31 FIND v(dout1_78) AT=160.025n

* CHECK dout1_79 Vdout1_79ck31 = 0.9 time = 160
.meas tran vdout1_79ck31 FIND v(dout1_79) AT=160.025n

* CHECK dout1_80 Vdout1_80ck31 = 0.9 time = 160
.meas tran vdout1_80ck31 FIND v(dout1_80) AT=160.025n

* CHECK dout1_81 Vdout1_81ck31 = 0 time = 160
.meas tran vdout1_81ck31 FIND v(dout1_81) AT=160.025n

* CHECK dout1_82 Vdout1_82ck31 = 0.9 time = 160
.meas tran vdout1_82ck31 FIND v(dout1_82) AT=160.025n

* CHECK dout1_83 Vdout1_83ck31 = 0.9 time = 160
.meas tran vdout1_83ck31 FIND v(dout1_83) AT=160.025n

* CHECK dout1_84 Vdout1_84ck31 = 0.9 time = 160
.meas tran vdout1_84ck31 FIND v(dout1_84) AT=160.025n

* CHECK dout1_85 Vdout1_85ck31 = 0.9 time = 160
.meas tran vdout1_85ck31 FIND v(dout1_85) AT=160.025n

* CHECK dout1_86 Vdout1_86ck31 = 0 time = 160
.meas tran vdout1_86ck31 FIND v(dout1_86) AT=160.025n

* CHECK dout1_87 Vdout1_87ck31 = 0 time = 160
.meas tran vdout1_87ck31 FIND v(dout1_87) AT=160.025n

* CHECK dout1_88 Vdout1_88ck31 = 0.9 time = 160
.meas tran vdout1_88ck31 FIND v(dout1_88) AT=160.025n

* CHECK dout1_89 Vdout1_89ck31 = 0 time = 160
.meas tran vdout1_89ck31 FIND v(dout1_89) AT=160.025n

* CHECK dout1_90 Vdout1_90ck31 = 0 time = 160
.meas tran vdout1_90ck31 FIND v(dout1_90) AT=160.025n

* CHECK dout1_91 Vdout1_91ck31 = 0 time = 160
.meas tran vdout1_91ck31 FIND v(dout1_91) AT=160.025n

* CHECK dout1_92 Vdout1_92ck31 = 0 time = 160
.meas tran vdout1_92ck31 FIND v(dout1_92) AT=160.025n

* CHECK dout1_93 Vdout1_93ck31 = 0 time = 160
.meas tran vdout1_93ck31 FIND v(dout1_93) AT=160.025n

* CHECK dout1_94 Vdout1_94ck31 = 0 time = 160
.meas tran vdout1_94ck31 FIND v(dout1_94) AT=160.025n

* CHECK dout1_95 Vdout1_95ck31 = 0 time = 160
.meas tran vdout1_95ck31 FIND v(dout1_95) AT=160.025n

* CHECK dout1_96 Vdout1_96ck31 = 0 time = 160
.meas tran vdout1_96ck31 FIND v(dout1_96) AT=160.025n

* CHECK dout1_97 Vdout1_97ck31 = 0.9 time = 160
.meas tran vdout1_97ck31 FIND v(dout1_97) AT=160.025n

* CHECK dout1_98 Vdout1_98ck31 = 0.9 time = 160
.meas tran vdout1_98ck31 FIND v(dout1_98) AT=160.025n

* CHECK dout1_99 Vdout1_99ck31 = 0.9 time = 160
.meas tran vdout1_99ck31 FIND v(dout1_99) AT=160.025n

* CHECK dout1_100 Vdout1_100ck31 = 0 time = 160
.meas tran vdout1_100ck31 FIND v(dout1_100) AT=160.025n

* CHECK dout1_101 Vdout1_101ck31 = 0 time = 160
.meas tran vdout1_101ck31 FIND v(dout1_101) AT=160.025n

* CHECK dout1_102 Vdout1_102ck31 = 0 time = 160
.meas tran vdout1_102ck31 FIND v(dout1_102) AT=160.025n

* CHECK dout1_103 Vdout1_103ck31 = 0 time = 160
.meas tran vdout1_103ck31 FIND v(dout1_103) AT=160.025n

* CHECK dout1_104 Vdout1_104ck31 = 0 time = 160
.meas tran vdout1_104ck31 FIND v(dout1_104) AT=160.025n

* CHECK dout1_105 Vdout1_105ck31 = 0 time = 160
.meas tran vdout1_105ck31 FIND v(dout1_105) AT=160.025n

* CHECK dout1_106 Vdout1_106ck31 = 0.9 time = 160
.meas tran vdout1_106ck31 FIND v(dout1_106) AT=160.025n

* CHECK dout1_107 Vdout1_107ck31 = 0.9 time = 160
.meas tran vdout1_107ck31 FIND v(dout1_107) AT=160.025n

* CHECK dout1_108 Vdout1_108ck31 = 0 time = 160
.meas tran vdout1_108ck31 FIND v(dout1_108) AT=160.025n

* CHECK dout1_109 Vdout1_109ck31 = 0.9 time = 160
.meas tran vdout1_109ck31 FIND v(dout1_109) AT=160.025n

* CHECK dout1_110 Vdout1_110ck31 = 0.9 time = 160
.meas tran vdout1_110ck31 FIND v(dout1_110) AT=160.025n

* CHECK dout1_111 Vdout1_111ck31 = 0 time = 160
.meas tran vdout1_111ck31 FIND v(dout1_111) AT=160.025n

* CHECK dout1_112 Vdout1_112ck31 = 0 time = 160
.meas tran vdout1_112ck31 FIND v(dout1_112) AT=160.025n

* CHECK dout1_113 Vdout1_113ck31 = 0.9 time = 160
.meas tran vdout1_113ck31 FIND v(dout1_113) AT=160.025n

* CHECK dout1_114 Vdout1_114ck31 = 0 time = 160
.meas tran vdout1_114ck31 FIND v(dout1_114) AT=160.025n

* CHECK dout1_115 Vdout1_115ck31 = 0 time = 160
.meas tran vdout1_115ck31 FIND v(dout1_115) AT=160.025n

* CHECK dout1_116 Vdout1_116ck31 = 0 time = 160
.meas tran vdout1_116ck31 FIND v(dout1_116) AT=160.025n

* CHECK dout1_117 Vdout1_117ck31 = 0 time = 160
.meas tran vdout1_117ck31 FIND v(dout1_117) AT=160.025n

* CHECK dout1_118 Vdout1_118ck31 = 0.9 time = 160
.meas tran vdout1_118ck31 FIND v(dout1_118) AT=160.025n

* CHECK dout1_119 Vdout1_119ck31 = 0 time = 160
.meas tran vdout1_119ck31 FIND v(dout1_119) AT=160.025n

* CHECK dout1_0 Vdout1_0ck33 = 0 time = 170
.meas tran vdout1_0ck33 FIND v(dout1_0) AT=170.025n

* CHECK dout1_1 Vdout1_1ck33 = 0 time = 170
.meas tran vdout1_1ck33 FIND v(dout1_1) AT=170.025n

* CHECK dout1_2 Vdout1_2ck33 = 0.9 time = 170
.meas tran vdout1_2ck33 FIND v(dout1_2) AT=170.025n

* CHECK dout1_3 Vdout1_3ck33 = 0.9 time = 170
.meas tran vdout1_3ck33 FIND v(dout1_3) AT=170.025n

* CHECK dout1_4 Vdout1_4ck33 = 0 time = 170
.meas tran vdout1_4ck33 FIND v(dout1_4) AT=170.025n

* CHECK dout1_5 Vdout1_5ck33 = 0 time = 170
.meas tran vdout1_5ck33 FIND v(dout1_5) AT=170.025n

* CHECK dout1_6 Vdout1_6ck33 = 0.9 time = 170
.meas tran vdout1_6ck33 FIND v(dout1_6) AT=170.025n

* CHECK dout1_7 Vdout1_7ck33 = 0 time = 170
.meas tran vdout1_7ck33 FIND v(dout1_7) AT=170.025n

* CHECK dout1_8 Vdout1_8ck33 = 0.9 time = 170
.meas tran vdout1_8ck33 FIND v(dout1_8) AT=170.025n

* CHECK dout1_9 Vdout1_9ck33 = 0 time = 170
.meas tran vdout1_9ck33 FIND v(dout1_9) AT=170.025n

* CHECK dout1_10 Vdout1_10ck33 = 0 time = 170
.meas tran vdout1_10ck33 FIND v(dout1_10) AT=170.025n

* CHECK dout1_11 Vdout1_11ck33 = 0.9 time = 170
.meas tran vdout1_11ck33 FIND v(dout1_11) AT=170.025n

* CHECK dout1_12 Vdout1_12ck33 = 0 time = 170
.meas tran vdout1_12ck33 FIND v(dout1_12) AT=170.025n

* CHECK dout1_13 Vdout1_13ck33 = 0 time = 170
.meas tran vdout1_13ck33 FIND v(dout1_13) AT=170.025n

* CHECK dout1_14 Vdout1_14ck33 = 0.9 time = 170
.meas tran vdout1_14ck33 FIND v(dout1_14) AT=170.025n

* CHECK dout1_15 Vdout1_15ck33 = 0 time = 170
.meas tran vdout1_15ck33 FIND v(dout1_15) AT=170.025n

* CHECK dout1_16 Vdout1_16ck33 = 0 time = 170
.meas tran vdout1_16ck33 FIND v(dout1_16) AT=170.025n

* CHECK dout1_17 Vdout1_17ck33 = 0.9 time = 170
.meas tran vdout1_17ck33 FIND v(dout1_17) AT=170.025n

* CHECK dout1_18 Vdout1_18ck33 = 0 time = 170
.meas tran vdout1_18ck33 FIND v(dout1_18) AT=170.025n

* CHECK dout1_19 Vdout1_19ck33 = 0.9 time = 170
.meas tran vdout1_19ck33 FIND v(dout1_19) AT=170.025n

* CHECK dout1_20 Vdout1_20ck33 = 0.9 time = 170
.meas tran vdout1_20ck33 FIND v(dout1_20) AT=170.025n

* CHECK dout1_21 Vdout1_21ck33 = 0 time = 170
.meas tran vdout1_21ck33 FIND v(dout1_21) AT=170.025n

* CHECK dout1_22 Vdout1_22ck33 = 0.9 time = 170
.meas tran vdout1_22ck33 FIND v(dout1_22) AT=170.025n

* CHECK dout1_23 Vdout1_23ck33 = 0.9 time = 170
.meas tran vdout1_23ck33 FIND v(dout1_23) AT=170.025n

* CHECK dout1_24 Vdout1_24ck33 = 0.9 time = 170
.meas tran vdout1_24ck33 FIND v(dout1_24) AT=170.025n

* CHECK dout1_25 Vdout1_25ck33 = 0.9 time = 170
.meas tran vdout1_25ck33 FIND v(dout1_25) AT=170.025n

* CHECK dout1_26 Vdout1_26ck33 = 0 time = 170
.meas tran vdout1_26ck33 FIND v(dout1_26) AT=170.025n

* CHECK dout1_27 Vdout1_27ck33 = 0 time = 170
.meas tran vdout1_27ck33 FIND v(dout1_27) AT=170.025n

* CHECK dout1_28 Vdout1_28ck33 = 0 time = 170
.meas tran vdout1_28ck33 FIND v(dout1_28) AT=170.025n

* CHECK dout1_29 Vdout1_29ck33 = 0 time = 170
.meas tran vdout1_29ck33 FIND v(dout1_29) AT=170.025n

* CHECK dout1_30 Vdout1_30ck33 = 0.9 time = 170
.meas tran vdout1_30ck33 FIND v(dout1_30) AT=170.025n

* CHECK dout1_31 Vdout1_31ck33 = 0 time = 170
.meas tran vdout1_31ck33 FIND v(dout1_31) AT=170.025n

* CHECK dout1_32 Vdout1_32ck33 = 0 time = 170
.meas tran vdout1_32ck33 FIND v(dout1_32) AT=170.025n

* CHECK dout1_33 Vdout1_33ck33 = 0.9 time = 170
.meas tran vdout1_33ck33 FIND v(dout1_33) AT=170.025n

* CHECK dout1_34 Vdout1_34ck33 = 0.9 time = 170
.meas tran vdout1_34ck33 FIND v(dout1_34) AT=170.025n

* CHECK dout1_35 Vdout1_35ck33 = 0 time = 170
.meas tran vdout1_35ck33 FIND v(dout1_35) AT=170.025n

* CHECK dout1_36 Vdout1_36ck33 = 0.9 time = 170
.meas tran vdout1_36ck33 FIND v(dout1_36) AT=170.025n

* CHECK dout1_37 Vdout1_37ck33 = 0 time = 170
.meas tran vdout1_37ck33 FIND v(dout1_37) AT=170.025n

* CHECK dout1_38 Vdout1_38ck33 = 0.9 time = 170
.meas tran vdout1_38ck33 FIND v(dout1_38) AT=170.025n

* CHECK dout1_39 Vdout1_39ck33 = 0 time = 170
.meas tran vdout1_39ck33 FIND v(dout1_39) AT=170.025n

* CHECK dout1_40 Vdout1_40ck33 = 0.9 time = 170
.meas tran vdout1_40ck33 FIND v(dout1_40) AT=170.025n

* CHECK dout1_41 Vdout1_41ck33 = 0 time = 170
.meas tran vdout1_41ck33 FIND v(dout1_41) AT=170.025n

* CHECK dout1_42 Vdout1_42ck33 = 0 time = 170
.meas tran vdout1_42ck33 FIND v(dout1_42) AT=170.025n

* CHECK dout1_43 Vdout1_43ck33 = 0 time = 170
.meas tran vdout1_43ck33 FIND v(dout1_43) AT=170.025n

* CHECK dout1_44 Vdout1_44ck33 = 0 time = 170
.meas tran vdout1_44ck33 FIND v(dout1_44) AT=170.025n

* CHECK dout1_45 Vdout1_45ck33 = 0.9 time = 170
.meas tran vdout1_45ck33 FIND v(dout1_45) AT=170.025n

* CHECK dout1_46 Vdout1_46ck33 = 0.9 time = 170
.meas tran vdout1_46ck33 FIND v(dout1_46) AT=170.025n

* CHECK dout1_47 Vdout1_47ck33 = 0 time = 170
.meas tran vdout1_47ck33 FIND v(dout1_47) AT=170.025n

* CHECK dout1_48 Vdout1_48ck33 = 0.9 time = 170
.meas tran vdout1_48ck33 FIND v(dout1_48) AT=170.025n

* CHECK dout1_49 Vdout1_49ck33 = 0.9 time = 170
.meas tran vdout1_49ck33 FIND v(dout1_49) AT=170.025n

* CHECK dout1_50 Vdout1_50ck33 = 0.9 time = 170
.meas tran vdout1_50ck33 FIND v(dout1_50) AT=170.025n

* CHECK dout1_51 Vdout1_51ck33 = 0.9 time = 170
.meas tran vdout1_51ck33 FIND v(dout1_51) AT=170.025n

* CHECK dout1_52 Vdout1_52ck33 = 0 time = 170
.meas tran vdout1_52ck33 FIND v(dout1_52) AT=170.025n

* CHECK dout1_53 Vdout1_53ck33 = 0.9 time = 170
.meas tran vdout1_53ck33 FIND v(dout1_53) AT=170.025n

* CHECK dout1_54 Vdout1_54ck33 = 0.9 time = 170
.meas tran vdout1_54ck33 FIND v(dout1_54) AT=170.025n

* CHECK dout1_55 Vdout1_55ck33 = 0.9 time = 170
.meas tran vdout1_55ck33 FIND v(dout1_55) AT=170.025n

* CHECK dout1_56 Vdout1_56ck33 = 0.9 time = 170
.meas tran vdout1_56ck33 FIND v(dout1_56) AT=170.025n

* CHECK dout1_57 Vdout1_57ck33 = 0 time = 170
.meas tran vdout1_57ck33 FIND v(dout1_57) AT=170.025n

* CHECK dout1_58 Vdout1_58ck33 = 0.9 time = 170
.meas tran vdout1_58ck33 FIND v(dout1_58) AT=170.025n

* CHECK dout1_59 Vdout1_59ck33 = 0.9 time = 170
.meas tran vdout1_59ck33 FIND v(dout1_59) AT=170.025n

* CHECK dout1_60 Vdout1_60ck33 = 0.9 time = 170
.meas tran vdout1_60ck33 FIND v(dout1_60) AT=170.025n

* CHECK dout1_61 Vdout1_61ck33 = 0 time = 170
.meas tran vdout1_61ck33 FIND v(dout1_61) AT=170.025n

* CHECK dout1_62 Vdout1_62ck33 = 0 time = 170
.meas tran vdout1_62ck33 FIND v(dout1_62) AT=170.025n

* CHECK dout1_63 Vdout1_63ck33 = 0.9 time = 170
.meas tran vdout1_63ck33 FIND v(dout1_63) AT=170.025n

* CHECK dout1_64 Vdout1_64ck33 = 0.9 time = 170
.meas tran vdout1_64ck33 FIND v(dout1_64) AT=170.025n

* CHECK dout1_65 Vdout1_65ck33 = 0.9 time = 170
.meas tran vdout1_65ck33 FIND v(dout1_65) AT=170.025n

* CHECK dout1_66 Vdout1_66ck33 = 0 time = 170
.meas tran vdout1_66ck33 FIND v(dout1_66) AT=170.025n

* CHECK dout1_67 Vdout1_67ck33 = 0 time = 170
.meas tran vdout1_67ck33 FIND v(dout1_67) AT=170.025n

* CHECK dout1_68 Vdout1_68ck33 = 0 time = 170
.meas tran vdout1_68ck33 FIND v(dout1_68) AT=170.025n

* CHECK dout1_69 Vdout1_69ck33 = 0 time = 170
.meas tran vdout1_69ck33 FIND v(dout1_69) AT=170.025n

* CHECK dout1_70 Vdout1_70ck33 = 0.9 time = 170
.meas tran vdout1_70ck33 FIND v(dout1_70) AT=170.025n

* CHECK dout1_71 Vdout1_71ck33 = 0 time = 170
.meas tran vdout1_71ck33 FIND v(dout1_71) AT=170.025n

* CHECK dout1_72 Vdout1_72ck33 = 0.9 time = 170
.meas tran vdout1_72ck33 FIND v(dout1_72) AT=170.025n

* CHECK dout1_73 Vdout1_73ck33 = 0.9 time = 170
.meas tran vdout1_73ck33 FIND v(dout1_73) AT=170.025n

* CHECK dout1_74 Vdout1_74ck33 = 0.9 time = 170
.meas tran vdout1_74ck33 FIND v(dout1_74) AT=170.025n

* CHECK dout1_75 Vdout1_75ck33 = 0.9 time = 170
.meas tran vdout1_75ck33 FIND v(dout1_75) AT=170.025n

* CHECK dout1_76 Vdout1_76ck33 = 0.9 time = 170
.meas tran vdout1_76ck33 FIND v(dout1_76) AT=170.025n

* CHECK dout1_77 Vdout1_77ck33 = 0 time = 170
.meas tran vdout1_77ck33 FIND v(dout1_77) AT=170.025n

* CHECK dout1_78 Vdout1_78ck33 = 0.9 time = 170
.meas tran vdout1_78ck33 FIND v(dout1_78) AT=170.025n

* CHECK dout1_79 Vdout1_79ck33 = 0 time = 170
.meas tran vdout1_79ck33 FIND v(dout1_79) AT=170.025n

* CHECK dout1_80 Vdout1_80ck33 = 0 time = 170
.meas tran vdout1_80ck33 FIND v(dout1_80) AT=170.025n

* CHECK dout1_81 Vdout1_81ck33 = 0 time = 170
.meas tran vdout1_81ck33 FIND v(dout1_81) AT=170.025n

* CHECK dout1_82 Vdout1_82ck33 = 0.9 time = 170
.meas tran vdout1_82ck33 FIND v(dout1_82) AT=170.025n

* CHECK dout1_83 Vdout1_83ck33 = 0.9 time = 170
.meas tran vdout1_83ck33 FIND v(dout1_83) AT=170.025n

* CHECK dout1_84 Vdout1_84ck33 = 0.9 time = 170
.meas tran vdout1_84ck33 FIND v(dout1_84) AT=170.025n

* CHECK dout1_85 Vdout1_85ck33 = 0 time = 170
.meas tran vdout1_85ck33 FIND v(dout1_85) AT=170.025n

* CHECK dout1_86 Vdout1_86ck33 = 0 time = 170
.meas tran vdout1_86ck33 FIND v(dout1_86) AT=170.025n

* CHECK dout1_87 Vdout1_87ck33 = 0.9 time = 170
.meas tran vdout1_87ck33 FIND v(dout1_87) AT=170.025n

* CHECK dout1_88 Vdout1_88ck33 = 0 time = 170
.meas tran vdout1_88ck33 FIND v(dout1_88) AT=170.025n

* CHECK dout1_89 Vdout1_89ck33 = 0 time = 170
.meas tran vdout1_89ck33 FIND v(dout1_89) AT=170.025n

* CHECK dout1_90 Vdout1_90ck33 = 0.9 time = 170
.meas tran vdout1_90ck33 FIND v(dout1_90) AT=170.025n

* CHECK dout1_91 Vdout1_91ck33 = 0.9 time = 170
.meas tran vdout1_91ck33 FIND v(dout1_91) AT=170.025n

* CHECK dout1_92 Vdout1_92ck33 = 0.9 time = 170
.meas tran vdout1_92ck33 FIND v(dout1_92) AT=170.025n

* CHECK dout1_93 Vdout1_93ck33 = 0 time = 170
.meas tran vdout1_93ck33 FIND v(dout1_93) AT=170.025n

* CHECK dout1_94 Vdout1_94ck33 = 0 time = 170
.meas tran vdout1_94ck33 FIND v(dout1_94) AT=170.025n

* CHECK dout1_95 Vdout1_95ck33 = 0 time = 170
.meas tran vdout1_95ck33 FIND v(dout1_95) AT=170.025n

* CHECK dout1_96 Vdout1_96ck33 = 0.9 time = 170
.meas tran vdout1_96ck33 FIND v(dout1_96) AT=170.025n

* CHECK dout1_97 Vdout1_97ck33 = 0 time = 170
.meas tran vdout1_97ck33 FIND v(dout1_97) AT=170.025n

* CHECK dout1_98 Vdout1_98ck33 = 0 time = 170
.meas tran vdout1_98ck33 FIND v(dout1_98) AT=170.025n

* CHECK dout1_99 Vdout1_99ck33 = 0 time = 170
.meas tran vdout1_99ck33 FIND v(dout1_99) AT=170.025n

* CHECK dout1_100 Vdout1_100ck33 = 0.9 time = 170
.meas tran vdout1_100ck33 FIND v(dout1_100) AT=170.025n

* CHECK dout1_101 Vdout1_101ck33 = 0 time = 170
.meas tran vdout1_101ck33 FIND v(dout1_101) AT=170.025n

* CHECK dout1_102 Vdout1_102ck33 = 0.9 time = 170
.meas tran vdout1_102ck33 FIND v(dout1_102) AT=170.025n

* CHECK dout1_103 Vdout1_103ck33 = 0 time = 170
.meas tran vdout1_103ck33 FIND v(dout1_103) AT=170.025n

* CHECK dout1_104 Vdout1_104ck33 = 0.9 time = 170
.meas tran vdout1_104ck33 FIND v(dout1_104) AT=170.025n

* CHECK dout1_105 Vdout1_105ck33 = 0.9 time = 170
.meas tran vdout1_105ck33 FIND v(dout1_105) AT=170.025n

* CHECK dout1_106 Vdout1_106ck33 = 0.9 time = 170
.meas tran vdout1_106ck33 FIND v(dout1_106) AT=170.025n

* CHECK dout1_107 Vdout1_107ck33 = 0.9 time = 170
.meas tran vdout1_107ck33 FIND v(dout1_107) AT=170.025n

* CHECK dout1_108 Vdout1_108ck33 = 0.9 time = 170
.meas tran vdout1_108ck33 FIND v(dout1_108) AT=170.025n

* CHECK dout1_109 Vdout1_109ck33 = 0.9 time = 170
.meas tran vdout1_109ck33 FIND v(dout1_109) AT=170.025n

* CHECK dout1_110 Vdout1_110ck33 = 0 time = 170
.meas tran vdout1_110ck33 FIND v(dout1_110) AT=170.025n

* CHECK dout1_111 Vdout1_111ck33 = 0 time = 170
.meas tran vdout1_111ck33 FIND v(dout1_111) AT=170.025n

* CHECK dout1_112 Vdout1_112ck33 = 0 time = 170
.meas tran vdout1_112ck33 FIND v(dout1_112) AT=170.025n

* CHECK dout1_113 Vdout1_113ck33 = 0.9 time = 170
.meas tran vdout1_113ck33 FIND v(dout1_113) AT=170.025n

* CHECK dout1_114 Vdout1_114ck33 = 0 time = 170
.meas tran vdout1_114ck33 FIND v(dout1_114) AT=170.025n

* CHECK dout1_115 Vdout1_115ck33 = 0.9 time = 170
.meas tran vdout1_115ck33 FIND v(dout1_115) AT=170.025n

* CHECK dout1_116 Vdout1_116ck33 = 0.9 time = 170
.meas tran vdout1_116ck33 FIND v(dout1_116) AT=170.025n

* CHECK dout1_117 Vdout1_117ck33 = 0.9 time = 170
.meas tran vdout1_117ck33 FIND v(dout1_117) AT=170.025n

* CHECK dout1_118 Vdout1_118ck33 = 0 time = 170
.meas tran vdout1_118ck33 FIND v(dout1_118) AT=170.025n

* CHECK dout1_119 Vdout1_119ck33 = 0 time = 170
.meas tran vdout1_119ck33 FIND v(dout1_119) AT=170.025n

* CHECK dout1_0 Vdout1_0ck35 = 0 time = 180
.meas tran vdout1_0ck35 FIND v(dout1_0) AT=180.025n

* CHECK dout1_1 Vdout1_1ck35 = 0.9 time = 180
.meas tran vdout1_1ck35 FIND v(dout1_1) AT=180.025n

* CHECK dout1_2 Vdout1_2ck35 = 0.9 time = 180
.meas tran vdout1_2ck35 FIND v(dout1_2) AT=180.025n

* CHECK dout1_3 Vdout1_3ck35 = 0 time = 180
.meas tran vdout1_3ck35 FIND v(dout1_3) AT=180.025n

* CHECK dout1_4 Vdout1_4ck35 = 0 time = 180
.meas tran vdout1_4ck35 FIND v(dout1_4) AT=180.025n

* CHECK dout1_5 Vdout1_5ck35 = 0.9 time = 180
.meas tran vdout1_5ck35 FIND v(dout1_5) AT=180.025n

* CHECK dout1_6 Vdout1_6ck35 = 0.9 time = 180
.meas tran vdout1_6ck35 FIND v(dout1_6) AT=180.025n

* CHECK dout1_7 Vdout1_7ck35 = 0 time = 180
.meas tran vdout1_7ck35 FIND v(dout1_7) AT=180.025n

* CHECK dout1_8 Vdout1_8ck35 = 0.9 time = 180
.meas tran vdout1_8ck35 FIND v(dout1_8) AT=180.025n

* CHECK dout1_9 Vdout1_9ck35 = 0 time = 180
.meas tran vdout1_9ck35 FIND v(dout1_9) AT=180.025n

* CHECK dout1_10 Vdout1_10ck35 = 0 time = 180
.meas tran vdout1_10ck35 FIND v(dout1_10) AT=180.025n

* CHECK dout1_11 Vdout1_11ck35 = 0.9 time = 180
.meas tran vdout1_11ck35 FIND v(dout1_11) AT=180.025n

* CHECK dout1_12 Vdout1_12ck35 = 0 time = 180
.meas tran vdout1_12ck35 FIND v(dout1_12) AT=180.025n

* CHECK dout1_13 Vdout1_13ck35 = 0 time = 180
.meas tran vdout1_13ck35 FIND v(dout1_13) AT=180.025n

* CHECK dout1_14 Vdout1_14ck35 = 0.9 time = 180
.meas tran vdout1_14ck35 FIND v(dout1_14) AT=180.025n

* CHECK dout1_15 Vdout1_15ck35 = 0.9 time = 180
.meas tran vdout1_15ck35 FIND v(dout1_15) AT=180.025n

* CHECK dout1_16 Vdout1_16ck35 = 0.9 time = 180
.meas tran vdout1_16ck35 FIND v(dout1_16) AT=180.025n

* CHECK dout1_17 Vdout1_17ck35 = 0 time = 180
.meas tran vdout1_17ck35 FIND v(dout1_17) AT=180.025n

* CHECK dout1_18 Vdout1_18ck35 = 0 time = 180
.meas tran vdout1_18ck35 FIND v(dout1_18) AT=180.025n

* CHECK dout1_19 Vdout1_19ck35 = 0.9 time = 180
.meas tran vdout1_19ck35 FIND v(dout1_19) AT=180.025n

* CHECK dout1_20 Vdout1_20ck35 = 0.9 time = 180
.meas tran vdout1_20ck35 FIND v(dout1_20) AT=180.025n

* CHECK dout1_21 Vdout1_21ck35 = 0 time = 180
.meas tran vdout1_21ck35 FIND v(dout1_21) AT=180.025n

* CHECK dout1_22 Vdout1_22ck35 = 0 time = 180
.meas tran vdout1_22ck35 FIND v(dout1_22) AT=180.025n

* CHECK dout1_23 Vdout1_23ck35 = 0.9 time = 180
.meas tran vdout1_23ck35 FIND v(dout1_23) AT=180.025n

* CHECK dout1_24 Vdout1_24ck35 = 0 time = 180
.meas tran vdout1_24ck35 FIND v(dout1_24) AT=180.025n

* CHECK dout1_25 Vdout1_25ck35 = 0.9 time = 180
.meas tran vdout1_25ck35 FIND v(dout1_25) AT=180.025n

* CHECK dout1_26 Vdout1_26ck35 = 0 time = 180
.meas tran vdout1_26ck35 FIND v(dout1_26) AT=180.025n

* CHECK dout1_27 Vdout1_27ck35 = 0 time = 180
.meas tran vdout1_27ck35 FIND v(dout1_27) AT=180.025n

* CHECK dout1_28 Vdout1_28ck35 = 0.9 time = 180
.meas tran vdout1_28ck35 FIND v(dout1_28) AT=180.025n

* CHECK dout1_29 Vdout1_29ck35 = 0 time = 180
.meas tran vdout1_29ck35 FIND v(dout1_29) AT=180.025n

* CHECK dout1_30 Vdout1_30ck35 = 0 time = 180
.meas tran vdout1_30ck35 FIND v(dout1_30) AT=180.025n

* CHECK dout1_31 Vdout1_31ck35 = 0 time = 180
.meas tran vdout1_31ck35 FIND v(dout1_31) AT=180.025n

* CHECK dout1_32 Vdout1_32ck35 = 0.9 time = 180
.meas tran vdout1_32ck35 FIND v(dout1_32) AT=180.025n

* CHECK dout1_33 Vdout1_33ck35 = 0 time = 180
.meas tran vdout1_33ck35 FIND v(dout1_33) AT=180.025n

* CHECK dout1_34 Vdout1_34ck35 = 0.9 time = 180
.meas tran vdout1_34ck35 FIND v(dout1_34) AT=180.025n

* CHECK dout1_35 Vdout1_35ck35 = 0 time = 180
.meas tran vdout1_35ck35 FIND v(dout1_35) AT=180.025n

* CHECK dout1_36 Vdout1_36ck35 = 0.9 time = 180
.meas tran vdout1_36ck35 FIND v(dout1_36) AT=180.025n

* CHECK dout1_37 Vdout1_37ck35 = 0 time = 180
.meas tran vdout1_37ck35 FIND v(dout1_37) AT=180.025n

* CHECK dout1_38 Vdout1_38ck35 = 0 time = 180
.meas tran vdout1_38ck35 FIND v(dout1_38) AT=180.025n

* CHECK dout1_39 Vdout1_39ck35 = 0 time = 180
.meas tran vdout1_39ck35 FIND v(dout1_39) AT=180.025n

* CHECK dout1_40 Vdout1_40ck35 = 0 time = 180
.meas tran vdout1_40ck35 FIND v(dout1_40) AT=180.025n

* CHECK dout1_41 Vdout1_41ck35 = 0.9 time = 180
.meas tran vdout1_41ck35 FIND v(dout1_41) AT=180.025n

* CHECK dout1_42 Vdout1_42ck35 = 0 time = 180
.meas tran vdout1_42ck35 FIND v(dout1_42) AT=180.025n

* CHECK dout1_43 Vdout1_43ck35 = 0 time = 180
.meas tran vdout1_43ck35 FIND v(dout1_43) AT=180.025n

* CHECK dout1_44 Vdout1_44ck35 = 0 time = 180
.meas tran vdout1_44ck35 FIND v(dout1_44) AT=180.025n

* CHECK dout1_45 Vdout1_45ck35 = 0.9 time = 180
.meas tran vdout1_45ck35 FIND v(dout1_45) AT=180.025n

* CHECK dout1_46 Vdout1_46ck35 = 0 time = 180
.meas tran vdout1_46ck35 FIND v(dout1_46) AT=180.025n

* CHECK dout1_47 Vdout1_47ck35 = 0.9 time = 180
.meas tran vdout1_47ck35 FIND v(dout1_47) AT=180.025n

* CHECK dout1_48 Vdout1_48ck35 = 0 time = 180
.meas tran vdout1_48ck35 FIND v(dout1_48) AT=180.025n

* CHECK dout1_49 Vdout1_49ck35 = 0 time = 180
.meas tran vdout1_49ck35 FIND v(dout1_49) AT=180.025n

* CHECK dout1_50 Vdout1_50ck35 = 0.9 time = 180
.meas tran vdout1_50ck35 FIND v(dout1_50) AT=180.025n

* CHECK dout1_51 Vdout1_51ck35 = 0 time = 180
.meas tran vdout1_51ck35 FIND v(dout1_51) AT=180.025n

* CHECK dout1_52 Vdout1_52ck35 = 0.9 time = 180
.meas tran vdout1_52ck35 FIND v(dout1_52) AT=180.025n

* CHECK dout1_53 Vdout1_53ck35 = 0.9 time = 180
.meas tran vdout1_53ck35 FIND v(dout1_53) AT=180.025n

* CHECK dout1_54 Vdout1_54ck35 = 0 time = 180
.meas tran vdout1_54ck35 FIND v(dout1_54) AT=180.025n

* CHECK dout1_55 Vdout1_55ck35 = 0.9 time = 180
.meas tran vdout1_55ck35 FIND v(dout1_55) AT=180.025n

* CHECK dout1_56 Vdout1_56ck35 = 0.9 time = 180
.meas tran vdout1_56ck35 FIND v(dout1_56) AT=180.025n

* CHECK dout1_57 Vdout1_57ck35 = 0 time = 180
.meas tran vdout1_57ck35 FIND v(dout1_57) AT=180.025n

* CHECK dout1_58 Vdout1_58ck35 = 0 time = 180
.meas tran vdout1_58ck35 FIND v(dout1_58) AT=180.025n

* CHECK dout1_59 Vdout1_59ck35 = 0 time = 180
.meas tran vdout1_59ck35 FIND v(dout1_59) AT=180.025n

* CHECK dout1_60 Vdout1_60ck35 = 0 time = 180
.meas tran vdout1_60ck35 FIND v(dout1_60) AT=180.025n

* CHECK dout1_61 Vdout1_61ck35 = 0.9 time = 180
.meas tran vdout1_61ck35 FIND v(dout1_61) AT=180.025n

* CHECK dout1_62 Vdout1_62ck35 = 0 time = 180
.meas tran vdout1_62ck35 FIND v(dout1_62) AT=180.025n

* CHECK dout1_63 Vdout1_63ck35 = 0 time = 180
.meas tran vdout1_63ck35 FIND v(dout1_63) AT=180.025n

* CHECK dout1_64 Vdout1_64ck35 = 0 time = 180
.meas tran vdout1_64ck35 FIND v(dout1_64) AT=180.025n

* CHECK dout1_65 Vdout1_65ck35 = 0.9 time = 180
.meas tran vdout1_65ck35 FIND v(dout1_65) AT=180.025n

* CHECK dout1_66 Vdout1_66ck35 = 0.9 time = 180
.meas tran vdout1_66ck35 FIND v(dout1_66) AT=180.025n

* CHECK dout1_67 Vdout1_67ck35 = 0 time = 180
.meas tran vdout1_67ck35 FIND v(dout1_67) AT=180.025n

* CHECK dout1_68 Vdout1_68ck35 = 0.9 time = 180
.meas tran vdout1_68ck35 FIND v(dout1_68) AT=180.025n

* CHECK dout1_69 Vdout1_69ck35 = 0.9 time = 180
.meas tran vdout1_69ck35 FIND v(dout1_69) AT=180.025n

* CHECK dout1_70 Vdout1_70ck35 = 0 time = 180
.meas tran vdout1_70ck35 FIND v(dout1_70) AT=180.025n

* CHECK dout1_71 Vdout1_71ck35 = 0 time = 180
.meas tran vdout1_71ck35 FIND v(dout1_71) AT=180.025n

* CHECK dout1_72 Vdout1_72ck35 = 0 time = 180
.meas tran vdout1_72ck35 FIND v(dout1_72) AT=180.025n

* CHECK dout1_73 Vdout1_73ck35 = 0.9 time = 180
.meas tran vdout1_73ck35 FIND v(dout1_73) AT=180.025n

* CHECK dout1_74 Vdout1_74ck35 = 0.9 time = 180
.meas tran vdout1_74ck35 FIND v(dout1_74) AT=180.025n

* CHECK dout1_75 Vdout1_75ck35 = 0 time = 180
.meas tran vdout1_75ck35 FIND v(dout1_75) AT=180.025n

* CHECK dout1_76 Vdout1_76ck35 = 0.9 time = 180
.meas tran vdout1_76ck35 FIND v(dout1_76) AT=180.025n

* CHECK dout1_77 Vdout1_77ck35 = 0 time = 180
.meas tran vdout1_77ck35 FIND v(dout1_77) AT=180.025n

* CHECK dout1_78 Vdout1_78ck35 = 0 time = 180
.meas tran vdout1_78ck35 FIND v(dout1_78) AT=180.025n

* CHECK dout1_79 Vdout1_79ck35 = 0.9 time = 180
.meas tran vdout1_79ck35 FIND v(dout1_79) AT=180.025n

* CHECK dout1_80 Vdout1_80ck35 = 0.9 time = 180
.meas tran vdout1_80ck35 FIND v(dout1_80) AT=180.025n

* CHECK dout1_81 Vdout1_81ck35 = 0 time = 180
.meas tran vdout1_81ck35 FIND v(dout1_81) AT=180.025n

* CHECK dout1_82 Vdout1_82ck35 = 0.9 time = 180
.meas tran vdout1_82ck35 FIND v(dout1_82) AT=180.025n

* CHECK dout1_83 Vdout1_83ck35 = 0.9 time = 180
.meas tran vdout1_83ck35 FIND v(dout1_83) AT=180.025n

* CHECK dout1_84 Vdout1_84ck35 = 0.9 time = 180
.meas tran vdout1_84ck35 FIND v(dout1_84) AT=180.025n

* CHECK dout1_85 Vdout1_85ck35 = 0.9 time = 180
.meas tran vdout1_85ck35 FIND v(dout1_85) AT=180.025n

* CHECK dout1_86 Vdout1_86ck35 = 0 time = 180
.meas tran vdout1_86ck35 FIND v(dout1_86) AT=180.025n

* CHECK dout1_87 Vdout1_87ck35 = 0 time = 180
.meas tran vdout1_87ck35 FIND v(dout1_87) AT=180.025n

* CHECK dout1_88 Vdout1_88ck35 = 0.9 time = 180
.meas tran vdout1_88ck35 FIND v(dout1_88) AT=180.025n

* CHECK dout1_89 Vdout1_89ck35 = 0 time = 180
.meas tran vdout1_89ck35 FIND v(dout1_89) AT=180.025n

* CHECK dout1_90 Vdout1_90ck35 = 0 time = 180
.meas tran vdout1_90ck35 FIND v(dout1_90) AT=180.025n

* CHECK dout1_91 Vdout1_91ck35 = 0 time = 180
.meas tran vdout1_91ck35 FIND v(dout1_91) AT=180.025n

* CHECK dout1_92 Vdout1_92ck35 = 0 time = 180
.meas tran vdout1_92ck35 FIND v(dout1_92) AT=180.025n

* CHECK dout1_93 Vdout1_93ck35 = 0 time = 180
.meas tran vdout1_93ck35 FIND v(dout1_93) AT=180.025n

* CHECK dout1_94 Vdout1_94ck35 = 0 time = 180
.meas tran vdout1_94ck35 FIND v(dout1_94) AT=180.025n

* CHECK dout1_95 Vdout1_95ck35 = 0 time = 180
.meas tran vdout1_95ck35 FIND v(dout1_95) AT=180.025n

* CHECK dout1_96 Vdout1_96ck35 = 0 time = 180
.meas tran vdout1_96ck35 FIND v(dout1_96) AT=180.025n

* CHECK dout1_97 Vdout1_97ck35 = 0.9 time = 180
.meas tran vdout1_97ck35 FIND v(dout1_97) AT=180.025n

* CHECK dout1_98 Vdout1_98ck35 = 0.9 time = 180
.meas tran vdout1_98ck35 FIND v(dout1_98) AT=180.025n

* CHECK dout1_99 Vdout1_99ck35 = 0.9 time = 180
.meas tran vdout1_99ck35 FIND v(dout1_99) AT=180.025n

* CHECK dout1_100 Vdout1_100ck35 = 0 time = 180
.meas tran vdout1_100ck35 FIND v(dout1_100) AT=180.025n

* CHECK dout1_101 Vdout1_101ck35 = 0 time = 180
.meas tran vdout1_101ck35 FIND v(dout1_101) AT=180.025n

* CHECK dout1_102 Vdout1_102ck35 = 0 time = 180
.meas tran vdout1_102ck35 FIND v(dout1_102) AT=180.025n

* CHECK dout1_103 Vdout1_103ck35 = 0 time = 180
.meas tran vdout1_103ck35 FIND v(dout1_103) AT=180.025n

* CHECK dout1_104 Vdout1_104ck35 = 0 time = 180
.meas tran vdout1_104ck35 FIND v(dout1_104) AT=180.025n

* CHECK dout1_105 Vdout1_105ck35 = 0 time = 180
.meas tran vdout1_105ck35 FIND v(dout1_105) AT=180.025n

* CHECK dout1_106 Vdout1_106ck35 = 0.9 time = 180
.meas tran vdout1_106ck35 FIND v(dout1_106) AT=180.025n

* CHECK dout1_107 Vdout1_107ck35 = 0.9 time = 180
.meas tran vdout1_107ck35 FIND v(dout1_107) AT=180.025n

* CHECK dout1_108 Vdout1_108ck35 = 0 time = 180
.meas tran vdout1_108ck35 FIND v(dout1_108) AT=180.025n

* CHECK dout1_109 Vdout1_109ck35 = 0.9 time = 180
.meas tran vdout1_109ck35 FIND v(dout1_109) AT=180.025n

* CHECK dout1_110 Vdout1_110ck35 = 0.9 time = 180
.meas tran vdout1_110ck35 FIND v(dout1_110) AT=180.025n

* CHECK dout1_111 Vdout1_111ck35 = 0 time = 180
.meas tran vdout1_111ck35 FIND v(dout1_111) AT=180.025n

* CHECK dout1_112 Vdout1_112ck35 = 0 time = 180
.meas tran vdout1_112ck35 FIND v(dout1_112) AT=180.025n

* CHECK dout1_113 Vdout1_113ck35 = 0.9 time = 180
.meas tran vdout1_113ck35 FIND v(dout1_113) AT=180.025n

* CHECK dout1_114 Vdout1_114ck35 = 0 time = 180
.meas tran vdout1_114ck35 FIND v(dout1_114) AT=180.025n

* CHECK dout1_115 Vdout1_115ck35 = 0 time = 180
.meas tran vdout1_115ck35 FIND v(dout1_115) AT=180.025n

* CHECK dout1_116 Vdout1_116ck35 = 0 time = 180
.meas tran vdout1_116ck35 FIND v(dout1_116) AT=180.025n

* CHECK dout1_117 Vdout1_117ck35 = 0 time = 180
.meas tran vdout1_117ck35 FIND v(dout1_117) AT=180.025n

* CHECK dout1_118 Vdout1_118ck35 = 0.9 time = 180
.meas tran vdout1_118ck35 FIND v(dout1_118) AT=180.025n

* CHECK dout1_119 Vdout1_119ck35 = 0 time = 180
.meas tran vdout1_119ck35 FIND v(dout1_119) AT=180.025n

* CHECK dout1_0 Vdout1_0ck36 = 0 time = 185
.meas tran vdout1_0ck36 FIND v(dout1_0) AT=185.025n

* CHECK dout1_1 Vdout1_1ck36 = 0 time = 185
.meas tran vdout1_1ck36 FIND v(dout1_1) AT=185.025n

* CHECK dout1_2 Vdout1_2ck36 = 0 time = 185
.meas tran vdout1_2ck36 FIND v(dout1_2) AT=185.025n

* CHECK dout1_3 Vdout1_3ck36 = 0.9 time = 185
.meas tran vdout1_3ck36 FIND v(dout1_3) AT=185.025n

* CHECK dout1_4 Vdout1_4ck36 = 0.9 time = 185
.meas tran vdout1_4ck36 FIND v(dout1_4) AT=185.025n

* CHECK dout1_5 Vdout1_5ck36 = 0 time = 185
.meas tran vdout1_5ck36 FIND v(dout1_5) AT=185.025n

* CHECK dout1_6 Vdout1_6ck36 = 0 time = 185
.meas tran vdout1_6ck36 FIND v(dout1_6) AT=185.025n

* CHECK dout1_7 Vdout1_7ck36 = 0.9 time = 185
.meas tran vdout1_7ck36 FIND v(dout1_7) AT=185.025n

* CHECK dout1_8 Vdout1_8ck36 = 0 time = 185
.meas tran vdout1_8ck36 FIND v(dout1_8) AT=185.025n

* CHECK dout1_9 Vdout1_9ck36 = 0 time = 185
.meas tran vdout1_9ck36 FIND v(dout1_9) AT=185.025n

* CHECK dout1_10 Vdout1_10ck36 = 0 time = 185
.meas tran vdout1_10ck36 FIND v(dout1_10) AT=185.025n

* CHECK dout1_11 Vdout1_11ck36 = 0.9 time = 185
.meas tran vdout1_11ck36 FIND v(dout1_11) AT=185.025n

* CHECK dout1_12 Vdout1_12ck36 = 0 time = 185
.meas tran vdout1_12ck36 FIND v(dout1_12) AT=185.025n

* CHECK dout1_13 Vdout1_13ck36 = 0 time = 185
.meas tran vdout1_13ck36 FIND v(dout1_13) AT=185.025n

* CHECK dout1_14 Vdout1_14ck36 = 0.9 time = 185
.meas tran vdout1_14ck36 FIND v(dout1_14) AT=185.025n

* CHECK dout1_15 Vdout1_15ck36 = 0.9 time = 185
.meas tran vdout1_15ck36 FIND v(dout1_15) AT=185.025n

* CHECK dout1_16 Vdout1_16ck36 = 0.9 time = 185
.meas tran vdout1_16ck36 FIND v(dout1_16) AT=185.025n

* CHECK dout1_17 Vdout1_17ck36 = 0.9 time = 185
.meas tran vdout1_17ck36 FIND v(dout1_17) AT=185.025n

* CHECK dout1_18 Vdout1_18ck36 = 0 time = 185
.meas tran vdout1_18ck36 FIND v(dout1_18) AT=185.025n

* CHECK dout1_19 Vdout1_19ck36 = 0.9 time = 185
.meas tran vdout1_19ck36 FIND v(dout1_19) AT=185.025n

* CHECK dout1_20 Vdout1_20ck36 = 0.9 time = 185
.meas tran vdout1_20ck36 FIND v(dout1_20) AT=185.025n

* CHECK dout1_21 Vdout1_21ck36 = 0.9 time = 185
.meas tran vdout1_21ck36 FIND v(dout1_21) AT=185.025n

* CHECK dout1_22 Vdout1_22ck36 = 0.9 time = 185
.meas tran vdout1_22ck36 FIND v(dout1_22) AT=185.025n

* CHECK dout1_23 Vdout1_23ck36 = 0 time = 185
.meas tran vdout1_23ck36 FIND v(dout1_23) AT=185.025n

* CHECK dout1_24 Vdout1_24ck36 = 0.9 time = 185
.meas tran vdout1_24ck36 FIND v(dout1_24) AT=185.025n

* CHECK dout1_25 Vdout1_25ck36 = 0.9 time = 185
.meas tran vdout1_25ck36 FIND v(dout1_25) AT=185.025n

* CHECK dout1_26 Vdout1_26ck36 = 0 time = 185
.meas tran vdout1_26ck36 FIND v(dout1_26) AT=185.025n

* CHECK dout1_27 Vdout1_27ck36 = 0 time = 185
.meas tran vdout1_27ck36 FIND v(dout1_27) AT=185.025n

* CHECK dout1_28 Vdout1_28ck36 = 0.9 time = 185
.meas tran vdout1_28ck36 FIND v(dout1_28) AT=185.025n

* CHECK dout1_29 Vdout1_29ck36 = 0.9 time = 185
.meas tran vdout1_29ck36 FIND v(dout1_29) AT=185.025n

* CHECK dout1_30 Vdout1_30ck36 = 0.9 time = 185
.meas tran vdout1_30ck36 FIND v(dout1_30) AT=185.025n

* CHECK dout1_31 Vdout1_31ck36 = 0 time = 185
.meas tran vdout1_31ck36 FIND v(dout1_31) AT=185.025n

* CHECK dout1_32 Vdout1_32ck36 = 0.9 time = 185
.meas tran vdout1_32ck36 FIND v(dout1_32) AT=185.025n

* CHECK dout1_33 Vdout1_33ck36 = 0.9 time = 185
.meas tran vdout1_33ck36 FIND v(dout1_33) AT=185.025n

* CHECK dout1_34 Vdout1_34ck36 = 0 time = 185
.meas tran vdout1_34ck36 FIND v(dout1_34) AT=185.025n

* CHECK dout1_35 Vdout1_35ck36 = 0 time = 185
.meas tran vdout1_35ck36 FIND v(dout1_35) AT=185.025n

* CHECK dout1_36 Vdout1_36ck36 = 0 time = 185
.meas tran vdout1_36ck36 FIND v(dout1_36) AT=185.025n

* CHECK dout1_37 Vdout1_37ck36 = 0.9 time = 185
.meas tran vdout1_37ck36 FIND v(dout1_37) AT=185.025n

* CHECK dout1_38 Vdout1_38ck36 = 0 time = 185
.meas tran vdout1_38ck36 FIND v(dout1_38) AT=185.025n

* CHECK dout1_39 Vdout1_39ck36 = 0.9 time = 185
.meas tran vdout1_39ck36 FIND v(dout1_39) AT=185.025n

* CHECK dout1_40 Vdout1_40ck36 = 0 time = 185
.meas tran vdout1_40ck36 FIND v(dout1_40) AT=185.025n

* CHECK dout1_41 Vdout1_41ck36 = 0.9 time = 185
.meas tran vdout1_41ck36 FIND v(dout1_41) AT=185.025n

* CHECK dout1_42 Vdout1_42ck36 = 0.9 time = 185
.meas tran vdout1_42ck36 FIND v(dout1_42) AT=185.025n

* CHECK dout1_43 Vdout1_43ck36 = 0.9 time = 185
.meas tran vdout1_43ck36 FIND v(dout1_43) AT=185.025n

* CHECK dout1_44 Vdout1_44ck36 = 0 time = 185
.meas tran vdout1_44ck36 FIND v(dout1_44) AT=185.025n

* CHECK dout1_45 Vdout1_45ck36 = 0.9 time = 185
.meas tran vdout1_45ck36 FIND v(dout1_45) AT=185.025n

* CHECK dout1_46 Vdout1_46ck36 = 0 time = 185
.meas tran vdout1_46ck36 FIND v(dout1_46) AT=185.025n

* CHECK dout1_47 Vdout1_47ck36 = 0.9 time = 185
.meas tran vdout1_47ck36 FIND v(dout1_47) AT=185.025n

* CHECK dout1_48 Vdout1_48ck36 = 0 time = 185
.meas tran vdout1_48ck36 FIND v(dout1_48) AT=185.025n

* CHECK dout1_49 Vdout1_49ck36 = 0.9 time = 185
.meas tran vdout1_49ck36 FIND v(dout1_49) AT=185.025n

* CHECK dout1_50 Vdout1_50ck36 = 0.9 time = 185
.meas tran vdout1_50ck36 FIND v(dout1_50) AT=185.025n

* CHECK dout1_51 Vdout1_51ck36 = 0 time = 185
.meas tran vdout1_51ck36 FIND v(dout1_51) AT=185.025n

* CHECK dout1_52 Vdout1_52ck36 = 0.9 time = 185
.meas tran vdout1_52ck36 FIND v(dout1_52) AT=185.025n

* CHECK dout1_53 Vdout1_53ck36 = 0.9 time = 185
.meas tran vdout1_53ck36 FIND v(dout1_53) AT=185.025n

* CHECK dout1_54 Vdout1_54ck36 = 0.9 time = 185
.meas tran vdout1_54ck36 FIND v(dout1_54) AT=185.025n

* CHECK dout1_55 Vdout1_55ck36 = 0.9 time = 185
.meas tran vdout1_55ck36 FIND v(dout1_55) AT=185.025n

* CHECK dout1_56 Vdout1_56ck36 = 0.9 time = 185
.meas tran vdout1_56ck36 FIND v(dout1_56) AT=185.025n

* CHECK dout1_57 Vdout1_57ck36 = 0.9 time = 185
.meas tran vdout1_57ck36 FIND v(dout1_57) AT=185.025n

* CHECK dout1_58 Vdout1_58ck36 = 0.9 time = 185
.meas tran vdout1_58ck36 FIND v(dout1_58) AT=185.025n

* CHECK dout1_59 Vdout1_59ck36 = 0 time = 185
.meas tran vdout1_59ck36 FIND v(dout1_59) AT=185.025n

* CHECK dout1_60 Vdout1_60ck36 = 0 time = 185
.meas tran vdout1_60ck36 FIND v(dout1_60) AT=185.025n

* CHECK dout1_61 Vdout1_61ck36 = 0.9 time = 185
.meas tran vdout1_61ck36 FIND v(dout1_61) AT=185.025n

* CHECK dout1_62 Vdout1_62ck36 = 0.9 time = 185
.meas tran vdout1_62ck36 FIND v(dout1_62) AT=185.025n

* CHECK dout1_63 Vdout1_63ck36 = 0.9 time = 185
.meas tran vdout1_63ck36 FIND v(dout1_63) AT=185.025n

* CHECK dout1_64 Vdout1_64ck36 = 0.9 time = 185
.meas tran vdout1_64ck36 FIND v(dout1_64) AT=185.025n

* CHECK dout1_65 Vdout1_65ck36 = 0 time = 185
.meas tran vdout1_65ck36 FIND v(dout1_65) AT=185.025n

* CHECK dout1_66 Vdout1_66ck36 = 0 time = 185
.meas tran vdout1_66ck36 FIND v(dout1_66) AT=185.025n

* CHECK dout1_67 Vdout1_67ck36 = 0 time = 185
.meas tran vdout1_67ck36 FIND v(dout1_67) AT=185.025n

* CHECK dout1_68 Vdout1_68ck36 = 0 time = 185
.meas tran vdout1_68ck36 FIND v(dout1_68) AT=185.025n

* CHECK dout1_69 Vdout1_69ck36 = 0.9 time = 185
.meas tran vdout1_69ck36 FIND v(dout1_69) AT=185.025n

* CHECK dout1_70 Vdout1_70ck36 = 0.9 time = 185
.meas tran vdout1_70ck36 FIND v(dout1_70) AT=185.025n

* CHECK dout1_71 Vdout1_71ck36 = 0 time = 185
.meas tran vdout1_71ck36 FIND v(dout1_71) AT=185.025n

* CHECK dout1_72 Vdout1_72ck36 = 0 time = 185
.meas tran vdout1_72ck36 FIND v(dout1_72) AT=185.025n

* CHECK dout1_73 Vdout1_73ck36 = 0.9 time = 185
.meas tran vdout1_73ck36 FIND v(dout1_73) AT=185.025n

* CHECK dout1_74 Vdout1_74ck36 = 0.9 time = 185
.meas tran vdout1_74ck36 FIND v(dout1_74) AT=185.025n

* CHECK dout1_75 Vdout1_75ck36 = 0.9 time = 185
.meas tran vdout1_75ck36 FIND v(dout1_75) AT=185.025n

* CHECK dout1_76 Vdout1_76ck36 = 0 time = 185
.meas tran vdout1_76ck36 FIND v(dout1_76) AT=185.025n

* CHECK dout1_77 Vdout1_77ck36 = 0.9 time = 185
.meas tran vdout1_77ck36 FIND v(dout1_77) AT=185.025n

* CHECK dout1_78 Vdout1_78ck36 = 0 time = 185
.meas tran vdout1_78ck36 FIND v(dout1_78) AT=185.025n

* CHECK dout1_79 Vdout1_79ck36 = 0 time = 185
.meas tran vdout1_79ck36 FIND v(dout1_79) AT=185.025n

* CHECK dout1_80 Vdout1_80ck36 = 0 time = 185
.meas tran vdout1_80ck36 FIND v(dout1_80) AT=185.025n

* CHECK dout1_81 Vdout1_81ck36 = 0 time = 185
.meas tran vdout1_81ck36 FIND v(dout1_81) AT=185.025n

* CHECK dout1_82 Vdout1_82ck36 = 0 time = 185
.meas tran vdout1_82ck36 FIND v(dout1_82) AT=185.025n

* CHECK dout1_83 Vdout1_83ck36 = 0.9 time = 185
.meas tran vdout1_83ck36 FIND v(dout1_83) AT=185.025n

* CHECK dout1_84 Vdout1_84ck36 = 0 time = 185
.meas tran vdout1_84ck36 FIND v(dout1_84) AT=185.025n

* CHECK dout1_85 Vdout1_85ck36 = 0 time = 185
.meas tran vdout1_85ck36 FIND v(dout1_85) AT=185.025n

* CHECK dout1_86 Vdout1_86ck36 = 0 time = 185
.meas tran vdout1_86ck36 FIND v(dout1_86) AT=185.025n

* CHECK dout1_87 Vdout1_87ck36 = 0 time = 185
.meas tran vdout1_87ck36 FIND v(dout1_87) AT=185.025n

* CHECK dout1_88 Vdout1_88ck36 = 0.9 time = 185
.meas tran vdout1_88ck36 FIND v(dout1_88) AT=185.025n

* CHECK dout1_89 Vdout1_89ck36 = 0 time = 185
.meas tran vdout1_89ck36 FIND v(dout1_89) AT=185.025n

* CHECK dout1_90 Vdout1_90ck36 = 0 time = 185
.meas tran vdout1_90ck36 FIND v(dout1_90) AT=185.025n

* CHECK dout1_91 Vdout1_91ck36 = 0.9 time = 185
.meas tran vdout1_91ck36 FIND v(dout1_91) AT=185.025n

* CHECK dout1_92 Vdout1_92ck36 = 0.9 time = 185
.meas tran vdout1_92ck36 FIND v(dout1_92) AT=185.025n

* CHECK dout1_93 Vdout1_93ck36 = 0 time = 185
.meas tran vdout1_93ck36 FIND v(dout1_93) AT=185.025n

* CHECK dout1_94 Vdout1_94ck36 = 0 time = 185
.meas tran vdout1_94ck36 FIND v(dout1_94) AT=185.025n

* CHECK dout1_95 Vdout1_95ck36 = 0 time = 185
.meas tran vdout1_95ck36 FIND v(dout1_95) AT=185.025n

* CHECK dout1_96 Vdout1_96ck36 = 0 time = 185
.meas tran vdout1_96ck36 FIND v(dout1_96) AT=185.025n

* CHECK dout1_97 Vdout1_97ck36 = 0.9 time = 185
.meas tran vdout1_97ck36 FIND v(dout1_97) AT=185.025n

* CHECK dout1_98 Vdout1_98ck36 = 0 time = 185
.meas tran vdout1_98ck36 FIND v(dout1_98) AT=185.025n

* CHECK dout1_99 Vdout1_99ck36 = 0 time = 185
.meas tran vdout1_99ck36 FIND v(dout1_99) AT=185.025n

* CHECK dout1_100 Vdout1_100ck36 = 0 time = 185
.meas tran vdout1_100ck36 FIND v(dout1_100) AT=185.025n

* CHECK dout1_101 Vdout1_101ck36 = 0.9 time = 185
.meas tran vdout1_101ck36 FIND v(dout1_101) AT=185.025n

* CHECK dout1_102 Vdout1_102ck36 = 0.9 time = 185
.meas tran vdout1_102ck36 FIND v(dout1_102) AT=185.025n

* CHECK dout1_103 Vdout1_103ck36 = 0.9 time = 185
.meas tran vdout1_103ck36 FIND v(dout1_103) AT=185.025n

* CHECK dout1_104 Vdout1_104ck36 = 0 time = 185
.meas tran vdout1_104ck36 FIND v(dout1_104) AT=185.025n

* CHECK dout1_105 Vdout1_105ck36 = 0 time = 185
.meas tran vdout1_105ck36 FIND v(dout1_105) AT=185.025n

* CHECK dout1_106 Vdout1_106ck36 = 0.9 time = 185
.meas tran vdout1_106ck36 FIND v(dout1_106) AT=185.025n

* CHECK dout1_107 Vdout1_107ck36 = 0 time = 185
.meas tran vdout1_107ck36 FIND v(dout1_107) AT=185.025n

* CHECK dout1_108 Vdout1_108ck36 = 0.9 time = 185
.meas tran vdout1_108ck36 FIND v(dout1_108) AT=185.025n

* CHECK dout1_109 Vdout1_109ck36 = 0.9 time = 185
.meas tran vdout1_109ck36 FIND v(dout1_109) AT=185.025n

* CHECK dout1_110 Vdout1_110ck36 = 0.9 time = 185
.meas tran vdout1_110ck36 FIND v(dout1_110) AT=185.025n

* CHECK dout1_111 Vdout1_111ck36 = 0.9 time = 185
.meas tran vdout1_111ck36 FIND v(dout1_111) AT=185.025n

* CHECK dout1_112 Vdout1_112ck36 = 0 time = 185
.meas tran vdout1_112ck36 FIND v(dout1_112) AT=185.025n

* CHECK dout1_113 Vdout1_113ck36 = 0 time = 185
.meas tran vdout1_113ck36 FIND v(dout1_113) AT=185.025n

* CHECK dout1_114 Vdout1_114ck36 = 0 time = 185
.meas tran vdout1_114ck36 FIND v(dout1_114) AT=185.025n

* CHECK dout1_115 Vdout1_115ck36 = 0.9 time = 185
.meas tran vdout1_115ck36 FIND v(dout1_115) AT=185.025n

* CHECK dout1_116 Vdout1_116ck36 = 0 time = 185
.meas tran vdout1_116ck36 FIND v(dout1_116) AT=185.025n

* CHECK dout1_117 Vdout1_117ck36 = 0.9 time = 185
.meas tran vdout1_117ck36 FIND v(dout1_117) AT=185.025n

* CHECK dout1_118 Vdout1_118ck36 = 0.9 time = 185
.meas tran vdout1_118ck36 FIND v(dout1_118) AT=185.025n

* CHECK dout1_119 Vdout1_119ck36 = 0.9 time = 185
.meas tran vdout1_119ck36 FIND v(dout1_119) AT=185.025n

* CHECK dout1_0 Vdout1_0ck38 = 0 time = 195
.meas tran vdout1_0ck38 FIND v(dout1_0) AT=195.025n

* CHECK dout1_1 Vdout1_1ck38 = 0.9 time = 195
.meas tran vdout1_1ck38 FIND v(dout1_1) AT=195.025n

* CHECK dout1_2 Vdout1_2ck38 = 0.9 time = 195
.meas tran vdout1_2ck38 FIND v(dout1_2) AT=195.025n

* CHECK dout1_3 Vdout1_3ck38 = 0 time = 195
.meas tran vdout1_3ck38 FIND v(dout1_3) AT=195.025n

* CHECK dout1_4 Vdout1_4ck38 = 0 time = 195
.meas tran vdout1_4ck38 FIND v(dout1_4) AT=195.025n

* CHECK dout1_5 Vdout1_5ck38 = 0.9 time = 195
.meas tran vdout1_5ck38 FIND v(dout1_5) AT=195.025n

* CHECK dout1_6 Vdout1_6ck38 = 0.9 time = 195
.meas tran vdout1_6ck38 FIND v(dout1_6) AT=195.025n

* CHECK dout1_7 Vdout1_7ck38 = 0 time = 195
.meas tran vdout1_7ck38 FIND v(dout1_7) AT=195.025n

* CHECK dout1_8 Vdout1_8ck38 = 0.9 time = 195
.meas tran vdout1_8ck38 FIND v(dout1_8) AT=195.025n

* CHECK dout1_9 Vdout1_9ck38 = 0 time = 195
.meas tran vdout1_9ck38 FIND v(dout1_9) AT=195.025n

* CHECK dout1_10 Vdout1_10ck38 = 0 time = 195
.meas tran vdout1_10ck38 FIND v(dout1_10) AT=195.025n

* CHECK dout1_11 Vdout1_11ck38 = 0.9 time = 195
.meas tran vdout1_11ck38 FIND v(dout1_11) AT=195.025n

* CHECK dout1_12 Vdout1_12ck38 = 0 time = 195
.meas tran vdout1_12ck38 FIND v(dout1_12) AT=195.025n

* CHECK dout1_13 Vdout1_13ck38 = 0 time = 195
.meas tran vdout1_13ck38 FIND v(dout1_13) AT=195.025n

* CHECK dout1_14 Vdout1_14ck38 = 0.9 time = 195
.meas tran vdout1_14ck38 FIND v(dout1_14) AT=195.025n

* CHECK dout1_15 Vdout1_15ck38 = 0.9 time = 195
.meas tran vdout1_15ck38 FIND v(dout1_15) AT=195.025n

* CHECK dout1_16 Vdout1_16ck38 = 0.9 time = 195
.meas tran vdout1_16ck38 FIND v(dout1_16) AT=195.025n

* CHECK dout1_17 Vdout1_17ck38 = 0 time = 195
.meas tran vdout1_17ck38 FIND v(dout1_17) AT=195.025n

* CHECK dout1_18 Vdout1_18ck38 = 0 time = 195
.meas tran vdout1_18ck38 FIND v(dout1_18) AT=195.025n

* CHECK dout1_19 Vdout1_19ck38 = 0.9 time = 195
.meas tran vdout1_19ck38 FIND v(dout1_19) AT=195.025n

* CHECK dout1_20 Vdout1_20ck38 = 0.9 time = 195
.meas tran vdout1_20ck38 FIND v(dout1_20) AT=195.025n

* CHECK dout1_21 Vdout1_21ck38 = 0 time = 195
.meas tran vdout1_21ck38 FIND v(dout1_21) AT=195.025n

* CHECK dout1_22 Vdout1_22ck38 = 0 time = 195
.meas tran vdout1_22ck38 FIND v(dout1_22) AT=195.025n

* CHECK dout1_23 Vdout1_23ck38 = 0.9 time = 195
.meas tran vdout1_23ck38 FIND v(dout1_23) AT=195.025n

* CHECK dout1_24 Vdout1_24ck38 = 0 time = 195
.meas tran vdout1_24ck38 FIND v(dout1_24) AT=195.025n

* CHECK dout1_25 Vdout1_25ck38 = 0.9 time = 195
.meas tran vdout1_25ck38 FIND v(dout1_25) AT=195.025n

* CHECK dout1_26 Vdout1_26ck38 = 0 time = 195
.meas tran vdout1_26ck38 FIND v(dout1_26) AT=195.025n

* CHECK dout1_27 Vdout1_27ck38 = 0 time = 195
.meas tran vdout1_27ck38 FIND v(dout1_27) AT=195.025n

* CHECK dout1_28 Vdout1_28ck38 = 0.9 time = 195
.meas tran vdout1_28ck38 FIND v(dout1_28) AT=195.025n

* CHECK dout1_29 Vdout1_29ck38 = 0 time = 195
.meas tran vdout1_29ck38 FIND v(dout1_29) AT=195.025n

* CHECK dout1_30 Vdout1_30ck38 = 0 time = 195
.meas tran vdout1_30ck38 FIND v(dout1_30) AT=195.025n

* CHECK dout1_31 Vdout1_31ck38 = 0 time = 195
.meas tran vdout1_31ck38 FIND v(dout1_31) AT=195.025n

* CHECK dout1_32 Vdout1_32ck38 = 0.9 time = 195
.meas tran vdout1_32ck38 FIND v(dout1_32) AT=195.025n

* CHECK dout1_33 Vdout1_33ck38 = 0 time = 195
.meas tran vdout1_33ck38 FIND v(dout1_33) AT=195.025n

* CHECK dout1_34 Vdout1_34ck38 = 0.9 time = 195
.meas tran vdout1_34ck38 FIND v(dout1_34) AT=195.025n

* CHECK dout1_35 Vdout1_35ck38 = 0 time = 195
.meas tran vdout1_35ck38 FIND v(dout1_35) AT=195.025n

* CHECK dout1_36 Vdout1_36ck38 = 0.9 time = 195
.meas tran vdout1_36ck38 FIND v(dout1_36) AT=195.025n

* CHECK dout1_37 Vdout1_37ck38 = 0 time = 195
.meas tran vdout1_37ck38 FIND v(dout1_37) AT=195.025n

* CHECK dout1_38 Vdout1_38ck38 = 0 time = 195
.meas tran vdout1_38ck38 FIND v(dout1_38) AT=195.025n

* CHECK dout1_39 Vdout1_39ck38 = 0 time = 195
.meas tran vdout1_39ck38 FIND v(dout1_39) AT=195.025n

* CHECK dout1_40 Vdout1_40ck38 = 0 time = 195
.meas tran vdout1_40ck38 FIND v(dout1_40) AT=195.025n

* CHECK dout1_41 Vdout1_41ck38 = 0.9 time = 195
.meas tran vdout1_41ck38 FIND v(dout1_41) AT=195.025n

* CHECK dout1_42 Vdout1_42ck38 = 0 time = 195
.meas tran vdout1_42ck38 FIND v(dout1_42) AT=195.025n

* CHECK dout1_43 Vdout1_43ck38 = 0 time = 195
.meas tran vdout1_43ck38 FIND v(dout1_43) AT=195.025n

* CHECK dout1_44 Vdout1_44ck38 = 0 time = 195
.meas tran vdout1_44ck38 FIND v(dout1_44) AT=195.025n

* CHECK dout1_45 Vdout1_45ck38 = 0.9 time = 195
.meas tran vdout1_45ck38 FIND v(dout1_45) AT=195.025n

* CHECK dout1_46 Vdout1_46ck38 = 0 time = 195
.meas tran vdout1_46ck38 FIND v(dout1_46) AT=195.025n

* CHECK dout1_47 Vdout1_47ck38 = 0.9 time = 195
.meas tran vdout1_47ck38 FIND v(dout1_47) AT=195.025n

* CHECK dout1_48 Vdout1_48ck38 = 0 time = 195
.meas tran vdout1_48ck38 FIND v(dout1_48) AT=195.025n

* CHECK dout1_49 Vdout1_49ck38 = 0 time = 195
.meas tran vdout1_49ck38 FIND v(dout1_49) AT=195.025n

* CHECK dout1_50 Vdout1_50ck38 = 0.9 time = 195
.meas tran vdout1_50ck38 FIND v(dout1_50) AT=195.025n

* CHECK dout1_51 Vdout1_51ck38 = 0 time = 195
.meas tran vdout1_51ck38 FIND v(dout1_51) AT=195.025n

* CHECK dout1_52 Vdout1_52ck38 = 0.9 time = 195
.meas tran vdout1_52ck38 FIND v(dout1_52) AT=195.025n

* CHECK dout1_53 Vdout1_53ck38 = 0.9 time = 195
.meas tran vdout1_53ck38 FIND v(dout1_53) AT=195.025n

* CHECK dout1_54 Vdout1_54ck38 = 0 time = 195
.meas tran vdout1_54ck38 FIND v(dout1_54) AT=195.025n

* CHECK dout1_55 Vdout1_55ck38 = 0.9 time = 195
.meas tran vdout1_55ck38 FIND v(dout1_55) AT=195.025n

* CHECK dout1_56 Vdout1_56ck38 = 0.9 time = 195
.meas tran vdout1_56ck38 FIND v(dout1_56) AT=195.025n

* CHECK dout1_57 Vdout1_57ck38 = 0 time = 195
.meas tran vdout1_57ck38 FIND v(dout1_57) AT=195.025n

* CHECK dout1_58 Vdout1_58ck38 = 0 time = 195
.meas tran vdout1_58ck38 FIND v(dout1_58) AT=195.025n

* CHECK dout1_59 Vdout1_59ck38 = 0 time = 195
.meas tran vdout1_59ck38 FIND v(dout1_59) AT=195.025n

* CHECK dout1_60 Vdout1_60ck38 = 0 time = 195
.meas tran vdout1_60ck38 FIND v(dout1_60) AT=195.025n

* CHECK dout1_61 Vdout1_61ck38 = 0.9 time = 195
.meas tran vdout1_61ck38 FIND v(dout1_61) AT=195.025n

* CHECK dout1_62 Vdout1_62ck38 = 0 time = 195
.meas tran vdout1_62ck38 FIND v(dout1_62) AT=195.025n

* CHECK dout1_63 Vdout1_63ck38 = 0 time = 195
.meas tran vdout1_63ck38 FIND v(dout1_63) AT=195.025n

* CHECK dout1_64 Vdout1_64ck38 = 0 time = 195
.meas tran vdout1_64ck38 FIND v(dout1_64) AT=195.025n

* CHECK dout1_65 Vdout1_65ck38 = 0.9 time = 195
.meas tran vdout1_65ck38 FIND v(dout1_65) AT=195.025n

* CHECK dout1_66 Vdout1_66ck38 = 0.9 time = 195
.meas tran vdout1_66ck38 FIND v(dout1_66) AT=195.025n

* CHECK dout1_67 Vdout1_67ck38 = 0 time = 195
.meas tran vdout1_67ck38 FIND v(dout1_67) AT=195.025n

* CHECK dout1_68 Vdout1_68ck38 = 0.9 time = 195
.meas tran vdout1_68ck38 FIND v(dout1_68) AT=195.025n

* CHECK dout1_69 Vdout1_69ck38 = 0.9 time = 195
.meas tran vdout1_69ck38 FIND v(dout1_69) AT=195.025n

* CHECK dout1_70 Vdout1_70ck38 = 0 time = 195
.meas tran vdout1_70ck38 FIND v(dout1_70) AT=195.025n

* CHECK dout1_71 Vdout1_71ck38 = 0 time = 195
.meas tran vdout1_71ck38 FIND v(dout1_71) AT=195.025n

* CHECK dout1_72 Vdout1_72ck38 = 0 time = 195
.meas tran vdout1_72ck38 FIND v(dout1_72) AT=195.025n

* CHECK dout1_73 Vdout1_73ck38 = 0.9 time = 195
.meas tran vdout1_73ck38 FIND v(dout1_73) AT=195.025n

* CHECK dout1_74 Vdout1_74ck38 = 0.9 time = 195
.meas tran vdout1_74ck38 FIND v(dout1_74) AT=195.025n

* CHECK dout1_75 Vdout1_75ck38 = 0 time = 195
.meas tran vdout1_75ck38 FIND v(dout1_75) AT=195.025n

* CHECK dout1_76 Vdout1_76ck38 = 0.9 time = 195
.meas tran vdout1_76ck38 FIND v(dout1_76) AT=195.025n

* CHECK dout1_77 Vdout1_77ck38 = 0 time = 195
.meas tran vdout1_77ck38 FIND v(dout1_77) AT=195.025n

* CHECK dout1_78 Vdout1_78ck38 = 0 time = 195
.meas tran vdout1_78ck38 FIND v(dout1_78) AT=195.025n

* CHECK dout1_79 Vdout1_79ck38 = 0.9 time = 195
.meas tran vdout1_79ck38 FIND v(dout1_79) AT=195.025n

* CHECK dout1_80 Vdout1_80ck38 = 0.9 time = 195
.meas tran vdout1_80ck38 FIND v(dout1_80) AT=195.025n

* CHECK dout1_81 Vdout1_81ck38 = 0 time = 195
.meas tran vdout1_81ck38 FIND v(dout1_81) AT=195.025n

* CHECK dout1_82 Vdout1_82ck38 = 0.9 time = 195
.meas tran vdout1_82ck38 FIND v(dout1_82) AT=195.025n

* CHECK dout1_83 Vdout1_83ck38 = 0.9 time = 195
.meas tran vdout1_83ck38 FIND v(dout1_83) AT=195.025n

* CHECK dout1_84 Vdout1_84ck38 = 0.9 time = 195
.meas tran vdout1_84ck38 FIND v(dout1_84) AT=195.025n

* CHECK dout1_85 Vdout1_85ck38 = 0.9 time = 195
.meas tran vdout1_85ck38 FIND v(dout1_85) AT=195.025n

* CHECK dout1_86 Vdout1_86ck38 = 0 time = 195
.meas tran vdout1_86ck38 FIND v(dout1_86) AT=195.025n

* CHECK dout1_87 Vdout1_87ck38 = 0 time = 195
.meas tran vdout1_87ck38 FIND v(dout1_87) AT=195.025n

* CHECK dout1_88 Vdout1_88ck38 = 0.9 time = 195
.meas tran vdout1_88ck38 FIND v(dout1_88) AT=195.025n

* CHECK dout1_89 Vdout1_89ck38 = 0 time = 195
.meas tran vdout1_89ck38 FIND v(dout1_89) AT=195.025n

* CHECK dout1_90 Vdout1_90ck38 = 0 time = 195
.meas tran vdout1_90ck38 FIND v(dout1_90) AT=195.025n

* CHECK dout1_91 Vdout1_91ck38 = 0 time = 195
.meas tran vdout1_91ck38 FIND v(dout1_91) AT=195.025n

* CHECK dout1_92 Vdout1_92ck38 = 0 time = 195
.meas tran vdout1_92ck38 FIND v(dout1_92) AT=195.025n

* CHECK dout1_93 Vdout1_93ck38 = 0 time = 195
.meas tran vdout1_93ck38 FIND v(dout1_93) AT=195.025n

* CHECK dout1_94 Vdout1_94ck38 = 0 time = 195
.meas tran vdout1_94ck38 FIND v(dout1_94) AT=195.025n

* CHECK dout1_95 Vdout1_95ck38 = 0 time = 195
.meas tran vdout1_95ck38 FIND v(dout1_95) AT=195.025n

* CHECK dout1_96 Vdout1_96ck38 = 0 time = 195
.meas tran vdout1_96ck38 FIND v(dout1_96) AT=195.025n

* CHECK dout1_97 Vdout1_97ck38 = 0.9 time = 195
.meas tran vdout1_97ck38 FIND v(dout1_97) AT=195.025n

* CHECK dout1_98 Vdout1_98ck38 = 0.9 time = 195
.meas tran vdout1_98ck38 FIND v(dout1_98) AT=195.025n

* CHECK dout1_99 Vdout1_99ck38 = 0.9 time = 195
.meas tran vdout1_99ck38 FIND v(dout1_99) AT=195.025n

* CHECK dout1_100 Vdout1_100ck38 = 0 time = 195
.meas tran vdout1_100ck38 FIND v(dout1_100) AT=195.025n

* CHECK dout1_101 Vdout1_101ck38 = 0 time = 195
.meas tran vdout1_101ck38 FIND v(dout1_101) AT=195.025n

* CHECK dout1_102 Vdout1_102ck38 = 0 time = 195
.meas tran vdout1_102ck38 FIND v(dout1_102) AT=195.025n

* CHECK dout1_103 Vdout1_103ck38 = 0 time = 195
.meas tran vdout1_103ck38 FIND v(dout1_103) AT=195.025n

* CHECK dout1_104 Vdout1_104ck38 = 0 time = 195
.meas tran vdout1_104ck38 FIND v(dout1_104) AT=195.025n

* CHECK dout1_105 Vdout1_105ck38 = 0 time = 195
.meas tran vdout1_105ck38 FIND v(dout1_105) AT=195.025n

* CHECK dout1_106 Vdout1_106ck38 = 0.9 time = 195
.meas tran vdout1_106ck38 FIND v(dout1_106) AT=195.025n

* CHECK dout1_107 Vdout1_107ck38 = 0.9 time = 195
.meas tran vdout1_107ck38 FIND v(dout1_107) AT=195.025n

* CHECK dout1_108 Vdout1_108ck38 = 0 time = 195
.meas tran vdout1_108ck38 FIND v(dout1_108) AT=195.025n

* CHECK dout1_109 Vdout1_109ck38 = 0.9 time = 195
.meas tran vdout1_109ck38 FIND v(dout1_109) AT=195.025n

* CHECK dout1_110 Vdout1_110ck38 = 0.9 time = 195
.meas tran vdout1_110ck38 FIND v(dout1_110) AT=195.025n

* CHECK dout1_111 Vdout1_111ck38 = 0 time = 195
.meas tran vdout1_111ck38 FIND v(dout1_111) AT=195.025n

* CHECK dout1_112 Vdout1_112ck38 = 0 time = 195
.meas tran vdout1_112ck38 FIND v(dout1_112) AT=195.025n

* CHECK dout1_113 Vdout1_113ck38 = 0.9 time = 195
.meas tran vdout1_113ck38 FIND v(dout1_113) AT=195.025n

* CHECK dout1_114 Vdout1_114ck38 = 0 time = 195
.meas tran vdout1_114ck38 FIND v(dout1_114) AT=195.025n

* CHECK dout1_115 Vdout1_115ck38 = 0 time = 195
.meas tran vdout1_115ck38 FIND v(dout1_115) AT=195.025n

* CHECK dout1_116 Vdout1_116ck38 = 0 time = 195
.meas tran vdout1_116ck38 FIND v(dout1_116) AT=195.025n

* CHECK dout1_117 Vdout1_117ck38 = 0 time = 195
.meas tran vdout1_117ck38 FIND v(dout1_117) AT=195.025n

* CHECK dout1_118 Vdout1_118ck38 = 0.9 time = 195
.meas tran vdout1_118ck38 FIND v(dout1_118) AT=195.025n

* CHECK dout1_119 Vdout1_119ck38 = 0 time = 195
.meas tran vdout1_119ck38 FIND v(dout1_119) AT=195.025n

* CHECK dout1_0 Vdout1_0ck40 = 0 time = 205
.meas tran vdout1_0ck40 FIND v(dout1_0) AT=205.025n

* CHECK dout1_1 Vdout1_1ck40 = 0.9 time = 205
.meas tran vdout1_1ck40 FIND v(dout1_1) AT=205.025n

* CHECK dout1_2 Vdout1_2ck40 = 0.9 time = 205
.meas tran vdout1_2ck40 FIND v(dout1_2) AT=205.025n

* CHECK dout1_3 Vdout1_3ck40 = 0 time = 205
.meas tran vdout1_3ck40 FIND v(dout1_3) AT=205.025n

* CHECK dout1_4 Vdout1_4ck40 = 0 time = 205
.meas tran vdout1_4ck40 FIND v(dout1_4) AT=205.025n

* CHECK dout1_5 Vdout1_5ck40 = 0.9 time = 205
.meas tran vdout1_5ck40 FIND v(dout1_5) AT=205.025n

* CHECK dout1_6 Vdout1_6ck40 = 0.9 time = 205
.meas tran vdout1_6ck40 FIND v(dout1_6) AT=205.025n

* CHECK dout1_7 Vdout1_7ck40 = 0 time = 205
.meas tran vdout1_7ck40 FIND v(dout1_7) AT=205.025n

* CHECK dout1_8 Vdout1_8ck40 = 0.9 time = 205
.meas tran vdout1_8ck40 FIND v(dout1_8) AT=205.025n

* CHECK dout1_9 Vdout1_9ck40 = 0 time = 205
.meas tran vdout1_9ck40 FIND v(dout1_9) AT=205.025n

* CHECK dout1_10 Vdout1_10ck40 = 0 time = 205
.meas tran vdout1_10ck40 FIND v(dout1_10) AT=205.025n

* CHECK dout1_11 Vdout1_11ck40 = 0.9 time = 205
.meas tran vdout1_11ck40 FIND v(dout1_11) AT=205.025n

* CHECK dout1_12 Vdout1_12ck40 = 0 time = 205
.meas tran vdout1_12ck40 FIND v(dout1_12) AT=205.025n

* CHECK dout1_13 Vdout1_13ck40 = 0 time = 205
.meas tran vdout1_13ck40 FIND v(dout1_13) AT=205.025n

* CHECK dout1_14 Vdout1_14ck40 = 0.9 time = 205
.meas tran vdout1_14ck40 FIND v(dout1_14) AT=205.025n

* CHECK dout1_15 Vdout1_15ck40 = 0.9 time = 205
.meas tran vdout1_15ck40 FIND v(dout1_15) AT=205.025n

* CHECK dout1_16 Vdout1_16ck40 = 0.9 time = 205
.meas tran vdout1_16ck40 FIND v(dout1_16) AT=205.025n

* CHECK dout1_17 Vdout1_17ck40 = 0 time = 205
.meas tran vdout1_17ck40 FIND v(dout1_17) AT=205.025n

* CHECK dout1_18 Vdout1_18ck40 = 0 time = 205
.meas tran vdout1_18ck40 FIND v(dout1_18) AT=205.025n

* CHECK dout1_19 Vdout1_19ck40 = 0.9 time = 205
.meas tran vdout1_19ck40 FIND v(dout1_19) AT=205.025n

* CHECK dout1_20 Vdout1_20ck40 = 0.9 time = 205
.meas tran vdout1_20ck40 FIND v(dout1_20) AT=205.025n

* CHECK dout1_21 Vdout1_21ck40 = 0 time = 205
.meas tran vdout1_21ck40 FIND v(dout1_21) AT=205.025n

* CHECK dout1_22 Vdout1_22ck40 = 0 time = 205
.meas tran vdout1_22ck40 FIND v(dout1_22) AT=205.025n

* CHECK dout1_23 Vdout1_23ck40 = 0.9 time = 205
.meas tran vdout1_23ck40 FIND v(dout1_23) AT=205.025n

* CHECK dout1_24 Vdout1_24ck40 = 0 time = 205
.meas tran vdout1_24ck40 FIND v(dout1_24) AT=205.025n

* CHECK dout1_25 Vdout1_25ck40 = 0.9 time = 205
.meas tran vdout1_25ck40 FIND v(dout1_25) AT=205.025n

* CHECK dout1_26 Vdout1_26ck40 = 0 time = 205
.meas tran vdout1_26ck40 FIND v(dout1_26) AT=205.025n

* CHECK dout1_27 Vdout1_27ck40 = 0 time = 205
.meas tran vdout1_27ck40 FIND v(dout1_27) AT=205.025n

* CHECK dout1_28 Vdout1_28ck40 = 0.9 time = 205
.meas tran vdout1_28ck40 FIND v(dout1_28) AT=205.025n

* CHECK dout1_29 Vdout1_29ck40 = 0 time = 205
.meas tran vdout1_29ck40 FIND v(dout1_29) AT=205.025n

* CHECK dout1_30 Vdout1_30ck40 = 0 time = 205
.meas tran vdout1_30ck40 FIND v(dout1_30) AT=205.025n

* CHECK dout1_31 Vdout1_31ck40 = 0 time = 205
.meas tran vdout1_31ck40 FIND v(dout1_31) AT=205.025n

* CHECK dout1_32 Vdout1_32ck40 = 0.9 time = 205
.meas tran vdout1_32ck40 FIND v(dout1_32) AT=205.025n

* CHECK dout1_33 Vdout1_33ck40 = 0 time = 205
.meas tran vdout1_33ck40 FIND v(dout1_33) AT=205.025n

* CHECK dout1_34 Vdout1_34ck40 = 0.9 time = 205
.meas tran vdout1_34ck40 FIND v(dout1_34) AT=205.025n

* CHECK dout1_35 Vdout1_35ck40 = 0 time = 205
.meas tran vdout1_35ck40 FIND v(dout1_35) AT=205.025n

* CHECK dout1_36 Vdout1_36ck40 = 0.9 time = 205
.meas tran vdout1_36ck40 FIND v(dout1_36) AT=205.025n

* CHECK dout1_37 Vdout1_37ck40 = 0 time = 205
.meas tran vdout1_37ck40 FIND v(dout1_37) AT=205.025n

* CHECK dout1_38 Vdout1_38ck40 = 0 time = 205
.meas tran vdout1_38ck40 FIND v(dout1_38) AT=205.025n

* CHECK dout1_39 Vdout1_39ck40 = 0 time = 205
.meas tran vdout1_39ck40 FIND v(dout1_39) AT=205.025n

* CHECK dout1_40 Vdout1_40ck40 = 0 time = 205
.meas tran vdout1_40ck40 FIND v(dout1_40) AT=205.025n

* CHECK dout1_41 Vdout1_41ck40 = 0.9 time = 205
.meas tran vdout1_41ck40 FIND v(dout1_41) AT=205.025n

* CHECK dout1_42 Vdout1_42ck40 = 0 time = 205
.meas tran vdout1_42ck40 FIND v(dout1_42) AT=205.025n

* CHECK dout1_43 Vdout1_43ck40 = 0 time = 205
.meas tran vdout1_43ck40 FIND v(dout1_43) AT=205.025n

* CHECK dout1_44 Vdout1_44ck40 = 0 time = 205
.meas tran vdout1_44ck40 FIND v(dout1_44) AT=205.025n

* CHECK dout1_45 Vdout1_45ck40 = 0.9 time = 205
.meas tran vdout1_45ck40 FIND v(dout1_45) AT=205.025n

* CHECK dout1_46 Vdout1_46ck40 = 0 time = 205
.meas tran vdout1_46ck40 FIND v(dout1_46) AT=205.025n

* CHECK dout1_47 Vdout1_47ck40 = 0.9 time = 205
.meas tran vdout1_47ck40 FIND v(dout1_47) AT=205.025n

* CHECK dout1_48 Vdout1_48ck40 = 0 time = 205
.meas tran vdout1_48ck40 FIND v(dout1_48) AT=205.025n

* CHECK dout1_49 Vdout1_49ck40 = 0 time = 205
.meas tran vdout1_49ck40 FIND v(dout1_49) AT=205.025n

* CHECK dout1_50 Vdout1_50ck40 = 0.9 time = 205
.meas tran vdout1_50ck40 FIND v(dout1_50) AT=205.025n

* CHECK dout1_51 Vdout1_51ck40 = 0 time = 205
.meas tran vdout1_51ck40 FIND v(dout1_51) AT=205.025n

* CHECK dout1_52 Vdout1_52ck40 = 0.9 time = 205
.meas tran vdout1_52ck40 FIND v(dout1_52) AT=205.025n

* CHECK dout1_53 Vdout1_53ck40 = 0.9 time = 205
.meas tran vdout1_53ck40 FIND v(dout1_53) AT=205.025n

* CHECK dout1_54 Vdout1_54ck40 = 0 time = 205
.meas tran vdout1_54ck40 FIND v(dout1_54) AT=205.025n

* CHECK dout1_55 Vdout1_55ck40 = 0.9 time = 205
.meas tran vdout1_55ck40 FIND v(dout1_55) AT=205.025n

* CHECK dout1_56 Vdout1_56ck40 = 0.9 time = 205
.meas tran vdout1_56ck40 FIND v(dout1_56) AT=205.025n

* CHECK dout1_57 Vdout1_57ck40 = 0 time = 205
.meas tran vdout1_57ck40 FIND v(dout1_57) AT=205.025n

* CHECK dout1_58 Vdout1_58ck40 = 0 time = 205
.meas tran vdout1_58ck40 FIND v(dout1_58) AT=205.025n

* CHECK dout1_59 Vdout1_59ck40 = 0 time = 205
.meas tran vdout1_59ck40 FIND v(dout1_59) AT=205.025n

* CHECK dout1_60 Vdout1_60ck40 = 0 time = 205
.meas tran vdout1_60ck40 FIND v(dout1_60) AT=205.025n

* CHECK dout1_61 Vdout1_61ck40 = 0.9 time = 205
.meas tran vdout1_61ck40 FIND v(dout1_61) AT=205.025n

* CHECK dout1_62 Vdout1_62ck40 = 0 time = 205
.meas tran vdout1_62ck40 FIND v(dout1_62) AT=205.025n

* CHECK dout1_63 Vdout1_63ck40 = 0 time = 205
.meas tran vdout1_63ck40 FIND v(dout1_63) AT=205.025n

* CHECK dout1_64 Vdout1_64ck40 = 0 time = 205
.meas tran vdout1_64ck40 FIND v(dout1_64) AT=205.025n

* CHECK dout1_65 Vdout1_65ck40 = 0.9 time = 205
.meas tran vdout1_65ck40 FIND v(dout1_65) AT=205.025n

* CHECK dout1_66 Vdout1_66ck40 = 0.9 time = 205
.meas tran vdout1_66ck40 FIND v(dout1_66) AT=205.025n

* CHECK dout1_67 Vdout1_67ck40 = 0 time = 205
.meas tran vdout1_67ck40 FIND v(dout1_67) AT=205.025n

* CHECK dout1_68 Vdout1_68ck40 = 0.9 time = 205
.meas tran vdout1_68ck40 FIND v(dout1_68) AT=205.025n

* CHECK dout1_69 Vdout1_69ck40 = 0.9 time = 205
.meas tran vdout1_69ck40 FIND v(dout1_69) AT=205.025n

* CHECK dout1_70 Vdout1_70ck40 = 0 time = 205
.meas tran vdout1_70ck40 FIND v(dout1_70) AT=205.025n

* CHECK dout1_71 Vdout1_71ck40 = 0 time = 205
.meas tran vdout1_71ck40 FIND v(dout1_71) AT=205.025n

* CHECK dout1_72 Vdout1_72ck40 = 0 time = 205
.meas tran vdout1_72ck40 FIND v(dout1_72) AT=205.025n

* CHECK dout1_73 Vdout1_73ck40 = 0.9 time = 205
.meas tran vdout1_73ck40 FIND v(dout1_73) AT=205.025n

* CHECK dout1_74 Vdout1_74ck40 = 0.9 time = 205
.meas tran vdout1_74ck40 FIND v(dout1_74) AT=205.025n

* CHECK dout1_75 Vdout1_75ck40 = 0 time = 205
.meas tran vdout1_75ck40 FIND v(dout1_75) AT=205.025n

* CHECK dout1_76 Vdout1_76ck40 = 0.9 time = 205
.meas tran vdout1_76ck40 FIND v(dout1_76) AT=205.025n

* CHECK dout1_77 Vdout1_77ck40 = 0 time = 205
.meas tran vdout1_77ck40 FIND v(dout1_77) AT=205.025n

* CHECK dout1_78 Vdout1_78ck40 = 0 time = 205
.meas tran vdout1_78ck40 FIND v(dout1_78) AT=205.025n

* CHECK dout1_79 Vdout1_79ck40 = 0.9 time = 205
.meas tran vdout1_79ck40 FIND v(dout1_79) AT=205.025n

* CHECK dout1_80 Vdout1_80ck40 = 0.9 time = 205
.meas tran vdout1_80ck40 FIND v(dout1_80) AT=205.025n

* CHECK dout1_81 Vdout1_81ck40 = 0 time = 205
.meas tran vdout1_81ck40 FIND v(dout1_81) AT=205.025n

* CHECK dout1_82 Vdout1_82ck40 = 0.9 time = 205
.meas tran vdout1_82ck40 FIND v(dout1_82) AT=205.025n

* CHECK dout1_83 Vdout1_83ck40 = 0.9 time = 205
.meas tran vdout1_83ck40 FIND v(dout1_83) AT=205.025n

* CHECK dout1_84 Vdout1_84ck40 = 0.9 time = 205
.meas tran vdout1_84ck40 FIND v(dout1_84) AT=205.025n

* CHECK dout1_85 Vdout1_85ck40 = 0.9 time = 205
.meas tran vdout1_85ck40 FIND v(dout1_85) AT=205.025n

* CHECK dout1_86 Vdout1_86ck40 = 0 time = 205
.meas tran vdout1_86ck40 FIND v(dout1_86) AT=205.025n

* CHECK dout1_87 Vdout1_87ck40 = 0 time = 205
.meas tran vdout1_87ck40 FIND v(dout1_87) AT=205.025n

* CHECK dout1_88 Vdout1_88ck40 = 0.9 time = 205
.meas tran vdout1_88ck40 FIND v(dout1_88) AT=205.025n

* CHECK dout1_89 Vdout1_89ck40 = 0 time = 205
.meas tran vdout1_89ck40 FIND v(dout1_89) AT=205.025n

* CHECK dout1_90 Vdout1_90ck40 = 0 time = 205
.meas tran vdout1_90ck40 FIND v(dout1_90) AT=205.025n

* CHECK dout1_91 Vdout1_91ck40 = 0 time = 205
.meas tran vdout1_91ck40 FIND v(dout1_91) AT=205.025n

* CHECK dout1_92 Vdout1_92ck40 = 0 time = 205
.meas tran vdout1_92ck40 FIND v(dout1_92) AT=205.025n

* CHECK dout1_93 Vdout1_93ck40 = 0 time = 205
.meas tran vdout1_93ck40 FIND v(dout1_93) AT=205.025n

* CHECK dout1_94 Vdout1_94ck40 = 0 time = 205
.meas tran vdout1_94ck40 FIND v(dout1_94) AT=205.025n

* CHECK dout1_95 Vdout1_95ck40 = 0 time = 205
.meas tran vdout1_95ck40 FIND v(dout1_95) AT=205.025n

* CHECK dout1_96 Vdout1_96ck40 = 0 time = 205
.meas tran vdout1_96ck40 FIND v(dout1_96) AT=205.025n

* CHECK dout1_97 Vdout1_97ck40 = 0.9 time = 205
.meas tran vdout1_97ck40 FIND v(dout1_97) AT=205.025n

* CHECK dout1_98 Vdout1_98ck40 = 0.9 time = 205
.meas tran vdout1_98ck40 FIND v(dout1_98) AT=205.025n

* CHECK dout1_99 Vdout1_99ck40 = 0.9 time = 205
.meas tran vdout1_99ck40 FIND v(dout1_99) AT=205.025n

* CHECK dout1_100 Vdout1_100ck40 = 0 time = 205
.meas tran vdout1_100ck40 FIND v(dout1_100) AT=205.025n

* CHECK dout1_101 Vdout1_101ck40 = 0 time = 205
.meas tran vdout1_101ck40 FIND v(dout1_101) AT=205.025n

* CHECK dout1_102 Vdout1_102ck40 = 0 time = 205
.meas tran vdout1_102ck40 FIND v(dout1_102) AT=205.025n

* CHECK dout1_103 Vdout1_103ck40 = 0 time = 205
.meas tran vdout1_103ck40 FIND v(dout1_103) AT=205.025n

* CHECK dout1_104 Vdout1_104ck40 = 0 time = 205
.meas tran vdout1_104ck40 FIND v(dout1_104) AT=205.025n

* CHECK dout1_105 Vdout1_105ck40 = 0 time = 205
.meas tran vdout1_105ck40 FIND v(dout1_105) AT=205.025n

* CHECK dout1_106 Vdout1_106ck40 = 0.9 time = 205
.meas tran vdout1_106ck40 FIND v(dout1_106) AT=205.025n

* CHECK dout1_107 Vdout1_107ck40 = 0.9 time = 205
.meas tran vdout1_107ck40 FIND v(dout1_107) AT=205.025n

* CHECK dout1_108 Vdout1_108ck40 = 0 time = 205
.meas tran vdout1_108ck40 FIND v(dout1_108) AT=205.025n

* CHECK dout1_109 Vdout1_109ck40 = 0.9 time = 205
.meas tran vdout1_109ck40 FIND v(dout1_109) AT=205.025n

* CHECK dout1_110 Vdout1_110ck40 = 0.9 time = 205
.meas tran vdout1_110ck40 FIND v(dout1_110) AT=205.025n

* CHECK dout1_111 Vdout1_111ck40 = 0 time = 205
.meas tran vdout1_111ck40 FIND v(dout1_111) AT=205.025n

* CHECK dout1_112 Vdout1_112ck40 = 0 time = 205
.meas tran vdout1_112ck40 FIND v(dout1_112) AT=205.025n

* CHECK dout1_113 Vdout1_113ck40 = 0.9 time = 205
.meas tran vdout1_113ck40 FIND v(dout1_113) AT=205.025n

* CHECK dout1_114 Vdout1_114ck40 = 0 time = 205
.meas tran vdout1_114ck40 FIND v(dout1_114) AT=205.025n

* CHECK dout1_115 Vdout1_115ck40 = 0 time = 205
.meas tran vdout1_115ck40 FIND v(dout1_115) AT=205.025n

* CHECK dout1_116 Vdout1_116ck40 = 0 time = 205
.meas tran vdout1_116ck40 FIND v(dout1_116) AT=205.025n

* CHECK dout1_117 Vdout1_117ck40 = 0 time = 205
.meas tran vdout1_117ck40 FIND v(dout1_117) AT=205.025n

* CHECK dout1_118 Vdout1_118ck40 = 0.9 time = 205
.meas tran vdout1_118ck40 FIND v(dout1_118) AT=205.025n

* CHECK dout1_119 Vdout1_119ck40 = 0 time = 205
.meas tran vdout1_119ck40 FIND v(dout1_119) AT=205.025n

* CHECK dout1_0 Vdout1_0ck43 = 0.9 time = 220
.meas tran vdout1_0ck43 FIND v(dout1_0) AT=220.025n

* CHECK dout1_1 Vdout1_1ck43 = 0 time = 220
.meas tran vdout1_1ck43 FIND v(dout1_1) AT=220.025n

* CHECK dout1_2 Vdout1_2ck43 = 0 time = 220
.meas tran vdout1_2ck43 FIND v(dout1_2) AT=220.025n

* CHECK dout1_3 Vdout1_3ck43 = 0.9 time = 220
.meas tran vdout1_3ck43 FIND v(dout1_3) AT=220.025n

* CHECK dout1_4 Vdout1_4ck43 = 0 time = 220
.meas tran vdout1_4ck43 FIND v(dout1_4) AT=220.025n

* CHECK dout1_5 Vdout1_5ck43 = 0 time = 220
.meas tran vdout1_5ck43 FIND v(dout1_5) AT=220.025n

* CHECK dout1_6 Vdout1_6ck43 = 0.9 time = 220
.meas tran vdout1_6ck43 FIND v(dout1_6) AT=220.025n

* CHECK dout1_7 Vdout1_7ck43 = 0 time = 220
.meas tran vdout1_7ck43 FIND v(dout1_7) AT=220.025n

* CHECK dout1_8 Vdout1_8ck43 = 0 time = 220
.meas tran vdout1_8ck43 FIND v(dout1_8) AT=220.025n

* CHECK dout1_9 Vdout1_9ck43 = 0.9 time = 220
.meas tran vdout1_9ck43 FIND v(dout1_9) AT=220.025n

* CHECK dout1_10 Vdout1_10ck43 = 0.9 time = 220
.meas tran vdout1_10ck43 FIND v(dout1_10) AT=220.025n

* CHECK dout1_11 Vdout1_11ck43 = 0 time = 220
.meas tran vdout1_11ck43 FIND v(dout1_11) AT=220.025n

* CHECK dout1_12 Vdout1_12ck43 = 0.9 time = 220
.meas tran vdout1_12ck43 FIND v(dout1_12) AT=220.025n

* CHECK dout1_13 Vdout1_13ck43 = 0.9 time = 220
.meas tran vdout1_13ck43 FIND v(dout1_13) AT=220.025n

* CHECK dout1_14 Vdout1_14ck43 = 0.9 time = 220
.meas tran vdout1_14ck43 FIND v(dout1_14) AT=220.025n

* CHECK dout1_15 Vdout1_15ck43 = 0 time = 220
.meas tran vdout1_15ck43 FIND v(dout1_15) AT=220.025n

* CHECK dout1_16 Vdout1_16ck43 = 0.9 time = 220
.meas tran vdout1_16ck43 FIND v(dout1_16) AT=220.025n

* CHECK dout1_17 Vdout1_17ck43 = 0 time = 220
.meas tran vdout1_17ck43 FIND v(dout1_17) AT=220.025n

* CHECK dout1_18 Vdout1_18ck43 = 0 time = 220
.meas tran vdout1_18ck43 FIND v(dout1_18) AT=220.025n

* CHECK dout1_19 Vdout1_19ck43 = 0 time = 220
.meas tran vdout1_19ck43 FIND v(dout1_19) AT=220.025n

* CHECK dout1_20 Vdout1_20ck43 = 0.9 time = 220
.meas tran vdout1_20ck43 FIND v(dout1_20) AT=220.025n

* CHECK dout1_21 Vdout1_21ck43 = 0 time = 220
.meas tran vdout1_21ck43 FIND v(dout1_21) AT=220.025n

* CHECK dout1_22 Vdout1_22ck43 = 0 time = 220
.meas tran vdout1_22ck43 FIND v(dout1_22) AT=220.025n

* CHECK dout1_23 Vdout1_23ck43 = 0 time = 220
.meas tran vdout1_23ck43 FIND v(dout1_23) AT=220.025n

* CHECK dout1_24 Vdout1_24ck43 = 0 time = 220
.meas tran vdout1_24ck43 FIND v(dout1_24) AT=220.025n

* CHECK dout1_25 Vdout1_25ck43 = 0.9 time = 220
.meas tran vdout1_25ck43 FIND v(dout1_25) AT=220.025n

* CHECK dout1_26 Vdout1_26ck43 = 0.9 time = 220
.meas tran vdout1_26ck43 FIND v(dout1_26) AT=220.025n

* CHECK dout1_27 Vdout1_27ck43 = 0.9 time = 220
.meas tran vdout1_27ck43 FIND v(dout1_27) AT=220.025n

* CHECK dout1_28 Vdout1_28ck43 = 0 time = 220
.meas tran vdout1_28ck43 FIND v(dout1_28) AT=220.025n

* CHECK dout1_29 Vdout1_29ck43 = 0.9 time = 220
.meas tran vdout1_29ck43 FIND v(dout1_29) AT=220.025n

* CHECK dout1_30 Vdout1_30ck43 = 0.9 time = 220
.meas tran vdout1_30ck43 FIND v(dout1_30) AT=220.025n

* CHECK dout1_31 Vdout1_31ck43 = 0.9 time = 220
.meas tran vdout1_31ck43 FIND v(dout1_31) AT=220.025n

* CHECK dout1_32 Vdout1_32ck43 = 0.9 time = 220
.meas tran vdout1_32ck43 FIND v(dout1_32) AT=220.025n

* CHECK dout1_33 Vdout1_33ck43 = 0 time = 220
.meas tran vdout1_33ck43 FIND v(dout1_33) AT=220.025n

* CHECK dout1_34 Vdout1_34ck43 = 0 time = 220
.meas tran vdout1_34ck43 FIND v(dout1_34) AT=220.025n

* CHECK dout1_35 Vdout1_35ck43 = 0 time = 220
.meas tran vdout1_35ck43 FIND v(dout1_35) AT=220.025n

* CHECK dout1_36 Vdout1_36ck43 = 0 time = 220
.meas tran vdout1_36ck43 FIND v(dout1_36) AT=220.025n

* CHECK dout1_37 Vdout1_37ck43 = 0 time = 220
.meas tran vdout1_37ck43 FIND v(dout1_37) AT=220.025n

* CHECK dout1_38 Vdout1_38ck43 = 0 time = 220
.meas tran vdout1_38ck43 FIND v(dout1_38) AT=220.025n

* CHECK dout1_39 Vdout1_39ck43 = 0.9 time = 220
.meas tran vdout1_39ck43 FIND v(dout1_39) AT=220.025n

* CHECK dout1_40 Vdout1_40ck43 = 0 time = 220
.meas tran vdout1_40ck43 FIND v(dout1_40) AT=220.025n

* CHECK dout1_41 Vdout1_41ck43 = 0.9 time = 220
.meas tran vdout1_41ck43 FIND v(dout1_41) AT=220.025n

* CHECK dout1_42 Vdout1_42ck43 = 0.9 time = 220
.meas tran vdout1_42ck43 FIND v(dout1_42) AT=220.025n

* CHECK dout1_43 Vdout1_43ck43 = 0.9 time = 220
.meas tran vdout1_43ck43 FIND v(dout1_43) AT=220.025n

* CHECK dout1_44 Vdout1_44ck43 = 0 time = 220
.meas tran vdout1_44ck43 FIND v(dout1_44) AT=220.025n

* CHECK dout1_45 Vdout1_45ck43 = 0 time = 220
.meas tran vdout1_45ck43 FIND v(dout1_45) AT=220.025n

* CHECK dout1_46 Vdout1_46ck43 = 0 time = 220
.meas tran vdout1_46ck43 FIND v(dout1_46) AT=220.025n

* CHECK dout1_47 Vdout1_47ck43 = 0.9 time = 220
.meas tran vdout1_47ck43 FIND v(dout1_47) AT=220.025n

* CHECK dout1_48 Vdout1_48ck43 = 0 time = 220
.meas tran vdout1_48ck43 FIND v(dout1_48) AT=220.025n

* CHECK dout1_49 Vdout1_49ck43 = 0 time = 220
.meas tran vdout1_49ck43 FIND v(dout1_49) AT=220.025n

* CHECK dout1_50 Vdout1_50ck43 = 0.9 time = 220
.meas tran vdout1_50ck43 FIND v(dout1_50) AT=220.025n

* CHECK dout1_51 Vdout1_51ck43 = 0 time = 220
.meas tran vdout1_51ck43 FIND v(dout1_51) AT=220.025n

* CHECK dout1_52 Vdout1_52ck43 = 0.9 time = 220
.meas tran vdout1_52ck43 FIND v(dout1_52) AT=220.025n

* CHECK dout1_53 Vdout1_53ck43 = 0 time = 220
.meas tran vdout1_53ck43 FIND v(dout1_53) AT=220.025n

* CHECK dout1_54 Vdout1_54ck43 = 0.9 time = 220
.meas tran vdout1_54ck43 FIND v(dout1_54) AT=220.025n

* CHECK dout1_55 Vdout1_55ck43 = 0.9 time = 220
.meas tran vdout1_55ck43 FIND v(dout1_55) AT=220.025n

* CHECK dout1_56 Vdout1_56ck43 = 0 time = 220
.meas tran vdout1_56ck43 FIND v(dout1_56) AT=220.025n

* CHECK dout1_57 Vdout1_57ck43 = 0 time = 220
.meas tran vdout1_57ck43 FIND v(dout1_57) AT=220.025n

* CHECK dout1_58 Vdout1_58ck43 = 0 time = 220
.meas tran vdout1_58ck43 FIND v(dout1_58) AT=220.025n

* CHECK dout1_59 Vdout1_59ck43 = 0.9 time = 220
.meas tran vdout1_59ck43 FIND v(dout1_59) AT=220.025n

* CHECK dout1_60 Vdout1_60ck43 = 0.9 time = 220
.meas tran vdout1_60ck43 FIND v(dout1_60) AT=220.025n

* CHECK dout1_61 Vdout1_61ck43 = 0 time = 220
.meas tran vdout1_61ck43 FIND v(dout1_61) AT=220.025n

* CHECK dout1_62 Vdout1_62ck43 = 0 time = 220
.meas tran vdout1_62ck43 FIND v(dout1_62) AT=220.025n

* CHECK dout1_63 Vdout1_63ck43 = 0.9 time = 220
.meas tran vdout1_63ck43 FIND v(dout1_63) AT=220.025n

* CHECK dout1_64 Vdout1_64ck43 = 0.9 time = 220
.meas tran vdout1_64ck43 FIND v(dout1_64) AT=220.025n

* CHECK dout1_65 Vdout1_65ck43 = 0 time = 220
.meas tran vdout1_65ck43 FIND v(dout1_65) AT=220.025n

* CHECK dout1_66 Vdout1_66ck43 = 0 time = 220
.meas tran vdout1_66ck43 FIND v(dout1_66) AT=220.025n

* CHECK dout1_67 Vdout1_67ck43 = 0 time = 220
.meas tran vdout1_67ck43 FIND v(dout1_67) AT=220.025n

* CHECK dout1_68 Vdout1_68ck43 = 0 time = 220
.meas tran vdout1_68ck43 FIND v(dout1_68) AT=220.025n

* CHECK dout1_69 Vdout1_69ck43 = 0.9 time = 220
.meas tran vdout1_69ck43 FIND v(dout1_69) AT=220.025n

* CHECK dout1_70 Vdout1_70ck43 = 0 time = 220
.meas tran vdout1_70ck43 FIND v(dout1_70) AT=220.025n

* CHECK dout1_71 Vdout1_71ck43 = 0.9 time = 220
.meas tran vdout1_71ck43 FIND v(dout1_71) AT=220.025n

* CHECK dout1_72 Vdout1_72ck43 = 0 time = 220
.meas tran vdout1_72ck43 FIND v(dout1_72) AT=220.025n

* CHECK dout1_73 Vdout1_73ck43 = 0 time = 220
.meas tran vdout1_73ck43 FIND v(dout1_73) AT=220.025n

* CHECK dout1_74 Vdout1_74ck43 = 0.9 time = 220
.meas tran vdout1_74ck43 FIND v(dout1_74) AT=220.025n

* CHECK dout1_75 Vdout1_75ck43 = 0 time = 220
.meas tran vdout1_75ck43 FIND v(dout1_75) AT=220.025n

* CHECK dout1_76 Vdout1_76ck43 = 0 time = 220
.meas tran vdout1_76ck43 FIND v(dout1_76) AT=220.025n

* CHECK dout1_77 Vdout1_77ck43 = 0 time = 220
.meas tran vdout1_77ck43 FIND v(dout1_77) AT=220.025n

* CHECK dout1_78 Vdout1_78ck43 = 0 time = 220
.meas tran vdout1_78ck43 FIND v(dout1_78) AT=220.025n

* CHECK dout1_79 Vdout1_79ck43 = 0.9 time = 220
.meas tran vdout1_79ck43 FIND v(dout1_79) AT=220.025n

* CHECK dout1_80 Vdout1_80ck43 = 0 time = 220
.meas tran vdout1_80ck43 FIND v(dout1_80) AT=220.025n

* CHECK dout1_81 Vdout1_81ck43 = 0.9 time = 220
.meas tran vdout1_81ck43 FIND v(dout1_81) AT=220.025n

* CHECK dout1_82 Vdout1_82ck43 = 0.9 time = 220
.meas tran vdout1_82ck43 FIND v(dout1_82) AT=220.025n

* CHECK dout1_83 Vdout1_83ck43 = 0.9 time = 220
.meas tran vdout1_83ck43 FIND v(dout1_83) AT=220.025n

* CHECK dout1_84 Vdout1_84ck43 = 0.9 time = 220
.meas tran vdout1_84ck43 FIND v(dout1_84) AT=220.025n

* CHECK dout1_85 Vdout1_85ck43 = 0.9 time = 220
.meas tran vdout1_85ck43 FIND v(dout1_85) AT=220.025n

* CHECK dout1_86 Vdout1_86ck43 = 0 time = 220
.meas tran vdout1_86ck43 FIND v(dout1_86) AT=220.025n

* CHECK dout1_87 Vdout1_87ck43 = 0.9 time = 220
.meas tran vdout1_87ck43 FIND v(dout1_87) AT=220.025n

* CHECK dout1_88 Vdout1_88ck43 = 0.9 time = 220
.meas tran vdout1_88ck43 FIND v(dout1_88) AT=220.025n

* CHECK dout1_89 Vdout1_89ck43 = 0 time = 220
.meas tran vdout1_89ck43 FIND v(dout1_89) AT=220.025n

* CHECK dout1_90 Vdout1_90ck43 = 0.9 time = 220
.meas tran vdout1_90ck43 FIND v(dout1_90) AT=220.025n

* CHECK dout1_91 Vdout1_91ck43 = 0 time = 220
.meas tran vdout1_91ck43 FIND v(dout1_91) AT=220.025n

* CHECK dout1_92 Vdout1_92ck43 = 0.9 time = 220
.meas tran vdout1_92ck43 FIND v(dout1_92) AT=220.025n

* CHECK dout1_93 Vdout1_93ck43 = 0.9 time = 220
.meas tran vdout1_93ck43 FIND v(dout1_93) AT=220.025n

* CHECK dout1_94 Vdout1_94ck43 = 0 time = 220
.meas tran vdout1_94ck43 FIND v(dout1_94) AT=220.025n

* CHECK dout1_95 Vdout1_95ck43 = 0 time = 220
.meas tran vdout1_95ck43 FIND v(dout1_95) AT=220.025n

* CHECK dout1_96 Vdout1_96ck43 = 0.9 time = 220
.meas tran vdout1_96ck43 FIND v(dout1_96) AT=220.025n

* CHECK dout1_97 Vdout1_97ck43 = 0.9 time = 220
.meas tran vdout1_97ck43 FIND v(dout1_97) AT=220.025n

* CHECK dout1_98 Vdout1_98ck43 = 0 time = 220
.meas tran vdout1_98ck43 FIND v(dout1_98) AT=220.025n

* CHECK dout1_99 Vdout1_99ck43 = 0.9 time = 220
.meas tran vdout1_99ck43 FIND v(dout1_99) AT=220.025n

* CHECK dout1_100 Vdout1_100ck43 = 0.9 time = 220
.meas tran vdout1_100ck43 FIND v(dout1_100) AT=220.025n

* CHECK dout1_101 Vdout1_101ck43 = 0 time = 220
.meas tran vdout1_101ck43 FIND v(dout1_101) AT=220.025n

* CHECK dout1_102 Vdout1_102ck43 = 0 time = 220
.meas tran vdout1_102ck43 FIND v(dout1_102) AT=220.025n

* CHECK dout1_103 Vdout1_103ck43 = 0 time = 220
.meas tran vdout1_103ck43 FIND v(dout1_103) AT=220.025n

* CHECK dout1_104 Vdout1_104ck43 = 0 time = 220
.meas tran vdout1_104ck43 FIND v(dout1_104) AT=220.025n

* CHECK dout1_105 Vdout1_105ck43 = 0 time = 220
.meas tran vdout1_105ck43 FIND v(dout1_105) AT=220.025n

* CHECK dout1_106 Vdout1_106ck43 = 0.9 time = 220
.meas tran vdout1_106ck43 FIND v(dout1_106) AT=220.025n

* CHECK dout1_107 Vdout1_107ck43 = 0.9 time = 220
.meas tran vdout1_107ck43 FIND v(dout1_107) AT=220.025n

* CHECK dout1_108 Vdout1_108ck43 = 0.9 time = 220
.meas tran vdout1_108ck43 FIND v(dout1_108) AT=220.025n

* CHECK dout1_109 Vdout1_109ck43 = 0.9 time = 220
.meas tran vdout1_109ck43 FIND v(dout1_109) AT=220.025n

* CHECK dout1_110 Vdout1_110ck43 = 0 time = 220
.meas tran vdout1_110ck43 FIND v(dout1_110) AT=220.025n

* CHECK dout1_111 Vdout1_111ck43 = 0 time = 220
.meas tran vdout1_111ck43 FIND v(dout1_111) AT=220.025n

* CHECK dout1_112 Vdout1_112ck43 = 0.9 time = 220
.meas tran vdout1_112ck43 FIND v(dout1_112) AT=220.025n

* CHECK dout1_113 Vdout1_113ck43 = 0.9 time = 220
.meas tran vdout1_113ck43 FIND v(dout1_113) AT=220.025n

* CHECK dout1_114 Vdout1_114ck43 = 0 time = 220
.meas tran vdout1_114ck43 FIND v(dout1_114) AT=220.025n

* CHECK dout1_115 Vdout1_115ck43 = 0 time = 220
.meas tran vdout1_115ck43 FIND v(dout1_115) AT=220.025n

* CHECK dout1_116 Vdout1_116ck43 = 0.9 time = 220
.meas tran vdout1_116ck43 FIND v(dout1_116) AT=220.025n

* CHECK dout1_117 Vdout1_117ck43 = 0.9 time = 220
.meas tran vdout1_117ck43 FIND v(dout1_117) AT=220.025n

* CHECK dout1_118 Vdout1_118ck43 = 0 time = 220
.meas tran vdout1_118ck43 FIND v(dout1_118) AT=220.025n

* CHECK dout1_119 Vdout1_119ck43 = 0 time = 220
.meas tran vdout1_119ck43 FIND v(dout1_119) AT=220.025n

* CHECK dout1_0 Vdout1_0ck49 = 0 time = 250
.meas tran vdout1_0ck49 FIND v(dout1_0) AT=250.025n

* CHECK dout1_1 Vdout1_1ck49 = 0.9 time = 250
.meas tran vdout1_1ck49 FIND v(dout1_1) AT=250.025n

* CHECK dout1_2 Vdout1_2ck49 = 0 time = 250
.meas tran vdout1_2ck49 FIND v(dout1_2) AT=250.025n

* CHECK dout1_3 Vdout1_3ck49 = 0 time = 250
.meas tran vdout1_3ck49 FIND v(dout1_3) AT=250.025n

* CHECK dout1_4 Vdout1_4ck49 = 0 time = 250
.meas tran vdout1_4ck49 FIND v(dout1_4) AT=250.025n

* CHECK dout1_5 Vdout1_5ck49 = 0 time = 250
.meas tran vdout1_5ck49 FIND v(dout1_5) AT=250.025n

* CHECK dout1_6 Vdout1_6ck49 = 0 time = 250
.meas tran vdout1_6ck49 FIND v(dout1_6) AT=250.025n

* CHECK dout1_7 Vdout1_7ck49 = 0.9 time = 250
.meas tran vdout1_7ck49 FIND v(dout1_7) AT=250.025n

* CHECK dout1_8 Vdout1_8ck49 = 0.9 time = 250
.meas tran vdout1_8ck49 FIND v(dout1_8) AT=250.025n

* CHECK dout1_9 Vdout1_9ck49 = 0 time = 250
.meas tran vdout1_9ck49 FIND v(dout1_9) AT=250.025n

* CHECK dout1_10 Vdout1_10ck49 = 0 time = 250
.meas tran vdout1_10ck49 FIND v(dout1_10) AT=250.025n

* CHECK dout1_11 Vdout1_11ck49 = 0.9 time = 250
.meas tran vdout1_11ck49 FIND v(dout1_11) AT=250.025n

* CHECK dout1_12 Vdout1_12ck49 = 0.9 time = 250
.meas tran vdout1_12ck49 FIND v(dout1_12) AT=250.025n

* CHECK dout1_13 Vdout1_13ck49 = 0.9 time = 250
.meas tran vdout1_13ck49 FIND v(dout1_13) AT=250.025n

* CHECK dout1_14 Vdout1_14ck49 = 0.9 time = 250
.meas tran vdout1_14ck49 FIND v(dout1_14) AT=250.025n

* CHECK dout1_15 Vdout1_15ck49 = 0 time = 250
.meas tran vdout1_15ck49 FIND v(dout1_15) AT=250.025n

* CHECK dout1_16 Vdout1_16ck49 = 0.9 time = 250
.meas tran vdout1_16ck49 FIND v(dout1_16) AT=250.025n

* CHECK dout1_17 Vdout1_17ck49 = 0.9 time = 250
.meas tran vdout1_17ck49 FIND v(dout1_17) AT=250.025n

* CHECK dout1_18 Vdout1_18ck49 = 0.9 time = 250
.meas tran vdout1_18ck49 FIND v(dout1_18) AT=250.025n

* CHECK dout1_19 Vdout1_19ck49 = 0 time = 250
.meas tran vdout1_19ck49 FIND v(dout1_19) AT=250.025n

* CHECK dout1_20 Vdout1_20ck49 = 0 time = 250
.meas tran vdout1_20ck49 FIND v(dout1_20) AT=250.025n

* CHECK dout1_21 Vdout1_21ck49 = 0.9 time = 250
.meas tran vdout1_21ck49 FIND v(dout1_21) AT=250.025n

* CHECK dout1_22 Vdout1_22ck49 = 0.9 time = 250
.meas tran vdout1_22ck49 FIND v(dout1_22) AT=250.025n

* CHECK dout1_23 Vdout1_23ck49 = 0 time = 250
.meas tran vdout1_23ck49 FIND v(dout1_23) AT=250.025n

* CHECK dout1_24 Vdout1_24ck49 = 0 time = 250
.meas tran vdout1_24ck49 FIND v(dout1_24) AT=250.025n

* CHECK dout1_25 Vdout1_25ck49 = 0.9 time = 250
.meas tran vdout1_25ck49 FIND v(dout1_25) AT=250.025n

* CHECK dout1_26 Vdout1_26ck49 = 0.9 time = 250
.meas tran vdout1_26ck49 FIND v(dout1_26) AT=250.025n

* CHECK dout1_27 Vdout1_27ck49 = 0 time = 250
.meas tran vdout1_27ck49 FIND v(dout1_27) AT=250.025n

* CHECK dout1_28 Vdout1_28ck49 = 0.9 time = 250
.meas tran vdout1_28ck49 FIND v(dout1_28) AT=250.025n

* CHECK dout1_29 Vdout1_29ck49 = 0.9 time = 250
.meas tran vdout1_29ck49 FIND v(dout1_29) AT=250.025n

* CHECK dout1_30 Vdout1_30ck49 = 0.9 time = 250
.meas tran vdout1_30ck49 FIND v(dout1_30) AT=250.025n

* CHECK dout1_31 Vdout1_31ck49 = 0.9 time = 250
.meas tran vdout1_31ck49 FIND v(dout1_31) AT=250.025n

* CHECK dout1_32 Vdout1_32ck49 = 0.9 time = 250
.meas tran vdout1_32ck49 FIND v(dout1_32) AT=250.025n

* CHECK dout1_33 Vdout1_33ck49 = 0 time = 250
.meas tran vdout1_33ck49 FIND v(dout1_33) AT=250.025n

* CHECK dout1_34 Vdout1_34ck49 = 0.9 time = 250
.meas tran vdout1_34ck49 FIND v(dout1_34) AT=250.025n

* CHECK dout1_35 Vdout1_35ck49 = 0.9 time = 250
.meas tran vdout1_35ck49 FIND v(dout1_35) AT=250.025n

* CHECK dout1_36 Vdout1_36ck49 = 0 time = 250
.meas tran vdout1_36ck49 FIND v(dout1_36) AT=250.025n

* CHECK dout1_37 Vdout1_37ck49 = 0 time = 250
.meas tran vdout1_37ck49 FIND v(dout1_37) AT=250.025n

* CHECK dout1_38 Vdout1_38ck49 = 0.9 time = 250
.meas tran vdout1_38ck49 FIND v(dout1_38) AT=250.025n

* CHECK dout1_39 Vdout1_39ck49 = 0 time = 250
.meas tran vdout1_39ck49 FIND v(dout1_39) AT=250.025n

* CHECK dout1_40 Vdout1_40ck49 = 0.9 time = 250
.meas tran vdout1_40ck49 FIND v(dout1_40) AT=250.025n

* CHECK dout1_41 Vdout1_41ck49 = 0 time = 250
.meas tran vdout1_41ck49 FIND v(dout1_41) AT=250.025n

* CHECK dout1_42 Vdout1_42ck49 = 0.9 time = 250
.meas tran vdout1_42ck49 FIND v(dout1_42) AT=250.025n

* CHECK dout1_43 Vdout1_43ck49 = 0 time = 250
.meas tran vdout1_43ck49 FIND v(dout1_43) AT=250.025n

* CHECK dout1_44 Vdout1_44ck49 = 0.9 time = 250
.meas tran vdout1_44ck49 FIND v(dout1_44) AT=250.025n

* CHECK dout1_45 Vdout1_45ck49 = 0.9 time = 250
.meas tran vdout1_45ck49 FIND v(dout1_45) AT=250.025n

* CHECK dout1_46 Vdout1_46ck49 = 0 time = 250
.meas tran vdout1_46ck49 FIND v(dout1_46) AT=250.025n

* CHECK dout1_47 Vdout1_47ck49 = 0.9 time = 250
.meas tran vdout1_47ck49 FIND v(dout1_47) AT=250.025n

* CHECK dout1_48 Vdout1_48ck49 = 0 time = 250
.meas tran vdout1_48ck49 FIND v(dout1_48) AT=250.025n

* CHECK dout1_49 Vdout1_49ck49 = 0.9 time = 250
.meas tran vdout1_49ck49 FIND v(dout1_49) AT=250.025n

* CHECK dout1_50 Vdout1_50ck49 = 0.9 time = 250
.meas tran vdout1_50ck49 FIND v(dout1_50) AT=250.025n

* CHECK dout1_51 Vdout1_51ck49 = 0.9 time = 250
.meas tran vdout1_51ck49 FIND v(dout1_51) AT=250.025n

* CHECK dout1_52 Vdout1_52ck49 = 0.9 time = 250
.meas tran vdout1_52ck49 FIND v(dout1_52) AT=250.025n

* CHECK dout1_53 Vdout1_53ck49 = 0.9 time = 250
.meas tran vdout1_53ck49 FIND v(dout1_53) AT=250.025n

* CHECK dout1_54 Vdout1_54ck49 = 0.9 time = 250
.meas tran vdout1_54ck49 FIND v(dout1_54) AT=250.025n

* CHECK dout1_55 Vdout1_55ck49 = 0.9 time = 250
.meas tran vdout1_55ck49 FIND v(dout1_55) AT=250.025n

* CHECK dout1_56 Vdout1_56ck49 = 0.9 time = 250
.meas tran vdout1_56ck49 FIND v(dout1_56) AT=250.025n

* CHECK dout1_57 Vdout1_57ck49 = 0 time = 250
.meas tran vdout1_57ck49 FIND v(dout1_57) AT=250.025n

* CHECK dout1_58 Vdout1_58ck49 = 0 time = 250
.meas tran vdout1_58ck49 FIND v(dout1_58) AT=250.025n

* CHECK dout1_59 Vdout1_59ck49 = 0 time = 250
.meas tran vdout1_59ck49 FIND v(dout1_59) AT=250.025n

* CHECK dout1_60 Vdout1_60ck49 = 0 time = 250
.meas tran vdout1_60ck49 FIND v(dout1_60) AT=250.025n

* CHECK dout1_61 Vdout1_61ck49 = 0 time = 250
.meas tran vdout1_61ck49 FIND v(dout1_61) AT=250.025n

* CHECK dout1_62 Vdout1_62ck49 = 0 time = 250
.meas tran vdout1_62ck49 FIND v(dout1_62) AT=250.025n

* CHECK dout1_63 Vdout1_63ck49 = 0 time = 250
.meas tran vdout1_63ck49 FIND v(dout1_63) AT=250.025n

* CHECK dout1_64 Vdout1_64ck49 = 0.9 time = 250
.meas tran vdout1_64ck49 FIND v(dout1_64) AT=250.025n

* CHECK dout1_65 Vdout1_65ck49 = 0 time = 250
.meas tran vdout1_65ck49 FIND v(dout1_65) AT=250.025n

* CHECK dout1_66 Vdout1_66ck49 = 0.9 time = 250
.meas tran vdout1_66ck49 FIND v(dout1_66) AT=250.025n

* CHECK dout1_67 Vdout1_67ck49 = 0 time = 250
.meas tran vdout1_67ck49 FIND v(dout1_67) AT=250.025n

* CHECK dout1_68 Vdout1_68ck49 = 0 time = 250
.meas tran vdout1_68ck49 FIND v(dout1_68) AT=250.025n

* CHECK dout1_69 Vdout1_69ck49 = 0.9 time = 250
.meas tran vdout1_69ck49 FIND v(dout1_69) AT=250.025n

* CHECK dout1_70 Vdout1_70ck49 = 0.9 time = 250
.meas tran vdout1_70ck49 FIND v(dout1_70) AT=250.025n

* CHECK dout1_71 Vdout1_71ck49 = 0.9 time = 250
.meas tran vdout1_71ck49 FIND v(dout1_71) AT=250.025n

* CHECK dout1_72 Vdout1_72ck49 = 0.9 time = 250
.meas tran vdout1_72ck49 FIND v(dout1_72) AT=250.025n

* CHECK dout1_73 Vdout1_73ck49 = 0.9 time = 250
.meas tran vdout1_73ck49 FIND v(dout1_73) AT=250.025n

* CHECK dout1_74 Vdout1_74ck49 = 0 time = 250
.meas tran vdout1_74ck49 FIND v(dout1_74) AT=250.025n

* CHECK dout1_75 Vdout1_75ck49 = 0 time = 250
.meas tran vdout1_75ck49 FIND v(dout1_75) AT=250.025n

* CHECK dout1_76 Vdout1_76ck49 = 0.9 time = 250
.meas tran vdout1_76ck49 FIND v(dout1_76) AT=250.025n

* CHECK dout1_77 Vdout1_77ck49 = 0 time = 250
.meas tran vdout1_77ck49 FIND v(dout1_77) AT=250.025n

* CHECK dout1_78 Vdout1_78ck49 = 0.9 time = 250
.meas tran vdout1_78ck49 FIND v(dout1_78) AT=250.025n

* CHECK dout1_79 Vdout1_79ck49 = 0.9 time = 250
.meas tran vdout1_79ck49 FIND v(dout1_79) AT=250.025n

* CHECK dout1_80 Vdout1_80ck49 = 0 time = 250
.meas tran vdout1_80ck49 FIND v(dout1_80) AT=250.025n

* CHECK dout1_81 Vdout1_81ck49 = 0.9 time = 250
.meas tran vdout1_81ck49 FIND v(dout1_81) AT=250.025n

* CHECK dout1_82 Vdout1_82ck49 = 0.9 time = 250
.meas tran vdout1_82ck49 FIND v(dout1_82) AT=250.025n

* CHECK dout1_83 Vdout1_83ck49 = 0 time = 250
.meas tran vdout1_83ck49 FIND v(dout1_83) AT=250.025n

* CHECK dout1_84 Vdout1_84ck49 = 0.9 time = 250
.meas tran vdout1_84ck49 FIND v(dout1_84) AT=250.025n

* CHECK dout1_85 Vdout1_85ck49 = 0 time = 250
.meas tran vdout1_85ck49 FIND v(dout1_85) AT=250.025n

* CHECK dout1_86 Vdout1_86ck49 = 0 time = 250
.meas tran vdout1_86ck49 FIND v(dout1_86) AT=250.025n

* CHECK dout1_87 Vdout1_87ck49 = 0.9 time = 250
.meas tran vdout1_87ck49 FIND v(dout1_87) AT=250.025n

* CHECK dout1_88 Vdout1_88ck49 = 0.9 time = 250
.meas tran vdout1_88ck49 FIND v(dout1_88) AT=250.025n

* CHECK dout1_89 Vdout1_89ck49 = 0 time = 250
.meas tran vdout1_89ck49 FIND v(dout1_89) AT=250.025n

* CHECK dout1_90 Vdout1_90ck49 = 0.9 time = 250
.meas tran vdout1_90ck49 FIND v(dout1_90) AT=250.025n

* CHECK dout1_91 Vdout1_91ck49 = 0.9 time = 250
.meas tran vdout1_91ck49 FIND v(dout1_91) AT=250.025n

* CHECK dout1_92 Vdout1_92ck49 = 0 time = 250
.meas tran vdout1_92ck49 FIND v(dout1_92) AT=250.025n

* CHECK dout1_93 Vdout1_93ck49 = 0 time = 250
.meas tran vdout1_93ck49 FIND v(dout1_93) AT=250.025n

* CHECK dout1_94 Vdout1_94ck49 = 0 time = 250
.meas tran vdout1_94ck49 FIND v(dout1_94) AT=250.025n

* CHECK dout1_95 Vdout1_95ck49 = 0 time = 250
.meas tran vdout1_95ck49 FIND v(dout1_95) AT=250.025n

* CHECK dout1_96 Vdout1_96ck49 = 0.9 time = 250
.meas tran vdout1_96ck49 FIND v(dout1_96) AT=250.025n

* CHECK dout1_97 Vdout1_97ck49 = 0 time = 250
.meas tran vdout1_97ck49 FIND v(dout1_97) AT=250.025n

* CHECK dout1_98 Vdout1_98ck49 = 0.9 time = 250
.meas tran vdout1_98ck49 FIND v(dout1_98) AT=250.025n

* CHECK dout1_99 Vdout1_99ck49 = 0.9 time = 250
.meas tran vdout1_99ck49 FIND v(dout1_99) AT=250.025n

* CHECK dout1_100 Vdout1_100ck49 = 0.9 time = 250
.meas tran vdout1_100ck49 FIND v(dout1_100) AT=250.025n

* CHECK dout1_101 Vdout1_101ck49 = 0 time = 250
.meas tran vdout1_101ck49 FIND v(dout1_101) AT=250.025n

* CHECK dout1_102 Vdout1_102ck49 = 0.9 time = 250
.meas tran vdout1_102ck49 FIND v(dout1_102) AT=250.025n

* CHECK dout1_103 Vdout1_103ck49 = 0.9 time = 250
.meas tran vdout1_103ck49 FIND v(dout1_103) AT=250.025n

* CHECK dout1_104 Vdout1_104ck49 = 0 time = 250
.meas tran vdout1_104ck49 FIND v(dout1_104) AT=250.025n

* CHECK dout1_105 Vdout1_105ck49 = 0 time = 250
.meas tran vdout1_105ck49 FIND v(dout1_105) AT=250.025n

* CHECK dout1_106 Vdout1_106ck49 = 0 time = 250
.meas tran vdout1_106ck49 FIND v(dout1_106) AT=250.025n

* CHECK dout1_107 Vdout1_107ck49 = 0 time = 250
.meas tran vdout1_107ck49 FIND v(dout1_107) AT=250.025n

* CHECK dout1_108 Vdout1_108ck49 = 0.9 time = 250
.meas tran vdout1_108ck49 FIND v(dout1_108) AT=250.025n

* CHECK dout1_109 Vdout1_109ck49 = 0 time = 250
.meas tran vdout1_109ck49 FIND v(dout1_109) AT=250.025n

* CHECK dout1_110 Vdout1_110ck49 = 0.9 time = 250
.meas tran vdout1_110ck49 FIND v(dout1_110) AT=250.025n

* CHECK dout1_111 Vdout1_111ck49 = 0.9 time = 250
.meas tran vdout1_111ck49 FIND v(dout1_111) AT=250.025n

* CHECK dout1_112 Vdout1_112ck49 = 0.9 time = 250
.meas tran vdout1_112ck49 FIND v(dout1_112) AT=250.025n

* CHECK dout1_113 Vdout1_113ck49 = 0.9 time = 250
.meas tran vdout1_113ck49 FIND v(dout1_113) AT=250.025n

* CHECK dout1_114 Vdout1_114ck49 = 0 time = 250
.meas tran vdout1_114ck49 FIND v(dout1_114) AT=250.025n

* CHECK dout1_115 Vdout1_115ck49 = 0.9 time = 250
.meas tran vdout1_115ck49 FIND v(dout1_115) AT=250.025n

* CHECK dout1_116 Vdout1_116ck49 = 0.9 time = 250
.meas tran vdout1_116ck49 FIND v(dout1_116) AT=250.025n

* CHECK dout1_117 Vdout1_117ck49 = 0.9 time = 250
.meas tran vdout1_117ck49 FIND v(dout1_117) AT=250.025n

* CHECK dout1_118 Vdout1_118ck49 = 0.9 time = 250
.meas tran vdout1_118ck49 FIND v(dout1_118) AT=250.025n

* CHECK dout1_119 Vdout1_119ck49 = 0.9 time = 250
.meas tran vdout1_119ck49 FIND v(dout1_119) AT=250.025n

* CHECK dout1_0 Vdout1_0ck55 = 0 time = 280
.meas tran vdout1_0ck55 FIND v(dout1_0) AT=280.025n

* CHECK dout1_1 Vdout1_1ck55 = 0 time = 280
.meas tran vdout1_1ck55 FIND v(dout1_1) AT=280.025n

* CHECK dout1_2 Vdout1_2ck55 = 0 time = 280
.meas tran vdout1_2ck55 FIND v(dout1_2) AT=280.025n

* CHECK dout1_3 Vdout1_3ck55 = 0 time = 280
.meas tran vdout1_3ck55 FIND v(dout1_3) AT=280.025n

* CHECK dout1_4 Vdout1_4ck55 = 0 time = 280
.meas tran vdout1_4ck55 FIND v(dout1_4) AT=280.025n

* CHECK dout1_5 Vdout1_5ck55 = 0 time = 280
.meas tran vdout1_5ck55 FIND v(dout1_5) AT=280.025n

* CHECK dout1_6 Vdout1_6ck55 = 0.9 time = 280
.meas tran vdout1_6ck55 FIND v(dout1_6) AT=280.025n

* CHECK dout1_7 Vdout1_7ck55 = 0.9 time = 280
.meas tran vdout1_7ck55 FIND v(dout1_7) AT=280.025n

* CHECK dout1_8 Vdout1_8ck55 = 0 time = 280
.meas tran vdout1_8ck55 FIND v(dout1_8) AT=280.025n

* CHECK dout1_9 Vdout1_9ck55 = 0.9 time = 280
.meas tran vdout1_9ck55 FIND v(dout1_9) AT=280.025n

* CHECK dout1_10 Vdout1_10ck55 = 0 time = 280
.meas tran vdout1_10ck55 FIND v(dout1_10) AT=280.025n

* CHECK dout1_11 Vdout1_11ck55 = 0.9 time = 280
.meas tran vdout1_11ck55 FIND v(dout1_11) AT=280.025n

* CHECK dout1_12 Vdout1_12ck55 = 0.9 time = 280
.meas tran vdout1_12ck55 FIND v(dout1_12) AT=280.025n

* CHECK dout1_13 Vdout1_13ck55 = 0.9 time = 280
.meas tran vdout1_13ck55 FIND v(dout1_13) AT=280.025n

* CHECK dout1_14 Vdout1_14ck55 = 0.9 time = 280
.meas tran vdout1_14ck55 FIND v(dout1_14) AT=280.025n

* CHECK dout1_15 Vdout1_15ck55 = 0 time = 280
.meas tran vdout1_15ck55 FIND v(dout1_15) AT=280.025n

* CHECK dout1_16 Vdout1_16ck55 = 0.9 time = 280
.meas tran vdout1_16ck55 FIND v(dout1_16) AT=280.025n

* CHECK dout1_17 Vdout1_17ck55 = 0 time = 280
.meas tran vdout1_17ck55 FIND v(dout1_17) AT=280.025n

* CHECK dout1_18 Vdout1_18ck55 = 0.9 time = 280
.meas tran vdout1_18ck55 FIND v(dout1_18) AT=280.025n

* CHECK dout1_19 Vdout1_19ck55 = 0 time = 280
.meas tran vdout1_19ck55 FIND v(dout1_19) AT=280.025n

* CHECK dout1_20 Vdout1_20ck55 = 0.9 time = 280
.meas tran vdout1_20ck55 FIND v(dout1_20) AT=280.025n

* CHECK dout1_21 Vdout1_21ck55 = 0 time = 280
.meas tran vdout1_21ck55 FIND v(dout1_21) AT=280.025n

* CHECK dout1_22 Vdout1_22ck55 = 0 time = 280
.meas tran vdout1_22ck55 FIND v(dout1_22) AT=280.025n

* CHECK dout1_23 Vdout1_23ck55 = 0 time = 280
.meas tran vdout1_23ck55 FIND v(dout1_23) AT=280.025n

* CHECK dout1_24 Vdout1_24ck55 = 0 time = 280
.meas tran vdout1_24ck55 FIND v(dout1_24) AT=280.025n

* CHECK dout1_25 Vdout1_25ck55 = 0 time = 280
.meas tran vdout1_25ck55 FIND v(dout1_25) AT=280.025n

* CHECK dout1_26 Vdout1_26ck55 = 0 time = 280
.meas tran vdout1_26ck55 FIND v(dout1_26) AT=280.025n

* CHECK dout1_27 Vdout1_27ck55 = 0.9 time = 280
.meas tran vdout1_27ck55 FIND v(dout1_27) AT=280.025n

* CHECK dout1_28 Vdout1_28ck55 = 0.9 time = 280
.meas tran vdout1_28ck55 FIND v(dout1_28) AT=280.025n

* CHECK dout1_29 Vdout1_29ck55 = 0 time = 280
.meas tran vdout1_29ck55 FIND v(dout1_29) AT=280.025n

* CHECK dout1_30 Vdout1_30ck55 = 0 time = 280
.meas tran vdout1_30ck55 FIND v(dout1_30) AT=280.025n

* CHECK dout1_31 Vdout1_31ck55 = 0.9 time = 280
.meas tran vdout1_31ck55 FIND v(dout1_31) AT=280.025n

* CHECK dout1_32 Vdout1_32ck55 = 0 time = 280
.meas tran vdout1_32ck55 FIND v(dout1_32) AT=280.025n

* CHECK dout1_33 Vdout1_33ck55 = 0.9 time = 280
.meas tran vdout1_33ck55 FIND v(dout1_33) AT=280.025n

* CHECK dout1_34 Vdout1_34ck55 = 0.9 time = 280
.meas tran vdout1_34ck55 FIND v(dout1_34) AT=280.025n

* CHECK dout1_35 Vdout1_35ck55 = 0 time = 280
.meas tran vdout1_35ck55 FIND v(dout1_35) AT=280.025n

* CHECK dout1_36 Vdout1_36ck55 = 0 time = 280
.meas tran vdout1_36ck55 FIND v(dout1_36) AT=280.025n

* CHECK dout1_37 Vdout1_37ck55 = 0 time = 280
.meas tran vdout1_37ck55 FIND v(dout1_37) AT=280.025n

* CHECK dout1_38 Vdout1_38ck55 = 0.9 time = 280
.meas tran vdout1_38ck55 FIND v(dout1_38) AT=280.025n

* CHECK dout1_39 Vdout1_39ck55 = 0.9 time = 280
.meas tran vdout1_39ck55 FIND v(dout1_39) AT=280.025n

* CHECK dout1_40 Vdout1_40ck55 = 0 time = 280
.meas tran vdout1_40ck55 FIND v(dout1_40) AT=280.025n

* CHECK dout1_41 Vdout1_41ck55 = 0 time = 280
.meas tran vdout1_41ck55 FIND v(dout1_41) AT=280.025n

* CHECK dout1_42 Vdout1_42ck55 = 0.9 time = 280
.meas tran vdout1_42ck55 FIND v(dout1_42) AT=280.025n

* CHECK dout1_43 Vdout1_43ck55 = 0.9 time = 280
.meas tran vdout1_43ck55 FIND v(dout1_43) AT=280.025n

* CHECK dout1_44 Vdout1_44ck55 = 0.9 time = 280
.meas tran vdout1_44ck55 FIND v(dout1_44) AT=280.025n

* CHECK dout1_45 Vdout1_45ck55 = 0.9 time = 280
.meas tran vdout1_45ck55 FIND v(dout1_45) AT=280.025n

* CHECK dout1_46 Vdout1_46ck55 = 0.9 time = 280
.meas tran vdout1_46ck55 FIND v(dout1_46) AT=280.025n

* CHECK dout1_47 Vdout1_47ck55 = 0.9 time = 280
.meas tran vdout1_47ck55 FIND v(dout1_47) AT=280.025n

* CHECK dout1_48 Vdout1_48ck55 = 0.9 time = 280
.meas tran vdout1_48ck55 FIND v(dout1_48) AT=280.025n

* CHECK dout1_49 Vdout1_49ck55 = 0.9 time = 280
.meas tran vdout1_49ck55 FIND v(dout1_49) AT=280.025n

* CHECK dout1_50 Vdout1_50ck55 = 0 time = 280
.meas tran vdout1_50ck55 FIND v(dout1_50) AT=280.025n

* CHECK dout1_51 Vdout1_51ck55 = 0.9 time = 280
.meas tran vdout1_51ck55 FIND v(dout1_51) AT=280.025n

* CHECK dout1_52 Vdout1_52ck55 = 0 time = 280
.meas tran vdout1_52ck55 FIND v(dout1_52) AT=280.025n

* CHECK dout1_53 Vdout1_53ck55 = 0.9 time = 280
.meas tran vdout1_53ck55 FIND v(dout1_53) AT=280.025n

* CHECK dout1_54 Vdout1_54ck55 = 0.9 time = 280
.meas tran vdout1_54ck55 FIND v(dout1_54) AT=280.025n

* CHECK dout1_55 Vdout1_55ck55 = 0.9 time = 280
.meas tran vdout1_55ck55 FIND v(dout1_55) AT=280.025n

* CHECK dout1_56 Vdout1_56ck55 = 0 time = 280
.meas tran vdout1_56ck55 FIND v(dout1_56) AT=280.025n

* CHECK dout1_57 Vdout1_57ck55 = 0 time = 280
.meas tran vdout1_57ck55 FIND v(dout1_57) AT=280.025n

* CHECK dout1_58 Vdout1_58ck55 = 0.9 time = 280
.meas tran vdout1_58ck55 FIND v(dout1_58) AT=280.025n

* CHECK dout1_59 Vdout1_59ck55 = 0.9 time = 280
.meas tran vdout1_59ck55 FIND v(dout1_59) AT=280.025n

* CHECK dout1_60 Vdout1_60ck55 = 0 time = 280
.meas tran vdout1_60ck55 FIND v(dout1_60) AT=280.025n

* CHECK dout1_61 Vdout1_61ck55 = 0 time = 280
.meas tran vdout1_61ck55 FIND v(dout1_61) AT=280.025n

* CHECK dout1_62 Vdout1_62ck55 = 0.9 time = 280
.meas tran vdout1_62ck55 FIND v(dout1_62) AT=280.025n

* CHECK dout1_63 Vdout1_63ck55 = 0.9 time = 280
.meas tran vdout1_63ck55 FIND v(dout1_63) AT=280.025n

* CHECK dout1_64 Vdout1_64ck55 = 0 time = 280
.meas tran vdout1_64ck55 FIND v(dout1_64) AT=280.025n

* CHECK dout1_65 Vdout1_65ck55 = 0.9 time = 280
.meas tran vdout1_65ck55 FIND v(dout1_65) AT=280.025n

* CHECK dout1_66 Vdout1_66ck55 = 0.9 time = 280
.meas tran vdout1_66ck55 FIND v(dout1_66) AT=280.025n

* CHECK dout1_67 Vdout1_67ck55 = 0 time = 280
.meas tran vdout1_67ck55 FIND v(dout1_67) AT=280.025n

* CHECK dout1_68 Vdout1_68ck55 = 0.9 time = 280
.meas tran vdout1_68ck55 FIND v(dout1_68) AT=280.025n

* CHECK dout1_69 Vdout1_69ck55 = 0.9 time = 280
.meas tran vdout1_69ck55 FIND v(dout1_69) AT=280.025n

* CHECK dout1_70 Vdout1_70ck55 = 0 time = 280
.meas tran vdout1_70ck55 FIND v(dout1_70) AT=280.025n

* CHECK dout1_71 Vdout1_71ck55 = 0.9 time = 280
.meas tran vdout1_71ck55 FIND v(dout1_71) AT=280.025n

* CHECK dout1_72 Vdout1_72ck55 = 0.9 time = 280
.meas tran vdout1_72ck55 FIND v(dout1_72) AT=280.025n

* CHECK dout1_73 Vdout1_73ck55 = 0 time = 280
.meas tran vdout1_73ck55 FIND v(dout1_73) AT=280.025n

* CHECK dout1_74 Vdout1_74ck55 = 0 time = 280
.meas tran vdout1_74ck55 FIND v(dout1_74) AT=280.025n

* CHECK dout1_75 Vdout1_75ck55 = 0 time = 280
.meas tran vdout1_75ck55 FIND v(dout1_75) AT=280.025n

* CHECK dout1_76 Vdout1_76ck55 = 0.9 time = 280
.meas tran vdout1_76ck55 FIND v(dout1_76) AT=280.025n

* CHECK dout1_77 Vdout1_77ck55 = 0 time = 280
.meas tran vdout1_77ck55 FIND v(dout1_77) AT=280.025n

* CHECK dout1_78 Vdout1_78ck55 = 0 time = 280
.meas tran vdout1_78ck55 FIND v(dout1_78) AT=280.025n

* CHECK dout1_79 Vdout1_79ck55 = 0 time = 280
.meas tran vdout1_79ck55 FIND v(dout1_79) AT=280.025n

* CHECK dout1_80 Vdout1_80ck55 = 0.9 time = 280
.meas tran vdout1_80ck55 FIND v(dout1_80) AT=280.025n

* CHECK dout1_81 Vdout1_81ck55 = 0.9 time = 280
.meas tran vdout1_81ck55 FIND v(dout1_81) AT=280.025n

* CHECK dout1_82 Vdout1_82ck55 = 0 time = 280
.meas tran vdout1_82ck55 FIND v(dout1_82) AT=280.025n

* CHECK dout1_83 Vdout1_83ck55 = 0 time = 280
.meas tran vdout1_83ck55 FIND v(dout1_83) AT=280.025n

* CHECK dout1_84 Vdout1_84ck55 = 0 time = 280
.meas tran vdout1_84ck55 FIND v(dout1_84) AT=280.025n

* CHECK dout1_85 Vdout1_85ck55 = 0 time = 280
.meas tran vdout1_85ck55 FIND v(dout1_85) AT=280.025n

* CHECK dout1_86 Vdout1_86ck55 = 0.9 time = 280
.meas tran vdout1_86ck55 FIND v(dout1_86) AT=280.025n

* CHECK dout1_87 Vdout1_87ck55 = 0.9 time = 280
.meas tran vdout1_87ck55 FIND v(dout1_87) AT=280.025n

* CHECK dout1_88 Vdout1_88ck55 = 0.9 time = 280
.meas tran vdout1_88ck55 FIND v(dout1_88) AT=280.025n

* CHECK dout1_89 Vdout1_89ck55 = 0 time = 280
.meas tran vdout1_89ck55 FIND v(dout1_89) AT=280.025n

* CHECK dout1_90 Vdout1_90ck55 = 0.9 time = 280
.meas tran vdout1_90ck55 FIND v(dout1_90) AT=280.025n

* CHECK dout1_91 Vdout1_91ck55 = 0 time = 280
.meas tran vdout1_91ck55 FIND v(dout1_91) AT=280.025n

* CHECK dout1_92 Vdout1_92ck55 = 0.9 time = 280
.meas tran vdout1_92ck55 FIND v(dout1_92) AT=280.025n

* CHECK dout1_93 Vdout1_93ck55 = 0 time = 280
.meas tran vdout1_93ck55 FIND v(dout1_93) AT=280.025n

* CHECK dout1_94 Vdout1_94ck55 = 0.9 time = 280
.meas tran vdout1_94ck55 FIND v(dout1_94) AT=280.025n

* CHECK dout1_95 Vdout1_95ck55 = 0.9 time = 280
.meas tran vdout1_95ck55 FIND v(dout1_95) AT=280.025n

* CHECK dout1_96 Vdout1_96ck55 = 0 time = 280
.meas tran vdout1_96ck55 FIND v(dout1_96) AT=280.025n

* CHECK dout1_97 Vdout1_97ck55 = 0 time = 280
.meas tran vdout1_97ck55 FIND v(dout1_97) AT=280.025n

* CHECK dout1_98 Vdout1_98ck55 = 0 time = 280
.meas tran vdout1_98ck55 FIND v(dout1_98) AT=280.025n

* CHECK dout1_99 Vdout1_99ck55 = 0 time = 280
.meas tran vdout1_99ck55 FIND v(dout1_99) AT=280.025n

* CHECK dout1_100 Vdout1_100ck55 = 0 time = 280
.meas tran vdout1_100ck55 FIND v(dout1_100) AT=280.025n

* CHECK dout1_101 Vdout1_101ck55 = 0 time = 280
.meas tran vdout1_101ck55 FIND v(dout1_101) AT=280.025n

* CHECK dout1_102 Vdout1_102ck55 = 0.9 time = 280
.meas tran vdout1_102ck55 FIND v(dout1_102) AT=280.025n

* CHECK dout1_103 Vdout1_103ck55 = 0 time = 280
.meas tran vdout1_103ck55 FIND v(dout1_103) AT=280.025n

* CHECK dout1_104 Vdout1_104ck55 = 0.9 time = 280
.meas tran vdout1_104ck55 FIND v(dout1_104) AT=280.025n

* CHECK dout1_105 Vdout1_105ck55 = 0.9 time = 280
.meas tran vdout1_105ck55 FIND v(dout1_105) AT=280.025n

* CHECK dout1_106 Vdout1_106ck55 = 0 time = 280
.meas tran vdout1_106ck55 FIND v(dout1_106) AT=280.025n

* CHECK dout1_107 Vdout1_107ck55 = 0.9 time = 280
.meas tran vdout1_107ck55 FIND v(dout1_107) AT=280.025n

* CHECK dout1_108 Vdout1_108ck55 = 0 time = 280
.meas tran vdout1_108ck55 FIND v(dout1_108) AT=280.025n

* CHECK dout1_109 Vdout1_109ck55 = 0.9 time = 280
.meas tran vdout1_109ck55 FIND v(dout1_109) AT=280.025n

* CHECK dout1_110 Vdout1_110ck55 = 0 time = 280
.meas tran vdout1_110ck55 FIND v(dout1_110) AT=280.025n

* CHECK dout1_111 Vdout1_111ck55 = 0.9 time = 280
.meas tran vdout1_111ck55 FIND v(dout1_111) AT=280.025n

* CHECK dout1_112 Vdout1_112ck55 = 0 time = 280
.meas tran vdout1_112ck55 FIND v(dout1_112) AT=280.025n

* CHECK dout1_113 Vdout1_113ck55 = 0.9 time = 280
.meas tran vdout1_113ck55 FIND v(dout1_113) AT=280.025n

* CHECK dout1_114 Vdout1_114ck55 = 0.9 time = 280
.meas tran vdout1_114ck55 FIND v(dout1_114) AT=280.025n

* CHECK dout1_115 Vdout1_115ck55 = 0 time = 280
.meas tran vdout1_115ck55 FIND v(dout1_115) AT=280.025n

* CHECK dout1_116 Vdout1_116ck55 = 0.9 time = 280
.meas tran vdout1_116ck55 FIND v(dout1_116) AT=280.025n

* CHECK dout1_117 Vdout1_117ck55 = 0 time = 280
.meas tran vdout1_117ck55 FIND v(dout1_117) AT=280.025n

* CHECK dout1_118 Vdout1_118ck55 = 0.9 time = 280
.meas tran vdout1_118ck55 FIND v(dout1_118) AT=280.025n

* CHECK dout1_119 Vdout1_119ck55 = 0.9 time = 280
.meas tran vdout1_119ck55 FIND v(dout1_119) AT=280.025n

* CHECK dout1_0 Vdout1_0ck64 = 0.9 time = 325
.meas tran vdout1_0ck64 FIND v(dout1_0) AT=325.025n

* CHECK dout1_1 Vdout1_1ck64 = 0 time = 325
.meas tran vdout1_1ck64 FIND v(dout1_1) AT=325.025n

* CHECK dout1_2 Vdout1_2ck64 = 0.9 time = 325
.meas tran vdout1_2ck64 FIND v(dout1_2) AT=325.025n

* CHECK dout1_3 Vdout1_3ck64 = 0 time = 325
.meas tran vdout1_3ck64 FIND v(dout1_3) AT=325.025n

* CHECK dout1_4 Vdout1_4ck64 = 0 time = 325
.meas tran vdout1_4ck64 FIND v(dout1_4) AT=325.025n

* CHECK dout1_5 Vdout1_5ck64 = 0.9 time = 325
.meas tran vdout1_5ck64 FIND v(dout1_5) AT=325.025n

* CHECK dout1_6 Vdout1_6ck64 = 0.9 time = 325
.meas tran vdout1_6ck64 FIND v(dout1_6) AT=325.025n

* CHECK dout1_7 Vdout1_7ck64 = 0 time = 325
.meas tran vdout1_7ck64 FIND v(dout1_7) AT=325.025n

* CHECK dout1_8 Vdout1_8ck64 = 0.9 time = 325
.meas tran vdout1_8ck64 FIND v(dout1_8) AT=325.025n

* CHECK dout1_9 Vdout1_9ck64 = 0.9 time = 325
.meas tran vdout1_9ck64 FIND v(dout1_9) AT=325.025n

* CHECK dout1_10 Vdout1_10ck64 = 0.9 time = 325
.meas tran vdout1_10ck64 FIND v(dout1_10) AT=325.025n

* CHECK dout1_11 Vdout1_11ck64 = 0 time = 325
.meas tran vdout1_11ck64 FIND v(dout1_11) AT=325.025n

* CHECK dout1_12 Vdout1_12ck64 = 0 time = 325
.meas tran vdout1_12ck64 FIND v(dout1_12) AT=325.025n

* CHECK dout1_13 Vdout1_13ck64 = 0 time = 325
.meas tran vdout1_13ck64 FIND v(dout1_13) AT=325.025n

* CHECK dout1_14 Vdout1_14ck64 = 0 time = 325
.meas tran vdout1_14ck64 FIND v(dout1_14) AT=325.025n

* CHECK dout1_15 Vdout1_15ck64 = 0.9 time = 325
.meas tran vdout1_15ck64 FIND v(dout1_15) AT=325.025n

* CHECK dout1_16 Vdout1_16ck64 = 0.9 time = 325
.meas tran vdout1_16ck64 FIND v(dout1_16) AT=325.025n

* CHECK dout1_17 Vdout1_17ck64 = 0 time = 325
.meas tran vdout1_17ck64 FIND v(dout1_17) AT=325.025n

* CHECK dout1_18 Vdout1_18ck64 = 0.9 time = 325
.meas tran vdout1_18ck64 FIND v(dout1_18) AT=325.025n

* CHECK dout1_19 Vdout1_19ck64 = 0.9 time = 325
.meas tran vdout1_19ck64 FIND v(dout1_19) AT=325.025n

* CHECK dout1_20 Vdout1_20ck64 = 0.9 time = 325
.meas tran vdout1_20ck64 FIND v(dout1_20) AT=325.025n

* CHECK dout1_21 Vdout1_21ck64 = 0.9 time = 325
.meas tran vdout1_21ck64 FIND v(dout1_21) AT=325.025n

* CHECK dout1_22 Vdout1_22ck64 = 0 time = 325
.meas tran vdout1_22ck64 FIND v(dout1_22) AT=325.025n

* CHECK dout1_23 Vdout1_23ck64 = 0 time = 325
.meas tran vdout1_23ck64 FIND v(dout1_23) AT=325.025n

* CHECK dout1_24 Vdout1_24ck64 = 0 time = 325
.meas tran vdout1_24ck64 FIND v(dout1_24) AT=325.025n

* CHECK dout1_25 Vdout1_25ck64 = 0.9 time = 325
.meas tran vdout1_25ck64 FIND v(dout1_25) AT=325.025n

* CHECK dout1_26 Vdout1_26ck64 = 0 time = 325
.meas tran vdout1_26ck64 FIND v(dout1_26) AT=325.025n

* CHECK dout1_27 Vdout1_27ck64 = 0.9 time = 325
.meas tran vdout1_27ck64 FIND v(dout1_27) AT=325.025n

* CHECK dout1_28 Vdout1_28ck64 = 0 time = 325
.meas tran vdout1_28ck64 FIND v(dout1_28) AT=325.025n

* CHECK dout1_29 Vdout1_29ck64 = 0.9 time = 325
.meas tran vdout1_29ck64 FIND v(dout1_29) AT=325.025n

* CHECK dout1_30 Vdout1_30ck64 = 0 time = 325
.meas tran vdout1_30ck64 FIND v(dout1_30) AT=325.025n

* CHECK dout1_31 Vdout1_31ck64 = 0 time = 325
.meas tran vdout1_31ck64 FIND v(dout1_31) AT=325.025n

* CHECK dout1_32 Vdout1_32ck64 = 0 time = 325
.meas tran vdout1_32ck64 FIND v(dout1_32) AT=325.025n

* CHECK dout1_33 Vdout1_33ck64 = 0.9 time = 325
.meas tran vdout1_33ck64 FIND v(dout1_33) AT=325.025n

* CHECK dout1_34 Vdout1_34ck64 = 0 time = 325
.meas tran vdout1_34ck64 FIND v(dout1_34) AT=325.025n

* CHECK dout1_35 Vdout1_35ck64 = 0.9 time = 325
.meas tran vdout1_35ck64 FIND v(dout1_35) AT=325.025n

* CHECK dout1_36 Vdout1_36ck64 = 0.9 time = 325
.meas tran vdout1_36ck64 FIND v(dout1_36) AT=325.025n

* CHECK dout1_37 Vdout1_37ck64 = 0.9 time = 325
.meas tran vdout1_37ck64 FIND v(dout1_37) AT=325.025n

* CHECK dout1_38 Vdout1_38ck64 = 0 time = 325
.meas tran vdout1_38ck64 FIND v(dout1_38) AT=325.025n

* CHECK dout1_39 Vdout1_39ck64 = 0 time = 325
.meas tran vdout1_39ck64 FIND v(dout1_39) AT=325.025n

* CHECK dout1_40 Vdout1_40ck64 = 0.9 time = 325
.meas tran vdout1_40ck64 FIND v(dout1_40) AT=325.025n

* CHECK dout1_41 Vdout1_41ck64 = 0 time = 325
.meas tran vdout1_41ck64 FIND v(dout1_41) AT=325.025n

* CHECK dout1_42 Vdout1_42ck64 = 0.9 time = 325
.meas tran vdout1_42ck64 FIND v(dout1_42) AT=325.025n

* CHECK dout1_43 Vdout1_43ck64 = 0.9 time = 325
.meas tran vdout1_43ck64 FIND v(dout1_43) AT=325.025n

* CHECK dout1_44 Vdout1_44ck64 = 0.9 time = 325
.meas tran vdout1_44ck64 FIND v(dout1_44) AT=325.025n

* CHECK dout1_45 Vdout1_45ck64 = 0 time = 325
.meas tran vdout1_45ck64 FIND v(dout1_45) AT=325.025n

* CHECK dout1_46 Vdout1_46ck64 = 0 time = 325
.meas tran vdout1_46ck64 FIND v(dout1_46) AT=325.025n

* CHECK dout1_47 Vdout1_47ck64 = 0 time = 325
.meas tran vdout1_47ck64 FIND v(dout1_47) AT=325.025n

* CHECK dout1_48 Vdout1_48ck64 = 0.9 time = 325
.meas tran vdout1_48ck64 FIND v(dout1_48) AT=325.025n

* CHECK dout1_49 Vdout1_49ck64 = 0 time = 325
.meas tran vdout1_49ck64 FIND v(dout1_49) AT=325.025n

* CHECK dout1_50 Vdout1_50ck64 = 0 time = 325
.meas tran vdout1_50ck64 FIND v(dout1_50) AT=325.025n

* CHECK dout1_51 Vdout1_51ck64 = 0 time = 325
.meas tran vdout1_51ck64 FIND v(dout1_51) AT=325.025n

* CHECK dout1_52 Vdout1_52ck64 = 0 time = 325
.meas tran vdout1_52ck64 FIND v(dout1_52) AT=325.025n

* CHECK dout1_53 Vdout1_53ck64 = 0 time = 325
.meas tran vdout1_53ck64 FIND v(dout1_53) AT=325.025n

* CHECK dout1_54 Vdout1_54ck64 = 0.9 time = 325
.meas tran vdout1_54ck64 FIND v(dout1_54) AT=325.025n

* CHECK dout1_55 Vdout1_55ck64 = 0 time = 325
.meas tran vdout1_55ck64 FIND v(dout1_55) AT=325.025n

* CHECK dout1_56 Vdout1_56ck64 = 0 time = 325
.meas tran vdout1_56ck64 FIND v(dout1_56) AT=325.025n

* CHECK dout1_57 Vdout1_57ck64 = 0 time = 325
.meas tran vdout1_57ck64 FIND v(dout1_57) AT=325.025n

* CHECK dout1_58 Vdout1_58ck64 = 0.9 time = 325
.meas tran vdout1_58ck64 FIND v(dout1_58) AT=325.025n

* CHECK dout1_59 Vdout1_59ck64 = 0 time = 325
.meas tran vdout1_59ck64 FIND v(dout1_59) AT=325.025n

* CHECK dout1_60 Vdout1_60ck64 = 0 time = 325
.meas tran vdout1_60ck64 FIND v(dout1_60) AT=325.025n

* CHECK dout1_61 Vdout1_61ck64 = 0.9 time = 325
.meas tran vdout1_61ck64 FIND v(dout1_61) AT=325.025n

* CHECK dout1_62 Vdout1_62ck64 = 0 time = 325
.meas tran vdout1_62ck64 FIND v(dout1_62) AT=325.025n

* CHECK dout1_63 Vdout1_63ck64 = 0.9 time = 325
.meas tran vdout1_63ck64 FIND v(dout1_63) AT=325.025n

* CHECK dout1_64 Vdout1_64ck64 = 0 time = 325
.meas tran vdout1_64ck64 FIND v(dout1_64) AT=325.025n

* CHECK dout1_65 Vdout1_65ck64 = 0 time = 325
.meas tran vdout1_65ck64 FIND v(dout1_65) AT=325.025n

* CHECK dout1_66 Vdout1_66ck64 = 0.9 time = 325
.meas tran vdout1_66ck64 FIND v(dout1_66) AT=325.025n

* CHECK dout1_67 Vdout1_67ck64 = 0 time = 325
.meas tran vdout1_67ck64 FIND v(dout1_67) AT=325.025n

* CHECK dout1_68 Vdout1_68ck64 = 0 time = 325
.meas tran vdout1_68ck64 FIND v(dout1_68) AT=325.025n

* CHECK dout1_69 Vdout1_69ck64 = 0.9 time = 325
.meas tran vdout1_69ck64 FIND v(dout1_69) AT=325.025n

* CHECK dout1_70 Vdout1_70ck64 = 0 time = 325
.meas tran vdout1_70ck64 FIND v(dout1_70) AT=325.025n

* CHECK dout1_71 Vdout1_71ck64 = 0 time = 325
.meas tran vdout1_71ck64 FIND v(dout1_71) AT=325.025n

* CHECK dout1_72 Vdout1_72ck64 = 0.9 time = 325
.meas tran vdout1_72ck64 FIND v(dout1_72) AT=325.025n

* CHECK dout1_73 Vdout1_73ck64 = 0.9 time = 325
.meas tran vdout1_73ck64 FIND v(dout1_73) AT=325.025n

* CHECK dout1_74 Vdout1_74ck64 = 0.9 time = 325
.meas tran vdout1_74ck64 FIND v(dout1_74) AT=325.025n

* CHECK dout1_75 Vdout1_75ck64 = 0.9 time = 325
.meas tran vdout1_75ck64 FIND v(dout1_75) AT=325.025n

* CHECK dout1_76 Vdout1_76ck64 = 0.9 time = 325
.meas tran vdout1_76ck64 FIND v(dout1_76) AT=325.025n

* CHECK dout1_77 Vdout1_77ck64 = 0.9 time = 325
.meas tran vdout1_77ck64 FIND v(dout1_77) AT=325.025n

* CHECK dout1_78 Vdout1_78ck64 = 0 time = 325
.meas tran vdout1_78ck64 FIND v(dout1_78) AT=325.025n

* CHECK dout1_79 Vdout1_79ck64 = 0 time = 325
.meas tran vdout1_79ck64 FIND v(dout1_79) AT=325.025n

* CHECK dout1_80 Vdout1_80ck64 = 0.9 time = 325
.meas tran vdout1_80ck64 FIND v(dout1_80) AT=325.025n

* CHECK dout1_81 Vdout1_81ck64 = 0.9 time = 325
.meas tran vdout1_81ck64 FIND v(dout1_81) AT=325.025n

* CHECK dout1_82 Vdout1_82ck64 = 0 time = 325
.meas tran vdout1_82ck64 FIND v(dout1_82) AT=325.025n

* CHECK dout1_83 Vdout1_83ck64 = 0.9 time = 325
.meas tran vdout1_83ck64 FIND v(dout1_83) AT=325.025n

* CHECK dout1_84 Vdout1_84ck64 = 0 time = 325
.meas tran vdout1_84ck64 FIND v(dout1_84) AT=325.025n

* CHECK dout1_85 Vdout1_85ck64 = 0 time = 325
.meas tran vdout1_85ck64 FIND v(dout1_85) AT=325.025n

* CHECK dout1_86 Vdout1_86ck64 = 0 time = 325
.meas tran vdout1_86ck64 FIND v(dout1_86) AT=325.025n

* CHECK dout1_87 Vdout1_87ck64 = 0.9 time = 325
.meas tran vdout1_87ck64 FIND v(dout1_87) AT=325.025n

* CHECK dout1_88 Vdout1_88ck64 = 0.9 time = 325
.meas tran vdout1_88ck64 FIND v(dout1_88) AT=325.025n

* CHECK dout1_89 Vdout1_89ck64 = 0 time = 325
.meas tran vdout1_89ck64 FIND v(dout1_89) AT=325.025n

* CHECK dout1_90 Vdout1_90ck64 = 0.9 time = 325
.meas tran vdout1_90ck64 FIND v(dout1_90) AT=325.025n

* CHECK dout1_91 Vdout1_91ck64 = 0.9 time = 325
.meas tran vdout1_91ck64 FIND v(dout1_91) AT=325.025n

* CHECK dout1_92 Vdout1_92ck64 = 0.9 time = 325
.meas tran vdout1_92ck64 FIND v(dout1_92) AT=325.025n

* CHECK dout1_93 Vdout1_93ck64 = 0 time = 325
.meas tran vdout1_93ck64 FIND v(dout1_93) AT=325.025n

* CHECK dout1_94 Vdout1_94ck64 = 0.9 time = 325
.meas tran vdout1_94ck64 FIND v(dout1_94) AT=325.025n

* CHECK dout1_95 Vdout1_95ck64 = 0 time = 325
.meas tran vdout1_95ck64 FIND v(dout1_95) AT=325.025n

* CHECK dout1_96 Vdout1_96ck64 = 0.9 time = 325
.meas tran vdout1_96ck64 FIND v(dout1_96) AT=325.025n

* CHECK dout1_97 Vdout1_97ck64 = 0.9 time = 325
.meas tran vdout1_97ck64 FIND v(dout1_97) AT=325.025n

* CHECK dout1_98 Vdout1_98ck64 = 0.9 time = 325
.meas tran vdout1_98ck64 FIND v(dout1_98) AT=325.025n

* CHECK dout1_99 Vdout1_99ck64 = 0 time = 325
.meas tran vdout1_99ck64 FIND v(dout1_99) AT=325.025n

* CHECK dout1_100 Vdout1_100ck64 = 0.9 time = 325
.meas tran vdout1_100ck64 FIND v(dout1_100) AT=325.025n

* CHECK dout1_101 Vdout1_101ck64 = 0.9 time = 325
.meas tran vdout1_101ck64 FIND v(dout1_101) AT=325.025n

* CHECK dout1_102 Vdout1_102ck64 = 0.9 time = 325
.meas tran vdout1_102ck64 FIND v(dout1_102) AT=325.025n

* CHECK dout1_103 Vdout1_103ck64 = 0 time = 325
.meas tran vdout1_103ck64 FIND v(dout1_103) AT=325.025n

* CHECK dout1_104 Vdout1_104ck64 = 0.9 time = 325
.meas tran vdout1_104ck64 FIND v(dout1_104) AT=325.025n

* CHECK dout1_105 Vdout1_105ck64 = 0 time = 325
.meas tran vdout1_105ck64 FIND v(dout1_105) AT=325.025n

* CHECK dout1_106 Vdout1_106ck64 = 0.9 time = 325
.meas tran vdout1_106ck64 FIND v(dout1_106) AT=325.025n

* CHECK dout1_107 Vdout1_107ck64 = 0.9 time = 325
.meas tran vdout1_107ck64 FIND v(dout1_107) AT=325.025n

* CHECK dout1_108 Vdout1_108ck64 = 0.9 time = 325
.meas tran vdout1_108ck64 FIND v(dout1_108) AT=325.025n

* CHECK dout1_109 Vdout1_109ck64 = 0.9 time = 325
.meas tran vdout1_109ck64 FIND v(dout1_109) AT=325.025n

* CHECK dout1_110 Vdout1_110ck64 = 0.9 time = 325
.meas tran vdout1_110ck64 FIND v(dout1_110) AT=325.025n

* CHECK dout1_111 Vdout1_111ck64 = 0 time = 325
.meas tran vdout1_111ck64 FIND v(dout1_111) AT=325.025n

* CHECK dout1_112 Vdout1_112ck64 = 0 time = 325
.meas tran vdout1_112ck64 FIND v(dout1_112) AT=325.025n

* CHECK dout1_113 Vdout1_113ck64 = 0 time = 325
.meas tran vdout1_113ck64 FIND v(dout1_113) AT=325.025n

* CHECK dout1_114 Vdout1_114ck64 = 0.9 time = 325
.meas tran vdout1_114ck64 FIND v(dout1_114) AT=325.025n

* CHECK dout1_115 Vdout1_115ck64 = 0.9 time = 325
.meas tran vdout1_115ck64 FIND v(dout1_115) AT=325.025n

* CHECK dout1_116 Vdout1_116ck64 = 0.9 time = 325
.meas tran vdout1_116ck64 FIND v(dout1_116) AT=325.025n

* CHECK dout1_117 Vdout1_117ck64 = 0 time = 325
.meas tran vdout1_117ck64 FIND v(dout1_117) AT=325.025n

* CHECK dout1_118 Vdout1_118ck64 = 0 time = 325
.meas tran vdout1_118ck64 FIND v(dout1_118) AT=325.025n

* CHECK dout1_119 Vdout1_119ck64 = 0 time = 325
.meas tran vdout1_119ck64 FIND v(dout1_119) AT=325.025n

* CHECK dout1_0 Vdout1_0ck68 = 0.9 time = 345
.meas tran vdout1_0ck68 FIND v(dout1_0) AT=345.025n

* CHECK dout1_1 Vdout1_1ck68 = 0.9 time = 345
.meas tran vdout1_1ck68 FIND v(dout1_1) AT=345.025n

* CHECK dout1_2 Vdout1_2ck68 = 0 time = 345
.meas tran vdout1_2ck68 FIND v(dout1_2) AT=345.025n

* CHECK dout1_3 Vdout1_3ck68 = 0 time = 345
.meas tran vdout1_3ck68 FIND v(dout1_3) AT=345.025n

* CHECK dout1_4 Vdout1_4ck68 = 0 time = 345
.meas tran vdout1_4ck68 FIND v(dout1_4) AT=345.025n

* CHECK dout1_5 Vdout1_5ck68 = 0.9 time = 345
.meas tran vdout1_5ck68 FIND v(dout1_5) AT=345.025n

* CHECK dout1_6 Vdout1_6ck68 = 0.9 time = 345
.meas tran vdout1_6ck68 FIND v(dout1_6) AT=345.025n

* CHECK dout1_7 Vdout1_7ck68 = 0.9 time = 345
.meas tran vdout1_7ck68 FIND v(dout1_7) AT=345.025n

* CHECK dout1_8 Vdout1_8ck68 = 0 time = 345
.meas tran vdout1_8ck68 FIND v(dout1_8) AT=345.025n

* CHECK dout1_9 Vdout1_9ck68 = 0 time = 345
.meas tran vdout1_9ck68 FIND v(dout1_9) AT=345.025n

* CHECK dout1_10 Vdout1_10ck68 = 0 time = 345
.meas tran vdout1_10ck68 FIND v(dout1_10) AT=345.025n

* CHECK dout1_11 Vdout1_11ck68 = 0.9 time = 345
.meas tran vdout1_11ck68 FIND v(dout1_11) AT=345.025n

* CHECK dout1_12 Vdout1_12ck68 = 0.9 time = 345
.meas tran vdout1_12ck68 FIND v(dout1_12) AT=345.025n

* CHECK dout1_13 Vdout1_13ck68 = 0.9 time = 345
.meas tran vdout1_13ck68 FIND v(dout1_13) AT=345.025n

* CHECK dout1_14 Vdout1_14ck68 = 0 time = 345
.meas tran vdout1_14ck68 FIND v(dout1_14) AT=345.025n

* CHECK dout1_15 Vdout1_15ck68 = 0.9 time = 345
.meas tran vdout1_15ck68 FIND v(dout1_15) AT=345.025n

* CHECK dout1_16 Vdout1_16ck68 = 0.9 time = 345
.meas tran vdout1_16ck68 FIND v(dout1_16) AT=345.025n

* CHECK dout1_17 Vdout1_17ck68 = 0.9 time = 345
.meas tran vdout1_17ck68 FIND v(dout1_17) AT=345.025n

* CHECK dout1_18 Vdout1_18ck68 = 0 time = 345
.meas tran vdout1_18ck68 FIND v(dout1_18) AT=345.025n

* CHECK dout1_19 Vdout1_19ck68 = 0.9 time = 345
.meas tran vdout1_19ck68 FIND v(dout1_19) AT=345.025n

* CHECK dout1_20 Vdout1_20ck68 = 0.9 time = 345
.meas tran vdout1_20ck68 FIND v(dout1_20) AT=345.025n

* CHECK dout1_21 Vdout1_21ck68 = 0 time = 345
.meas tran vdout1_21ck68 FIND v(dout1_21) AT=345.025n

* CHECK dout1_22 Vdout1_22ck68 = 0.9 time = 345
.meas tran vdout1_22ck68 FIND v(dout1_22) AT=345.025n

* CHECK dout1_23 Vdout1_23ck68 = 0.9 time = 345
.meas tran vdout1_23ck68 FIND v(dout1_23) AT=345.025n

* CHECK dout1_24 Vdout1_24ck68 = 0.9 time = 345
.meas tran vdout1_24ck68 FIND v(dout1_24) AT=345.025n

* CHECK dout1_25 Vdout1_25ck68 = 0.9 time = 345
.meas tran vdout1_25ck68 FIND v(dout1_25) AT=345.025n

* CHECK dout1_26 Vdout1_26ck68 = 0 time = 345
.meas tran vdout1_26ck68 FIND v(dout1_26) AT=345.025n

* CHECK dout1_27 Vdout1_27ck68 = 0.9 time = 345
.meas tran vdout1_27ck68 FIND v(dout1_27) AT=345.025n

* CHECK dout1_28 Vdout1_28ck68 = 0.9 time = 345
.meas tran vdout1_28ck68 FIND v(dout1_28) AT=345.025n

* CHECK dout1_29 Vdout1_29ck68 = 0 time = 345
.meas tran vdout1_29ck68 FIND v(dout1_29) AT=345.025n

* CHECK dout1_30 Vdout1_30ck68 = 0.9 time = 345
.meas tran vdout1_30ck68 FIND v(dout1_30) AT=345.025n

* CHECK dout1_31 Vdout1_31ck68 = 0 time = 345
.meas tran vdout1_31ck68 FIND v(dout1_31) AT=345.025n

* CHECK dout1_32 Vdout1_32ck68 = 0.9 time = 345
.meas tran vdout1_32ck68 FIND v(dout1_32) AT=345.025n

* CHECK dout1_33 Vdout1_33ck68 = 0 time = 345
.meas tran vdout1_33ck68 FIND v(dout1_33) AT=345.025n

* CHECK dout1_34 Vdout1_34ck68 = 0.9 time = 345
.meas tran vdout1_34ck68 FIND v(dout1_34) AT=345.025n

* CHECK dout1_35 Vdout1_35ck68 = 0.9 time = 345
.meas tran vdout1_35ck68 FIND v(dout1_35) AT=345.025n

* CHECK dout1_36 Vdout1_36ck68 = 0 time = 345
.meas tran vdout1_36ck68 FIND v(dout1_36) AT=345.025n

* CHECK dout1_37 Vdout1_37ck68 = 0 time = 345
.meas tran vdout1_37ck68 FIND v(dout1_37) AT=345.025n

* CHECK dout1_38 Vdout1_38ck68 = 0.9 time = 345
.meas tran vdout1_38ck68 FIND v(dout1_38) AT=345.025n

* CHECK dout1_39 Vdout1_39ck68 = 0 time = 345
.meas tran vdout1_39ck68 FIND v(dout1_39) AT=345.025n

* CHECK dout1_40 Vdout1_40ck68 = 0 time = 345
.meas tran vdout1_40ck68 FIND v(dout1_40) AT=345.025n

* CHECK dout1_41 Vdout1_41ck68 = 0.9 time = 345
.meas tran vdout1_41ck68 FIND v(dout1_41) AT=345.025n

* CHECK dout1_42 Vdout1_42ck68 = 0 time = 345
.meas tran vdout1_42ck68 FIND v(dout1_42) AT=345.025n

* CHECK dout1_43 Vdout1_43ck68 = 0 time = 345
.meas tran vdout1_43ck68 FIND v(dout1_43) AT=345.025n

* CHECK dout1_44 Vdout1_44ck68 = 0.9 time = 345
.meas tran vdout1_44ck68 FIND v(dout1_44) AT=345.025n

* CHECK dout1_45 Vdout1_45ck68 = 0 time = 345
.meas tran vdout1_45ck68 FIND v(dout1_45) AT=345.025n

* CHECK dout1_46 Vdout1_46ck68 = 0.9 time = 345
.meas tran vdout1_46ck68 FIND v(dout1_46) AT=345.025n

* CHECK dout1_47 Vdout1_47ck68 = 0.9 time = 345
.meas tran vdout1_47ck68 FIND v(dout1_47) AT=345.025n

* CHECK dout1_48 Vdout1_48ck68 = 0.9 time = 345
.meas tran vdout1_48ck68 FIND v(dout1_48) AT=345.025n

* CHECK dout1_49 Vdout1_49ck68 = 0 time = 345
.meas tran vdout1_49ck68 FIND v(dout1_49) AT=345.025n

* CHECK dout1_50 Vdout1_50ck68 = 0.9 time = 345
.meas tran vdout1_50ck68 FIND v(dout1_50) AT=345.025n

* CHECK dout1_51 Vdout1_51ck68 = 0 time = 345
.meas tran vdout1_51ck68 FIND v(dout1_51) AT=345.025n

* CHECK dout1_52 Vdout1_52ck68 = 0.9 time = 345
.meas tran vdout1_52ck68 FIND v(dout1_52) AT=345.025n

* CHECK dout1_53 Vdout1_53ck68 = 0 time = 345
.meas tran vdout1_53ck68 FIND v(dout1_53) AT=345.025n

* CHECK dout1_54 Vdout1_54ck68 = 0.9 time = 345
.meas tran vdout1_54ck68 FIND v(dout1_54) AT=345.025n

* CHECK dout1_55 Vdout1_55ck68 = 0.9 time = 345
.meas tran vdout1_55ck68 FIND v(dout1_55) AT=345.025n

* CHECK dout1_56 Vdout1_56ck68 = 0 time = 345
.meas tran vdout1_56ck68 FIND v(dout1_56) AT=345.025n

* CHECK dout1_57 Vdout1_57ck68 = 0.9 time = 345
.meas tran vdout1_57ck68 FIND v(dout1_57) AT=345.025n

* CHECK dout1_58 Vdout1_58ck68 = 0 time = 345
.meas tran vdout1_58ck68 FIND v(dout1_58) AT=345.025n

* CHECK dout1_59 Vdout1_59ck68 = 0.9 time = 345
.meas tran vdout1_59ck68 FIND v(dout1_59) AT=345.025n

* CHECK dout1_60 Vdout1_60ck68 = 0 time = 345
.meas tran vdout1_60ck68 FIND v(dout1_60) AT=345.025n

* CHECK dout1_61 Vdout1_61ck68 = 0 time = 345
.meas tran vdout1_61ck68 FIND v(dout1_61) AT=345.025n

* CHECK dout1_62 Vdout1_62ck68 = 0 time = 345
.meas tran vdout1_62ck68 FIND v(dout1_62) AT=345.025n

* CHECK dout1_63 Vdout1_63ck68 = 0 time = 345
.meas tran vdout1_63ck68 FIND v(dout1_63) AT=345.025n

* CHECK dout1_64 Vdout1_64ck68 = 0.9 time = 345
.meas tran vdout1_64ck68 FIND v(dout1_64) AT=345.025n

* CHECK dout1_65 Vdout1_65ck68 = 0 time = 345
.meas tran vdout1_65ck68 FIND v(dout1_65) AT=345.025n

* CHECK dout1_66 Vdout1_66ck68 = 0.9 time = 345
.meas tran vdout1_66ck68 FIND v(dout1_66) AT=345.025n

* CHECK dout1_67 Vdout1_67ck68 = 0 time = 345
.meas tran vdout1_67ck68 FIND v(dout1_67) AT=345.025n

* CHECK dout1_68 Vdout1_68ck68 = 0 time = 345
.meas tran vdout1_68ck68 FIND v(dout1_68) AT=345.025n

* CHECK dout1_69 Vdout1_69ck68 = 0 time = 345
.meas tran vdout1_69ck68 FIND v(dout1_69) AT=345.025n

* CHECK dout1_70 Vdout1_70ck68 = 0.9 time = 345
.meas tran vdout1_70ck68 FIND v(dout1_70) AT=345.025n

* CHECK dout1_71 Vdout1_71ck68 = 0 time = 345
.meas tran vdout1_71ck68 FIND v(dout1_71) AT=345.025n

* CHECK dout1_72 Vdout1_72ck68 = 0.9 time = 345
.meas tran vdout1_72ck68 FIND v(dout1_72) AT=345.025n

* CHECK dout1_73 Vdout1_73ck68 = 0.9 time = 345
.meas tran vdout1_73ck68 FIND v(dout1_73) AT=345.025n

* CHECK dout1_74 Vdout1_74ck68 = 0.9 time = 345
.meas tran vdout1_74ck68 FIND v(dout1_74) AT=345.025n

* CHECK dout1_75 Vdout1_75ck68 = 0.9 time = 345
.meas tran vdout1_75ck68 FIND v(dout1_75) AT=345.025n

* CHECK dout1_76 Vdout1_76ck68 = 0.9 time = 345
.meas tran vdout1_76ck68 FIND v(dout1_76) AT=345.025n

* CHECK dout1_77 Vdout1_77ck68 = 0 time = 345
.meas tran vdout1_77ck68 FIND v(dout1_77) AT=345.025n

* CHECK dout1_78 Vdout1_78ck68 = 0 time = 345
.meas tran vdout1_78ck68 FIND v(dout1_78) AT=345.025n

* CHECK dout1_79 Vdout1_79ck68 = 0.9 time = 345
.meas tran vdout1_79ck68 FIND v(dout1_79) AT=345.025n

* CHECK dout1_80 Vdout1_80ck68 = 0 time = 345
.meas tran vdout1_80ck68 FIND v(dout1_80) AT=345.025n

* CHECK dout1_81 Vdout1_81ck68 = 0.9 time = 345
.meas tran vdout1_81ck68 FIND v(dout1_81) AT=345.025n

* CHECK dout1_82 Vdout1_82ck68 = 0 time = 345
.meas tran vdout1_82ck68 FIND v(dout1_82) AT=345.025n

* CHECK dout1_83 Vdout1_83ck68 = 0 time = 345
.meas tran vdout1_83ck68 FIND v(dout1_83) AT=345.025n

* CHECK dout1_84 Vdout1_84ck68 = 0 time = 345
.meas tran vdout1_84ck68 FIND v(dout1_84) AT=345.025n

* CHECK dout1_85 Vdout1_85ck68 = 0.9 time = 345
.meas tran vdout1_85ck68 FIND v(dout1_85) AT=345.025n

* CHECK dout1_86 Vdout1_86ck68 = 0.9 time = 345
.meas tran vdout1_86ck68 FIND v(dout1_86) AT=345.025n

* CHECK dout1_87 Vdout1_87ck68 = 0.9 time = 345
.meas tran vdout1_87ck68 FIND v(dout1_87) AT=345.025n

* CHECK dout1_88 Vdout1_88ck68 = 0.9 time = 345
.meas tran vdout1_88ck68 FIND v(dout1_88) AT=345.025n

* CHECK dout1_89 Vdout1_89ck68 = 0 time = 345
.meas tran vdout1_89ck68 FIND v(dout1_89) AT=345.025n

* CHECK dout1_90 Vdout1_90ck68 = 0.9 time = 345
.meas tran vdout1_90ck68 FIND v(dout1_90) AT=345.025n

* CHECK dout1_91 Vdout1_91ck68 = 0 time = 345
.meas tran vdout1_91ck68 FIND v(dout1_91) AT=345.025n

* CHECK dout1_92 Vdout1_92ck68 = 0.9 time = 345
.meas tran vdout1_92ck68 FIND v(dout1_92) AT=345.025n

* CHECK dout1_93 Vdout1_93ck68 = 0.9 time = 345
.meas tran vdout1_93ck68 FIND v(dout1_93) AT=345.025n

* CHECK dout1_94 Vdout1_94ck68 = 0.9 time = 345
.meas tran vdout1_94ck68 FIND v(dout1_94) AT=345.025n

* CHECK dout1_95 Vdout1_95ck68 = 0.9 time = 345
.meas tran vdout1_95ck68 FIND v(dout1_95) AT=345.025n

* CHECK dout1_96 Vdout1_96ck68 = 0 time = 345
.meas tran vdout1_96ck68 FIND v(dout1_96) AT=345.025n

* CHECK dout1_97 Vdout1_97ck68 = 0.9 time = 345
.meas tran vdout1_97ck68 FIND v(dout1_97) AT=345.025n

* CHECK dout1_98 Vdout1_98ck68 = 0 time = 345
.meas tran vdout1_98ck68 FIND v(dout1_98) AT=345.025n

* CHECK dout1_99 Vdout1_99ck68 = 0 time = 345
.meas tran vdout1_99ck68 FIND v(dout1_99) AT=345.025n

* CHECK dout1_100 Vdout1_100ck68 = 0.9 time = 345
.meas tran vdout1_100ck68 FIND v(dout1_100) AT=345.025n

* CHECK dout1_101 Vdout1_101ck68 = 0 time = 345
.meas tran vdout1_101ck68 FIND v(dout1_101) AT=345.025n

* CHECK dout1_102 Vdout1_102ck68 = 0.9 time = 345
.meas tran vdout1_102ck68 FIND v(dout1_102) AT=345.025n

* CHECK dout1_103 Vdout1_103ck68 = 0 time = 345
.meas tran vdout1_103ck68 FIND v(dout1_103) AT=345.025n

* CHECK dout1_104 Vdout1_104ck68 = 0.9 time = 345
.meas tran vdout1_104ck68 FIND v(dout1_104) AT=345.025n

* CHECK dout1_105 Vdout1_105ck68 = 0 time = 345
.meas tran vdout1_105ck68 FIND v(dout1_105) AT=345.025n

* CHECK dout1_106 Vdout1_106ck68 = 0.9 time = 345
.meas tran vdout1_106ck68 FIND v(dout1_106) AT=345.025n

* CHECK dout1_107 Vdout1_107ck68 = 0.9 time = 345
.meas tran vdout1_107ck68 FIND v(dout1_107) AT=345.025n

* CHECK dout1_108 Vdout1_108ck68 = 0.9 time = 345
.meas tran vdout1_108ck68 FIND v(dout1_108) AT=345.025n

* CHECK dout1_109 Vdout1_109ck68 = 0 time = 345
.meas tran vdout1_109ck68 FIND v(dout1_109) AT=345.025n

* CHECK dout1_110 Vdout1_110ck68 = 0.9 time = 345
.meas tran vdout1_110ck68 FIND v(dout1_110) AT=345.025n

* CHECK dout1_111 Vdout1_111ck68 = 0.9 time = 345
.meas tran vdout1_111ck68 FIND v(dout1_111) AT=345.025n

* CHECK dout1_112 Vdout1_112ck68 = 0.9 time = 345
.meas tran vdout1_112ck68 FIND v(dout1_112) AT=345.025n

* CHECK dout1_113 Vdout1_113ck68 = 0.9 time = 345
.meas tran vdout1_113ck68 FIND v(dout1_113) AT=345.025n

* CHECK dout1_114 Vdout1_114ck68 = 0.9 time = 345
.meas tran vdout1_114ck68 FIND v(dout1_114) AT=345.025n

* CHECK dout1_115 Vdout1_115ck68 = 0 time = 345
.meas tran vdout1_115ck68 FIND v(dout1_115) AT=345.025n

* CHECK dout1_116 Vdout1_116ck68 = 0.9 time = 345
.meas tran vdout1_116ck68 FIND v(dout1_116) AT=345.025n

* CHECK dout1_117 Vdout1_117ck68 = 0.9 time = 345
.meas tran vdout1_117ck68 FIND v(dout1_117) AT=345.025n

* CHECK dout1_118 Vdout1_118ck68 = 0 time = 345
.meas tran vdout1_118ck68 FIND v(dout1_118) AT=345.025n

* CHECK dout1_119 Vdout1_119ck68 = 0 time = 345
.meas tran vdout1_119ck68 FIND v(dout1_119) AT=345.025n

* CHECK dout1_0 Vdout1_0ck73 = 0.9 time = 370
.meas tran vdout1_0ck73 FIND v(dout1_0) AT=370.025n

* CHECK dout1_1 Vdout1_1ck73 = 0.9 time = 370
.meas tran vdout1_1ck73 FIND v(dout1_1) AT=370.025n

* CHECK dout1_2 Vdout1_2ck73 = 0 time = 370
.meas tran vdout1_2ck73 FIND v(dout1_2) AT=370.025n

* CHECK dout1_3 Vdout1_3ck73 = 0 time = 370
.meas tran vdout1_3ck73 FIND v(dout1_3) AT=370.025n

* CHECK dout1_4 Vdout1_4ck73 = 0 time = 370
.meas tran vdout1_4ck73 FIND v(dout1_4) AT=370.025n

* CHECK dout1_5 Vdout1_5ck73 = 0.9 time = 370
.meas tran vdout1_5ck73 FIND v(dout1_5) AT=370.025n

* CHECK dout1_6 Vdout1_6ck73 = 0.9 time = 370
.meas tran vdout1_6ck73 FIND v(dout1_6) AT=370.025n

* CHECK dout1_7 Vdout1_7ck73 = 0.9 time = 370
.meas tran vdout1_7ck73 FIND v(dout1_7) AT=370.025n

* CHECK dout1_8 Vdout1_8ck73 = 0 time = 370
.meas tran vdout1_8ck73 FIND v(dout1_8) AT=370.025n

* CHECK dout1_9 Vdout1_9ck73 = 0 time = 370
.meas tran vdout1_9ck73 FIND v(dout1_9) AT=370.025n

* CHECK dout1_10 Vdout1_10ck73 = 0 time = 370
.meas tran vdout1_10ck73 FIND v(dout1_10) AT=370.025n

* CHECK dout1_11 Vdout1_11ck73 = 0.9 time = 370
.meas tran vdout1_11ck73 FIND v(dout1_11) AT=370.025n

* CHECK dout1_12 Vdout1_12ck73 = 0.9 time = 370
.meas tran vdout1_12ck73 FIND v(dout1_12) AT=370.025n

* CHECK dout1_13 Vdout1_13ck73 = 0.9 time = 370
.meas tran vdout1_13ck73 FIND v(dout1_13) AT=370.025n

* CHECK dout1_14 Vdout1_14ck73 = 0 time = 370
.meas tran vdout1_14ck73 FIND v(dout1_14) AT=370.025n

* CHECK dout1_15 Vdout1_15ck73 = 0.9 time = 370
.meas tran vdout1_15ck73 FIND v(dout1_15) AT=370.025n

* CHECK dout1_16 Vdout1_16ck73 = 0.9 time = 370
.meas tran vdout1_16ck73 FIND v(dout1_16) AT=370.025n

* CHECK dout1_17 Vdout1_17ck73 = 0.9 time = 370
.meas tran vdout1_17ck73 FIND v(dout1_17) AT=370.025n

* CHECK dout1_18 Vdout1_18ck73 = 0 time = 370
.meas tran vdout1_18ck73 FIND v(dout1_18) AT=370.025n

* CHECK dout1_19 Vdout1_19ck73 = 0.9 time = 370
.meas tran vdout1_19ck73 FIND v(dout1_19) AT=370.025n

* CHECK dout1_20 Vdout1_20ck73 = 0.9 time = 370
.meas tran vdout1_20ck73 FIND v(dout1_20) AT=370.025n

* CHECK dout1_21 Vdout1_21ck73 = 0 time = 370
.meas tran vdout1_21ck73 FIND v(dout1_21) AT=370.025n

* CHECK dout1_22 Vdout1_22ck73 = 0.9 time = 370
.meas tran vdout1_22ck73 FIND v(dout1_22) AT=370.025n

* CHECK dout1_23 Vdout1_23ck73 = 0.9 time = 370
.meas tran vdout1_23ck73 FIND v(dout1_23) AT=370.025n

* CHECK dout1_24 Vdout1_24ck73 = 0.9 time = 370
.meas tran vdout1_24ck73 FIND v(dout1_24) AT=370.025n

* CHECK dout1_25 Vdout1_25ck73 = 0.9 time = 370
.meas tran vdout1_25ck73 FIND v(dout1_25) AT=370.025n

* CHECK dout1_26 Vdout1_26ck73 = 0 time = 370
.meas tran vdout1_26ck73 FIND v(dout1_26) AT=370.025n

* CHECK dout1_27 Vdout1_27ck73 = 0.9 time = 370
.meas tran vdout1_27ck73 FIND v(dout1_27) AT=370.025n

* CHECK dout1_28 Vdout1_28ck73 = 0.9 time = 370
.meas tran vdout1_28ck73 FIND v(dout1_28) AT=370.025n

* CHECK dout1_29 Vdout1_29ck73 = 0 time = 370
.meas tran vdout1_29ck73 FIND v(dout1_29) AT=370.025n

* CHECK dout1_30 Vdout1_30ck73 = 0.9 time = 370
.meas tran vdout1_30ck73 FIND v(dout1_30) AT=370.025n

* CHECK dout1_31 Vdout1_31ck73 = 0 time = 370
.meas tran vdout1_31ck73 FIND v(dout1_31) AT=370.025n

* CHECK dout1_32 Vdout1_32ck73 = 0.9 time = 370
.meas tran vdout1_32ck73 FIND v(dout1_32) AT=370.025n

* CHECK dout1_33 Vdout1_33ck73 = 0 time = 370
.meas tran vdout1_33ck73 FIND v(dout1_33) AT=370.025n

* CHECK dout1_34 Vdout1_34ck73 = 0.9 time = 370
.meas tran vdout1_34ck73 FIND v(dout1_34) AT=370.025n

* CHECK dout1_35 Vdout1_35ck73 = 0.9 time = 370
.meas tran vdout1_35ck73 FIND v(dout1_35) AT=370.025n

* CHECK dout1_36 Vdout1_36ck73 = 0 time = 370
.meas tran vdout1_36ck73 FIND v(dout1_36) AT=370.025n

* CHECK dout1_37 Vdout1_37ck73 = 0 time = 370
.meas tran vdout1_37ck73 FIND v(dout1_37) AT=370.025n

* CHECK dout1_38 Vdout1_38ck73 = 0.9 time = 370
.meas tran vdout1_38ck73 FIND v(dout1_38) AT=370.025n

* CHECK dout1_39 Vdout1_39ck73 = 0 time = 370
.meas tran vdout1_39ck73 FIND v(dout1_39) AT=370.025n

* CHECK dout1_40 Vdout1_40ck73 = 0 time = 370
.meas tran vdout1_40ck73 FIND v(dout1_40) AT=370.025n

* CHECK dout1_41 Vdout1_41ck73 = 0.9 time = 370
.meas tran vdout1_41ck73 FIND v(dout1_41) AT=370.025n

* CHECK dout1_42 Vdout1_42ck73 = 0 time = 370
.meas tran vdout1_42ck73 FIND v(dout1_42) AT=370.025n

* CHECK dout1_43 Vdout1_43ck73 = 0 time = 370
.meas tran vdout1_43ck73 FIND v(dout1_43) AT=370.025n

* CHECK dout1_44 Vdout1_44ck73 = 0.9 time = 370
.meas tran vdout1_44ck73 FIND v(dout1_44) AT=370.025n

* CHECK dout1_45 Vdout1_45ck73 = 0 time = 370
.meas tran vdout1_45ck73 FIND v(dout1_45) AT=370.025n

* CHECK dout1_46 Vdout1_46ck73 = 0.9 time = 370
.meas tran vdout1_46ck73 FIND v(dout1_46) AT=370.025n

* CHECK dout1_47 Vdout1_47ck73 = 0.9 time = 370
.meas tran vdout1_47ck73 FIND v(dout1_47) AT=370.025n

* CHECK dout1_48 Vdout1_48ck73 = 0.9 time = 370
.meas tran vdout1_48ck73 FIND v(dout1_48) AT=370.025n

* CHECK dout1_49 Vdout1_49ck73 = 0 time = 370
.meas tran vdout1_49ck73 FIND v(dout1_49) AT=370.025n

* CHECK dout1_50 Vdout1_50ck73 = 0.9 time = 370
.meas tran vdout1_50ck73 FIND v(dout1_50) AT=370.025n

* CHECK dout1_51 Vdout1_51ck73 = 0 time = 370
.meas tran vdout1_51ck73 FIND v(dout1_51) AT=370.025n

* CHECK dout1_52 Vdout1_52ck73 = 0.9 time = 370
.meas tran vdout1_52ck73 FIND v(dout1_52) AT=370.025n

* CHECK dout1_53 Vdout1_53ck73 = 0 time = 370
.meas tran vdout1_53ck73 FIND v(dout1_53) AT=370.025n

* CHECK dout1_54 Vdout1_54ck73 = 0.9 time = 370
.meas tran vdout1_54ck73 FIND v(dout1_54) AT=370.025n

* CHECK dout1_55 Vdout1_55ck73 = 0.9 time = 370
.meas tran vdout1_55ck73 FIND v(dout1_55) AT=370.025n

* CHECK dout1_56 Vdout1_56ck73 = 0 time = 370
.meas tran vdout1_56ck73 FIND v(dout1_56) AT=370.025n

* CHECK dout1_57 Vdout1_57ck73 = 0.9 time = 370
.meas tran vdout1_57ck73 FIND v(dout1_57) AT=370.025n

* CHECK dout1_58 Vdout1_58ck73 = 0 time = 370
.meas tran vdout1_58ck73 FIND v(dout1_58) AT=370.025n

* CHECK dout1_59 Vdout1_59ck73 = 0.9 time = 370
.meas tran vdout1_59ck73 FIND v(dout1_59) AT=370.025n

* CHECK dout1_60 Vdout1_60ck73 = 0 time = 370
.meas tran vdout1_60ck73 FIND v(dout1_60) AT=370.025n

* CHECK dout1_61 Vdout1_61ck73 = 0 time = 370
.meas tran vdout1_61ck73 FIND v(dout1_61) AT=370.025n

* CHECK dout1_62 Vdout1_62ck73 = 0 time = 370
.meas tran vdout1_62ck73 FIND v(dout1_62) AT=370.025n

* CHECK dout1_63 Vdout1_63ck73 = 0 time = 370
.meas tran vdout1_63ck73 FIND v(dout1_63) AT=370.025n

* CHECK dout1_64 Vdout1_64ck73 = 0.9 time = 370
.meas tran vdout1_64ck73 FIND v(dout1_64) AT=370.025n

* CHECK dout1_65 Vdout1_65ck73 = 0 time = 370
.meas tran vdout1_65ck73 FIND v(dout1_65) AT=370.025n

* CHECK dout1_66 Vdout1_66ck73 = 0.9 time = 370
.meas tran vdout1_66ck73 FIND v(dout1_66) AT=370.025n

* CHECK dout1_67 Vdout1_67ck73 = 0 time = 370
.meas tran vdout1_67ck73 FIND v(dout1_67) AT=370.025n

* CHECK dout1_68 Vdout1_68ck73 = 0 time = 370
.meas tran vdout1_68ck73 FIND v(dout1_68) AT=370.025n

* CHECK dout1_69 Vdout1_69ck73 = 0 time = 370
.meas tran vdout1_69ck73 FIND v(dout1_69) AT=370.025n

* CHECK dout1_70 Vdout1_70ck73 = 0.9 time = 370
.meas tran vdout1_70ck73 FIND v(dout1_70) AT=370.025n

* CHECK dout1_71 Vdout1_71ck73 = 0 time = 370
.meas tran vdout1_71ck73 FIND v(dout1_71) AT=370.025n

* CHECK dout1_72 Vdout1_72ck73 = 0.9 time = 370
.meas tran vdout1_72ck73 FIND v(dout1_72) AT=370.025n

* CHECK dout1_73 Vdout1_73ck73 = 0.9 time = 370
.meas tran vdout1_73ck73 FIND v(dout1_73) AT=370.025n

* CHECK dout1_74 Vdout1_74ck73 = 0.9 time = 370
.meas tran vdout1_74ck73 FIND v(dout1_74) AT=370.025n

* CHECK dout1_75 Vdout1_75ck73 = 0.9 time = 370
.meas tran vdout1_75ck73 FIND v(dout1_75) AT=370.025n

* CHECK dout1_76 Vdout1_76ck73 = 0.9 time = 370
.meas tran vdout1_76ck73 FIND v(dout1_76) AT=370.025n

* CHECK dout1_77 Vdout1_77ck73 = 0 time = 370
.meas tran vdout1_77ck73 FIND v(dout1_77) AT=370.025n

* CHECK dout1_78 Vdout1_78ck73 = 0 time = 370
.meas tran vdout1_78ck73 FIND v(dout1_78) AT=370.025n

* CHECK dout1_79 Vdout1_79ck73 = 0.9 time = 370
.meas tran vdout1_79ck73 FIND v(dout1_79) AT=370.025n

* CHECK dout1_80 Vdout1_80ck73 = 0 time = 370
.meas tran vdout1_80ck73 FIND v(dout1_80) AT=370.025n

* CHECK dout1_81 Vdout1_81ck73 = 0.9 time = 370
.meas tran vdout1_81ck73 FIND v(dout1_81) AT=370.025n

* CHECK dout1_82 Vdout1_82ck73 = 0 time = 370
.meas tran vdout1_82ck73 FIND v(dout1_82) AT=370.025n

* CHECK dout1_83 Vdout1_83ck73 = 0 time = 370
.meas tran vdout1_83ck73 FIND v(dout1_83) AT=370.025n

* CHECK dout1_84 Vdout1_84ck73 = 0 time = 370
.meas tran vdout1_84ck73 FIND v(dout1_84) AT=370.025n

* CHECK dout1_85 Vdout1_85ck73 = 0.9 time = 370
.meas tran vdout1_85ck73 FIND v(dout1_85) AT=370.025n

* CHECK dout1_86 Vdout1_86ck73 = 0.9 time = 370
.meas tran vdout1_86ck73 FIND v(dout1_86) AT=370.025n

* CHECK dout1_87 Vdout1_87ck73 = 0.9 time = 370
.meas tran vdout1_87ck73 FIND v(dout1_87) AT=370.025n

* CHECK dout1_88 Vdout1_88ck73 = 0.9 time = 370
.meas tran vdout1_88ck73 FIND v(dout1_88) AT=370.025n

* CHECK dout1_89 Vdout1_89ck73 = 0 time = 370
.meas tran vdout1_89ck73 FIND v(dout1_89) AT=370.025n

* CHECK dout1_90 Vdout1_90ck73 = 0.9 time = 370
.meas tran vdout1_90ck73 FIND v(dout1_90) AT=370.025n

* CHECK dout1_91 Vdout1_91ck73 = 0 time = 370
.meas tran vdout1_91ck73 FIND v(dout1_91) AT=370.025n

* CHECK dout1_92 Vdout1_92ck73 = 0.9 time = 370
.meas tran vdout1_92ck73 FIND v(dout1_92) AT=370.025n

* CHECK dout1_93 Vdout1_93ck73 = 0.9 time = 370
.meas tran vdout1_93ck73 FIND v(dout1_93) AT=370.025n

* CHECK dout1_94 Vdout1_94ck73 = 0.9 time = 370
.meas tran vdout1_94ck73 FIND v(dout1_94) AT=370.025n

* CHECK dout1_95 Vdout1_95ck73 = 0.9 time = 370
.meas tran vdout1_95ck73 FIND v(dout1_95) AT=370.025n

* CHECK dout1_96 Vdout1_96ck73 = 0 time = 370
.meas tran vdout1_96ck73 FIND v(dout1_96) AT=370.025n

* CHECK dout1_97 Vdout1_97ck73 = 0.9 time = 370
.meas tran vdout1_97ck73 FIND v(dout1_97) AT=370.025n

* CHECK dout1_98 Vdout1_98ck73 = 0 time = 370
.meas tran vdout1_98ck73 FIND v(dout1_98) AT=370.025n

* CHECK dout1_99 Vdout1_99ck73 = 0 time = 370
.meas tran vdout1_99ck73 FIND v(dout1_99) AT=370.025n

* CHECK dout1_100 Vdout1_100ck73 = 0.9 time = 370
.meas tran vdout1_100ck73 FIND v(dout1_100) AT=370.025n

* CHECK dout1_101 Vdout1_101ck73 = 0 time = 370
.meas tran vdout1_101ck73 FIND v(dout1_101) AT=370.025n

* CHECK dout1_102 Vdout1_102ck73 = 0.9 time = 370
.meas tran vdout1_102ck73 FIND v(dout1_102) AT=370.025n

* CHECK dout1_103 Vdout1_103ck73 = 0 time = 370
.meas tran vdout1_103ck73 FIND v(dout1_103) AT=370.025n

* CHECK dout1_104 Vdout1_104ck73 = 0.9 time = 370
.meas tran vdout1_104ck73 FIND v(dout1_104) AT=370.025n

* CHECK dout1_105 Vdout1_105ck73 = 0 time = 370
.meas tran vdout1_105ck73 FIND v(dout1_105) AT=370.025n

* CHECK dout1_106 Vdout1_106ck73 = 0.9 time = 370
.meas tran vdout1_106ck73 FIND v(dout1_106) AT=370.025n

* CHECK dout1_107 Vdout1_107ck73 = 0.9 time = 370
.meas tran vdout1_107ck73 FIND v(dout1_107) AT=370.025n

* CHECK dout1_108 Vdout1_108ck73 = 0.9 time = 370
.meas tran vdout1_108ck73 FIND v(dout1_108) AT=370.025n

* CHECK dout1_109 Vdout1_109ck73 = 0 time = 370
.meas tran vdout1_109ck73 FIND v(dout1_109) AT=370.025n

* CHECK dout1_110 Vdout1_110ck73 = 0.9 time = 370
.meas tran vdout1_110ck73 FIND v(dout1_110) AT=370.025n

* CHECK dout1_111 Vdout1_111ck73 = 0.9 time = 370
.meas tran vdout1_111ck73 FIND v(dout1_111) AT=370.025n

* CHECK dout1_112 Vdout1_112ck73 = 0.9 time = 370
.meas tran vdout1_112ck73 FIND v(dout1_112) AT=370.025n

* CHECK dout1_113 Vdout1_113ck73 = 0.9 time = 370
.meas tran vdout1_113ck73 FIND v(dout1_113) AT=370.025n

* CHECK dout1_114 Vdout1_114ck73 = 0.9 time = 370
.meas tran vdout1_114ck73 FIND v(dout1_114) AT=370.025n

* CHECK dout1_115 Vdout1_115ck73 = 0 time = 370
.meas tran vdout1_115ck73 FIND v(dout1_115) AT=370.025n

* CHECK dout1_116 Vdout1_116ck73 = 0.9 time = 370
.meas tran vdout1_116ck73 FIND v(dout1_116) AT=370.025n

* CHECK dout1_117 Vdout1_117ck73 = 0.9 time = 370
.meas tran vdout1_117ck73 FIND v(dout1_117) AT=370.025n

* CHECK dout1_118 Vdout1_118ck73 = 0 time = 370
.meas tran vdout1_118ck73 FIND v(dout1_118) AT=370.025n

* CHECK dout1_119 Vdout1_119ck73 = 0 time = 370
.meas tran vdout1_119ck73 FIND v(dout1_119) AT=370.025n

* CHECK dout1_0 Vdout1_0ck74 = 0.9 time = 375
.meas tran vdout1_0ck74 FIND v(dout1_0) AT=375.025n

* CHECK dout1_1 Vdout1_1ck74 = 0.9 time = 375
.meas tran vdout1_1ck74 FIND v(dout1_1) AT=375.025n

* CHECK dout1_2 Vdout1_2ck74 = 0 time = 375
.meas tran vdout1_2ck74 FIND v(dout1_2) AT=375.025n

* CHECK dout1_3 Vdout1_3ck74 = 0 time = 375
.meas tran vdout1_3ck74 FIND v(dout1_3) AT=375.025n

* CHECK dout1_4 Vdout1_4ck74 = 0.9 time = 375
.meas tran vdout1_4ck74 FIND v(dout1_4) AT=375.025n

* CHECK dout1_5 Vdout1_5ck74 = 0.9 time = 375
.meas tran vdout1_5ck74 FIND v(dout1_5) AT=375.025n

* CHECK dout1_6 Vdout1_6ck74 = 0.9 time = 375
.meas tran vdout1_6ck74 FIND v(dout1_6) AT=375.025n

* CHECK dout1_7 Vdout1_7ck74 = 0.9 time = 375
.meas tran vdout1_7ck74 FIND v(dout1_7) AT=375.025n

* CHECK dout1_8 Vdout1_8ck74 = 0 time = 375
.meas tran vdout1_8ck74 FIND v(dout1_8) AT=375.025n

* CHECK dout1_9 Vdout1_9ck74 = 0 time = 375
.meas tran vdout1_9ck74 FIND v(dout1_9) AT=375.025n

* CHECK dout1_10 Vdout1_10ck74 = 0.9 time = 375
.meas tran vdout1_10ck74 FIND v(dout1_10) AT=375.025n

* CHECK dout1_11 Vdout1_11ck74 = 0.9 time = 375
.meas tran vdout1_11ck74 FIND v(dout1_11) AT=375.025n

* CHECK dout1_12 Vdout1_12ck74 = 0 time = 375
.meas tran vdout1_12ck74 FIND v(dout1_12) AT=375.025n

* CHECK dout1_13 Vdout1_13ck74 = 0 time = 375
.meas tran vdout1_13ck74 FIND v(dout1_13) AT=375.025n

* CHECK dout1_14 Vdout1_14ck74 = 0.9 time = 375
.meas tran vdout1_14ck74 FIND v(dout1_14) AT=375.025n

* CHECK dout1_15 Vdout1_15ck74 = 0.9 time = 375
.meas tran vdout1_15ck74 FIND v(dout1_15) AT=375.025n

* CHECK dout1_16 Vdout1_16ck74 = 0.9 time = 375
.meas tran vdout1_16ck74 FIND v(dout1_16) AT=375.025n

* CHECK dout1_17 Vdout1_17ck74 = 0.9 time = 375
.meas tran vdout1_17ck74 FIND v(dout1_17) AT=375.025n

* CHECK dout1_18 Vdout1_18ck74 = 0 time = 375
.meas tran vdout1_18ck74 FIND v(dout1_18) AT=375.025n

* CHECK dout1_19 Vdout1_19ck74 = 0.9 time = 375
.meas tran vdout1_19ck74 FIND v(dout1_19) AT=375.025n

* CHECK dout1_20 Vdout1_20ck74 = 0 time = 375
.meas tran vdout1_20ck74 FIND v(dout1_20) AT=375.025n

* CHECK dout1_21 Vdout1_21ck74 = 0.9 time = 375
.meas tran vdout1_21ck74 FIND v(dout1_21) AT=375.025n

* CHECK dout1_22 Vdout1_22ck74 = 0 time = 375
.meas tran vdout1_22ck74 FIND v(dout1_22) AT=375.025n

* CHECK dout1_23 Vdout1_23ck74 = 0 time = 375
.meas tran vdout1_23ck74 FIND v(dout1_23) AT=375.025n

* CHECK dout1_24 Vdout1_24ck74 = 0.9 time = 375
.meas tran vdout1_24ck74 FIND v(dout1_24) AT=375.025n

* CHECK dout1_25 Vdout1_25ck74 = 0.9 time = 375
.meas tran vdout1_25ck74 FIND v(dout1_25) AT=375.025n

* CHECK dout1_26 Vdout1_26ck74 = 0.9 time = 375
.meas tran vdout1_26ck74 FIND v(dout1_26) AT=375.025n

* CHECK dout1_27 Vdout1_27ck74 = 0 time = 375
.meas tran vdout1_27ck74 FIND v(dout1_27) AT=375.025n

* CHECK dout1_28 Vdout1_28ck74 = 0 time = 375
.meas tran vdout1_28ck74 FIND v(dout1_28) AT=375.025n

* CHECK dout1_29 Vdout1_29ck74 = 0.9 time = 375
.meas tran vdout1_29ck74 FIND v(dout1_29) AT=375.025n

* CHECK dout1_30 Vdout1_30ck74 = 0.9 time = 375
.meas tran vdout1_30ck74 FIND v(dout1_30) AT=375.025n

* CHECK dout1_31 Vdout1_31ck74 = 0 time = 375
.meas tran vdout1_31ck74 FIND v(dout1_31) AT=375.025n

* CHECK dout1_32 Vdout1_32ck74 = 0.9 time = 375
.meas tran vdout1_32ck74 FIND v(dout1_32) AT=375.025n

* CHECK dout1_33 Vdout1_33ck74 = 0 time = 375
.meas tran vdout1_33ck74 FIND v(dout1_33) AT=375.025n

* CHECK dout1_34 Vdout1_34ck74 = 0 time = 375
.meas tran vdout1_34ck74 FIND v(dout1_34) AT=375.025n

* CHECK dout1_35 Vdout1_35ck74 = 0.9 time = 375
.meas tran vdout1_35ck74 FIND v(dout1_35) AT=375.025n

* CHECK dout1_36 Vdout1_36ck74 = 0.9 time = 375
.meas tran vdout1_36ck74 FIND v(dout1_36) AT=375.025n

* CHECK dout1_37 Vdout1_37ck74 = 0.9 time = 375
.meas tran vdout1_37ck74 FIND v(dout1_37) AT=375.025n

* CHECK dout1_38 Vdout1_38ck74 = 0 time = 375
.meas tran vdout1_38ck74 FIND v(dout1_38) AT=375.025n

* CHECK dout1_39 Vdout1_39ck74 = 0.9 time = 375
.meas tran vdout1_39ck74 FIND v(dout1_39) AT=375.025n

* CHECK dout1_40 Vdout1_40ck74 = 0.9 time = 375
.meas tran vdout1_40ck74 FIND v(dout1_40) AT=375.025n

* CHECK dout1_41 Vdout1_41ck74 = 0.9 time = 375
.meas tran vdout1_41ck74 FIND v(dout1_41) AT=375.025n

* CHECK dout1_42 Vdout1_42ck74 = 0 time = 375
.meas tran vdout1_42ck74 FIND v(dout1_42) AT=375.025n

* CHECK dout1_43 Vdout1_43ck74 = 0 time = 375
.meas tran vdout1_43ck74 FIND v(dout1_43) AT=375.025n

* CHECK dout1_44 Vdout1_44ck74 = 0 time = 375
.meas tran vdout1_44ck74 FIND v(dout1_44) AT=375.025n

* CHECK dout1_45 Vdout1_45ck74 = 0.9 time = 375
.meas tran vdout1_45ck74 FIND v(dout1_45) AT=375.025n

* CHECK dout1_46 Vdout1_46ck74 = 0 time = 375
.meas tran vdout1_46ck74 FIND v(dout1_46) AT=375.025n

* CHECK dout1_47 Vdout1_47ck74 = 0 time = 375
.meas tran vdout1_47ck74 FIND v(dout1_47) AT=375.025n

* CHECK dout1_48 Vdout1_48ck74 = 0.9 time = 375
.meas tran vdout1_48ck74 FIND v(dout1_48) AT=375.025n

* CHECK dout1_49 Vdout1_49ck74 = 0 time = 375
.meas tran vdout1_49ck74 FIND v(dout1_49) AT=375.025n

* CHECK dout1_50 Vdout1_50ck74 = 0 time = 375
.meas tran vdout1_50ck74 FIND v(dout1_50) AT=375.025n

* CHECK dout1_51 Vdout1_51ck74 = 0.9 time = 375
.meas tran vdout1_51ck74 FIND v(dout1_51) AT=375.025n

* CHECK dout1_52 Vdout1_52ck74 = 0.9 time = 375
.meas tran vdout1_52ck74 FIND v(dout1_52) AT=375.025n

* CHECK dout1_53 Vdout1_53ck74 = 0.9 time = 375
.meas tran vdout1_53ck74 FIND v(dout1_53) AT=375.025n

* CHECK dout1_54 Vdout1_54ck74 = 0 time = 375
.meas tran vdout1_54ck74 FIND v(dout1_54) AT=375.025n

* CHECK dout1_55 Vdout1_55ck74 = 0.9 time = 375
.meas tran vdout1_55ck74 FIND v(dout1_55) AT=375.025n

* CHECK dout1_56 Vdout1_56ck74 = 0 time = 375
.meas tran vdout1_56ck74 FIND v(dout1_56) AT=375.025n

* CHECK dout1_57 Vdout1_57ck74 = 0 time = 375
.meas tran vdout1_57ck74 FIND v(dout1_57) AT=375.025n

* CHECK dout1_58 Vdout1_58ck74 = 0 time = 375
.meas tran vdout1_58ck74 FIND v(dout1_58) AT=375.025n

* CHECK dout1_59 Vdout1_59ck74 = 0 time = 375
.meas tran vdout1_59ck74 FIND v(dout1_59) AT=375.025n

* CHECK dout1_60 Vdout1_60ck74 = 0.9 time = 375
.meas tran vdout1_60ck74 FIND v(dout1_60) AT=375.025n

* CHECK dout1_61 Vdout1_61ck74 = 0 time = 375
.meas tran vdout1_61ck74 FIND v(dout1_61) AT=375.025n

* CHECK dout1_62 Vdout1_62ck74 = 0.9 time = 375
.meas tran vdout1_62ck74 FIND v(dout1_62) AT=375.025n

* CHECK dout1_63 Vdout1_63ck74 = 0 time = 375
.meas tran vdout1_63ck74 FIND v(dout1_63) AT=375.025n

* CHECK dout1_64 Vdout1_64ck74 = 0.9 time = 375
.meas tran vdout1_64ck74 FIND v(dout1_64) AT=375.025n

* CHECK dout1_65 Vdout1_65ck74 = 0.9 time = 375
.meas tran vdout1_65ck74 FIND v(dout1_65) AT=375.025n

* CHECK dout1_66 Vdout1_66ck74 = 0 time = 375
.meas tran vdout1_66ck74 FIND v(dout1_66) AT=375.025n

* CHECK dout1_67 Vdout1_67ck74 = 0.9 time = 375
.meas tran vdout1_67ck74 FIND v(dout1_67) AT=375.025n

* CHECK dout1_68 Vdout1_68ck74 = 0 time = 375
.meas tran vdout1_68ck74 FIND v(dout1_68) AT=375.025n

* CHECK dout1_69 Vdout1_69ck74 = 0 time = 375
.meas tran vdout1_69ck74 FIND v(dout1_69) AT=375.025n

* CHECK dout1_70 Vdout1_70ck74 = 0 time = 375
.meas tran vdout1_70ck74 FIND v(dout1_70) AT=375.025n

* CHECK dout1_71 Vdout1_71ck74 = 0 time = 375
.meas tran vdout1_71ck74 FIND v(dout1_71) AT=375.025n

* CHECK dout1_72 Vdout1_72ck74 = 0.9 time = 375
.meas tran vdout1_72ck74 FIND v(dout1_72) AT=375.025n

* CHECK dout1_73 Vdout1_73ck74 = 0.9 time = 375
.meas tran vdout1_73ck74 FIND v(dout1_73) AT=375.025n

* CHECK dout1_74 Vdout1_74ck74 = 0 time = 375
.meas tran vdout1_74ck74 FIND v(dout1_74) AT=375.025n

* CHECK dout1_75 Vdout1_75ck74 = 0.9 time = 375
.meas tran vdout1_75ck74 FIND v(dout1_75) AT=375.025n

* CHECK dout1_76 Vdout1_76ck74 = 0.9 time = 375
.meas tran vdout1_76ck74 FIND v(dout1_76) AT=375.025n

* CHECK dout1_77 Vdout1_77ck74 = 0.9 time = 375
.meas tran vdout1_77ck74 FIND v(dout1_77) AT=375.025n

* CHECK dout1_78 Vdout1_78ck74 = 0.9 time = 375
.meas tran vdout1_78ck74 FIND v(dout1_78) AT=375.025n

* CHECK dout1_79 Vdout1_79ck74 = 0.9 time = 375
.meas tran vdout1_79ck74 FIND v(dout1_79) AT=375.025n

* CHECK dout1_80 Vdout1_80ck74 = 0.9 time = 375
.meas tran vdout1_80ck74 FIND v(dout1_80) AT=375.025n

* CHECK dout1_81 Vdout1_81ck74 = 0 time = 375
.meas tran vdout1_81ck74 FIND v(dout1_81) AT=375.025n

* CHECK dout1_82 Vdout1_82ck74 = 0.9 time = 375
.meas tran vdout1_82ck74 FIND v(dout1_82) AT=375.025n

* CHECK dout1_83 Vdout1_83ck74 = 0.9 time = 375
.meas tran vdout1_83ck74 FIND v(dout1_83) AT=375.025n

* CHECK dout1_84 Vdout1_84ck74 = 0.9 time = 375
.meas tran vdout1_84ck74 FIND v(dout1_84) AT=375.025n

* CHECK dout1_85 Vdout1_85ck74 = 0 time = 375
.meas tran vdout1_85ck74 FIND v(dout1_85) AT=375.025n

* CHECK dout1_86 Vdout1_86ck74 = 0.9 time = 375
.meas tran vdout1_86ck74 FIND v(dout1_86) AT=375.025n

* CHECK dout1_87 Vdout1_87ck74 = 0 time = 375
.meas tran vdout1_87ck74 FIND v(dout1_87) AT=375.025n

* CHECK dout1_88 Vdout1_88ck74 = 0 time = 375
.meas tran vdout1_88ck74 FIND v(dout1_88) AT=375.025n

* CHECK dout1_89 Vdout1_89ck74 = 0.9 time = 375
.meas tran vdout1_89ck74 FIND v(dout1_89) AT=375.025n

* CHECK dout1_90 Vdout1_90ck74 = 0.9 time = 375
.meas tran vdout1_90ck74 FIND v(dout1_90) AT=375.025n

* CHECK dout1_91 Vdout1_91ck74 = 0 time = 375
.meas tran vdout1_91ck74 FIND v(dout1_91) AT=375.025n

* CHECK dout1_92 Vdout1_92ck74 = 0 time = 375
.meas tran vdout1_92ck74 FIND v(dout1_92) AT=375.025n

* CHECK dout1_93 Vdout1_93ck74 = 0 time = 375
.meas tran vdout1_93ck74 FIND v(dout1_93) AT=375.025n

* CHECK dout1_94 Vdout1_94ck74 = 0 time = 375
.meas tran vdout1_94ck74 FIND v(dout1_94) AT=375.025n

* CHECK dout1_95 Vdout1_95ck74 = 0.9 time = 375
.meas tran vdout1_95ck74 FIND v(dout1_95) AT=375.025n

* CHECK dout1_96 Vdout1_96ck74 = 0 time = 375
.meas tran vdout1_96ck74 FIND v(dout1_96) AT=375.025n

* CHECK dout1_97 Vdout1_97ck74 = 0.9 time = 375
.meas tran vdout1_97ck74 FIND v(dout1_97) AT=375.025n

* CHECK dout1_98 Vdout1_98ck74 = 0.9 time = 375
.meas tran vdout1_98ck74 FIND v(dout1_98) AT=375.025n

* CHECK dout1_99 Vdout1_99ck74 = 0.9 time = 375
.meas tran vdout1_99ck74 FIND v(dout1_99) AT=375.025n

* CHECK dout1_100 Vdout1_100ck74 = 0.9 time = 375
.meas tran vdout1_100ck74 FIND v(dout1_100) AT=375.025n

* CHECK dout1_101 Vdout1_101ck74 = 0.9 time = 375
.meas tran vdout1_101ck74 FIND v(dout1_101) AT=375.025n

* CHECK dout1_102 Vdout1_102ck74 = 0 time = 375
.meas tran vdout1_102ck74 FIND v(dout1_102) AT=375.025n

* CHECK dout1_103 Vdout1_103ck74 = 0.9 time = 375
.meas tran vdout1_103ck74 FIND v(dout1_103) AT=375.025n

* CHECK dout1_104 Vdout1_104ck74 = 0.9 time = 375
.meas tran vdout1_104ck74 FIND v(dout1_104) AT=375.025n

* CHECK dout1_105 Vdout1_105ck74 = 0 time = 375
.meas tran vdout1_105ck74 FIND v(dout1_105) AT=375.025n

* CHECK dout1_106 Vdout1_106ck74 = 0.9 time = 375
.meas tran vdout1_106ck74 FIND v(dout1_106) AT=375.025n

* CHECK dout1_107 Vdout1_107ck74 = 0.9 time = 375
.meas tran vdout1_107ck74 FIND v(dout1_107) AT=375.025n

* CHECK dout1_108 Vdout1_108ck74 = 0 time = 375
.meas tran vdout1_108ck74 FIND v(dout1_108) AT=375.025n

* CHECK dout1_109 Vdout1_109ck74 = 0 time = 375
.meas tran vdout1_109ck74 FIND v(dout1_109) AT=375.025n

* CHECK dout1_110 Vdout1_110ck74 = 0.9 time = 375
.meas tran vdout1_110ck74 FIND v(dout1_110) AT=375.025n

* CHECK dout1_111 Vdout1_111ck74 = 0.9 time = 375
.meas tran vdout1_111ck74 FIND v(dout1_111) AT=375.025n

* CHECK dout1_112 Vdout1_112ck74 = 0 time = 375
.meas tran vdout1_112ck74 FIND v(dout1_112) AT=375.025n

* CHECK dout1_113 Vdout1_113ck74 = 0.9 time = 375
.meas tran vdout1_113ck74 FIND v(dout1_113) AT=375.025n

* CHECK dout1_114 Vdout1_114ck74 = 0.9 time = 375
.meas tran vdout1_114ck74 FIND v(dout1_114) AT=375.025n

* CHECK dout1_115 Vdout1_115ck74 = 0 time = 375
.meas tran vdout1_115ck74 FIND v(dout1_115) AT=375.025n

* CHECK dout1_116 Vdout1_116ck74 = 0 time = 375
.meas tran vdout1_116ck74 FIND v(dout1_116) AT=375.025n

* CHECK dout1_117 Vdout1_117ck74 = 0 time = 375
.meas tran vdout1_117ck74 FIND v(dout1_117) AT=375.025n

* CHECK dout1_118 Vdout1_118ck74 = 0.9 time = 375
.meas tran vdout1_118ck74 FIND v(dout1_118) AT=375.025n

* CHECK dout1_119 Vdout1_119ck74 = 0.9 time = 375
.meas tran vdout1_119ck74 FIND v(dout1_119) AT=375.025n

* CHECK dout1_0 Vdout1_0ck75 = 0.9 time = 380
.meas tran vdout1_0ck75 FIND v(dout1_0) AT=380.025n

* CHECK dout1_1 Vdout1_1ck75 = 0.9 time = 380
.meas tran vdout1_1ck75 FIND v(dout1_1) AT=380.025n

* CHECK dout1_2 Vdout1_2ck75 = 0 time = 380
.meas tran vdout1_2ck75 FIND v(dout1_2) AT=380.025n

* CHECK dout1_3 Vdout1_3ck75 = 0 time = 380
.meas tran vdout1_3ck75 FIND v(dout1_3) AT=380.025n

* CHECK dout1_4 Vdout1_4ck75 = 0.9 time = 380
.meas tran vdout1_4ck75 FIND v(dout1_4) AT=380.025n

* CHECK dout1_5 Vdout1_5ck75 = 0.9 time = 380
.meas tran vdout1_5ck75 FIND v(dout1_5) AT=380.025n

* CHECK dout1_6 Vdout1_6ck75 = 0.9 time = 380
.meas tran vdout1_6ck75 FIND v(dout1_6) AT=380.025n

* CHECK dout1_7 Vdout1_7ck75 = 0.9 time = 380
.meas tran vdout1_7ck75 FIND v(dout1_7) AT=380.025n

* CHECK dout1_8 Vdout1_8ck75 = 0 time = 380
.meas tran vdout1_8ck75 FIND v(dout1_8) AT=380.025n

* CHECK dout1_9 Vdout1_9ck75 = 0 time = 380
.meas tran vdout1_9ck75 FIND v(dout1_9) AT=380.025n

* CHECK dout1_10 Vdout1_10ck75 = 0.9 time = 380
.meas tran vdout1_10ck75 FIND v(dout1_10) AT=380.025n

* CHECK dout1_11 Vdout1_11ck75 = 0.9 time = 380
.meas tran vdout1_11ck75 FIND v(dout1_11) AT=380.025n

* CHECK dout1_12 Vdout1_12ck75 = 0 time = 380
.meas tran vdout1_12ck75 FIND v(dout1_12) AT=380.025n

* CHECK dout1_13 Vdout1_13ck75 = 0 time = 380
.meas tran vdout1_13ck75 FIND v(dout1_13) AT=380.025n

* CHECK dout1_14 Vdout1_14ck75 = 0.9 time = 380
.meas tran vdout1_14ck75 FIND v(dout1_14) AT=380.025n

* CHECK dout1_15 Vdout1_15ck75 = 0.9 time = 380
.meas tran vdout1_15ck75 FIND v(dout1_15) AT=380.025n

* CHECK dout1_16 Vdout1_16ck75 = 0.9 time = 380
.meas tran vdout1_16ck75 FIND v(dout1_16) AT=380.025n

* CHECK dout1_17 Vdout1_17ck75 = 0.9 time = 380
.meas tran vdout1_17ck75 FIND v(dout1_17) AT=380.025n

* CHECK dout1_18 Vdout1_18ck75 = 0 time = 380
.meas tran vdout1_18ck75 FIND v(dout1_18) AT=380.025n

* CHECK dout1_19 Vdout1_19ck75 = 0.9 time = 380
.meas tran vdout1_19ck75 FIND v(dout1_19) AT=380.025n

* CHECK dout1_20 Vdout1_20ck75 = 0 time = 380
.meas tran vdout1_20ck75 FIND v(dout1_20) AT=380.025n

* CHECK dout1_21 Vdout1_21ck75 = 0.9 time = 380
.meas tran vdout1_21ck75 FIND v(dout1_21) AT=380.025n

* CHECK dout1_22 Vdout1_22ck75 = 0 time = 380
.meas tran vdout1_22ck75 FIND v(dout1_22) AT=380.025n

* CHECK dout1_23 Vdout1_23ck75 = 0 time = 380
.meas tran vdout1_23ck75 FIND v(dout1_23) AT=380.025n

* CHECK dout1_24 Vdout1_24ck75 = 0.9 time = 380
.meas tran vdout1_24ck75 FIND v(dout1_24) AT=380.025n

* CHECK dout1_25 Vdout1_25ck75 = 0.9 time = 380
.meas tran vdout1_25ck75 FIND v(dout1_25) AT=380.025n

* CHECK dout1_26 Vdout1_26ck75 = 0.9 time = 380
.meas tran vdout1_26ck75 FIND v(dout1_26) AT=380.025n

* CHECK dout1_27 Vdout1_27ck75 = 0 time = 380
.meas tran vdout1_27ck75 FIND v(dout1_27) AT=380.025n

* CHECK dout1_28 Vdout1_28ck75 = 0 time = 380
.meas tran vdout1_28ck75 FIND v(dout1_28) AT=380.025n

* CHECK dout1_29 Vdout1_29ck75 = 0.9 time = 380
.meas tran vdout1_29ck75 FIND v(dout1_29) AT=380.025n

* CHECK dout1_30 Vdout1_30ck75 = 0.9 time = 380
.meas tran vdout1_30ck75 FIND v(dout1_30) AT=380.025n

* CHECK dout1_31 Vdout1_31ck75 = 0 time = 380
.meas tran vdout1_31ck75 FIND v(dout1_31) AT=380.025n

* CHECK dout1_32 Vdout1_32ck75 = 0.9 time = 380
.meas tran vdout1_32ck75 FIND v(dout1_32) AT=380.025n

* CHECK dout1_33 Vdout1_33ck75 = 0 time = 380
.meas tran vdout1_33ck75 FIND v(dout1_33) AT=380.025n

* CHECK dout1_34 Vdout1_34ck75 = 0 time = 380
.meas tran vdout1_34ck75 FIND v(dout1_34) AT=380.025n

* CHECK dout1_35 Vdout1_35ck75 = 0.9 time = 380
.meas tran vdout1_35ck75 FIND v(dout1_35) AT=380.025n

* CHECK dout1_36 Vdout1_36ck75 = 0.9 time = 380
.meas tran vdout1_36ck75 FIND v(dout1_36) AT=380.025n

* CHECK dout1_37 Vdout1_37ck75 = 0.9 time = 380
.meas tran vdout1_37ck75 FIND v(dout1_37) AT=380.025n

* CHECK dout1_38 Vdout1_38ck75 = 0 time = 380
.meas tran vdout1_38ck75 FIND v(dout1_38) AT=380.025n

* CHECK dout1_39 Vdout1_39ck75 = 0.9 time = 380
.meas tran vdout1_39ck75 FIND v(dout1_39) AT=380.025n

* CHECK dout1_40 Vdout1_40ck75 = 0.9 time = 380
.meas tran vdout1_40ck75 FIND v(dout1_40) AT=380.025n

* CHECK dout1_41 Vdout1_41ck75 = 0.9 time = 380
.meas tran vdout1_41ck75 FIND v(dout1_41) AT=380.025n

* CHECK dout1_42 Vdout1_42ck75 = 0 time = 380
.meas tran vdout1_42ck75 FIND v(dout1_42) AT=380.025n

* CHECK dout1_43 Vdout1_43ck75 = 0 time = 380
.meas tran vdout1_43ck75 FIND v(dout1_43) AT=380.025n

* CHECK dout1_44 Vdout1_44ck75 = 0 time = 380
.meas tran vdout1_44ck75 FIND v(dout1_44) AT=380.025n

* CHECK dout1_45 Vdout1_45ck75 = 0.9 time = 380
.meas tran vdout1_45ck75 FIND v(dout1_45) AT=380.025n

* CHECK dout1_46 Vdout1_46ck75 = 0 time = 380
.meas tran vdout1_46ck75 FIND v(dout1_46) AT=380.025n

* CHECK dout1_47 Vdout1_47ck75 = 0 time = 380
.meas tran vdout1_47ck75 FIND v(dout1_47) AT=380.025n

* CHECK dout1_48 Vdout1_48ck75 = 0.9 time = 380
.meas tran vdout1_48ck75 FIND v(dout1_48) AT=380.025n

* CHECK dout1_49 Vdout1_49ck75 = 0 time = 380
.meas tran vdout1_49ck75 FIND v(dout1_49) AT=380.025n

* CHECK dout1_50 Vdout1_50ck75 = 0 time = 380
.meas tran vdout1_50ck75 FIND v(dout1_50) AT=380.025n

* CHECK dout1_51 Vdout1_51ck75 = 0.9 time = 380
.meas tran vdout1_51ck75 FIND v(dout1_51) AT=380.025n

* CHECK dout1_52 Vdout1_52ck75 = 0.9 time = 380
.meas tran vdout1_52ck75 FIND v(dout1_52) AT=380.025n

* CHECK dout1_53 Vdout1_53ck75 = 0.9 time = 380
.meas tran vdout1_53ck75 FIND v(dout1_53) AT=380.025n

* CHECK dout1_54 Vdout1_54ck75 = 0 time = 380
.meas tran vdout1_54ck75 FIND v(dout1_54) AT=380.025n

* CHECK dout1_55 Vdout1_55ck75 = 0.9 time = 380
.meas tran vdout1_55ck75 FIND v(dout1_55) AT=380.025n

* CHECK dout1_56 Vdout1_56ck75 = 0 time = 380
.meas tran vdout1_56ck75 FIND v(dout1_56) AT=380.025n

* CHECK dout1_57 Vdout1_57ck75 = 0 time = 380
.meas tran vdout1_57ck75 FIND v(dout1_57) AT=380.025n

* CHECK dout1_58 Vdout1_58ck75 = 0 time = 380
.meas tran vdout1_58ck75 FIND v(dout1_58) AT=380.025n

* CHECK dout1_59 Vdout1_59ck75 = 0 time = 380
.meas tran vdout1_59ck75 FIND v(dout1_59) AT=380.025n

* CHECK dout1_60 Vdout1_60ck75 = 0.9 time = 380
.meas tran vdout1_60ck75 FIND v(dout1_60) AT=380.025n

* CHECK dout1_61 Vdout1_61ck75 = 0 time = 380
.meas tran vdout1_61ck75 FIND v(dout1_61) AT=380.025n

* CHECK dout1_62 Vdout1_62ck75 = 0.9 time = 380
.meas tran vdout1_62ck75 FIND v(dout1_62) AT=380.025n

* CHECK dout1_63 Vdout1_63ck75 = 0 time = 380
.meas tran vdout1_63ck75 FIND v(dout1_63) AT=380.025n

* CHECK dout1_64 Vdout1_64ck75 = 0.9 time = 380
.meas tran vdout1_64ck75 FIND v(dout1_64) AT=380.025n

* CHECK dout1_65 Vdout1_65ck75 = 0.9 time = 380
.meas tran vdout1_65ck75 FIND v(dout1_65) AT=380.025n

* CHECK dout1_66 Vdout1_66ck75 = 0 time = 380
.meas tran vdout1_66ck75 FIND v(dout1_66) AT=380.025n

* CHECK dout1_67 Vdout1_67ck75 = 0.9 time = 380
.meas tran vdout1_67ck75 FIND v(dout1_67) AT=380.025n

* CHECK dout1_68 Vdout1_68ck75 = 0 time = 380
.meas tran vdout1_68ck75 FIND v(dout1_68) AT=380.025n

* CHECK dout1_69 Vdout1_69ck75 = 0 time = 380
.meas tran vdout1_69ck75 FIND v(dout1_69) AT=380.025n

* CHECK dout1_70 Vdout1_70ck75 = 0 time = 380
.meas tran vdout1_70ck75 FIND v(dout1_70) AT=380.025n

* CHECK dout1_71 Vdout1_71ck75 = 0 time = 380
.meas tran vdout1_71ck75 FIND v(dout1_71) AT=380.025n

* CHECK dout1_72 Vdout1_72ck75 = 0.9 time = 380
.meas tran vdout1_72ck75 FIND v(dout1_72) AT=380.025n

* CHECK dout1_73 Vdout1_73ck75 = 0.9 time = 380
.meas tran vdout1_73ck75 FIND v(dout1_73) AT=380.025n

* CHECK dout1_74 Vdout1_74ck75 = 0 time = 380
.meas tran vdout1_74ck75 FIND v(dout1_74) AT=380.025n

* CHECK dout1_75 Vdout1_75ck75 = 0.9 time = 380
.meas tran vdout1_75ck75 FIND v(dout1_75) AT=380.025n

* CHECK dout1_76 Vdout1_76ck75 = 0.9 time = 380
.meas tran vdout1_76ck75 FIND v(dout1_76) AT=380.025n

* CHECK dout1_77 Vdout1_77ck75 = 0.9 time = 380
.meas tran vdout1_77ck75 FIND v(dout1_77) AT=380.025n

* CHECK dout1_78 Vdout1_78ck75 = 0.9 time = 380
.meas tran vdout1_78ck75 FIND v(dout1_78) AT=380.025n

* CHECK dout1_79 Vdout1_79ck75 = 0.9 time = 380
.meas tran vdout1_79ck75 FIND v(dout1_79) AT=380.025n

* CHECK dout1_80 Vdout1_80ck75 = 0.9 time = 380
.meas tran vdout1_80ck75 FIND v(dout1_80) AT=380.025n

* CHECK dout1_81 Vdout1_81ck75 = 0 time = 380
.meas tran vdout1_81ck75 FIND v(dout1_81) AT=380.025n

* CHECK dout1_82 Vdout1_82ck75 = 0.9 time = 380
.meas tran vdout1_82ck75 FIND v(dout1_82) AT=380.025n

* CHECK dout1_83 Vdout1_83ck75 = 0.9 time = 380
.meas tran vdout1_83ck75 FIND v(dout1_83) AT=380.025n

* CHECK dout1_84 Vdout1_84ck75 = 0.9 time = 380
.meas tran vdout1_84ck75 FIND v(dout1_84) AT=380.025n

* CHECK dout1_85 Vdout1_85ck75 = 0 time = 380
.meas tran vdout1_85ck75 FIND v(dout1_85) AT=380.025n

* CHECK dout1_86 Vdout1_86ck75 = 0.9 time = 380
.meas tran vdout1_86ck75 FIND v(dout1_86) AT=380.025n

* CHECK dout1_87 Vdout1_87ck75 = 0 time = 380
.meas tran vdout1_87ck75 FIND v(dout1_87) AT=380.025n

* CHECK dout1_88 Vdout1_88ck75 = 0 time = 380
.meas tran vdout1_88ck75 FIND v(dout1_88) AT=380.025n

* CHECK dout1_89 Vdout1_89ck75 = 0.9 time = 380
.meas tran vdout1_89ck75 FIND v(dout1_89) AT=380.025n

* CHECK dout1_90 Vdout1_90ck75 = 0.9 time = 380
.meas tran vdout1_90ck75 FIND v(dout1_90) AT=380.025n

* CHECK dout1_91 Vdout1_91ck75 = 0 time = 380
.meas tran vdout1_91ck75 FIND v(dout1_91) AT=380.025n

* CHECK dout1_92 Vdout1_92ck75 = 0 time = 380
.meas tran vdout1_92ck75 FIND v(dout1_92) AT=380.025n

* CHECK dout1_93 Vdout1_93ck75 = 0 time = 380
.meas tran vdout1_93ck75 FIND v(dout1_93) AT=380.025n

* CHECK dout1_94 Vdout1_94ck75 = 0 time = 380
.meas tran vdout1_94ck75 FIND v(dout1_94) AT=380.025n

* CHECK dout1_95 Vdout1_95ck75 = 0.9 time = 380
.meas tran vdout1_95ck75 FIND v(dout1_95) AT=380.025n

* CHECK dout1_96 Vdout1_96ck75 = 0 time = 380
.meas tran vdout1_96ck75 FIND v(dout1_96) AT=380.025n

* CHECK dout1_97 Vdout1_97ck75 = 0.9 time = 380
.meas tran vdout1_97ck75 FIND v(dout1_97) AT=380.025n

* CHECK dout1_98 Vdout1_98ck75 = 0.9 time = 380
.meas tran vdout1_98ck75 FIND v(dout1_98) AT=380.025n

* CHECK dout1_99 Vdout1_99ck75 = 0.9 time = 380
.meas tran vdout1_99ck75 FIND v(dout1_99) AT=380.025n

* CHECK dout1_100 Vdout1_100ck75 = 0.9 time = 380
.meas tran vdout1_100ck75 FIND v(dout1_100) AT=380.025n

* CHECK dout1_101 Vdout1_101ck75 = 0.9 time = 380
.meas tran vdout1_101ck75 FIND v(dout1_101) AT=380.025n

* CHECK dout1_102 Vdout1_102ck75 = 0 time = 380
.meas tran vdout1_102ck75 FIND v(dout1_102) AT=380.025n

* CHECK dout1_103 Vdout1_103ck75 = 0.9 time = 380
.meas tran vdout1_103ck75 FIND v(dout1_103) AT=380.025n

* CHECK dout1_104 Vdout1_104ck75 = 0.9 time = 380
.meas tran vdout1_104ck75 FIND v(dout1_104) AT=380.025n

* CHECK dout1_105 Vdout1_105ck75 = 0 time = 380
.meas tran vdout1_105ck75 FIND v(dout1_105) AT=380.025n

* CHECK dout1_106 Vdout1_106ck75 = 0.9 time = 380
.meas tran vdout1_106ck75 FIND v(dout1_106) AT=380.025n

* CHECK dout1_107 Vdout1_107ck75 = 0.9 time = 380
.meas tran vdout1_107ck75 FIND v(dout1_107) AT=380.025n

* CHECK dout1_108 Vdout1_108ck75 = 0 time = 380
.meas tran vdout1_108ck75 FIND v(dout1_108) AT=380.025n

* CHECK dout1_109 Vdout1_109ck75 = 0 time = 380
.meas tran vdout1_109ck75 FIND v(dout1_109) AT=380.025n

* CHECK dout1_110 Vdout1_110ck75 = 0.9 time = 380
.meas tran vdout1_110ck75 FIND v(dout1_110) AT=380.025n

* CHECK dout1_111 Vdout1_111ck75 = 0.9 time = 380
.meas tran vdout1_111ck75 FIND v(dout1_111) AT=380.025n

* CHECK dout1_112 Vdout1_112ck75 = 0 time = 380
.meas tran vdout1_112ck75 FIND v(dout1_112) AT=380.025n

* CHECK dout1_113 Vdout1_113ck75 = 0.9 time = 380
.meas tran vdout1_113ck75 FIND v(dout1_113) AT=380.025n

* CHECK dout1_114 Vdout1_114ck75 = 0.9 time = 380
.meas tran vdout1_114ck75 FIND v(dout1_114) AT=380.025n

* CHECK dout1_115 Vdout1_115ck75 = 0 time = 380
.meas tran vdout1_115ck75 FIND v(dout1_115) AT=380.025n

* CHECK dout1_116 Vdout1_116ck75 = 0 time = 380
.meas tran vdout1_116ck75 FIND v(dout1_116) AT=380.025n

* CHECK dout1_117 Vdout1_117ck75 = 0 time = 380
.meas tran vdout1_117ck75 FIND v(dout1_117) AT=380.025n

* CHECK dout1_118 Vdout1_118ck75 = 0.9 time = 380
.meas tran vdout1_118ck75 FIND v(dout1_118) AT=380.025n

* CHECK dout1_119 Vdout1_119ck75 = 0.9 time = 380
.meas tran vdout1_119ck75 FIND v(dout1_119) AT=380.025n

* CHECK dout1_0 Vdout1_0ck77 = 0.9 time = 390
.meas tran vdout1_0ck77 FIND v(dout1_0) AT=390.025n

* CHECK dout1_1 Vdout1_1ck77 = 0 time = 390
.meas tran vdout1_1ck77 FIND v(dout1_1) AT=390.025n

* CHECK dout1_2 Vdout1_2ck77 = 0.9 time = 390
.meas tran vdout1_2ck77 FIND v(dout1_2) AT=390.025n

* CHECK dout1_3 Vdout1_3ck77 = 0 time = 390
.meas tran vdout1_3ck77 FIND v(dout1_3) AT=390.025n

* CHECK dout1_4 Vdout1_4ck77 = 0 time = 390
.meas tran vdout1_4ck77 FIND v(dout1_4) AT=390.025n

* CHECK dout1_5 Vdout1_5ck77 = 0.9 time = 390
.meas tran vdout1_5ck77 FIND v(dout1_5) AT=390.025n

* CHECK dout1_6 Vdout1_6ck77 = 0.9 time = 390
.meas tran vdout1_6ck77 FIND v(dout1_6) AT=390.025n

* CHECK dout1_7 Vdout1_7ck77 = 0 time = 390
.meas tran vdout1_7ck77 FIND v(dout1_7) AT=390.025n

* CHECK dout1_8 Vdout1_8ck77 = 0 time = 390
.meas tran vdout1_8ck77 FIND v(dout1_8) AT=390.025n

* CHECK dout1_9 Vdout1_9ck77 = 0 time = 390
.meas tran vdout1_9ck77 FIND v(dout1_9) AT=390.025n

* CHECK dout1_10 Vdout1_10ck77 = 0 time = 390
.meas tran vdout1_10ck77 FIND v(dout1_10) AT=390.025n

* CHECK dout1_11 Vdout1_11ck77 = 0 time = 390
.meas tran vdout1_11ck77 FIND v(dout1_11) AT=390.025n

* CHECK dout1_12 Vdout1_12ck77 = 0.9 time = 390
.meas tran vdout1_12ck77 FIND v(dout1_12) AT=390.025n

* CHECK dout1_13 Vdout1_13ck77 = 0.9 time = 390
.meas tran vdout1_13ck77 FIND v(dout1_13) AT=390.025n

* CHECK dout1_14 Vdout1_14ck77 = 0.9 time = 390
.meas tran vdout1_14ck77 FIND v(dout1_14) AT=390.025n

* CHECK dout1_15 Vdout1_15ck77 = 0 time = 390
.meas tran vdout1_15ck77 FIND v(dout1_15) AT=390.025n

* CHECK dout1_16 Vdout1_16ck77 = 0 time = 390
.meas tran vdout1_16ck77 FIND v(dout1_16) AT=390.025n

* CHECK dout1_17 Vdout1_17ck77 = 0.9 time = 390
.meas tran vdout1_17ck77 FIND v(dout1_17) AT=390.025n

* CHECK dout1_18 Vdout1_18ck77 = 0.9 time = 390
.meas tran vdout1_18ck77 FIND v(dout1_18) AT=390.025n

* CHECK dout1_19 Vdout1_19ck77 = 0 time = 390
.meas tran vdout1_19ck77 FIND v(dout1_19) AT=390.025n

* CHECK dout1_20 Vdout1_20ck77 = 0 time = 390
.meas tran vdout1_20ck77 FIND v(dout1_20) AT=390.025n

* CHECK dout1_21 Vdout1_21ck77 = 0 time = 390
.meas tran vdout1_21ck77 FIND v(dout1_21) AT=390.025n

* CHECK dout1_22 Vdout1_22ck77 = 0.9 time = 390
.meas tran vdout1_22ck77 FIND v(dout1_22) AT=390.025n

* CHECK dout1_23 Vdout1_23ck77 = 0 time = 390
.meas tran vdout1_23ck77 FIND v(dout1_23) AT=390.025n

* CHECK dout1_24 Vdout1_24ck77 = 0.9 time = 390
.meas tran vdout1_24ck77 FIND v(dout1_24) AT=390.025n

* CHECK dout1_25 Vdout1_25ck77 = 0.9 time = 390
.meas tran vdout1_25ck77 FIND v(dout1_25) AT=390.025n

* CHECK dout1_26 Vdout1_26ck77 = 0.9 time = 390
.meas tran vdout1_26ck77 FIND v(dout1_26) AT=390.025n

* CHECK dout1_27 Vdout1_27ck77 = 0.9 time = 390
.meas tran vdout1_27ck77 FIND v(dout1_27) AT=390.025n

* CHECK dout1_28 Vdout1_28ck77 = 0 time = 390
.meas tran vdout1_28ck77 FIND v(dout1_28) AT=390.025n

* CHECK dout1_29 Vdout1_29ck77 = 0 time = 390
.meas tran vdout1_29ck77 FIND v(dout1_29) AT=390.025n

* CHECK dout1_30 Vdout1_30ck77 = 0 time = 390
.meas tran vdout1_30ck77 FIND v(dout1_30) AT=390.025n

* CHECK dout1_31 Vdout1_31ck77 = 0.9 time = 390
.meas tran vdout1_31ck77 FIND v(dout1_31) AT=390.025n

* CHECK dout1_32 Vdout1_32ck77 = 0 time = 390
.meas tran vdout1_32ck77 FIND v(dout1_32) AT=390.025n

* CHECK dout1_33 Vdout1_33ck77 = 0 time = 390
.meas tran vdout1_33ck77 FIND v(dout1_33) AT=390.025n

* CHECK dout1_34 Vdout1_34ck77 = 0 time = 390
.meas tran vdout1_34ck77 FIND v(dout1_34) AT=390.025n

* CHECK dout1_35 Vdout1_35ck77 = 0 time = 390
.meas tran vdout1_35ck77 FIND v(dout1_35) AT=390.025n

* CHECK dout1_36 Vdout1_36ck77 = 0 time = 390
.meas tran vdout1_36ck77 FIND v(dout1_36) AT=390.025n

* CHECK dout1_37 Vdout1_37ck77 = 0 time = 390
.meas tran vdout1_37ck77 FIND v(dout1_37) AT=390.025n

* CHECK dout1_38 Vdout1_38ck77 = 0.9 time = 390
.meas tran vdout1_38ck77 FIND v(dout1_38) AT=390.025n

* CHECK dout1_39 Vdout1_39ck77 = 0 time = 390
.meas tran vdout1_39ck77 FIND v(dout1_39) AT=390.025n

* CHECK dout1_40 Vdout1_40ck77 = 0.9 time = 390
.meas tran vdout1_40ck77 FIND v(dout1_40) AT=390.025n

* CHECK dout1_41 Vdout1_41ck77 = 0.9 time = 390
.meas tran vdout1_41ck77 FIND v(dout1_41) AT=390.025n

* CHECK dout1_42 Vdout1_42ck77 = 0 time = 390
.meas tran vdout1_42ck77 FIND v(dout1_42) AT=390.025n

* CHECK dout1_43 Vdout1_43ck77 = 0.9 time = 390
.meas tran vdout1_43ck77 FIND v(dout1_43) AT=390.025n

* CHECK dout1_44 Vdout1_44ck77 = 0 time = 390
.meas tran vdout1_44ck77 FIND v(dout1_44) AT=390.025n

* CHECK dout1_45 Vdout1_45ck77 = 0 time = 390
.meas tran vdout1_45ck77 FIND v(dout1_45) AT=390.025n

* CHECK dout1_46 Vdout1_46ck77 = 0 time = 390
.meas tran vdout1_46ck77 FIND v(dout1_46) AT=390.025n

* CHECK dout1_47 Vdout1_47ck77 = 0 time = 390
.meas tran vdout1_47ck77 FIND v(dout1_47) AT=390.025n

* CHECK dout1_48 Vdout1_48ck77 = 0 time = 390
.meas tran vdout1_48ck77 FIND v(dout1_48) AT=390.025n

* CHECK dout1_49 Vdout1_49ck77 = 0 time = 390
.meas tran vdout1_49ck77 FIND v(dout1_49) AT=390.025n

* CHECK dout1_50 Vdout1_50ck77 = 0 time = 390
.meas tran vdout1_50ck77 FIND v(dout1_50) AT=390.025n

* CHECK dout1_51 Vdout1_51ck77 = 0.9 time = 390
.meas tran vdout1_51ck77 FIND v(dout1_51) AT=390.025n

* CHECK dout1_52 Vdout1_52ck77 = 0.9 time = 390
.meas tran vdout1_52ck77 FIND v(dout1_52) AT=390.025n

* CHECK dout1_53 Vdout1_53ck77 = 0 time = 390
.meas tran vdout1_53ck77 FIND v(dout1_53) AT=390.025n

* CHECK dout1_54 Vdout1_54ck77 = 0.9 time = 390
.meas tran vdout1_54ck77 FIND v(dout1_54) AT=390.025n

* CHECK dout1_55 Vdout1_55ck77 = 0 time = 390
.meas tran vdout1_55ck77 FIND v(dout1_55) AT=390.025n

* CHECK dout1_56 Vdout1_56ck77 = 0 time = 390
.meas tran vdout1_56ck77 FIND v(dout1_56) AT=390.025n

* CHECK dout1_57 Vdout1_57ck77 = 0.9 time = 390
.meas tran vdout1_57ck77 FIND v(dout1_57) AT=390.025n

* CHECK dout1_58 Vdout1_58ck77 = 0.9 time = 390
.meas tran vdout1_58ck77 FIND v(dout1_58) AT=390.025n

* CHECK dout1_59 Vdout1_59ck77 = 0.9 time = 390
.meas tran vdout1_59ck77 FIND v(dout1_59) AT=390.025n

* CHECK dout1_60 Vdout1_60ck77 = 0 time = 390
.meas tran vdout1_60ck77 FIND v(dout1_60) AT=390.025n

* CHECK dout1_61 Vdout1_61ck77 = 0 time = 390
.meas tran vdout1_61ck77 FIND v(dout1_61) AT=390.025n

* CHECK dout1_62 Vdout1_62ck77 = 0.9 time = 390
.meas tran vdout1_62ck77 FIND v(dout1_62) AT=390.025n

* CHECK dout1_63 Vdout1_63ck77 = 0.9 time = 390
.meas tran vdout1_63ck77 FIND v(dout1_63) AT=390.025n

* CHECK dout1_64 Vdout1_64ck77 = 0 time = 390
.meas tran vdout1_64ck77 FIND v(dout1_64) AT=390.025n

* CHECK dout1_65 Vdout1_65ck77 = 0 time = 390
.meas tran vdout1_65ck77 FIND v(dout1_65) AT=390.025n

* CHECK dout1_66 Vdout1_66ck77 = 0 time = 390
.meas tran vdout1_66ck77 FIND v(dout1_66) AT=390.025n

* CHECK dout1_67 Vdout1_67ck77 = 0.9 time = 390
.meas tran vdout1_67ck77 FIND v(dout1_67) AT=390.025n

* CHECK dout1_68 Vdout1_68ck77 = 0.9 time = 390
.meas tran vdout1_68ck77 FIND v(dout1_68) AT=390.025n

* CHECK dout1_69 Vdout1_69ck77 = 0.9 time = 390
.meas tran vdout1_69ck77 FIND v(dout1_69) AT=390.025n

* CHECK dout1_70 Vdout1_70ck77 = 0.9 time = 390
.meas tran vdout1_70ck77 FIND v(dout1_70) AT=390.025n

* CHECK dout1_71 Vdout1_71ck77 = 0.9 time = 390
.meas tran vdout1_71ck77 FIND v(dout1_71) AT=390.025n

* CHECK dout1_72 Vdout1_72ck77 = 0.9 time = 390
.meas tran vdout1_72ck77 FIND v(dout1_72) AT=390.025n

* CHECK dout1_73 Vdout1_73ck77 = 0.9 time = 390
.meas tran vdout1_73ck77 FIND v(dout1_73) AT=390.025n

* CHECK dout1_74 Vdout1_74ck77 = 0 time = 390
.meas tran vdout1_74ck77 FIND v(dout1_74) AT=390.025n

* CHECK dout1_75 Vdout1_75ck77 = 0.9 time = 390
.meas tran vdout1_75ck77 FIND v(dout1_75) AT=390.025n

* CHECK dout1_76 Vdout1_76ck77 = 0.9 time = 390
.meas tran vdout1_76ck77 FIND v(dout1_76) AT=390.025n

* CHECK dout1_77 Vdout1_77ck77 = 0.9 time = 390
.meas tran vdout1_77ck77 FIND v(dout1_77) AT=390.025n

* CHECK dout1_78 Vdout1_78ck77 = 0 time = 390
.meas tran vdout1_78ck77 FIND v(dout1_78) AT=390.025n

* CHECK dout1_79 Vdout1_79ck77 = 0.9 time = 390
.meas tran vdout1_79ck77 FIND v(dout1_79) AT=390.025n

* CHECK dout1_80 Vdout1_80ck77 = 0.9 time = 390
.meas tran vdout1_80ck77 FIND v(dout1_80) AT=390.025n

* CHECK dout1_81 Vdout1_81ck77 = 0.9 time = 390
.meas tran vdout1_81ck77 FIND v(dout1_81) AT=390.025n

* CHECK dout1_82 Vdout1_82ck77 = 0.9 time = 390
.meas tran vdout1_82ck77 FIND v(dout1_82) AT=390.025n

* CHECK dout1_83 Vdout1_83ck77 = 0.9 time = 390
.meas tran vdout1_83ck77 FIND v(dout1_83) AT=390.025n

* CHECK dout1_84 Vdout1_84ck77 = 0.9 time = 390
.meas tran vdout1_84ck77 FIND v(dout1_84) AT=390.025n

* CHECK dout1_85 Vdout1_85ck77 = 0 time = 390
.meas tran vdout1_85ck77 FIND v(dout1_85) AT=390.025n

* CHECK dout1_86 Vdout1_86ck77 = 0 time = 390
.meas tran vdout1_86ck77 FIND v(dout1_86) AT=390.025n

* CHECK dout1_87 Vdout1_87ck77 = 0 time = 390
.meas tran vdout1_87ck77 FIND v(dout1_87) AT=390.025n

* CHECK dout1_88 Vdout1_88ck77 = 0 time = 390
.meas tran vdout1_88ck77 FIND v(dout1_88) AT=390.025n

* CHECK dout1_89 Vdout1_89ck77 = 0.9 time = 390
.meas tran vdout1_89ck77 FIND v(dout1_89) AT=390.025n

* CHECK dout1_90 Vdout1_90ck77 = 0.9 time = 390
.meas tran vdout1_90ck77 FIND v(dout1_90) AT=390.025n

* CHECK dout1_91 Vdout1_91ck77 = 0 time = 390
.meas tran vdout1_91ck77 FIND v(dout1_91) AT=390.025n

* CHECK dout1_92 Vdout1_92ck77 = 0 time = 390
.meas tran vdout1_92ck77 FIND v(dout1_92) AT=390.025n

* CHECK dout1_93 Vdout1_93ck77 = 0 time = 390
.meas tran vdout1_93ck77 FIND v(dout1_93) AT=390.025n

* CHECK dout1_94 Vdout1_94ck77 = 0 time = 390
.meas tran vdout1_94ck77 FIND v(dout1_94) AT=390.025n

* CHECK dout1_95 Vdout1_95ck77 = 0.9 time = 390
.meas tran vdout1_95ck77 FIND v(dout1_95) AT=390.025n

* CHECK dout1_96 Vdout1_96ck77 = 0 time = 390
.meas tran vdout1_96ck77 FIND v(dout1_96) AT=390.025n

* CHECK dout1_97 Vdout1_97ck77 = 0.9 time = 390
.meas tran vdout1_97ck77 FIND v(dout1_97) AT=390.025n

* CHECK dout1_98 Vdout1_98ck77 = 0 time = 390
.meas tran vdout1_98ck77 FIND v(dout1_98) AT=390.025n

* CHECK dout1_99 Vdout1_99ck77 = 0.9 time = 390
.meas tran vdout1_99ck77 FIND v(dout1_99) AT=390.025n

* CHECK dout1_100 Vdout1_100ck77 = 0.9 time = 390
.meas tran vdout1_100ck77 FIND v(dout1_100) AT=390.025n

* CHECK dout1_101 Vdout1_101ck77 = 0 time = 390
.meas tran vdout1_101ck77 FIND v(dout1_101) AT=390.025n

* CHECK dout1_102 Vdout1_102ck77 = 0.9 time = 390
.meas tran vdout1_102ck77 FIND v(dout1_102) AT=390.025n

* CHECK dout1_103 Vdout1_103ck77 = 0 time = 390
.meas tran vdout1_103ck77 FIND v(dout1_103) AT=390.025n

* CHECK dout1_104 Vdout1_104ck77 = 0 time = 390
.meas tran vdout1_104ck77 FIND v(dout1_104) AT=390.025n

* CHECK dout1_105 Vdout1_105ck77 = 0.9 time = 390
.meas tran vdout1_105ck77 FIND v(dout1_105) AT=390.025n

* CHECK dout1_106 Vdout1_106ck77 = 0.9 time = 390
.meas tran vdout1_106ck77 FIND v(dout1_106) AT=390.025n

* CHECK dout1_107 Vdout1_107ck77 = 0.9 time = 390
.meas tran vdout1_107ck77 FIND v(dout1_107) AT=390.025n

* CHECK dout1_108 Vdout1_108ck77 = 0.9 time = 390
.meas tran vdout1_108ck77 FIND v(dout1_108) AT=390.025n

* CHECK dout1_109 Vdout1_109ck77 = 0 time = 390
.meas tran vdout1_109ck77 FIND v(dout1_109) AT=390.025n

* CHECK dout1_110 Vdout1_110ck77 = 0 time = 390
.meas tran vdout1_110ck77 FIND v(dout1_110) AT=390.025n

* CHECK dout1_111 Vdout1_111ck77 = 0 time = 390
.meas tran vdout1_111ck77 FIND v(dout1_111) AT=390.025n

* CHECK dout1_112 Vdout1_112ck77 = 0 time = 390
.meas tran vdout1_112ck77 FIND v(dout1_112) AT=390.025n

* CHECK dout1_113 Vdout1_113ck77 = 0.9 time = 390
.meas tran vdout1_113ck77 FIND v(dout1_113) AT=390.025n

* CHECK dout1_114 Vdout1_114ck77 = 0.9 time = 390
.meas tran vdout1_114ck77 FIND v(dout1_114) AT=390.025n

* CHECK dout1_115 Vdout1_115ck77 = 0 time = 390
.meas tran vdout1_115ck77 FIND v(dout1_115) AT=390.025n

* CHECK dout1_116 Vdout1_116ck77 = 0.9 time = 390
.meas tran vdout1_116ck77 FIND v(dout1_116) AT=390.025n

* CHECK dout1_117 Vdout1_117ck77 = 0 time = 390
.meas tran vdout1_117ck77 FIND v(dout1_117) AT=390.025n

* CHECK dout1_118 Vdout1_118ck77 = 0 time = 390
.meas tran vdout1_118ck77 FIND v(dout1_118) AT=390.025n

* CHECK dout1_119 Vdout1_119ck77 = 0 time = 390
.meas tran vdout1_119ck77 FIND v(dout1_119) AT=390.025n

* CHECK dout1_0 Vdout1_0ck83 = 0 time = 420
.meas tran vdout1_0ck83 FIND v(dout1_0) AT=420.025n

* CHECK dout1_1 Vdout1_1ck83 = 0 time = 420
.meas tran vdout1_1ck83 FIND v(dout1_1) AT=420.025n

* CHECK dout1_2 Vdout1_2ck83 = 0 time = 420
.meas tran vdout1_2ck83 FIND v(dout1_2) AT=420.025n

* CHECK dout1_3 Vdout1_3ck83 = 0.9 time = 420
.meas tran vdout1_3ck83 FIND v(dout1_3) AT=420.025n

* CHECK dout1_4 Vdout1_4ck83 = 0 time = 420
.meas tran vdout1_4ck83 FIND v(dout1_4) AT=420.025n

* CHECK dout1_5 Vdout1_5ck83 = 0.9 time = 420
.meas tran vdout1_5ck83 FIND v(dout1_5) AT=420.025n

* CHECK dout1_6 Vdout1_6ck83 = 0.9 time = 420
.meas tran vdout1_6ck83 FIND v(dout1_6) AT=420.025n

* CHECK dout1_7 Vdout1_7ck83 = 0.9 time = 420
.meas tran vdout1_7ck83 FIND v(dout1_7) AT=420.025n

* CHECK dout1_8 Vdout1_8ck83 = 0.9 time = 420
.meas tran vdout1_8ck83 FIND v(dout1_8) AT=420.025n

* CHECK dout1_9 Vdout1_9ck83 = 0 time = 420
.meas tran vdout1_9ck83 FIND v(dout1_9) AT=420.025n

* CHECK dout1_10 Vdout1_10ck83 = 0 time = 420
.meas tran vdout1_10ck83 FIND v(dout1_10) AT=420.025n

* CHECK dout1_11 Vdout1_11ck83 = 0 time = 420
.meas tran vdout1_11ck83 FIND v(dout1_11) AT=420.025n

* CHECK dout1_12 Vdout1_12ck83 = 0 time = 420
.meas tran vdout1_12ck83 FIND v(dout1_12) AT=420.025n

* CHECK dout1_13 Vdout1_13ck83 = 0 time = 420
.meas tran vdout1_13ck83 FIND v(dout1_13) AT=420.025n

* CHECK dout1_14 Vdout1_14ck83 = 0 time = 420
.meas tran vdout1_14ck83 FIND v(dout1_14) AT=420.025n

* CHECK dout1_15 Vdout1_15ck83 = 0.9 time = 420
.meas tran vdout1_15ck83 FIND v(dout1_15) AT=420.025n

* CHECK dout1_16 Vdout1_16ck83 = 0.9 time = 420
.meas tran vdout1_16ck83 FIND v(dout1_16) AT=420.025n

* CHECK dout1_17 Vdout1_17ck83 = 0 time = 420
.meas tran vdout1_17ck83 FIND v(dout1_17) AT=420.025n

* CHECK dout1_18 Vdout1_18ck83 = 0 time = 420
.meas tran vdout1_18ck83 FIND v(dout1_18) AT=420.025n

* CHECK dout1_19 Vdout1_19ck83 = 0 time = 420
.meas tran vdout1_19ck83 FIND v(dout1_19) AT=420.025n

* CHECK dout1_20 Vdout1_20ck83 = 0 time = 420
.meas tran vdout1_20ck83 FIND v(dout1_20) AT=420.025n

* CHECK dout1_21 Vdout1_21ck83 = 0 time = 420
.meas tran vdout1_21ck83 FIND v(dout1_21) AT=420.025n

* CHECK dout1_22 Vdout1_22ck83 = 0.9 time = 420
.meas tran vdout1_22ck83 FIND v(dout1_22) AT=420.025n

* CHECK dout1_23 Vdout1_23ck83 = 0.9 time = 420
.meas tran vdout1_23ck83 FIND v(dout1_23) AT=420.025n

* CHECK dout1_24 Vdout1_24ck83 = 0 time = 420
.meas tran vdout1_24ck83 FIND v(dout1_24) AT=420.025n

* CHECK dout1_25 Vdout1_25ck83 = 0 time = 420
.meas tran vdout1_25ck83 FIND v(dout1_25) AT=420.025n

* CHECK dout1_26 Vdout1_26ck83 = 0 time = 420
.meas tran vdout1_26ck83 FIND v(dout1_26) AT=420.025n

* CHECK dout1_27 Vdout1_27ck83 = 0 time = 420
.meas tran vdout1_27ck83 FIND v(dout1_27) AT=420.025n

* CHECK dout1_28 Vdout1_28ck83 = 0.9 time = 420
.meas tran vdout1_28ck83 FIND v(dout1_28) AT=420.025n

* CHECK dout1_29 Vdout1_29ck83 = 0.9 time = 420
.meas tran vdout1_29ck83 FIND v(dout1_29) AT=420.025n

* CHECK dout1_30 Vdout1_30ck83 = 0.9 time = 420
.meas tran vdout1_30ck83 FIND v(dout1_30) AT=420.025n

* CHECK dout1_31 Vdout1_31ck83 = 0 time = 420
.meas tran vdout1_31ck83 FIND v(dout1_31) AT=420.025n

* CHECK dout1_32 Vdout1_32ck83 = 0.9 time = 420
.meas tran vdout1_32ck83 FIND v(dout1_32) AT=420.025n

* CHECK dout1_33 Vdout1_33ck83 = 0.9 time = 420
.meas tran vdout1_33ck83 FIND v(dout1_33) AT=420.025n

* CHECK dout1_34 Vdout1_34ck83 = 0.9 time = 420
.meas tran vdout1_34ck83 FIND v(dout1_34) AT=420.025n

* CHECK dout1_35 Vdout1_35ck83 = 0 time = 420
.meas tran vdout1_35ck83 FIND v(dout1_35) AT=420.025n

* CHECK dout1_36 Vdout1_36ck83 = 0 time = 420
.meas tran vdout1_36ck83 FIND v(dout1_36) AT=420.025n

* CHECK dout1_37 Vdout1_37ck83 = 0.9 time = 420
.meas tran vdout1_37ck83 FIND v(dout1_37) AT=420.025n

* CHECK dout1_38 Vdout1_38ck83 = 0.9 time = 420
.meas tran vdout1_38ck83 FIND v(dout1_38) AT=420.025n

* CHECK dout1_39 Vdout1_39ck83 = 0 time = 420
.meas tran vdout1_39ck83 FIND v(dout1_39) AT=420.025n

* CHECK dout1_40 Vdout1_40ck83 = 0 time = 420
.meas tran vdout1_40ck83 FIND v(dout1_40) AT=420.025n

* CHECK dout1_41 Vdout1_41ck83 = 0 time = 420
.meas tran vdout1_41ck83 FIND v(dout1_41) AT=420.025n

* CHECK dout1_42 Vdout1_42ck83 = 0 time = 420
.meas tran vdout1_42ck83 FIND v(dout1_42) AT=420.025n

* CHECK dout1_43 Vdout1_43ck83 = 0.9 time = 420
.meas tran vdout1_43ck83 FIND v(dout1_43) AT=420.025n

* CHECK dout1_44 Vdout1_44ck83 = 0 time = 420
.meas tran vdout1_44ck83 FIND v(dout1_44) AT=420.025n

* CHECK dout1_45 Vdout1_45ck83 = 0.9 time = 420
.meas tran vdout1_45ck83 FIND v(dout1_45) AT=420.025n

* CHECK dout1_46 Vdout1_46ck83 = 0.9 time = 420
.meas tran vdout1_46ck83 FIND v(dout1_46) AT=420.025n

* CHECK dout1_47 Vdout1_47ck83 = 0 time = 420
.meas tran vdout1_47ck83 FIND v(dout1_47) AT=420.025n

* CHECK dout1_48 Vdout1_48ck83 = 0 time = 420
.meas tran vdout1_48ck83 FIND v(dout1_48) AT=420.025n

* CHECK dout1_49 Vdout1_49ck83 = 0.9 time = 420
.meas tran vdout1_49ck83 FIND v(dout1_49) AT=420.025n

* CHECK dout1_50 Vdout1_50ck83 = 0.9 time = 420
.meas tran vdout1_50ck83 FIND v(dout1_50) AT=420.025n

* CHECK dout1_51 Vdout1_51ck83 = 0 time = 420
.meas tran vdout1_51ck83 FIND v(dout1_51) AT=420.025n

* CHECK dout1_52 Vdout1_52ck83 = 0.9 time = 420
.meas tran vdout1_52ck83 FIND v(dout1_52) AT=420.025n

* CHECK dout1_53 Vdout1_53ck83 = 0.9 time = 420
.meas tran vdout1_53ck83 FIND v(dout1_53) AT=420.025n

* CHECK dout1_54 Vdout1_54ck83 = 0.9 time = 420
.meas tran vdout1_54ck83 FIND v(dout1_54) AT=420.025n

* CHECK dout1_55 Vdout1_55ck83 = 0.9 time = 420
.meas tran vdout1_55ck83 FIND v(dout1_55) AT=420.025n

* CHECK dout1_56 Vdout1_56ck83 = 0.9 time = 420
.meas tran vdout1_56ck83 FIND v(dout1_56) AT=420.025n

* CHECK dout1_57 Vdout1_57ck83 = 0 time = 420
.meas tran vdout1_57ck83 FIND v(dout1_57) AT=420.025n

* CHECK dout1_58 Vdout1_58ck83 = 0.9 time = 420
.meas tran vdout1_58ck83 FIND v(dout1_58) AT=420.025n

* CHECK dout1_59 Vdout1_59ck83 = 0.9 time = 420
.meas tran vdout1_59ck83 FIND v(dout1_59) AT=420.025n

* CHECK dout1_60 Vdout1_60ck83 = 0 time = 420
.meas tran vdout1_60ck83 FIND v(dout1_60) AT=420.025n

* CHECK dout1_61 Vdout1_61ck83 = 0.9 time = 420
.meas tran vdout1_61ck83 FIND v(dout1_61) AT=420.025n

* CHECK dout1_62 Vdout1_62ck83 = 0.9 time = 420
.meas tran vdout1_62ck83 FIND v(dout1_62) AT=420.025n

* CHECK dout1_63 Vdout1_63ck83 = 0 time = 420
.meas tran vdout1_63ck83 FIND v(dout1_63) AT=420.025n

* CHECK dout1_64 Vdout1_64ck83 = 0.9 time = 420
.meas tran vdout1_64ck83 FIND v(dout1_64) AT=420.025n

* CHECK dout1_65 Vdout1_65ck83 = 0.9 time = 420
.meas tran vdout1_65ck83 FIND v(dout1_65) AT=420.025n

* CHECK dout1_66 Vdout1_66ck83 = 0 time = 420
.meas tran vdout1_66ck83 FIND v(dout1_66) AT=420.025n

* CHECK dout1_67 Vdout1_67ck83 = 0 time = 420
.meas tran vdout1_67ck83 FIND v(dout1_67) AT=420.025n

* CHECK dout1_68 Vdout1_68ck83 = 0 time = 420
.meas tran vdout1_68ck83 FIND v(dout1_68) AT=420.025n

* CHECK dout1_69 Vdout1_69ck83 = 0 time = 420
.meas tran vdout1_69ck83 FIND v(dout1_69) AT=420.025n

* CHECK dout1_70 Vdout1_70ck83 = 0 time = 420
.meas tran vdout1_70ck83 FIND v(dout1_70) AT=420.025n

* CHECK dout1_71 Vdout1_71ck83 = 0 time = 420
.meas tran vdout1_71ck83 FIND v(dout1_71) AT=420.025n

* CHECK dout1_72 Vdout1_72ck83 = 0 time = 420
.meas tran vdout1_72ck83 FIND v(dout1_72) AT=420.025n

* CHECK dout1_73 Vdout1_73ck83 = 0 time = 420
.meas tran vdout1_73ck83 FIND v(dout1_73) AT=420.025n

* CHECK dout1_74 Vdout1_74ck83 = 0 time = 420
.meas tran vdout1_74ck83 FIND v(dout1_74) AT=420.025n

* CHECK dout1_75 Vdout1_75ck83 = 0 time = 420
.meas tran vdout1_75ck83 FIND v(dout1_75) AT=420.025n

* CHECK dout1_76 Vdout1_76ck83 = 0.9 time = 420
.meas tran vdout1_76ck83 FIND v(dout1_76) AT=420.025n

* CHECK dout1_77 Vdout1_77ck83 = 0 time = 420
.meas tran vdout1_77ck83 FIND v(dout1_77) AT=420.025n

* CHECK dout1_78 Vdout1_78ck83 = 0.9 time = 420
.meas tran vdout1_78ck83 FIND v(dout1_78) AT=420.025n

* CHECK dout1_79 Vdout1_79ck83 = 0.9 time = 420
.meas tran vdout1_79ck83 FIND v(dout1_79) AT=420.025n

* CHECK dout1_80 Vdout1_80ck83 = 0 time = 420
.meas tran vdout1_80ck83 FIND v(dout1_80) AT=420.025n

* CHECK dout1_81 Vdout1_81ck83 = 0.9 time = 420
.meas tran vdout1_81ck83 FIND v(dout1_81) AT=420.025n

* CHECK dout1_82 Vdout1_82ck83 = 0 time = 420
.meas tran vdout1_82ck83 FIND v(dout1_82) AT=420.025n

* CHECK dout1_83 Vdout1_83ck83 = 0.9 time = 420
.meas tran vdout1_83ck83 FIND v(dout1_83) AT=420.025n

* CHECK dout1_84 Vdout1_84ck83 = 0.9 time = 420
.meas tran vdout1_84ck83 FIND v(dout1_84) AT=420.025n

* CHECK dout1_85 Vdout1_85ck83 = 0 time = 420
.meas tran vdout1_85ck83 FIND v(dout1_85) AT=420.025n

* CHECK dout1_86 Vdout1_86ck83 = 0.9 time = 420
.meas tran vdout1_86ck83 FIND v(dout1_86) AT=420.025n

* CHECK dout1_87 Vdout1_87ck83 = 0.9 time = 420
.meas tran vdout1_87ck83 FIND v(dout1_87) AT=420.025n

* CHECK dout1_88 Vdout1_88ck83 = 0.9 time = 420
.meas tran vdout1_88ck83 FIND v(dout1_88) AT=420.025n

* CHECK dout1_89 Vdout1_89ck83 = 0 time = 420
.meas tran vdout1_89ck83 FIND v(dout1_89) AT=420.025n

* CHECK dout1_90 Vdout1_90ck83 = 0.9 time = 420
.meas tran vdout1_90ck83 FIND v(dout1_90) AT=420.025n

* CHECK dout1_91 Vdout1_91ck83 = 0.9 time = 420
.meas tran vdout1_91ck83 FIND v(dout1_91) AT=420.025n

* CHECK dout1_92 Vdout1_92ck83 = 0 time = 420
.meas tran vdout1_92ck83 FIND v(dout1_92) AT=420.025n

* CHECK dout1_93 Vdout1_93ck83 = 0 time = 420
.meas tran vdout1_93ck83 FIND v(dout1_93) AT=420.025n

* CHECK dout1_94 Vdout1_94ck83 = 0 time = 420
.meas tran vdout1_94ck83 FIND v(dout1_94) AT=420.025n

* CHECK dout1_95 Vdout1_95ck83 = 0.9 time = 420
.meas tran vdout1_95ck83 FIND v(dout1_95) AT=420.025n

* CHECK dout1_96 Vdout1_96ck83 = 0 time = 420
.meas tran vdout1_96ck83 FIND v(dout1_96) AT=420.025n

* CHECK dout1_97 Vdout1_97ck83 = 0 time = 420
.meas tran vdout1_97ck83 FIND v(dout1_97) AT=420.025n

* CHECK dout1_98 Vdout1_98ck83 = 0.9 time = 420
.meas tran vdout1_98ck83 FIND v(dout1_98) AT=420.025n

* CHECK dout1_99 Vdout1_99ck83 = 0 time = 420
.meas tran vdout1_99ck83 FIND v(dout1_99) AT=420.025n

* CHECK dout1_100 Vdout1_100ck83 = 0.9 time = 420
.meas tran vdout1_100ck83 FIND v(dout1_100) AT=420.025n

* CHECK dout1_101 Vdout1_101ck83 = 0 time = 420
.meas tran vdout1_101ck83 FIND v(dout1_101) AT=420.025n

* CHECK dout1_102 Vdout1_102ck83 = 0 time = 420
.meas tran vdout1_102ck83 FIND v(dout1_102) AT=420.025n

* CHECK dout1_103 Vdout1_103ck83 = 0 time = 420
.meas tran vdout1_103ck83 FIND v(dout1_103) AT=420.025n

* CHECK dout1_104 Vdout1_104ck83 = 0 time = 420
.meas tran vdout1_104ck83 FIND v(dout1_104) AT=420.025n

* CHECK dout1_105 Vdout1_105ck83 = 0.9 time = 420
.meas tran vdout1_105ck83 FIND v(dout1_105) AT=420.025n

* CHECK dout1_106 Vdout1_106ck83 = 0 time = 420
.meas tran vdout1_106ck83 FIND v(dout1_106) AT=420.025n

* CHECK dout1_107 Vdout1_107ck83 = 0 time = 420
.meas tran vdout1_107ck83 FIND v(dout1_107) AT=420.025n

* CHECK dout1_108 Vdout1_108ck83 = 0 time = 420
.meas tran vdout1_108ck83 FIND v(dout1_108) AT=420.025n

* CHECK dout1_109 Vdout1_109ck83 = 0 time = 420
.meas tran vdout1_109ck83 FIND v(dout1_109) AT=420.025n

* CHECK dout1_110 Vdout1_110ck83 = 0 time = 420
.meas tran vdout1_110ck83 FIND v(dout1_110) AT=420.025n

* CHECK dout1_111 Vdout1_111ck83 = 0 time = 420
.meas tran vdout1_111ck83 FIND v(dout1_111) AT=420.025n

* CHECK dout1_112 Vdout1_112ck83 = 0.9 time = 420
.meas tran vdout1_112ck83 FIND v(dout1_112) AT=420.025n

* CHECK dout1_113 Vdout1_113ck83 = 0.9 time = 420
.meas tran vdout1_113ck83 FIND v(dout1_113) AT=420.025n

* CHECK dout1_114 Vdout1_114ck83 = 0 time = 420
.meas tran vdout1_114ck83 FIND v(dout1_114) AT=420.025n

* CHECK dout1_115 Vdout1_115ck83 = 0.9 time = 420
.meas tran vdout1_115ck83 FIND v(dout1_115) AT=420.025n

* CHECK dout1_116 Vdout1_116ck83 = 0.9 time = 420
.meas tran vdout1_116ck83 FIND v(dout1_116) AT=420.025n

* CHECK dout1_117 Vdout1_117ck83 = 0.9 time = 420
.meas tran vdout1_117ck83 FIND v(dout1_117) AT=420.025n

* CHECK dout1_118 Vdout1_118ck83 = 0 time = 420
.meas tran vdout1_118ck83 FIND v(dout1_118) AT=420.025n

* CHECK dout1_119 Vdout1_119ck83 = 0.9 time = 420
.meas tran vdout1_119ck83 FIND v(dout1_119) AT=420.025n

* CHECK dout1_0 Vdout1_0ck84 = 0 time = 425
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=425.025n

* CHECK dout1_1 Vdout1_1ck84 = 0 time = 425
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=425.025n

* CHECK dout1_2 Vdout1_2ck84 = 0.9 time = 425
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=425.025n

* CHECK dout1_3 Vdout1_3ck84 = 0 time = 425
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=425.025n

* CHECK dout1_4 Vdout1_4ck84 = 0 time = 425
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=425.025n

* CHECK dout1_5 Vdout1_5ck84 = 0 time = 425
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=425.025n

* CHECK dout1_6 Vdout1_6ck84 = 0.9 time = 425
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=425.025n

* CHECK dout1_7 Vdout1_7ck84 = 0.9 time = 425
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=425.025n

* CHECK dout1_8 Vdout1_8ck84 = 0 time = 425
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=425.025n

* CHECK dout1_9 Vdout1_9ck84 = 0.9 time = 425
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=425.025n

* CHECK dout1_10 Vdout1_10ck84 = 0 time = 425
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=425.025n

* CHECK dout1_11 Vdout1_11ck84 = 0 time = 425
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=425.025n

* CHECK dout1_12 Vdout1_12ck84 = 0.9 time = 425
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=425.025n

* CHECK dout1_13 Vdout1_13ck84 = 0 time = 425
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=425.025n

* CHECK dout1_14 Vdout1_14ck84 = 0 time = 425
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=425.025n

* CHECK dout1_15 Vdout1_15ck84 = 0.9 time = 425
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=425.025n

* CHECK dout1_16 Vdout1_16ck84 = 0.9 time = 425
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=425.025n

* CHECK dout1_17 Vdout1_17ck84 = 0.9 time = 425
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=425.025n

* CHECK dout1_18 Vdout1_18ck84 = 0.9 time = 425
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=425.025n

* CHECK dout1_19 Vdout1_19ck84 = 0.9 time = 425
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=425.025n

* CHECK dout1_20 Vdout1_20ck84 = 0 time = 425
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=425.025n

* CHECK dout1_21 Vdout1_21ck84 = 0 time = 425
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=425.025n

* CHECK dout1_22 Vdout1_22ck84 = 0 time = 425
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=425.025n

* CHECK dout1_23 Vdout1_23ck84 = 0 time = 425
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=425.025n

* CHECK dout1_24 Vdout1_24ck84 = 0 time = 425
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=425.025n

* CHECK dout1_25 Vdout1_25ck84 = 0 time = 425
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=425.025n

* CHECK dout1_26 Vdout1_26ck84 = 0.9 time = 425
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=425.025n

* CHECK dout1_27 Vdout1_27ck84 = 0 time = 425
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=425.025n

* CHECK dout1_28 Vdout1_28ck84 = 0.9 time = 425
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=425.025n

* CHECK dout1_29 Vdout1_29ck84 = 0.9 time = 425
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=425.025n

* CHECK dout1_30 Vdout1_30ck84 = 0.9 time = 425
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=425.025n

* CHECK dout1_31 Vdout1_31ck84 = 0.9 time = 425
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=425.025n

* CHECK dout1_32 Vdout1_32ck84 = 0.9 time = 425
.meas tran vdout1_32ck84 FIND v(dout1_32) AT=425.025n

* CHECK dout1_33 Vdout1_33ck84 = 0 time = 425
.meas tran vdout1_33ck84 FIND v(dout1_33) AT=425.025n

* CHECK dout1_34 Vdout1_34ck84 = 0.9 time = 425
.meas tran vdout1_34ck84 FIND v(dout1_34) AT=425.025n

* CHECK dout1_35 Vdout1_35ck84 = 0.9 time = 425
.meas tran vdout1_35ck84 FIND v(dout1_35) AT=425.025n

* CHECK dout1_36 Vdout1_36ck84 = 0.9 time = 425
.meas tran vdout1_36ck84 FIND v(dout1_36) AT=425.025n

* CHECK dout1_37 Vdout1_37ck84 = 0.9 time = 425
.meas tran vdout1_37ck84 FIND v(dout1_37) AT=425.025n

* CHECK dout1_38 Vdout1_38ck84 = 0 time = 425
.meas tran vdout1_38ck84 FIND v(dout1_38) AT=425.025n

* CHECK dout1_39 Vdout1_39ck84 = 0 time = 425
.meas tran vdout1_39ck84 FIND v(dout1_39) AT=425.025n

* CHECK dout1_40 Vdout1_40ck84 = 0 time = 425
.meas tran vdout1_40ck84 FIND v(dout1_40) AT=425.025n

* CHECK dout1_41 Vdout1_41ck84 = 0 time = 425
.meas tran vdout1_41ck84 FIND v(dout1_41) AT=425.025n

* CHECK dout1_42 Vdout1_42ck84 = 0 time = 425
.meas tran vdout1_42ck84 FIND v(dout1_42) AT=425.025n

* CHECK dout1_43 Vdout1_43ck84 = 0 time = 425
.meas tran vdout1_43ck84 FIND v(dout1_43) AT=425.025n

* CHECK dout1_44 Vdout1_44ck84 = 0 time = 425
.meas tran vdout1_44ck84 FIND v(dout1_44) AT=425.025n

* CHECK dout1_45 Vdout1_45ck84 = 0 time = 425
.meas tran vdout1_45ck84 FIND v(dout1_45) AT=425.025n

* CHECK dout1_46 Vdout1_46ck84 = 0.9 time = 425
.meas tran vdout1_46ck84 FIND v(dout1_46) AT=425.025n

* CHECK dout1_47 Vdout1_47ck84 = 0.9 time = 425
.meas tran vdout1_47ck84 FIND v(dout1_47) AT=425.025n

* CHECK dout1_48 Vdout1_48ck84 = 0.9 time = 425
.meas tran vdout1_48ck84 FIND v(dout1_48) AT=425.025n

* CHECK dout1_49 Vdout1_49ck84 = 0.9 time = 425
.meas tran vdout1_49ck84 FIND v(dout1_49) AT=425.025n

* CHECK dout1_50 Vdout1_50ck84 = 0.9 time = 425
.meas tran vdout1_50ck84 FIND v(dout1_50) AT=425.025n

* CHECK dout1_51 Vdout1_51ck84 = 0.9 time = 425
.meas tran vdout1_51ck84 FIND v(dout1_51) AT=425.025n

* CHECK dout1_52 Vdout1_52ck84 = 0.9 time = 425
.meas tran vdout1_52ck84 FIND v(dout1_52) AT=425.025n

* CHECK dout1_53 Vdout1_53ck84 = 0.9 time = 425
.meas tran vdout1_53ck84 FIND v(dout1_53) AT=425.025n

* CHECK dout1_54 Vdout1_54ck84 = 0.9 time = 425
.meas tran vdout1_54ck84 FIND v(dout1_54) AT=425.025n

* CHECK dout1_55 Vdout1_55ck84 = 0 time = 425
.meas tran vdout1_55ck84 FIND v(dout1_55) AT=425.025n

* CHECK dout1_56 Vdout1_56ck84 = 0.9 time = 425
.meas tran vdout1_56ck84 FIND v(dout1_56) AT=425.025n

* CHECK dout1_57 Vdout1_57ck84 = 0.9 time = 425
.meas tran vdout1_57ck84 FIND v(dout1_57) AT=425.025n

* CHECK dout1_58 Vdout1_58ck84 = 0 time = 425
.meas tran vdout1_58ck84 FIND v(dout1_58) AT=425.025n

* CHECK dout1_59 Vdout1_59ck84 = 0 time = 425
.meas tran vdout1_59ck84 FIND v(dout1_59) AT=425.025n

* CHECK dout1_60 Vdout1_60ck84 = 0 time = 425
.meas tran vdout1_60ck84 FIND v(dout1_60) AT=425.025n

* CHECK dout1_61 Vdout1_61ck84 = 0 time = 425
.meas tran vdout1_61ck84 FIND v(dout1_61) AT=425.025n

* CHECK dout1_62 Vdout1_62ck84 = 0.9 time = 425
.meas tran vdout1_62ck84 FIND v(dout1_62) AT=425.025n

* CHECK dout1_63 Vdout1_63ck84 = 0 time = 425
.meas tran vdout1_63ck84 FIND v(dout1_63) AT=425.025n

* CHECK dout1_64 Vdout1_64ck84 = 0.9 time = 425
.meas tran vdout1_64ck84 FIND v(dout1_64) AT=425.025n

* CHECK dout1_65 Vdout1_65ck84 = 0 time = 425
.meas tran vdout1_65ck84 FIND v(dout1_65) AT=425.025n

* CHECK dout1_66 Vdout1_66ck84 = 0 time = 425
.meas tran vdout1_66ck84 FIND v(dout1_66) AT=425.025n

* CHECK dout1_67 Vdout1_67ck84 = 0.9 time = 425
.meas tran vdout1_67ck84 FIND v(dout1_67) AT=425.025n

* CHECK dout1_68 Vdout1_68ck84 = 0.9 time = 425
.meas tran vdout1_68ck84 FIND v(dout1_68) AT=425.025n

* CHECK dout1_69 Vdout1_69ck84 = 0.9 time = 425
.meas tran vdout1_69ck84 FIND v(dout1_69) AT=425.025n

* CHECK dout1_70 Vdout1_70ck84 = 0.9 time = 425
.meas tran vdout1_70ck84 FIND v(dout1_70) AT=425.025n

* CHECK dout1_71 Vdout1_71ck84 = 0.9 time = 425
.meas tran vdout1_71ck84 FIND v(dout1_71) AT=425.025n

* CHECK dout1_72 Vdout1_72ck84 = 0 time = 425
.meas tran vdout1_72ck84 FIND v(dout1_72) AT=425.025n

* CHECK dout1_73 Vdout1_73ck84 = 0 time = 425
.meas tran vdout1_73ck84 FIND v(dout1_73) AT=425.025n

* CHECK dout1_74 Vdout1_74ck84 = 0 time = 425
.meas tran vdout1_74ck84 FIND v(dout1_74) AT=425.025n

* CHECK dout1_75 Vdout1_75ck84 = 0 time = 425
.meas tran vdout1_75ck84 FIND v(dout1_75) AT=425.025n

* CHECK dout1_76 Vdout1_76ck84 = 0.9 time = 425
.meas tran vdout1_76ck84 FIND v(dout1_76) AT=425.025n

* CHECK dout1_77 Vdout1_77ck84 = 0.9 time = 425
.meas tran vdout1_77ck84 FIND v(dout1_77) AT=425.025n

* CHECK dout1_78 Vdout1_78ck84 = 0.9 time = 425
.meas tran vdout1_78ck84 FIND v(dout1_78) AT=425.025n

* CHECK dout1_79 Vdout1_79ck84 = 0.9 time = 425
.meas tran vdout1_79ck84 FIND v(dout1_79) AT=425.025n

* CHECK dout1_80 Vdout1_80ck84 = 0.9 time = 425
.meas tran vdout1_80ck84 FIND v(dout1_80) AT=425.025n

* CHECK dout1_81 Vdout1_81ck84 = 0 time = 425
.meas tran vdout1_81ck84 FIND v(dout1_81) AT=425.025n

* CHECK dout1_82 Vdout1_82ck84 = 0.9 time = 425
.meas tran vdout1_82ck84 FIND v(dout1_82) AT=425.025n

* CHECK dout1_83 Vdout1_83ck84 = 0 time = 425
.meas tran vdout1_83ck84 FIND v(dout1_83) AT=425.025n

* CHECK dout1_84 Vdout1_84ck84 = 0.9 time = 425
.meas tran vdout1_84ck84 FIND v(dout1_84) AT=425.025n

* CHECK dout1_85 Vdout1_85ck84 = 0.9 time = 425
.meas tran vdout1_85ck84 FIND v(dout1_85) AT=425.025n

* CHECK dout1_86 Vdout1_86ck84 = 0 time = 425
.meas tran vdout1_86ck84 FIND v(dout1_86) AT=425.025n

* CHECK dout1_87 Vdout1_87ck84 = 0 time = 425
.meas tran vdout1_87ck84 FIND v(dout1_87) AT=425.025n

* CHECK dout1_88 Vdout1_88ck84 = 0.9 time = 425
.meas tran vdout1_88ck84 FIND v(dout1_88) AT=425.025n

* CHECK dout1_89 Vdout1_89ck84 = 0.9 time = 425
.meas tran vdout1_89ck84 FIND v(dout1_89) AT=425.025n

* CHECK dout1_90 Vdout1_90ck84 = 0 time = 425
.meas tran vdout1_90ck84 FIND v(dout1_90) AT=425.025n

* CHECK dout1_91 Vdout1_91ck84 = 0.9 time = 425
.meas tran vdout1_91ck84 FIND v(dout1_91) AT=425.025n

* CHECK dout1_92 Vdout1_92ck84 = 0.9 time = 425
.meas tran vdout1_92ck84 FIND v(dout1_92) AT=425.025n

* CHECK dout1_93 Vdout1_93ck84 = 0 time = 425
.meas tran vdout1_93ck84 FIND v(dout1_93) AT=425.025n

* CHECK dout1_94 Vdout1_94ck84 = 0.9 time = 425
.meas tran vdout1_94ck84 FIND v(dout1_94) AT=425.025n

* CHECK dout1_95 Vdout1_95ck84 = 0 time = 425
.meas tran vdout1_95ck84 FIND v(dout1_95) AT=425.025n

* CHECK dout1_96 Vdout1_96ck84 = 0 time = 425
.meas tran vdout1_96ck84 FIND v(dout1_96) AT=425.025n

* CHECK dout1_97 Vdout1_97ck84 = 0.9 time = 425
.meas tran vdout1_97ck84 FIND v(dout1_97) AT=425.025n

* CHECK dout1_98 Vdout1_98ck84 = 0 time = 425
.meas tran vdout1_98ck84 FIND v(dout1_98) AT=425.025n

* CHECK dout1_99 Vdout1_99ck84 = 0.9 time = 425
.meas tran vdout1_99ck84 FIND v(dout1_99) AT=425.025n

* CHECK dout1_100 Vdout1_100ck84 = 0 time = 425
.meas tran vdout1_100ck84 FIND v(dout1_100) AT=425.025n

* CHECK dout1_101 Vdout1_101ck84 = 0.9 time = 425
.meas tran vdout1_101ck84 FIND v(dout1_101) AT=425.025n

* CHECK dout1_102 Vdout1_102ck84 = 0.9 time = 425
.meas tran vdout1_102ck84 FIND v(dout1_102) AT=425.025n

* CHECK dout1_103 Vdout1_103ck84 = 0 time = 425
.meas tran vdout1_103ck84 FIND v(dout1_103) AT=425.025n

* CHECK dout1_104 Vdout1_104ck84 = 0.9 time = 425
.meas tran vdout1_104ck84 FIND v(dout1_104) AT=425.025n

* CHECK dout1_105 Vdout1_105ck84 = 0 time = 425
.meas tran vdout1_105ck84 FIND v(dout1_105) AT=425.025n

* CHECK dout1_106 Vdout1_106ck84 = 0.9 time = 425
.meas tran vdout1_106ck84 FIND v(dout1_106) AT=425.025n

* CHECK dout1_107 Vdout1_107ck84 = 0.9 time = 425
.meas tran vdout1_107ck84 FIND v(dout1_107) AT=425.025n

* CHECK dout1_108 Vdout1_108ck84 = 0.9 time = 425
.meas tran vdout1_108ck84 FIND v(dout1_108) AT=425.025n

* CHECK dout1_109 Vdout1_109ck84 = 0 time = 425
.meas tran vdout1_109ck84 FIND v(dout1_109) AT=425.025n

* CHECK dout1_110 Vdout1_110ck84 = 0 time = 425
.meas tran vdout1_110ck84 FIND v(dout1_110) AT=425.025n

* CHECK dout1_111 Vdout1_111ck84 = 0.9 time = 425
.meas tran vdout1_111ck84 FIND v(dout1_111) AT=425.025n

* CHECK dout1_112 Vdout1_112ck84 = 0 time = 425
.meas tran vdout1_112ck84 FIND v(dout1_112) AT=425.025n

* CHECK dout1_113 Vdout1_113ck84 = 0.9 time = 425
.meas tran vdout1_113ck84 FIND v(dout1_113) AT=425.025n

* CHECK dout1_114 Vdout1_114ck84 = 0.9 time = 425
.meas tran vdout1_114ck84 FIND v(dout1_114) AT=425.025n

* CHECK dout1_115 Vdout1_115ck84 = 0.9 time = 425
.meas tran vdout1_115ck84 FIND v(dout1_115) AT=425.025n

* CHECK dout1_116 Vdout1_116ck84 = 0.9 time = 425
.meas tran vdout1_116ck84 FIND v(dout1_116) AT=425.025n

* CHECK dout1_117 Vdout1_117ck84 = 0 time = 425
.meas tran vdout1_117ck84 FIND v(dout1_117) AT=425.025n

* CHECK dout1_118 Vdout1_118ck84 = 0 time = 425
.meas tran vdout1_118ck84 FIND v(dout1_118) AT=425.025n

* CHECK dout1_119 Vdout1_119ck84 = 0 time = 425
.meas tran vdout1_119ck84 FIND v(dout1_119) AT=425.025n

* CHECK dout1_0 Vdout1_0ck87 = 0 time = 440
.meas tran vdout1_0ck87 FIND v(dout1_0) AT=440.025n

* CHECK dout1_1 Vdout1_1ck87 = 0 time = 440
.meas tran vdout1_1ck87 FIND v(dout1_1) AT=440.025n

* CHECK dout1_2 Vdout1_2ck87 = 0 time = 440
.meas tran vdout1_2ck87 FIND v(dout1_2) AT=440.025n

* CHECK dout1_3 Vdout1_3ck87 = 0.9 time = 440
.meas tran vdout1_3ck87 FIND v(dout1_3) AT=440.025n

* CHECK dout1_4 Vdout1_4ck87 = 0 time = 440
.meas tran vdout1_4ck87 FIND v(dout1_4) AT=440.025n

* CHECK dout1_5 Vdout1_5ck87 = 0.9 time = 440
.meas tran vdout1_5ck87 FIND v(dout1_5) AT=440.025n

* CHECK dout1_6 Vdout1_6ck87 = 0.9 time = 440
.meas tran vdout1_6ck87 FIND v(dout1_6) AT=440.025n

* CHECK dout1_7 Vdout1_7ck87 = 0.9 time = 440
.meas tran vdout1_7ck87 FIND v(dout1_7) AT=440.025n

* CHECK dout1_8 Vdout1_8ck87 = 0.9 time = 440
.meas tran vdout1_8ck87 FIND v(dout1_8) AT=440.025n

* CHECK dout1_9 Vdout1_9ck87 = 0 time = 440
.meas tran vdout1_9ck87 FIND v(dout1_9) AT=440.025n

* CHECK dout1_10 Vdout1_10ck87 = 0 time = 440
.meas tran vdout1_10ck87 FIND v(dout1_10) AT=440.025n

* CHECK dout1_11 Vdout1_11ck87 = 0 time = 440
.meas tran vdout1_11ck87 FIND v(dout1_11) AT=440.025n

* CHECK dout1_12 Vdout1_12ck87 = 0 time = 440
.meas tran vdout1_12ck87 FIND v(dout1_12) AT=440.025n

* CHECK dout1_13 Vdout1_13ck87 = 0 time = 440
.meas tran vdout1_13ck87 FIND v(dout1_13) AT=440.025n

* CHECK dout1_14 Vdout1_14ck87 = 0 time = 440
.meas tran vdout1_14ck87 FIND v(dout1_14) AT=440.025n

* CHECK dout1_15 Vdout1_15ck87 = 0.9 time = 440
.meas tran vdout1_15ck87 FIND v(dout1_15) AT=440.025n

* CHECK dout1_16 Vdout1_16ck87 = 0.9 time = 440
.meas tran vdout1_16ck87 FIND v(dout1_16) AT=440.025n

* CHECK dout1_17 Vdout1_17ck87 = 0 time = 440
.meas tran vdout1_17ck87 FIND v(dout1_17) AT=440.025n

* CHECK dout1_18 Vdout1_18ck87 = 0 time = 440
.meas tran vdout1_18ck87 FIND v(dout1_18) AT=440.025n

* CHECK dout1_19 Vdout1_19ck87 = 0 time = 440
.meas tran vdout1_19ck87 FIND v(dout1_19) AT=440.025n

* CHECK dout1_20 Vdout1_20ck87 = 0 time = 440
.meas tran vdout1_20ck87 FIND v(dout1_20) AT=440.025n

* CHECK dout1_21 Vdout1_21ck87 = 0 time = 440
.meas tran vdout1_21ck87 FIND v(dout1_21) AT=440.025n

* CHECK dout1_22 Vdout1_22ck87 = 0.9 time = 440
.meas tran vdout1_22ck87 FIND v(dout1_22) AT=440.025n

* CHECK dout1_23 Vdout1_23ck87 = 0.9 time = 440
.meas tran vdout1_23ck87 FIND v(dout1_23) AT=440.025n

* CHECK dout1_24 Vdout1_24ck87 = 0 time = 440
.meas tran vdout1_24ck87 FIND v(dout1_24) AT=440.025n

* CHECK dout1_25 Vdout1_25ck87 = 0 time = 440
.meas tran vdout1_25ck87 FIND v(dout1_25) AT=440.025n

* CHECK dout1_26 Vdout1_26ck87 = 0 time = 440
.meas tran vdout1_26ck87 FIND v(dout1_26) AT=440.025n

* CHECK dout1_27 Vdout1_27ck87 = 0 time = 440
.meas tran vdout1_27ck87 FIND v(dout1_27) AT=440.025n

* CHECK dout1_28 Vdout1_28ck87 = 0.9 time = 440
.meas tran vdout1_28ck87 FIND v(dout1_28) AT=440.025n

* CHECK dout1_29 Vdout1_29ck87 = 0.9 time = 440
.meas tran vdout1_29ck87 FIND v(dout1_29) AT=440.025n

* CHECK dout1_30 Vdout1_30ck87 = 0.9 time = 440
.meas tran vdout1_30ck87 FIND v(dout1_30) AT=440.025n

* CHECK dout1_31 Vdout1_31ck87 = 0 time = 440
.meas tran vdout1_31ck87 FIND v(dout1_31) AT=440.025n

* CHECK dout1_32 Vdout1_32ck87 = 0.9 time = 440
.meas tran vdout1_32ck87 FIND v(dout1_32) AT=440.025n

* CHECK dout1_33 Vdout1_33ck87 = 0.9 time = 440
.meas tran vdout1_33ck87 FIND v(dout1_33) AT=440.025n

* CHECK dout1_34 Vdout1_34ck87 = 0.9 time = 440
.meas tran vdout1_34ck87 FIND v(dout1_34) AT=440.025n

* CHECK dout1_35 Vdout1_35ck87 = 0 time = 440
.meas tran vdout1_35ck87 FIND v(dout1_35) AT=440.025n

* CHECK dout1_36 Vdout1_36ck87 = 0 time = 440
.meas tran vdout1_36ck87 FIND v(dout1_36) AT=440.025n

* CHECK dout1_37 Vdout1_37ck87 = 0.9 time = 440
.meas tran vdout1_37ck87 FIND v(dout1_37) AT=440.025n

* CHECK dout1_38 Vdout1_38ck87 = 0.9 time = 440
.meas tran vdout1_38ck87 FIND v(dout1_38) AT=440.025n

* CHECK dout1_39 Vdout1_39ck87 = 0 time = 440
.meas tran vdout1_39ck87 FIND v(dout1_39) AT=440.025n

* CHECK dout1_40 Vdout1_40ck87 = 0 time = 440
.meas tran vdout1_40ck87 FIND v(dout1_40) AT=440.025n

* CHECK dout1_41 Vdout1_41ck87 = 0 time = 440
.meas tran vdout1_41ck87 FIND v(dout1_41) AT=440.025n

* CHECK dout1_42 Vdout1_42ck87 = 0 time = 440
.meas tran vdout1_42ck87 FIND v(dout1_42) AT=440.025n

* CHECK dout1_43 Vdout1_43ck87 = 0.9 time = 440
.meas tran vdout1_43ck87 FIND v(dout1_43) AT=440.025n

* CHECK dout1_44 Vdout1_44ck87 = 0 time = 440
.meas tran vdout1_44ck87 FIND v(dout1_44) AT=440.025n

* CHECK dout1_45 Vdout1_45ck87 = 0.9 time = 440
.meas tran vdout1_45ck87 FIND v(dout1_45) AT=440.025n

* CHECK dout1_46 Vdout1_46ck87 = 0.9 time = 440
.meas tran vdout1_46ck87 FIND v(dout1_46) AT=440.025n

* CHECK dout1_47 Vdout1_47ck87 = 0 time = 440
.meas tran vdout1_47ck87 FIND v(dout1_47) AT=440.025n

* CHECK dout1_48 Vdout1_48ck87 = 0 time = 440
.meas tran vdout1_48ck87 FIND v(dout1_48) AT=440.025n

* CHECK dout1_49 Vdout1_49ck87 = 0.9 time = 440
.meas tran vdout1_49ck87 FIND v(dout1_49) AT=440.025n

* CHECK dout1_50 Vdout1_50ck87 = 0.9 time = 440
.meas tran vdout1_50ck87 FIND v(dout1_50) AT=440.025n

* CHECK dout1_51 Vdout1_51ck87 = 0 time = 440
.meas tran vdout1_51ck87 FIND v(dout1_51) AT=440.025n

* CHECK dout1_52 Vdout1_52ck87 = 0.9 time = 440
.meas tran vdout1_52ck87 FIND v(dout1_52) AT=440.025n

* CHECK dout1_53 Vdout1_53ck87 = 0.9 time = 440
.meas tran vdout1_53ck87 FIND v(dout1_53) AT=440.025n

* CHECK dout1_54 Vdout1_54ck87 = 0.9 time = 440
.meas tran vdout1_54ck87 FIND v(dout1_54) AT=440.025n

* CHECK dout1_55 Vdout1_55ck87 = 0.9 time = 440
.meas tran vdout1_55ck87 FIND v(dout1_55) AT=440.025n

* CHECK dout1_56 Vdout1_56ck87 = 0.9 time = 440
.meas tran vdout1_56ck87 FIND v(dout1_56) AT=440.025n

* CHECK dout1_57 Vdout1_57ck87 = 0 time = 440
.meas tran vdout1_57ck87 FIND v(dout1_57) AT=440.025n

* CHECK dout1_58 Vdout1_58ck87 = 0.9 time = 440
.meas tran vdout1_58ck87 FIND v(dout1_58) AT=440.025n

* CHECK dout1_59 Vdout1_59ck87 = 0.9 time = 440
.meas tran vdout1_59ck87 FIND v(dout1_59) AT=440.025n

* CHECK dout1_60 Vdout1_60ck87 = 0 time = 440
.meas tran vdout1_60ck87 FIND v(dout1_60) AT=440.025n

* CHECK dout1_61 Vdout1_61ck87 = 0.9 time = 440
.meas tran vdout1_61ck87 FIND v(dout1_61) AT=440.025n

* CHECK dout1_62 Vdout1_62ck87 = 0.9 time = 440
.meas tran vdout1_62ck87 FIND v(dout1_62) AT=440.025n

* CHECK dout1_63 Vdout1_63ck87 = 0 time = 440
.meas tran vdout1_63ck87 FIND v(dout1_63) AT=440.025n

* CHECK dout1_64 Vdout1_64ck87 = 0.9 time = 440
.meas tran vdout1_64ck87 FIND v(dout1_64) AT=440.025n

* CHECK dout1_65 Vdout1_65ck87 = 0.9 time = 440
.meas tran vdout1_65ck87 FIND v(dout1_65) AT=440.025n

* CHECK dout1_66 Vdout1_66ck87 = 0 time = 440
.meas tran vdout1_66ck87 FIND v(dout1_66) AT=440.025n

* CHECK dout1_67 Vdout1_67ck87 = 0 time = 440
.meas tran vdout1_67ck87 FIND v(dout1_67) AT=440.025n

* CHECK dout1_68 Vdout1_68ck87 = 0 time = 440
.meas tran vdout1_68ck87 FIND v(dout1_68) AT=440.025n

* CHECK dout1_69 Vdout1_69ck87 = 0 time = 440
.meas tran vdout1_69ck87 FIND v(dout1_69) AT=440.025n

* CHECK dout1_70 Vdout1_70ck87 = 0 time = 440
.meas tran vdout1_70ck87 FIND v(dout1_70) AT=440.025n

* CHECK dout1_71 Vdout1_71ck87 = 0 time = 440
.meas tran vdout1_71ck87 FIND v(dout1_71) AT=440.025n

* CHECK dout1_72 Vdout1_72ck87 = 0 time = 440
.meas tran vdout1_72ck87 FIND v(dout1_72) AT=440.025n

* CHECK dout1_73 Vdout1_73ck87 = 0 time = 440
.meas tran vdout1_73ck87 FIND v(dout1_73) AT=440.025n

* CHECK dout1_74 Vdout1_74ck87 = 0 time = 440
.meas tran vdout1_74ck87 FIND v(dout1_74) AT=440.025n

* CHECK dout1_75 Vdout1_75ck87 = 0 time = 440
.meas tran vdout1_75ck87 FIND v(dout1_75) AT=440.025n

* CHECK dout1_76 Vdout1_76ck87 = 0.9 time = 440
.meas tran vdout1_76ck87 FIND v(dout1_76) AT=440.025n

* CHECK dout1_77 Vdout1_77ck87 = 0 time = 440
.meas tran vdout1_77ck87 FIND v(dout1_77) AT=440.025n

* CHECK dout1_78 Vdout1_78ck87 = 0.9 time = 440
.meas tran vdout1_78ck87 FIND v(dout1_78) AT=440.025n

* CHECK dout1_79 Vdout1_79ck87 = 0.9 time = 440
.meas tran vdout1_79ck87 FIND v(dout1_79) AT=440.025n

* CHECK dout1_80 Vdout1_80ck87 = 0 time = 440
.meas tran vdout1_80ck87 FIND v(dout1_80) AT=440.025n

* CHECK dout1_81 Vdout1_81ck87 = 0.9 time = 440
.meas tran vdout1_81ck87 FIND v(dout1_81) AT=440.025n

* CHECK dout1_82 Vdout1_82ck87 = 0 time = 440
.meas tran vdout1_82ck87 FIND v(dout1_82) AT=440.025n

* CHECK dout1_83 Vdout1_83ck87 = 0.9 time = 440
.meas tran vdout1_83ck87 FIND v(dout1_83) AT=440.025n

* CHECK dout1_84 Vdout1_84ck87 = 0.9 time = 440
.meas tran vdout1_84ck87 FIND v(dout1_84) AT=440.025n

* CHECK dout1_85 Vdout1_85ck87 = 0 time = 440
.meas tran vdout1_85ck87 FIND v(dout1_85) AT=440.025n

* CHECK dout1_86 Vdout1_86ck87 = 0.9 time = 440
.meas tran vdout1_86ck87 FIND v(dout1_86) AT=440.025n

* CHECK dout1_87 Vdout1_87ck87 = 0.9 time = 440
.meas tran vdout1_87ck87 FIND v(dout1_87) AT=440.025n

* CHECK dout1_88 Vdout1_88ck87 = 0.9 time = 440
.meas tran vdout1_88ck87 FIND v(dout1_88) AT=440.025n

* CHECK dout1_89 Vdout1_89ck87 = 0 time = 440
.meas tran vdout1_89ck87 FIND v(dout1_89) AT=440.025n

* CHECK dout1_90 Vdout1_90ck87 = 0.9 time = 440
.meas tran vdout1_90ck87 FIND v(dout1_90) AT=440.025n

* CHECK dout1_91 Vdout1_91ck87 = 0.9 time = 440
.meas tran vdout1_91ck87 FIND v(dout1_91) AT=440.025n

* CHECK dout1_92 Vdout1_92ck87 = 0 time = 440
.meas tran vdout1_92ck87 FIND v(dout1_92) AT=440.025n

* CHECK dout1_93 Vdout1_93ck87 = 0 time = 440
.meas tran vdout1_93ck87 FIND v(dout1_93) AT=440.025n

* CHECK dout1_94 Vdout1_94ck87 = 0 time = 440
.meas tran vdout1_94ck87 FIND v(dout1_94) AT=440.025n

* CHECK dout1_95 Vdout1_95ck87 = 0.9 time = 440
.meas tran vdout1_95ck87 FIND v(dout1_95) AT=440.025n

* CHECK dout1_96 Vdout1_96ck87 = 0 time = 440
.meas tran vdout1_96ck87 FIND v(dout1_96) AT=440.025n

* CHECK dout1_97 Vdout1_97ck87 = 0 time = 440
.meas tran vdout1_97ck87 FIND v(dout1_97) AT=440.025n

* CHECK dout1_98 Vdout1_98ck87 = 0.9 time = 440
.meas tran vdout1_98ck87 FIND v(dout1_98) AT=440.025n

* CHECK dout1_99 Vdout1_99ck87 = 0 time = 440
.meas tran vdout1_99ck87 FIND v(dout1_99) AT=440.025n

* CHECK dout1_100 Vdout1_100ck87 = 0.9 time = 440
.meas tran vdout1_100ck87 FIND v(dout1_100) AT=440.025n

* CHECK dout1_101 Vdout1_101ck87 = 0 time = 440
.meas tran vdout1_101ck87 FIND v(dout1_101) AT=440.025n

* CHECK dout1_102 Vdout1_102ck87 = 0 time = 440
.meas tran vdout1_102ck87 FIND v(dout1_102) AT=440.025n

* CHECK dout1_103 Vdout1_103ck87 = 0 time = 440
.meas tran vdout1_103ck87 FIND v(dout1_103) AT=440.025n

* CHECK dout1_104 Vdout1_104ck87 = 0 time = 440
.meas tran vdout1_104ck87 FIND v(dout1_104) AT=440.025n

* CHECK dout1_105 Vdout1_105ck87 = 0.9 time = 440
.meas tran vdout1_105ck87 FIND v(dout1_105) AT=440.025n

* CHECK dout1_106 Vdout1_106ck87 = 0 time = 440
.meas tran vdout1_106ck87 FIND v(dout1_106) AT=440.025n

* CHECK dout1_107 Vdout1_107ck87 = 0 time = 440
.meas tran vdout1_107ck87 FIND v(dout1_107) AT=440.025n

* CHECK dout1_108 Vdout1_108ck87 = 0 time = 440
.meas tran vdout1_108ck87 FIND v(dout1_108) AT=440.025n

* CHECK dout1_109 Vdout1_109ck87 = 0 time = 440
.meas tran vdout1_109ck87 FIND v(dout1_109) AT=440.025n

* CHECK dout1_110 Vdout1_110ck87 = 0 time = 440
.meas tran vdout1_110ck87 FIND v(dout1_110) AT=440.025n

* CHECK dout1_111 Vdout1_111ck87 = 0 time = 440
.meas tran vdout1_111ck87 FIND v(dout1_111) AT=440.025n

* CHECK dout1_112 Vdout1_112ck87 = 0.9 time = 440
.meas tran vdout1_112ck87 FIND v(dout1_112) AT=440.025n

* CHECK dout1_113 Vdout1_113ck87 = 0.9 time = 440
.meas tran vdout1_113ck87 FIND v(dout1_113) AT=440.025n

* CHECK dout1_114 Vdout1_114ck87 = 0 time = 440
.meas tran vdout1_114ck87 FIND v(dout1_114) AT=440.025n

* CHECK dout1_115 Vdout1_115ck87 = 0.9 time = 440
.meas tran vdout1_115ck87 FIND v(dout1_115) AT=440.025n

* CHECK dout1_116 Vdout1_116ck87 = 0.9 time = 440
.meas tran vdout1_116ck87 FIND v(dout1_116) AT=440.025n

* CHECK dout1_117 Vdout1_117ck87 = 0.9 time = 440
.meas tran vdout1_117ck87 FIND v(dout1_117) AT=440.025n

* CHECK dout1_118 Vdout1_118ck87 = 0 time = 440
.meas tran vdout1_118ck87 FIND v(dout1_118) AT=440.025n

* CHECK dout1_119 Vdout1_119ck87 = 0.9 time = 440
.meas tran vdout1_119ck87 FIND v(dout1_119) AT=440.025n

* CHECK dout1_0 Vdout1_0ck89 = 0 time = 450
.meas tran vdout1_0ck89 FIND v(dout1_0) AT=450.025n

* CHECK dout1_1 Vdout1_1ck89 = 0 time = 450
.meas tran vdout1_1ck89 FIND v(dout1_1) AT=450.025n

* CHECK dout1_2 Vdout1_2ck89 = 0 time = 450
.meas tran vdout1_2ck89 FIND v(dout1_2) AT=450.025n

* CHECK dout1_3 Vdout1_3ck89 = 0.9 time = 450
.meas tran vdout1_3ck89 FIND v(dout1_3) AT=450.025n

* CHECK dout1_4 Vdout1_4ck89 = 0 time = 450
.meas tran vdout1_4ck89 FIND v(dout1_4) AT=450.025n

* CHECK dout1_5 Vdout1_5ck89 = 0.9 time = 450
.meas tran vdout1_5ck89 FIND v(dout1_5) AT=450.025n

* CHECK dout1_6 Vdout1_6ck89 = 0 time = 450
.meas tran vdout1_6ck89 FIND v(dout1_6) AT=450.025n

* CHECK dout1_7 Vdout1_7ck89 = 0.9 time = 450
.meas tran vdout1_7ck89 FIND v(dout1_7) AT=450.025n

* CHECK dout1_8 Vdout1_8ck89 = 0 time = 450
.meas tran vdout1_8ck89 FIND v(dout1_8) AT=450.025n

* CHECK dout1_9 Vdout1_9ck89 = 0 time = 450
.meas tran vdout1_9ck89 FIND v(dout1_9) AT=450.025n

* CHECK dout1_10 Vdout1_10ck89 = 0 time = 450
.meas tran vdout1_10ck89 FIND v(dout1_10) AT=450.025n

* CHECK dout1_11 Vdout1_11ck89 = 0 time = 450
.meas tran vdout1_11ck89 FIND v(dout1_11) AT=450.025n

* CHECK dout1_12 Vdout1_12ck89 = 0 time = 450
.meas tran vdout1_12ck89 FIND v(dout1_12) AT=450.025n

* CHECK dout1_13 Vdout1_13ck89 = 0.9 time = 450
.meas tran vdout1_13ck89 FIND v(dout1_13) AT=450.025n

* CHECK dout1_14 Vdout1_14ck89 = 0.9 time = 450
.meas tran vdout1_14ck89 FIND v(dout1_14) AT=450.025n

* CHECK dout1_15 Vdout1_15ck89 = 0.9 time = 450
.meas tran vdout1_15ck89 FIND v(dout1_15) AT=450.025n

* CHECK dout1_16 Vdout1_16ck89 = 0 time = 450
.meas tran vdout1_16ck89 FIND v(dout1_16) AT=450.025n

* CHECK dout1_17 Vdout1_17ck89 = 0 time = 450
.meas tran vdout1_17ck89 FIND v(dout1_17) AT=450.025n

* CHECK dout1_18 Vdout1_18ck89 = 0.9 time = 450
.meas tran vdout1_18ck89 FIND v(dout1_18) AT=450.025n

* CHECK dout1_19 Vdout1_19ck89 = 0 time = 450
.meas tran vdout1_19ck89 FIND v(dout1_19) AT=450.025n

* CHECK dout1_20 Vdout1_20ck89 = 0 time = 450
.meas tran vdout1_20ck89 FIND v(dout1_20) AT=450.025n

* CHECK dout1_21 Vdout1_21ck89 = 0 time = 450
.meas tran vdout1_21ck89 FIND v(dout1_21) AT=450.025n

* CHECK dout1_22 Vdout1_22ck89 = 0.9 time = 450
.meas tran vdout1_22ck89 FIND v(dout1_22) AT=450.025n

* CHECK dout1_23 Vdout1_23ck89 = 0.9 time = 450
.meas tran vdout1_23ck89 FIND v(dout1_23) AT=450.025n

* CHECK dout1_24 Vdout1_24ck89 = 0 time = 450
.meas tran vdout1_24ck89 FIND v(dout1_24) AT=450.025n

* CHECK dout1_25 Vdout1_25ck89 = 0 time = 450
.meas tran vdout1_25ck89 FIND v(dout1_25) AT=450.025n

* CHECK dout1_26 Vdout1_26ck89 = 0.9 time = 450
.meas tran vdout1_26ck89 FIND v(dout1_26) AT=450.025n

* CHECK dout1_27 Vdout1_27ck89 = 0.9 time = 450
.meas tran vdout1_27ck89 FIND v(dout1_27) AT=450.025n

* CHECK dout1_28 Vdout1_28ck89 = 0 time = 450
.meas tran vdout1_28ck89 FIND v(dout1_28) AT=450.025n

* CHECK dout1_29 Vdout1_29ck89 = 0.9 time = 450
.meas tran vdout1_29ck89 FIND v(dout1_29) AT=450.025n

* CHECK dout1_30 Vdout1_30ck89 = 0.9 time = 450
.meas tran vdout1_30ck89 FIND v(dout1_30) AT=450.025n

* CHECK dout1_31 Vdout1_31ck89 = 0 time = 450
.meas tran vdout1_31ck89 FIND v(dout1_31) AT=450.025n

* CHECK dout1_32 Vdout1_32ck89 = 0 time = 450
.meas tran vdout1_32ck89 FIND v(dout1_32) AT=450.025n

* CHECK dout1_33 Vdout1_33ck89 = 0 time = 450
.meas tran vdout1_33ck89 FIND v(dout1_33) AT=450.025n

* CHECK dout1_34 Vdout1_34ck89 = 0.9 time = 450
.meas tran vdout1_34ck89 FIND v(dout1_34) AT=450.025n

* CHECK dout1_35 Vdout1_35ck89 = 0.9 time = 450
.meas tran vdout1_35ck89 FIND v(dout1_35) AT=450.025n

* CHECK dout1_36 Vdout1_36ck89 = 0.9 time = 450
.meas tran vdout1_36ck89 FIND v(dout1_36) AT=450.025n

* CHECK dout1_37 Vdout1_37ck89 = 0 time = 450
.meas tran vdout1_37ck89 FIND v(dout1_37) AT=450.025n

* CHECK dout1_38 Vdout1_38ck89 = 0.9 time = 450
.meas tran vdout1_38ck89 FIND v(dout1_38) AT=450.025n

* CHECK dout1_39 Vdout1_39ck89 = 0.9 time = 450
.meas tran vdout1_39ck89 FIND v(dout1_39) AT=450.025n

* CHECK dout1_40 Vdout1_40ck89 = 0 time = 450
.meas tran vdout1_40ck89 FIND v(dout1_40) AT=450.025n

* CHECK dout1_41 Vdout1_41ck89 = 0 time = 450
.meas tran vdout1_41ck89 FIND v(dout1_41) AT=450.025n

* CHECK dout1_42 Vdout1_42ck89 = 0.9 time = 450
.meas tran vdout1_42ck89 FIND v(dout1_42) AT=450.025n

* CHECK dout1_43 Vdout1_43ck89 = 0.9 time = 450
.meas tran vdout1_43ck89 FIND v(dout1_43) AT=450.025n

* CHECK dout1_44 Vdout1_44ck89 = 0 time = 450
.meas tran vdout1_44ck89 FIND v(dout1_44) AT=450.025n

* CHECK dout1_45 Vdout1_45ck89 = 0 time = 450
.meas tran vdout1_45ck89 FIND v(dout1_45) AT=450.025n

* CHECK dout1_46 Vdout1_46ck89 = 0 time = 450
.meas tran vdout1_46ck89 FIND v(dout1_46) AT=450.025n

* CHECK dout1_47 Vdout1_47ck89 = 0 time = 450
.meas tran vdout1_47ck89 FIND v(dout1_47) AT=450.025n

* CHECK dout1_48 Vdout1_48ck89 = 0 time = 450
.meas tran vdout1_48ck89 FIND v(dout1_48) AT=450.025n

* CHECK dout1_49 Vdout1_49ck89 = 0.9 time = 450
.meas tran vdout1_49ck89 FIND v(dout1_49) AT=450.025n

* CHECK dout1_50 Vdout1_50ck89 = 0.9 time = 450
.meas tran vdout1_50ck89 FIND v(dout1_50) AT=450.025n

* CHECK dout1_51 Vdout1_51ck89 = 0 time = 450
.meas tran vdout1_51ck89 FIND v(dout1_51) AT=450.025n

* CHECK dout1_52 Vdout1_52ck89 = 0.9 time = 450
.meas tran vdout1_52ck89 FIND v(dout1_52) AT=450.025n

* CHECK dout1_53 Vdout1_53ck89 = 0 time = 450
.meas tran vdout1_53ck89 FIND v(dout1_53) AT=450.025n

* CHECK dout1_54 Vdout1_54ck89 = 0.9 time = 450
.meas tran vdout1_54ck89 FIND v(dout1_54) AT=450.025n

* CHECK dout1_55 Vdout1_55ck89 = 0 time = 450
.meas tran vdout1_55ck89 FIND v(dout1_55) AT=450.025n

* CHECK dout1_56 Vdout1_56ck89 = 0 time = 450
.meas tran vdout1_56ck89 FIND v(dout1_56) AT=450.025n

* CHECK dout1_57 Vdout1_57ck89 = 0.9 time = 450
.meas tran vdout1_57ck89 FIND v(dout1_57) AT=450.025n

* CHECK dout1_58 Vdout1_58ck89 = 0 time = 450
.meas tran vdout1_58ck89 FIND v(dout1_58) AT=450.025n

* CHECK dout1_59 Vdout1_59ck89 = 0 time = 450
.meas tran vdout1_59ck89 FIND v(dout1_59) AT=450.025n

* CHECK dout1_60 Vdout1_60ck89 = 0.9 time = 450
.meas tran vdout1_60ck89 FIND v(dout1_60) AT=450.025n

* CHECK dout1_61 Vdout1_61ck89 = 0.9 time = 450
.meas tran vdout1_61ck89 FIND v(dout1_61) AT=450.025n

* CHECK dout1_62 Vdout1_62ck89 = 0.9 time = 450
.meas tran vdout1_62ck89 FIND v(dout1_62) AT=450.025n

* CHECK dout1_63 Vdout1_63ck89 = 0.9 time = 450
.meas tran vdout1_63ck89 FIND v(dout1_63) AT=450.025n

* CHECK dout1_64 Vdout1_64ck89 = 0 time = 450
.meas tran vdout1_64ck89 FIND v(dout1_64) AT=450.025n

* CHECK dout1_65 Vdout1_65ck89 = 0 time = 450
.meas tran vdout1_65ck89 FIND v(dout1_65) AT=450.025n

* CHECK dout1_66 Vdout1_66ck89 = 0 time = 450
.meas tran vdout1_66ck89 FIND v(dout1_66) AT=450.025n

* CHECK dout1_67 Vdout1_67ck89 = 0.9 time = 450
.meas tran vdout1_67ck89 FIND v(dout1_67) AT=450.025n

* CHECK dout1_68 Vdout1_68ck89 = 0.9 time = 450
.meas tran vdout1_68ck89 FIND v(dout1_68) AT=450.025n

* CHECK dout1_69 Vdout1_69ck89 = 0 time = 450
.meas tran vdout1_69ck89 FIND v(dout1_69) AT=450.025n

* CHECK dout1_70 Vdout1_70ck89 = 0.9 time = 450
.meas tran vdout1_70ck89 FIND v(dout1_70) AT=450.025n

* CHECK dout1_71 Vdout1_71ck89 = 0 time = 450
.meas tran vdout1_71ck89 FIND v(dout1_71) AT=450.025n

* CHECK dout1_72 Vdout1_72ck89 = 0 time = 450
.meas tran vdout1_72ck89 FIND v(dout1_72) AT=450.025n

* CHECK dout1_73 Vdout1_73ck89 = 0 time = 450
.meas tran vdout1_73ck89 FIND v(dout1_73) AT=450.025n

* CHECK dout1_74 Vdout1_74ck89 = 0.9 time = 450
.meas tran vdout1_74ck89 FIND v(dout1_74) AT=450.025n

* CHECK dout1_75 Vdout1_75ck89 = 0 time = 450
.meas tran vdout1_75ck89 FIND v(dout1_75) AT=450.025n

* CHECK dout1_76 Vdout1_76ck89 = 0.9 time = 450
.meas tran vdout1_76ck89 FIND v(dout1_76) AT=450.025n

* CHECK dout1_77 Vdout1_77ck89 = 0 time = 450
.meas tran vdout1_77ck89 FIND v(dout1_77) AT=450.025n

* CHECK dout1_78 Vdout1_78ck89 = 0.9 time = 450
.meas tran vdout1_78ck89 FIND v(dout1_78) AT=450.025n

* CHECK dout1_79 Vdout1_79ck89 = 0.9 time = 450
.meas tran vdout1_79ck89 FIND v(dout1_79) AT=450.025n

* CHECK dout1_80 Vdout1_80ck89 = 0.9 time = 450
.meas tran vdout1_80ck89 FIND v(dout1_80) AT=450.025n

* CHECK dout1_81 Vdout1_81ck89 = 0 time = 450
.meas tran vdout1_81ck89 FIND v(dout1_81) AT=450.025n

* CHECK dout1_82 Vdout1_82ck89 = 0 time = 450
.meas tran vdout1_82ck89 FIND v(dout1_82) AT=450.025n

* CHECK dout1_83 Vdout1_83ck89 = 0.9 time = 450
.meas tran vdout1_83ck89 FIND v(dout1_83) AT=450.025n

* CHECK dout1_84 Vdout1_84ck89 = 0.9 time = 450
.meas tran vdout1_84ck89 FIND v(dout1_84) AT=450.025n

* CHECK dout1_85 Vdout1_85ck89 = 0.9 time = 450
.meas tran vdout1_85ck89 FIND v(dout1_85) AT=450.025n

* CHECK dout1_86 Vdout1_86ck89 = 0.9 time = 450
.meas tran vdout1_86ck89 FIND v(dout1_86) AT=450.025n

* CHECK dout1_87 Vdout1_87ck89 = 0.9 time = 450
.meas tran vdout1_87ck89 FIND v(dout1_87) AT=450.025n

* CHECK dout1_88 Vdout1_88ck89 = 0.9 time = 450
.meas tran vdout1_88ck89 FIND v(dout1_88) AT=450.025n

* CHECK dout1_89 Vdout1_89ck89 = 0.9 time = 450
.meas tran vdout1_89ck89 FIND v(dout1_89) AT=450.025n

* CHECK dout1_90 Vdout1_90ck89 = 0 time = 450
.meas tran vdout1_90ck89 FIND v(dout1_90) AT=450.025n

* CHECK dout1_91 Vdout1_91ck89 = 0.9 time = 450
.meas tran vdout1_91ck89 FIND v(dout1_91) AT=450.025n

* CHECK dout1_92 Vdout1_92ck89 = 0 time = 450
.meas tran vdout1_92ck89 FIND v(dout1_92) AT=450.025n

* CHECK dout1_93 Vdout1_93ck89 = 0 time = 450
.meas tran vdout1_93ck89 FIND v(dout1_93) AT=450.025n

* CHECK dout1_94 Vdout1_94ck89 = 0.9 time = 450
.meas tran vdout1_94ck89 FIND v(dout1_94) AT=450.025n

* CHECK dout1_95 Vdout1_95ck89 = 0 time = 450
.meas tran vdout1_95ck89 FIND v(dout1_95) AT=450.025n

* CHECK dout1_96 Vdout1_96ck89 = 0.9 time = 450
.meas tran vdout1_96ck89 FIND v(dout1_96) AT=450.025n

* CHECK dout1_97 Vdout1_97ck89 = 0 time = 450
.meas tran vdout1_97ck89 FIND v(dout1_97) AT=450.025n

* CHECK dout1_98 Vdout1_98ck89 = 0.9 time = 450
.meas tran vdout1_98ck89 FIND v(dout1_98) AT=450.025n

* CHECK dout1_99 Vdout1_99ck89 = 0 time = 450
.meas tran vdout1_99ck89 FIND v(dout1_99) AT=450.025n

* CHECK dout1_100 Vdout1_100ck89 = 0 time = 450
.meas tran vdout1_100ck89 FIND v(dout1_100) AT=450.025n

* CHECK dout1_101 Vdout1_101ck89 = 0.9 time = 450
.meas tran vdout1_101ck89 FIND v(dout1_101) AT=450.025n

* CHECK dout1_102 Vdout1_102ck89 = 0 time = 450
.meas tran vdout1_102ck89 FIND v(dout1_102) AT=450.025n

* CHECK dout1_103 Vdout1_103ck89 = 0 time = 450
.meas tran vdout1_103ck89 FIND v(dout1_103) AT=450.025n

* CHECK dout1_104 Vdout1_104ck89 = 0 time = 450
.meas tran vdout1_104ck89 FIND v(dout1_104) AT=450.025n

* CHECK dout1_105 Vdout1_105ck89 = 0 time = 450
.meas tran vdout1_105ck89 FIND v(dout1_105) AT=450.025n

* CHECK dout1_106 Vdout1_106ck89 = 0 time = 450
.meas tran vdout1_106ck89 FIND v(dout1_106) AT=450.025n

* CHECK dout1_107 Vdout1_107ck89 = 0 time = 450
.meas tran vdout1_107ck89 FIND v(dout1_107) AT=450.025n

* CHECK dout1_108 Vdout1_108ck89 = 0 time = 450
.meas tran vdout1_108ck89 FIND v(dout1_108) AT=450.025n

* CHECK dout1_109 Vdout1_109ck89 = 0.9 time = 450
.meas tran vdout1_109ck89 FIND v(dout1_109) AT=450.025n

* CHECK dout1_110 Vdout1_110ck89 = 0.9 time = 450
.meas tran vdout1_110ck89 FIND v(dout1_110) AT=450.025n

* CHECK dout1_111 Vdout1_111ck89 = 0 time = 450
.meas tran vdout1_111ck89 FIND v(dout1_111) AT=450.025n

* CHECK dout1_112 Vdout1_112ck89 = 0 time = 450
.meas tran vdout1_112ck89 FIND v(dout1_112) AT=450.025n

* CHECK dout1_113 Vdout1_113ck89 = 0 time = 450
.meas tran vdout1_113ck89 FIND v(dout1_113) AT=450.025n

* CHECK dout1_114 Vdout1_114ck89 = 0.9 time = 450
.meas tran vdout1_114ck89 FIND v(dout1_114) AT=450.025n

* CHECK dout1_115 Vdout1_115ck89 = 0.9 time = 450
.meas tran vdout1_115ck89 FIND v(dout1_115) AT=450.025n

* CHECK dout1_116 Vdout1_116ck89 = 0 time = 450
.meas tran vdout1_116ck89 FIND v(dout1_116) AT=450.025n

* CHECK dout1_117 Vdout1_117ck89 = 0 time = 450
.meas tran vdout1_117ck89 FIND v(dout1_117) AT=450.025n

* CHECK dout1_118 Vdout1_118ck89 = 0 time = 450
.meas tran vdout1_118ck89 FIND v(dout1_118) AT=450.025n

* CHECK dout1_119 Vdout1_119ck89 = 0.9 time = 450
.meas tran vdout1_119ck89 FIND v(dout1_119) AT=450.025n

* CHECK dout1_0 Vdout1_0ck94 = 0.9 time = 475
.meas tran vdout1_0ck94 FIND v(dout1_0) AT=475.025n

* CHECK dout1_1 Vdout1_1ck94 = 0.9 time = 475
.meas tran vdout1_1ck94 FIND v(dout1_1) AT=475.025n

* CHECK dout1_2 Vdout1_2ck94 = 0 time = 475
.meas tran vdout1_2ck94 FIND v(dout1_2) AT=475.025n

* CHECK dout1_3 Vdout1_3ck94 = 0.9 time = 475
.meas tran vdout1_3ck94 FIND v(dout1_3) AT=475.025n

* CHECK dout1_4 Vdout1_4ck94 = 0 time = 475
.meas tran vdout1_4ck94 FIND v(dout1_4) AT=475.025n

* CHECK dout1_5 Vdout1_5ck94 = 0 time = 475
.meas tran vdout1_5ck94 FIND v(dout1_5) AT=475.025n

* CHECK dout1_6 Vdout1_6ck94 = 0.9 time = 475
.meas tran vdout1_6ck94 FIND v(dout1_6) AT=475.025n

* CHECK dout1_7 Vdout1_7ck94 = 0.9 time = 475
.meas tran vdout1_7ck94 FIND v(dout1_7) AT=475.025n

* CHECK dout1_8 Vdout1_8ck94 = 0 time = 475
.meas tran vdout1_8ck94 FIND v(dout1_8) AT=475.025n

* CHECK dout1_9 Vdout1_9ck94 = 0 time = 475
.meas tran vdout1_9ck94 FIND v(dout1_9) AT=475.025n

* CHECK dout1_10 Vdout1_10ck94 = 0 time = 475
.meas tran vdout1_10ck94 FIND v(dout1_10) AT=475.025n

* CHECK dout1_11 Vdout1_11ck94 = 0 time = 475
.meas tran vdout1_11ck94 FIND v(dout1_11) AT=475.025n

* CHECK dout1_12 Vdout1_12ck94 = 0.9 time = 475
.meas tran vdout1_12ck94 FIND v(dout1_12) AT=475.025n

* CHECK dout1_13 Vdout1_13ck94 = 0.9 time = 475
.meas tran vdout1_13ck94 FIND v(dout1_13) AT=475.025n

* CHECK dout1_14 Vdout1_14ck94 = 0 time = 475
.meas tran vdout1_14ck94 FIND v(dout1_14) AT=475.025n

* CHECK dout1_15 Vdout1_15ck94 = 0.9 time = 475
.meas tran vdout1_15ck94 FIND v(dout1_15) AT=475.025n

* CHECK dout1_16 Vdout1_16ck94 = 0 time = 475
.meas tran vdout1_16ck94 FIND v(dout1_16) AT=475.025n

* CHECK dout1_17 Vdout1_17ck94 = 0.9 time = 475
.meas tran vdout1_17ck94 FIND v(dout1_17) AT=475.025n

* CHECK dout1_18 Vdout1_18ck94 = 0.9 time = 475
.meas tran vdout1_18ck94 FIND v(dout1_18) AT=475.025n

* CHECK dout1_19 Vdout1_19ck94 = 0.9 time = 475
.meas tran vdout1_19ck94 FIND v(dout1_19) AT=475.025n

* CHECK dout1_20 Vdout1_20ck94 = 0 time = 475
.meas tran vdout1_20ck94 FIND v(dout1_20) AT=475.025n

* CHECK dout1_21 Vdout1_21ck94 = 0 time = 475
.meas tran vdout1_21ck94 FIND v(dout1_21) AT=475.025n

* CHECK dout1_22 Vdout1_22ck94 = 0.9 time = 475
.meas tran vdout1_22ck94 FIND v(dout1_22) AT=475.025n

* CHECK dout1_23 Vdout1_23ck94 = 0.9 time = 475
.meas tran vdout1_23ck94 FIND v(dout1_23) AT=475.025n

* CHECK dout1_24 Vdout1_24ck94 = 0 time = 475
.meas tran vdout1_24ck94 FIND v(dout1_24) AT=475.025n

* CHECK dout1_25 Vdout1_25ck94 = 0.9 time = 475
.meas tran vdout1_25ck94 FIND v(dout1_25) AT=475.025n

* CHECK dout1_26 Vdout1_26ck94 = 0.9 time = 475
.meas tran vdout1_26ck94 FIND v(dout1_26) AT=475.025n

* CHECK dout1_27 Vdout1_27ck94 = 0 time = 475
.meas tran vdout1_27ck94 FIND v(dout1_27) AT=475.025n

* CHECK dout1_28 Vdout1_28ck94 = 0 time = 475
.meas tran vdout1_28ck94 FIND v(dout1_28) AT=475.025n

* CHECK dout1_29 Vdout1_29ck94 = 0.9 time = 475
.meas tran vdout1_29ck94 FIND v(dout1_29) AT=475.025n

* CHECK dout1_30 Vdout1_30ck94 = 0.9 time = 475
.meas tran vdout1_30ck94 FIND v(dout1_30) AT=475.025n

* CHECK dout1_31 Vdout1_31ck94 = 0 time = 475
.meas tran vdout1_31ck94 FIND v(dout1_31) AT=475.025n

* CHECK dout1_32 Vdout1_32ck94 = 0.9 time = 475
.meas tran vdout1_32ck94 FIND v(dout1_32) AT=475.025n

* CHECK dout1_33 Vdout1_33ck94 = 0 time = 475
.meas tran vdout1_33ck94 FIND v(dout1_33) AT=475.025n

* CHECK dout1_34 Vdout1_34ck94 = 0 time = 475
.meas tran vdout1_34ck94 FIND v(dout1_34) AT=475.025n

* CHECK dout1_35 Vdout1_35ck94 = 0.9 time = 475
.meas tran vdout1_35ck94 FIND v(dout1_35) AT=475.025n

* CHECK dout1_36 Vdout1_36ck94 = 0 time = 475
.meas tran vdout1_36ck94 FIND v(dout1_36) AT=475.025n

* CHECK dout1_37 Vdout1_37ck94 = 0 time = 475
.meas tran vdout1_37ck94 FIND v(dout1_37) AT=475.025n

* CHECK dout1_38 Vdout1_38ck94 = 0 time = 475
.meas tran vdout1_38ck94 FIND v(dout1_38) AT=475.025n

* CHECK dout1_39 Vdout1_39ck94 = 0 time = 475
.meas tran vdout1_39ck94 FIND v(dout1_39) AT=475.025n

* CHECK dout1_40 Vdout1_40ck94 = 0.9 time = 475
.meas tran vdout1_40ck94 FIND v(dout1_40) AT=475.025n

* CHECK dout1_41 Vdout1_41ck94 = 0 time = 475
.meas tran vdout1_41ck94 FIND v(dout1_41) AT=475.025n

* CHECK dout1_42 Vdout1_42ck94 = 0 time = 475
.meas tran vdout1_42ck94 FIND v(dout1_42) AT=475.025n

* CHECK dout1_43 Vdout1_43ck94 = 0 time = 475
.meas tran vdout1_43ck94 FIND v(dout1_43) AT=475.025n

* CHECK dout1_44 Vdout1_44ck94 = 0.9 time = 475
.meas tran vdout1_44ck94 FIND v(dout1_44) AT=475.025n

* CHECK dout1_45 Vdout1_45ck94 = 0.9 time = 475
.meas tran vdout1_45ck94 FIND v(dout1_45) AT=475.025n

* CHECK dout1_46 Vdout1_46ck94 = 0.9 time = 475
.meas tran vdout1_46ck94 FIND v(dout1_46) AT=475.025n

* CHECK dout1_47 Vdout1_47ck94 = 0 time = 475
.meas tran vdout1_47ck94 FIND v(dout1_47) AT=475.025n

* CHECK dout1_48 Vdout1_48ck94 = 0 time = 475
.meas tran vdout1_48ck94 FIND v(dout1_48) AT=475.025n

* CHECK dout1_49 Vdout1_49ck94 = 0.9 time = 475
.meas tran vdout1_49ck94 FIND v(dout1_49) AT=475.025n

* CHECK dout1_50 Vdout1_50ck94 = 0 time = 475
.meas tran vdout1_50ck94 FIND v(dout1_50) AT=475.025n

* CHECK dout1_51 Vdout1_51ck94 = 0 time = 475
.meas tran vdout1_51ck94 FIND v(dout1_51) AT=475.025n

* CHECK dout1_52 Vdout1_52ck94 = 0.9 time = 475
.meas tran vdout1_52ck94 FIND v(dout1_52) AT=475.025n

* CHECK dout1_53 Vdout1_53ck94 = 0 time = 475
.meas tran vdout1_53ck94 FIND v(dout1_53) AT=475.025n

* CHECK dout1_54 Vdout1_54ck94 = 0 time = 475
.meas tran vdout1_54ck94 FIND v(dout1_54) AT=475.025n

* CHECK dout1_55 Vdout1_55ck94 = 0 time = 475
.meas tran vdout1_55ck94 FIND v(dout1_55) AT=475.025n

* CHECK dout1_56 Vdout1_56ck94 = 0.9 time = 475
.meas tran vdout1_56ck94 FIND v(dout1_56) AT=475.025n

* CHECK dout1_57 Vdout1_57ck94 = 0.9 time = 475
.meas tran vdout1_57ck94 FIND v(dout1_57) AT=475.025n

* CHECK dout1_58 Vdout1_58ck94 = 0 time = 475
.meas tran vdout1_58ck94 FIND v(dout1_58) AT=475.025n

* CHECK dout1_59 Vdout1_59ck94 = 0 time = 475
.meas tran vdout1_59ck94 FIND v(dout1_59) AT=475.025n

* CHECK dout1_60 Vdout1_60ck94 = 0.9 time = 475
.meas tran vdout1_60ck94 FIND v(dout1_60) AT=475.025n

* CHECK dout1_61 Vdout1_61ck94 = 0 time = 475
.meas tran vdout1_61ck94 FIND v(dout1_61) AT=475.025n

* CHECK dout1_62 Vdout1_62ck94 = 0.9 time = 475
.meas tran vdout1_62ck94 FIND v(dout1_62) AT=475.025n

* CHECK dout1_63 Vdout1_63ck94 = 0.9 time = 475
.meas tran vdout1_63ck94 FIND v(dout1_63) AT=475.025n

* CHECK dout1_64 Vdout1_64ck94 = 0.9 time = 475
.meas tran vdout1_64ck94 FIND v(dout1_64) AT=475.025n

* CHECK dout1_65 Vdout1_65ck94 = 0 time = 475
.meas tran vdout1_65ck94 FIND v(dout1_65) AT=475.025n

* CHECK dout1_66 Vdout1_66ck94 = 0.9 time = 475
.meas tran vdout1_66ck94 FIND v(dout1_66) AT=475.025n

* CHECK dout1_67 Vdout1_67ck94 = 0 time = 475
.meas tran vdout1_67ck94 FIND v(dout1_67) AT=475.025n

* CHECK dout1_68 Vdout1_68ck94 = 0 time = 475
.meas tran vdout1_68ck94 FIND v(dout1_68) AT=475.025n

* CHECK dout1_69 Vdout1_69ck94 = 0.9 time = 475
.meas tran vdout1_69ck94 FIND v(dout1_69) AT=475.025n

* CHECK dout1_70 Vdout1_70ck94 = 0 time = 475
.meas tran vdout1_70ck94 FIND v(dout1_70) AT=475.025n

* CHECK dout1_71 Vdout1_71ck94 = 0.9 time = 475
.meas tran vdout1_71ck94 FIND v(dout1_71) AT=475.025n

* CHECK dout1_72 Vdout1_72ck94 = 0 time = 475
.meas tran vdout1_72ck94 FIND v(dout1_72) AT=475.025n

* CHECK dout1_73 Vdout1_73ck94 = 0.9 time = 475
.meas tran vdout1_73ck94 FIND v(dout1_73) AT=475.025n

* CHECK dout1_74 Vdout1_74ck94 = 0.9 time = 475
.meas tran vdout1_74ck94 FIND v(dout1_74) AT=475.025n

* CHECK dout1_75 Vdout1_75ck94 = 0.9 time = 475
.meas tran vdout1_75ck94 FIND v(dout1_75) AT=475.025n

* CHECK dout1_76 Vdout1_76ck94 = 0 time = 475
.meas tran vdout1_76ck94 FIND v(dout1_76) AT=475.025n

* CHECK dout1_77 Vdout1_77ck94 = 0 time = 475
.meas tran vdout1_77ck94 FIND v(dout1_77) AT=475.025n

* CHECK dout1_78 Vdout1_78ck94 = 0 time = 475
.meas tran vdout1_78ck94 FIND v(dout1_78) AT=475.025n

* CHECK dout1_79 Vdout1_79ck94 = 0.9 time = 475
.meas tran vdout1_79ck94 FIND v(dout1_79) AT=475.025n

* CHECK dout1_80 Vdout1_80ck94 = 0 time = 475
.meas tran vdout1_80ck94 FIND v(dout1_80) AT=475.025n

* CHECK dout1_81 Vdout1_81ck94 = 0.9 time = 475
.meas tran vdout1_81ck94 FIND v(dout1_81) AT=475.025n

* CHECK dout1_82 Vdout1_82ck94 = 0 time = 475
.meas tran vdout1_82ck94 FIND v(dout1_82) AT=475.025n

* CHECK dout1_83 Vdout1_83ck94 = 0 time = 475
.meas tran vdout1_83ck94 FIND v(dout1_83) AT=475.025n

* CHECK dout1_84 Vdout1_84ck94 = 0.9 time = 475
.meas tran vdout1_84ck94 FIND v(dout1_84) AT=475.025n

* CHECK dout1_85 Vdout1_85ck94 = 0.9 time = 475
.meas tran vdout1_85ck94 FIND v(dout1_85) AT=475.025n

* CHECK dout1_86 Vdout1_86ck94 = 0.9 time = 475
.meas tran vdout1_86ck94 FIND v(dout1_86) AT=475.025n

* CHECK dout1_87 Vdout1_87ck94 = 0 time = 475
.meas tran vdout1_87ck94 FIND v(dout1_87) AT=475.025n

* CHECK dout1_88 Vdout1_88ck94 = 0.9 time = 475
.meas tran vdout1_88ck94 FIND v(dout1_88) AT=475.025n

* CHECK dout1_89 Vdout1_89ck94 = 0.9 time = 475
.meas tran vdout1_89ck94 FIND v(dout1_89) AT=475.025n

* CHECK dout1_90 Vdout1_90ck94 = 0 time = 475
.meas tran vdout1_90ck94 FIND v(dout1_90) AT=475.025n

* CHECK dout1_91 Vdout1_91ck94 = 0 time = 475
.meas tran vdout1_91ck94 FIND v(dout1_91) AT=475.025n

* CHECK dout1_92 Vdout1_92ck94 = 0 time = 475
.meas tran vdout1_92ck94 FIND v(dout1_92) AT=475.025n

* CHECK dout1_93 Vdout1_93ck94 = 0.9 time = 475
.meas tran vdout1_93ck94 FIND v(dout1_93) AT=475.025n

* CHECK dout1_94 Vdout1_94ck94 = 0 time = 475
.meas tran vdout1_94ck94 FIND v(dout1_94) AT=475.025n

* CHECK dout1_95 Vdout1_95ck94 = 0 time = 475
.meas tran vdout1_95ck94 FIND v(dout1_95) AT=475.025n

* CHECK dout1_96 Vdout1_96ck94 = 0 time = 475
.meas tran vdout1_96ck94 FIND v(dout1_96) AT=475.025n

* CHECK dout1_97 Vdout1_97ck94 = 0 time = 475
.meas tran vdout1_97ck94 FIND v(dout1_97) AT=475.025n

* CHECK dout1_98 Vdout1_98ck94 = 0.9 time = 475
.meas tran vdout1_98ck94 FIND v(dout1_98) AT=475.025n

* CHECK dout1_99 Vdout1_99ck94 = 0 time = 475
.meas tran vdout1_99ck94 FIND v(dout1_99) AT=475.025n

* CHECK dout1_100 Vdout1_100ck94 = 0 time = 475
.meas tran vdout1_100ck94 FIND v(dout1_100) AT=475.025n

* CHECK dout1_101 Vdout1_101ck94 = 0 time = 475
.meas tran vdout1_101ck94 FIND v(dout1_101) AT=475.025n

* CHECK dout1_102 Vdout1_102ck94 = 0.9 time = 475
.meas tran vdout1_102ck94 FIND v(dout1_102) AT=475.025n

* CHECK dout1_103 Vdout1_103ck94 = 0.9 time = 475
.meas tran vdout1_103ck94 FIND v(dout1_103) AT=475.025n

* CHECK dout1_104 Vdout1_104ck94 = 0.9 time = 475
.meas tran vdout1_104ck94 FIND v(dout1_104) AT=475.025n

* CHECK dout1_105 Vdout1_105ck94 = 0.9 time = 475
.meas tran vdout1_105ck94 FIND v(dout1_105) AT=475.025n

* CHECK dout1_106 Vdout1_106ck94 = 0 time = 475
.meas tran vdout1_106ck94 FIND v(dout1_106) AT=475.025n

* CHECK dout1_107 Vdout1_107ck94 = 0 time = 475
.meas tran vdout1_107ck94 FIND v(dout1_107) AT=475.025n

* CHECK dout1_108 Vdout1_108ck94 = 0.9 time = 475
.meas tran vdout1_108ck94 FIND v(dout1_108) AT=475.025n

* CHECK dout1_109 Vdout1_109ck94 = 0 time = 475
.meas tran vdout1_109ck94 FIND v(dout1_109) AT=475.025n

* CHECK dout1_110 Vdout1_110ck94 = 0 time = 475
.meas tran vdout1_110ck94 FIND v(dout1_110) AT=475.025n

* CHECK dout1_111 Vdout1_111ck94 = 0.9 time = 475
.meas tran vdout1_111ck94 FIND v(dout1_111) AT=475.025n

* CHECK dout1_112 Vdout1_112ck94 = 0 time = 475
.meas tran vdout1_112ck94 FIND v(dout1_112) AT=475.025n

* CHECK dout1_113 Vdout1_113ck94 = 0 time = 475
.meas tran vdout1_113ck94 FIND v(dout1_113) AT=475.025n

* CHECK dout1_114 Vdout1_114ck94 = 0.9 time = 475
.meas tran vdout1_114ck94 FIND v(dout1_114) AT=475.025n

* CHECK dout1_115 Vdout1_115ck94 = 0 time = 475
.meas tran vdout1_115ck94 FIND v(dout1_115) AT=475.025n

* CHECK dout1_116 Vdout1_116ck94 = 0.9 time = 475
.meas tran vdout1_116ck94 FIND v(dout1_116) AT=475.025n

* CHECK dout1_117 Vdout1_117ck94 = 0 time = 475
.meas tran vdout1_117ck94 FIND v(dout1_117) AT=475.025n

* CHECK dout1_118 Vdout1_118ck94 = 0.9 time = 475
.meas tran vdout1_118ck94 FIND v(dout1_118) AT=475.025n

* CHECK dout1_119 Vdout1_119ck94 = 0 time = 475
.meas tran vdout1_119ck94 FIND v(dout1_119) AT=475.025n

* CHECK dout1_0 Vdout1_0ck101 = 0.9 time = 510
.meas tran vdout1_0ck101 FIND v(dout1_0) AT=510.025n

* CHECK dout1_1 Vdout1_1ck101 = 0 time = 510
.meas tran vdout1_1ck101 FIND v(dout1_1) AT=510.025n

* CHECK dout1_2 Vdout1_2ck101 = 0 time = 510
.meas tran vdout1_2ck101 FIND v(dout1_2) AT=510.025n

* CHECK dout1_3 Vdout1_3ck101 = 0 time = 510
.meas tran vdout1_3ck101 FIND v(dout1_3) AT=510.025n

* CHECK dout1_4 Vdout1_4ck101 = 0.9 time = 510
.meas tran vdout1_4ck101 FIND v(dout1_4) AT=510.025n

* CHECK dout1_5 Vdout1_5ck101 = 0 time = 510
.meas tran vdout1_5ck101 FIND v(dout1_5) AT=510.025n

* CHECK dout1_6 Vdout1_6ck101 = 0.9 time = 510
.meas tran vdout1_6ck101 FIND v(dout1_6) AT=510.025n

* CHECK dout1_7 Vdout1_7ck101 = 0 time = 510
.meas tran vdout1_7ck101 FIND v(dout1_7) AT=510.025n

* CHECK dout1_8 Vdout1_8ck101 = 0 time = 510
.meas tran vdout1_8ck101 FIND v(dout1_8) AT=510.025n

* CHECK dout1_9 Vdout1_9ck101 = 0 time = 510
.meas tran vdout1_9ck101 FIND v(dout1_9) AT=510.025n

* CHECK dout1_10 Vdout1_10ck101 = 0 time = 510
.meas tran vdout1_10ck101 FIND v(dout1_10) AT=510.025n

* CHECK dout1_11 Vdout1_11ck101 = 0.9 time = 510
.meas tran vdout1_11ck101 FIND v(dout1_11) AT=510.025n

* CHECK dout1_12 Vdout1_12ck101 = 0 time = 510
.meas tran vdout1_12ck101 FIND v(dout1_12) AT=510.025n

* CHECK dout1_13 Vdout1_13ck101 = 0 time = 510
.meas tran vdout1_13ck101 FIND v(dout1_13) AT=510.025n

* CHECK dout1_14 Vdout1_14ck101 = 0 time = 510
.meas tran vdout1_14ck101 FIND v(dout1_14) AT=510.025n

* CHECK dout1_15 Vdout1_15ck101 = 0.9 time = 510
.meas tran vdout1_15ck101 FIND v(dout1_15) AT=510.025n

* CHECK dout1_16 Vdout1_16ck101 = 0 time = 510
.meas tran vdout1_16ck101 FIND v(dout1_16) AT=510.025n

* CHECK dout1_17 Vdout1_17ck101 = 0.9 time = 510
.meas tran vdout1_17ck101 FIND v(dout1_17) AT=510.025n

* CHECK dout1_18 Vdout1_18ck101 = 0 time = 510
.meas tran vdout1_18ck101 FIND v(dout1_18) AT=510.025n

* CHECK dout1_19 Vdout1_19ck101 = 0.9 time = 510
.meas tran vdout1_19ck101 FIND v(dout1_19) AT=510.025n

* CHECK dout1_20 Vdout1_20ck101 = 0.9 time = 510
.meas tran vdout1_20ck101 FIND v(dout1_20) AT=510.025n

* CHECK dout1_21 Vdout1_21ck101 = 0 time = 510
.meas tran vdout1_21ck101 FIND v(dout1_21) AT=510.025n

* CHECK dout1_22 Vdout1_22ck101 = 0.9 time = 510
.meas tran vdout1_22ck101 FIND v(dout1_22) AT=510.025n

* CHECK dout1_23 Vdout1_23ck101 = 0 time = 510
.meas tran vdout1_23ck101 FIND v(dout1_23) AT=510.025n

* CHECK dout1_24 Vdout1_24ck101 = 0.9 time = 510
.meas tran vdout1_24ck101 FIND v(dout1_24) AT=510.025n

* CHECK dout1_25 Vdout1_25ck101 = 0 time = 510
.meas tran vdout1_25ck101 FIND v(dout1_25) AT=510.025n

* CHECK dout1_26 Vdout1_26ck101 = 0 time = 510
.meas tran vdout1_26ck101 FIND v(dout1_26) AT=510.025n

* CHECK dout1_27 Vdout1_27ck101 = 0.9 time = 510
.meas tran vdout1_27ck101 FIND v(dout1_27) AT=510.025n

* CHECK dout1_28 Vdout1_28ck101 = 0.9 time = 510
.meas tran vdout1_28ck101 FIND v(dout1_28) AT=510.025n

* CHECK dout1_29 Vdout1_29ck101 = 0 time = 510
.meas tran vdout1_29ck101 FIND v(dout1_29) AT=510.025n

* CHECK dout1_30 Vdout1_30ck101 = 0.9 time = 510
.meas tran vdout1_30ck101 FIND v(dout1_30) AT=510.025n

* CHECK dout1_31 Vdout1_31ck101 = 0.9 time = 510
.meas tran vdout1_31ck101 FIND v(dout1_31) AT=510.025n

* CHECK dout1_32 Vdout1_32ck101 = 0 time = 510
.meas tran vdout1_32ck101 FIND v(dout1_32) AT=510.025n

* CHECK dout1_33 Vdout1_33ck101 = 0 time = 510
.meas tran vdout1_33ck101 FIND v(dout1_33) AT=510.025n

* CHECK dout1_34 Vdout1_34ck101 = 0 time = 510
.meas tran vdout1_34ck101 FIND v(dout1_34) AT=510.025n

* CHECK dout1_35 Vdout1_35ck101 = 0.9 time = 510
.meas tran vdout1_35ck101 FIND v(dout1_35) AT=510.025n

* CHECK dout1_36 Vdout1_36ck101 = 0 time = 510
.meas tran vdout1_36ck101 FIND v(dout1_36) AT=510.025n

* CHECK dout1_37 Vdout1_37ck101 = 0.9 time = 510
.meas tran vdout1_37ck101 FIND v(dout1_37) AT=510.025n

* CHECK dout1_38 Vdout1_38ck101 = 0 time = 510
.meas tran vdout1_38ck101 FIND v(dout1_38) AT=510.025n

* CHECK dout1_39 Vdout1_39ck101 = 0 time = 510
.meas tran vdout1_39ck101 FIND v(dout1_39) AT=510.025n

* CHECK dout1_40 Vdout1_40ck101 = 0 time = 510
.meas tran vdout1_40ck101 FIND v(dout1_40) AT=510.025n

* CHECK dout1_41 Vdout1_41ck101 = 0.9 time = 510
.meas tran vdout1_41ck101 FIND v(dout1_41) AT=510.025n

* CHECK dout1_42 Vdout1_42ck101 = 0.9 time = 510
.meas tran vdout1_42ck101 FIND v(dout1_42) AT=510.025n

* CHECK dout1_43 Vdout1_43ck101 = 0 time = 510
.meas tran vdout1_43ck101 FIND v(dout1_43) AT=510.025n

* CHECK dout1_44 Vdout1_44ck101 = 0 time = 510
.meas tran vdout1_44ck101 FIND v(dout1_44) AT=510.025n

* CHECK dout1_45 Vdout1_45ck101 = 0 time = 510
.meas tran vdout1_45ck101 FIND v(dout1_45) AT=510.025n

* CHECK dout1_46 Vdout1_46ck101 = 0 time = 510
.meas tran vdout1_46ck101 FIND v(dout1_46) AT=510.025n

* CHECK dout1_47 Vdout1_47ck101 = 0.9 time = 510
.meas tran vdout1_47ck101 FIND v(dout1_47) AT=510.025n

* CHECK dout1_48 Vdout1_48ck101 = 0 time = 510
.meas tran vdout1_48ck101 FIND v(dout1_48) AT=510.025n

* CHECK dout1_49 Vdout1_49ck101 = 0.9 time = 510
.meas tran vdout1_49ck101 FIND v(dout1_49) AT=510.025n

* CHECK dout1_50 Vdout1_50ck101 = 0 time = 510
.meas tran vdout1_50ck101 FIND v(dout1_50) AT=510.025n

* CHECK dout1_51 Vdout1_51ck101 = 0 time = 510
.meas tran vdout1_51ck101 FIND v(dout1_51) AT=510.025n

* CHECK dout1_52 Vdout1_52ck101 = 0.9 time = 510
.meas tran vdout1_52ck101 FIND v(dout1_52) AT=510.025n

* CHECK dout1_53 Vdout1_53ck101 = 0.9 time = 510
.meas tran vdout1_53ck101 FIND v(dout1_53) AT=510.025n

* CHECK dout1_54 Vdout1_54ck101 = 0 time = 510
.meas tran vdout1_54ck101 FIND v(dout1_54) AT=510.025n

* CHECK dout1_55 Vdout1_55ck101 = 0 time = 510
.meas tran vdout1_55ck101 FIND v(dout1_55) AT=510.025n

* CHECK dout1_56 Vdout1_56ck101 = 0.9 time = 510
.meas tran vdout1_56ck101 FIND v(dout1_56) AT=510.025n

* CHECK dout1_57 Vdout1_57ck101 = 0 time = 510
.meas tran vdout1_57ck101 FIND v(dout1_57) AT=510.025n

* CHECK dout1_58 Vdout1_58ck101 = 0.9 time = 510
.meas tran vdout1_58ck101 FIND v(dout1_58) AT=510.025n

* CHECK dout1_59 Vdout1_59ck101 = 0 time = 510
.meas tran vdout1_59ck101 FIND v(dout1_59) AT=510.025n

* CHECK dout1_60 Vdout1_60ck101 = 0.9 time = 510
.meas tran vdout1_60ck101 FIND v(dout1_60) AT=510.025n

* CHECK dout1_61 Vdout1_61ck101 = 0 time = 510
.meas tran vdout1_61ck101 FIND v(dout1_61) AT=510.025n

* CHECK dout1_62 Vdout1_62ck101 = 0.9 time = 510
.meas tran vdout1_62ck101 FIND v(dout1_62) AT=510.025n

* CHECK dout1_63 Vdout1_63ck101 = 0.9 time = 510
.meas tran vdout1_63ck101 FIND v(dout1_63) AT=510.025n

* CHECK dout1_64 Vdout1_64ck101 = 0 time = 510
.meas tran vdout1_64ck101 FIND v(dout1_64) AT=510.025n

* CHECK dout1_65 Vdout1_65ck101 = 0.9 time = 510
.meas tran vdout1_65ck101 FIND v(dout1_65) AT=510.025n

* CHECK dout1_66 Vdout1_66ck101 = 0 time = 510
.meas tran vdout1_66ck101 FIND v(dout1_66) AT=510.025n

* CHECK dout1_67 Vdout1_67ck101 = 0.9 time = 510
.meas tran vdout1_67ck101 FIND v(dout1_67) AT=510.025n

* CHECK dout1_68 Vdout1_68ck101 = 0.9 time = 510
.meas tran vdout1_68ck101 FIND v(dout1_68) AT=510.025n

* CHECK dout1_69 Vdout1_69ck101 = 0.9 time = 510
.meas tran vdout1_69ck101 FIND v(dout1_69) AT=510.025n

* CHECK dout1_70 Vdout1_70ck101 = 0.9 time = 510
.meas tran vdout1_70ck101 FIND v(dout1_70) AT=510.025n

* CHECK dout1_71 Vdout1_71ck101 = 0.9 time = 510
.meas tran vdout1_71ck101 FIND v(dout1_71) AT=510.025n

* CHECK dout1_72 Vdout1_72ck101 = 0.9 time = 510
.meas tran vdout1_72ck101 FIND v(dout1_72) AT=510.025n

* CHECK dout1_73 Vdout1_73ck101 = 0 time = 510
.meas tran vdout1_73ck101 FIND v(dout1_73) AT=510.025n

* CHECK dout1_74 Vdout1_74ck101 = 0.9 time = 510
.meas tran vdout1_74ck101 FIND v(dout1_74) AT=510.025n

* CHECK dout1_75 Vdout1_75ck101 = 0.9 time = 510
.meas tran vdout1_75ck101 FIND v(dout1_75) AT=510.025n

* CHECK dout1_76 Vdout1_76ck101 = 0.9 time = 510
.meas tran vdout1_76ck101 FIND v(dout1_76) AT=510.025n

* CHECK dout1_77 Vdout1_77ck101 = 0 time = 510
.meas tran vdout1_77ck101 FIND v(dout1_77) AT=510.025n

* CHECK dout1_78 Vdout1_78ck101 = 0 time = 510
.meas tran vdout1_78ck101 FIND v(dout1_78) AT=510.025n

* CHECK dout1_79 Vdout1_79ck101 = 0.9 time = 510
.meas tran vdout1_79ck101 FIND v(dout1_79) AT=510.025n

* CHECK dout1_80 Vdout1_80ck101 = 0.9 time = 510
.meas tran vdout1_80ck101 FIND v(dout1_80) AT=510.025n

* CHECK dout1_81 Vdout1_81ck101 = 0 time = 510
.meas tran vdout1_81ck101 FIND v(dout1_81) AT=510.025n

* CHECK dout1_82 Vdout1_82ck101 = 0.9 time = 510
.meas tran vdout1_82ck101 FIND v(dout1_82) AT=510.025n

* CHECK dout1_83 Vdout1_83ck101 = 0 time = 510
.meas tran vdout1_83ck101 FIND v(dout1_83) AT=510.025n

* CHECK dout1_84 Vdout1_84ck101 = 0 time = 510
.meas tran vdout1_84ck101 FIND v(dout1_84) AT=510.025n

* CHECK dout1_85 Vdout1_85ck101 = 0 time = 510
.meas tran vdout1_85ck101 FIND v(dout1_85) AT=510.025n

* CHECK dout1_86 Vdout1_86ck101 = 0.9 time = 510
.meas tran vdout1_86ck101 FIND v(dout1_86) AT=510.025n

* CHECK dout1_87 Vdout1_87ck101 = 0.9 time = 510
.meas tran vdout1_87ck101 FIND v(dout1_87) AT=510.025n

* CHECK dout1_88 Vdout1_88ck101 = 0 time = 510
.meas tran vdout1_88ck101 FIND v(dout1_88) AT=510.025n

* CHECK dout1_89 Vdout1_89ck101 = 0.9 time = 510
.meas tran vdout1_89ck101 FIND v(dout1_89) AT=510.025n

* CHECK dout1_90 Vdout1_90ck101 = 0.9 time = 510
.meas tran vdout1_90ck101 FIND v(dout1_90) AT=510.025n

* CHECK dout1_91 Vdout1_91ck101 = 0.9 time = 510
.meas tran vdout1_91ck101 FIND v(dout1_91) AT=510.025n

* CHECK dout1_92 Vdout1_92ck101 = 0 time = 510
.meas tran vdout1_92ck101 FIND v(dout1_92) AT=510.025n

* CHECK dout1_93 Vdout1_93ck101 = 0 time = 510
.meas tran vdout1_93ck101 FIND v(dout1_93) AT=510.025n

* CHECK dout1_94 Vdout1_94ck101 = 0 time = 510
.meas tran vdout1_94ck101 FIND v(dout1_94) AT=510.025n

* CHECK dout1_95 Vdout1_95ck101 = 0 time = 510
.meas tran vdout1_95ck101 FIND v(dout1_95) AT=510.025n

* CHECK dout1_96 Vdout1_96ck101 = 0 time = 510
.meas tran vdout1_96ck101 FIND v(dout1_96) AT=510.025n

* CHECK dout1_97 Vdout1_97ck101 = 0.9 time = 510
.meas tran vdout1_97ck101 FIND v(dout1_97) AT=510.025n

* CHECK dout1_98 Vdout1_98ck101 = 0 time = 510
.meas tran vdout1_98ck101 FIND v(dout1_98) AT=510.025n

* CHECK dout1_99 Vdout1_99ck101 = 0 time = 510
.meas tran vdout1_99ck101 FIND v(dout1_99) AT=510.025n

* CHECK dout1_100 Vdout1_100ck101 = 0.9 time = 510
.meas tran vdout1_100ck101 FIND v(dout1_100) AT=510.025n

* CHECK dout1_101 Vdout1_101ck101 = 0 time = 510
.meas tran vdout1_101ck101 FIND v(dout1_101) AT=510.025n

* CHECK dout1_102 Vdout1_102ck101 = 0.9 time = 510
.meas tran vdout1_102ck101 FIND v(dout1_102) AT=510.025n

* CHECK dout1_103 Vdout1_103ck101 = 0.9 time = 510
.meas tran vdout1_103ck101 FIND v(dout1_103) AT=510.025n

* CHECK dout1_104 Vdout1_104ck101 = 0.9 time = 510
.meas tran vdout1_104ck101 FIND v(dout1_104) AT=510.025n

* CHECK dout1_105 Vdout1_105ck101 = 0.9 time = 510
.meas tran vdout1_105ck101 FIND v(dout1_105) AT=510.025n

* CHECK dout1_106 Vdout1_106ck101 = 0.9 time = 510
.meas tran vdout1_106ck101 FIND v(dout1_106) AT=510.025n

* CHECK dout1_107 Vdout1_107ck101 = 0 time = 510
.meas tran vdout1_107ck101 FIND v(dout1_107) AT=510.025n

* CHECK dout1_108 Vdout1_108ck101 = 0 time = 510
.meas tran vdout1_108ck101 FIND v(dout1_108) AT=510.025n

* CHECK dout1_109 Vdout1_109ck101 = 0 time = 510
.meas tran vdout1_109ck101 FIND v(dout1_109) AT=510.025n

* CHECK dout1_110 Vdout1_110ck101 = 0 time = 510
.meas tran vdout1_110ck101 FIND v(dout1_110) AT=510.025n

* CHECK dout1_111 Vdout1_111ck101 = 0 time = 510
.meas tran vdout1_111ck101 FIND v(dout1_111) AT=510.025n

* CHECK dout1_112 Vdout1_112ck101 = 0.9 time = 510
.meas tran vdout1_112ck101 FIND v(dout1_112) AT=510.025n

* CHECK dout1_113 Vdout1_113ck101 = 0 time = 510
.meas tran vdout1_113ck101 FIND v(dout1_113) AT=510.025n

* CHECK dout1_114 Vdout1_114ck101 = 0.9 time = 510
.meas tran vdout1_114ck101 FIND v(dout1_114) AT=510.025n

* CHECK dout1_115 Vdout1_115ck101 = 0.9 time = 510
.meas tran vdout1_115ck101 FIND v(dout1_115) AT=510.025n

* CHECK dout1_116 Vdout1_116ck101 = 0 time = 510
.meas tran vdout1_116ck101 FIND v(dout1_116) AT=510.025n

* CHECK dout1_117 Vdout1_117ck101 = 0.9 time = 510
.meas tran vdout1_117ck101 FIND v(dout1_117) AT=510.025n

* CHECK dout1_118 Vdout1_118ck101 = 0.9 time = 510
.meas tran vdout1_118ck101 FIND v(dout1_118) AT=510.025n

* CHECK dout1_119 Vdout1_119ck101 = 0.9 time = 510
.meas tran vdout1_119ck101 FIND v(dout1_119) AT=510.025n

* CHECK dout1_0 Vdout1_0ck104 = 0.9 time = 525
.meas tran vdout1_0ck104 FIND v(dout1_0) AT=525.025n

* CHECK dout1_1 Vdout1_1ck104 = 0 time = 525
.meas tran vdout1_1ck104 FIND v(dout1_1) AT=525.025n

* CHECK dout1_2 Vdout1_2ck104 = 0 time = 525
.meas tran vdout1_2ck104 FIND v(dout1_2) AT=525.025n

* CHECK dout1_3 Vdout1_3ck104 = 0.9 time = 525
.meas tran vdout1_3ck104 FIND v(dout1_3) AT=525.025n

* CHECK dout1_4 Vdout1_4ck104 = 0.9 time = 525
.meas tran vdout1_4ck104 FIND v(dout1_4) AT=525.025n

* CHECK dout1_5 Vdout1_5ck104 = 0.9 time = 525
.meas tran vdout1_5ck104 FIND v(dout1_5) AT=525.025n

* CHECK dout1_6 Vdout1_6ck104 = 0.9 time = 525
.meas tran vdout1_6ck104 FIND v(dout1_6) AT=525.025n

* CHECK dout1_7 Vdout1_7ck104 = 0 time = 525
.meas tran vdout1_7ck104 FIND v(dout1_7) AT=525.025n

* CHECK dout1_8 Vdout1_8ck104 = 0 time = 525
.meas tran vdout1_8ck104 FIND v(dout1_8) AT=525.025n

* CHECK dout1_9 Vdout1_9ck104 = 0.9 time = 525
.meas tran vdout1_9ck104 FIND v(dout1_9) AT=525.025n

* CHECK dout1_10 Vdout1_10ck104 = 0 time = 525
.meas tran vdout1_10ck104 FIND v(dout1_10) AT=525.025n

* CHECK dout1_11 Vdout1_11ck104 = 0 time = 525
.meas tran vdout1_11ck104 FIND v(dout1_11) AT=525.025n

* CHECK dout1_12 Vdout1_12ck104 = 0 time = 525
.meas tran vdout1_12ck104 FIND v(dout1_12) AT=525.025n

* CHECK dout1_13 Vdout1_13ck104 = 0.9 time = 525
.meas tran vdout1_13ck104 FIND v(dout1_13) AT=525.025n

* CHECK dout1_14 Vdout1_14ck104 = 0.9 time = 525
.meas tran vdout1_14ck104 FIND v(dout1_14) AT=525.025n

* CHECK dout1_15 Vdout1_15ck104 = 0 time = 525
.meas tran vdout1_15ck104 FIND v(dout1_15) AT=525.025n

* CHECK dout1_16 Vdout1_16ck104 = 0 time = 525
.meas tran vdout1_16ck104 FIND v(dout1_16) AT=525.025n

* CHECK dout1_17 Vdout1_17ck104 = 0.9 time = 525
.meas tran vdout1_17ck104 FIND v(dout1_17) AT=525.025n

* CHECK dout1_18 Vdout1_18ck104 = 0.9 time = 525
.meas tran vdout1_18ck104 FIND v(dout1_18) AT=525.025n

* CHECK dout1_19 Vdout1_19ck104 = 0.9 time = 525
.meas tran vdout1_19ck104 FIND v(dout1_19) AT=525.025n

* CHECK dout1_20 Vdout1_20ck104 = 0.9 time = 525
.meas tran vdout1_20ck104 FIND v(dout1_20) AT=525.025n

* CHECK dout1_21 Vdout1_21ck104 = 0 time = 525
.meas tran vdout1_21ck104 FIND v(dout1_21) AT=525.025n

* CHECK dout1_22 Vdout1_22ck104 = 0.9 time = 525
.meas tran vdout1_22ck104 FIND v(dout1_22) AT=525.025n

* CHECK dout1_23 Vdout1_23ck104 = 0.9 time = 525
.meas tran vdout1_23ck104 FIND v(dout1_23) AT=525.025n

* CHECK dout1_24 Vdout1_24ck104 = 0 time = 525
.meas tran vdout1_24ck104 FIND v(dout1_24) AT=525.025n

* CHECK dout1_25 Vdout1_25ck104 = 0 time = 525
.meas tran vdout1_25ck104 FIND v(dout1_25) AT=525.025n

* CHECK dout1_26 Vdout1_26ck104 = 0 time = 525
.meas tran vdout1_26ck104 FIND v(dout1_26) AT=525.025n

* CHECK dout1_27 Vdout1_27ck104 = 0 time = 525
.meas tran vdout1_27ck104 FIND v(dout1_27) AT=525.025n

* CHECK dout1_28 Vdout1_28ck104 = 0.9 time = 525
.meas tran vdout1_28ck104 FIND v(dout1_28) AT=525.025n

* CHECK dout1_29 Vdout1_29ck104 = 0 time = 525
.meas tran vdout1_29ck104 FIND v(dout1_29) AT=525.025n

* CHECK dout1_30 Vdout1_30ck104 = 0 time = 525
.meas tran vdout1_30ck104 FIND v(dout1_30) AT=525.025n

* CHECK dout1_31 Vdout1_31ck104 = 0 time = 525
.meas tran vdout1_31ck104 FIND v(dout1_31) AT=525.025n

* CHECK dout1_32 Vdout1_32ck104 = 0.9 time = 525
.meas tran vdout1_32ck104 FIND v(dout1_32) AT=525.025n

* CHECK dout1_33 Vdout1_33ck104 = 0.9 time = 525
.meas tran vdout1_33ck104 FIND v(dout1_33) AT=525.025n

* CHECK dout1_34 Vdout1_34ck104 = 0.9 time = 525
.meas tran vdout1_34ck104 FIND v(dout1_34) AT=525.025n

* CHECK dout1_35 Vdout1_35ck104 = 0 time = 525
.meas tran vdout1_35ck104 FIND v(dout1_35) AT=525.025n

* CHECK dout1_36 Vdout1_36ck104 = 0.9 time = 525
.meas tran vdout1_36ck104 FIND v(dout1_36) AT=525.025n

* CHECK dout1_37 Vdout1_37ck104 = 0.9 time = 525
.meas tran vdout1_37ck104 FIND v(dout1_37) AT=525.025n

* CHECK dout1_38 Vdout1_38ck104 = 0 time = 525
.meas tran vdout1_38ck104 FIND v(dout1_38) AT=525.025n

* CHECK dout1_39 Vdout1_39ck104 = 0 time = 525
.meas tran vdout1_39ck104 FIND v(dout1_39) AT=525.025n

* CHECK dout1_40 Vdout1_40ck104 = 0.9 time = 525
.meas tran vdout1_40ck104 FIND v(dout1_40) AT=525.025n

* CHECK dout1_41 Vdout1_41ck104 = 0 time = 525
.meas tran vdout1_41ck104 FIND v(dout1_41) AT=525.025n

* CHECK dout1_42 Vdout1_42ck104 = 0 time = 525
.meas tran vdout1_42ck104 FIND v(dout1_42) AT=525.025n

* CHECK dout1_43 Vdout1_43ck104 = 0 time = 525
.meas tran vdout1_43ck104 FIND v(dout1_43) AT=525.025n

* CHECK dout1_44 Vdout1_44ck104 = 0.9 time = 525
.meas tran vdout1_44ck104 FIND v(dout1_44) AT=525.025n

* CHECK dout1_45 Vdout1_45ck104 = 0.9 time = 525
.meas tran vdout1_45ck104 FIND v(dout1_45) AT=525.025n

* CHECK dout1_46 Vdout1_46ck104 = 0 time = 525
.meas tran vdout1_46ck104 FIND v(dout1_46) AT=525.025n

* CHECK dout1_47 Vdout1_47ck104 = 0.9 time = 525
.meas tran vdout1_47ck104 FIND v(dout1_47) AT=525.025n

* CHECK dout1_48 Vdout1_48ck104 = 0.9 time = 525
.meas tran vdout1_48ck104 FIND v(dout1_48) AT=525.025n

* CHECK dout1_49 Vdout1_49ck104 = 0 time = 525
.meas tran vdout1_49ck104 FIND v(dout1_49) AT=525.025n

* CHECK dout1_50 Vdout1_50ck104 = 0.9 time = 525
.meas tran vdout1_50ck104 FIND v(dout1_50) AT=525.025n

* CHECK dout1_51 Vdout1_51ck104 = 0.9 time = 525
.meas tran vdout1_51ck104 FIND v(dout1_51) AT=525.025n

* CHECK dout1_52 Vdout1_52ck104 = 0 time = 525
.meas tran vdout1_52ck104 FIND v(dout1_52) AT=525.025n

* CHECK dout1_53 Vdout1_53ck104 = 0 time = 525
.meas tran vdout1_53ck104 FIND v(dout1_53) AT=525.025n

* CHECK dout1_54 Vdout1_54ck104 = 0.9 time = 525
.meas tran vdout1_54ck104 FIND v(dout1_54) AT=525.025n

* CHECK dout1_55 Vdout1_55ck104 = 0.9 time = 525
.meas tran vdout1_55ck104 FIND v(dout1_55) AT=525.025n

* CHECK dout1_56 Vdout1_56ck104 = 0.9 time = 525
.meas tran vdout1_56ck104 FIND v(dout1_56) AT=525.025n

* CHECK dout1_57 Vdout1_57ck104 = 0 time = 525
.meas tran vdout1_57ck104 FIND v(dout1_57) AT=525.025n

* CHECK dout1_58 Vdout1_58ck104 = 0 time = 525
.meas tran vdout1_58ck104 FIND v(dout1_58) AT=525.025n

* CHECK dout1_59 Vdout1_59ck104 = 0 time = 525
.meas tran vdout1_59ck104 FIND v(dout1_59) AT=525.025n

* CHECK dout1_60 Vdout1_60ck104 = 0 time = 525
.meas tran vdout1_60ck104 FIND v(dout1_60) AT=525.025n

* CHECK dout1_61 Vdout1_61ck104 = 0 time = 525
.meas tran vdout1_61ck104 FIND v(dout1_61) AT=525.025n

* CHECK dout1_62 Vdout1_62ck104 = 0 time = 525
.meas tran vdout1_62ck104 FIND v(dout1_62) AT=525.025n

* CHECK dout1_63 Vdout1_63ck104 = 0 time = 525
.meas tran vdout1_63ck104 FIND v(dout1_63) AT=525.025n

* CHECK dout1_64 Vdout1_64ck104 = 0 time = 525
.meas tran vdout1_64ck104 FIND v(dout1_64) AT=525.025n

* CHECK dout1_65 Vdout1_65ck104 = 0 time = 525
.meas tran vdout1_65ck104 FIND v(dout1_65) AT=525.025n

* CHECK dout1_66 Vdout1_66ck104 = 0.9 time = 525
.meas tran vdout1_66ck104 FIND v(dout1_66) AT=525.025n

* CHECK dout1_67 Vdout1_67ck104 = 0.9 time = 525
.meas tran vdout1_67ck104 FIND v(dout1_67) AT=525.025n

* CHECK dout1_68 Vdout1_68ck104 = 0 time = 525
.meas tran vdout1_68ck104 FIND v(dout1_68) AT=525.025n

* CHECK dout1_69 Vdout1_69ck104 = 0.9 time = 525
.meas tran vdout1_69ck104 FIND v(dout1_69) AT=525.025n

* CHECK dout1_70 Vdout1_70ck104 = 0 time = 525
.meas tran vdout1_70ck104 FIND v(dout1_70) AT=525.025n

* CHECK dout1_71 Vdout1_71ck104 = 0.9 time = 525
.meas tran vdout1_71ck104 FIND v(dout1_71) AT=525.025n

* CHECK dout1_72 Vdout1_72ck104 = 0.9 time = 525
.meas tran vdout1_72ck104 FIND v(dout1_72) AT=525.025n

* CHECK dout1_73 Vdout1_73ck104 = 0 time = 525
.meas tran vdout1_73ck104 FIND v(dout1_73) AT=525.025n

* CHECK dout1_74 Vdout1_74ck104 = 0.9 time = 525
.meas tran vdout1_74ck104 FIND v(dout1_74) AT=525.025n

* CHECK dout1_75 Vdout1_75ck104 = 0 time = 525
.meas tran vdout1_75ck104 FIND v(dout1_75) AT=525.025n

* CHECK dout1_76 Vdout1_76ck104 = 0.9 time = 525
.meas tran vdout1_76ck104 FIND v(dout1_76) AT=525.025n

* CHECK dout1_77 Vdout1_77ck104 = 0 time = 525
.meas tran vdout1_77ck104 FIND v(dout1_77) AT=525.025n

* CHECK dout1_78 Vdout1_78ck104 = 0 time = 525
.meas tran vdout1_78ck104 FIND v(dout1_78) AT=525.025n

* CHECK dout1_79 Vdout1_79ck104 = 0.9 time = 525
.meas tran vdout1_79ck104 FIND v(dout1_79) AT=525.025n

* CHECK dout1_80 Vdout1_80ck104 = 0 time = 525
.meas tran vdout1_80ck104 FIND v(dout1_80) AT=525.025n

* CHECK dout1_81 Vdout1_81ck104 = 0.9 time = 525
.meas tran vdout1_81ck104 FIND v(dout1_81) AT=525.025n

* CHECK dout1_82 Vdout1_82ck104 = 0 time = 525
.meas tran vdout1_82ck104 FIND v(dout1_82) AT=525.025n

* CHECK dout1_83 Vdout1_83ck104 = 0.9 time = 525
.meas tran vdout1_83ck104 FIND v(dout1_83) AT=525.025n

* CHECK dout1_84 Vdout1_84ck104 = 0.9 time = 525
.meas tran vdout1_84ck104 FIND v(dout1_84) AT=525.025n

* CHECK dout1_85 Vdout1_85ck104 = 0.9 time = 525
.meas tran vdout1_85ck104 FIND v(dout1_85) AT=525.025n

* CHECK dout1_86 Vdout1_86ck104 = 0 time = 525
.meas tran vdout1_86ck104 FIND v(dout1_86) AT=525.025n

* CHECK dout1_87 Vdout1_87ck104 = 0.9 time = 525
.meas tran vdout1_87ck104 FIND v(dout1_87) AT=525.025n

* CHECK dout1_88 Vdout1_88ck104 = 0.9 time = 525
.meas tran vdout1_88ck104 FIND v(dout1_88) AT=525.025n

* CHECK dout1_89 Vdout1_89ck104 = 0 time = 525
.meas tran vdout1_89ck104 FIND v(dout1_89) AT=525.025n

* CHECK dout1_90 Vdout1_90ck104 = 0.9 time = 525
.meas tran vdout1_90ck104 FIND v(dout1_90) AT=525.025n

* CHECK dout1_91 Vdout1_91ck104 = 0.9 time = 525
.meas tran vdout1_91ck104 FIND v(dout1_91) AT=525.025n

* CHECK dout1_92 Vdout1_92ck104 = 0 time = 525
.meas tran vdout1_92ck104 FIND v(dout1_92) AT=525.025n

* CHECK dout1_93 Vdout1_93ck104 = 0.9 time = 525
.meas tran vdout1_93ck104 FIND v(dout1_93) AT=525.025n

* CHECK dout1_94 Vdout1_94ck104 = 0 time = 525
.meas tran vdout1_94ck104 FIND v(dout1_94) AT=525.025n

* CHECK dout1_95 Vdout1_95ck104 = 0 time = 525
.meas tran vdout1_95ck104 FIND v(dout1_95) AT=525.025n

* CHECK dout1_96 Vdout1_96ck104 = 0 time = 525
.meas tran vdout1_96ck104 FIND v(dout1_96) AT=525.025n

* CHECK dout1_97 Vdout1_97ck104 = 0 time = 525
.meas tran vdout1_97ck104 FIND v(dout1_97) AT=525.025n

* CHECK dout1_98 Vdout1_98ck104 = 0 time = 525
.meas tran vdout1_98ck104 FIND v(dout1_98) AT=525.025n

* CHECK dout1_99 Vdout1_99ck104 = 0 time = 525
.meas tran vdout1_99ck104 FIND v(dout1_99) AT=525.025n

* CHECK dout1_100 Vdout1_100ck104 = 0.9 time = 525
.meas tran vdout1_100ck104 FIND v(dout1_100) AT=525.025n

* CHECK dout1_101 Vdout1_101ck104 = 0 time = 525
.meas tran vdout1_101ck104 FIND v(dout1_101) AT=525.025n

* CHECK dout1_102 Vdout1_102ck104 = 0 time = 525
.meas tran vdout1_102ck104 FIND v(dout1_102) AT=525.025n

* CHECK dout1_103 Vdout1_103ck104 = 0.9 time = 525
.meas tran vdout1_103ck104 FIND v(dout1_103) AT=525.025n

* CHECK dout1_104 Vdout1_104ck104 = 0.9 time = 525
.meas tran vdout1_104ck104 FIND v(dout1_104) AT=525.025n

* CHECK dout1_105 Vdout1_105ck104 = 0.9 time = 525
.meas tran vdout1_105ck104 FIND v(dout1_105) AT=525.025n

* CHECK dout1_106 Vdout1_106ck104 = 0 time = 525
.meas tran vdout1_106ck104 FIND v(dout1_106) AT=525.025n

* CHECK dout1_107 Vdout1_107ck104 = 0.9 time = 525
.meas tran vdout1_107ck104 FIND v(dout1_107) AT=525.025n

* CHECK dout1_108 Vdout1_108ck104 = 0.9 time = 525
.meas tran vdout1_108ck104 FIND v(dout1_108) AT=525.025n

* CHECK dout1_109 Vdout1_109ck104 = 0 time = 525
.meas tran vdout1_109ck104 FIND v(dout1_109) AT=525.025n

* CHECK dout1_110 Vdout1_110ck104 = 0 time = 525
.meas tran vdout1_110ck104 FIND v(dout1_110) AT=525.025n

* CHECK dout1_111 Vdout1_111ck104 = 0.9 time = 525
.meas tran vdout1_111ck104 FIND v(dout1_111) AT=525.025n

* CHECK dout1_112 Vdout1_112ck104 = 0.9 time = 525
.meas tran vdout1_112ck104 FIND v(dout1_112) AT=525.025n

* CHECK dout1_113 Vdout1_113ck104 = 0.9 time = 525
.meas tran vdout1_113ck104 FIND v(dout1_113) AT=525.025n

* CHECK dout1_114 Vdout1_114ck104 = 0 time = 525
.meas tran vdout1_114ck104 FIND v(dout1_114) AT=525.025n

* CHECK dout1_115 Vdout1_115ck104 = 0 time = 525
.meas tran vdout1_115ck104 FIND v(dout1_115) AT=525.025n

* CHECK dout1_116 Vdout1_116ck104 = 0.9 time = 525
.meas tran vdout1_116ck104 FIND v(dout1_116) AT=525.025n

* CHECK dout1_117 Vdout1_117ck104 = 0.9 time = 525
.meas tran vdout1_117ck104 FIND v(dout1_117) AT=525.025n

* CHECK dout1_118 Vdout1_118ck104 = 0 time = 525
.meas tran vdout1_118ck104 FIND v(dout1_118) AT=525.025n

* CHECK dout1_119 Vdout1_119ck104 = 0 time = 525
.meas tran vdout1_119ck104 FIND v(dout1_119) AT=525.025n

* CHECK dout1_0 Vdout1_0ck109 = 0.9 time = 550
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=550.025n

* CHECK dout1_1 Vdout1_1ck109 = 0 time = 550
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=550.025n

* CHECK dout1_2 Vdout1_2ck109 = 0 time = 550
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=550.025n

* CHECK dout1_3 Vdout1_3ck109 = 0 time = 550
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=550.025n

* CHECK dout1_4 Vdout1_4ck109 = 0 time = 550
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=550.025n

* CHECK dout1_5 Vdout1_5ck109 = 0.9 time = 550
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=550.025n

* CHECK dout1_6 Vdout1_6ck109 = 0.9 time = 550
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=550.025n

* CHECK dout1_7 Vdout1_7ck109 = 0 time = 550
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=550.025n

* CHECK dout1_8 Vdout1_8ck109 = 0.9 time = 550
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=550.025n

* CHECK dout1_9 Vdout1_9ck109 = 0 time = 550
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=550.025n

* CHECK dout1_10 Vdout1_10ck109 = 0.9 time = 550
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=550.025n

* CHECK dout1_11 Vdout1_11ck109 = 0.9 time = 550
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=550.025n

* CHECK dout1_12 Vdout1_12ck109 = 0 time = 550
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=550.025n

* CHECK dout1_13 Vdout1_13ck109 = 0 time = 550
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=550.025n

* CHECK dout1_14 Vdout1_14ck109 = 0.9 time = 550
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=550.025n

* CHECK dout1_15 Vdout1_15ck109 = 0.9 time = 550
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=550.025n

* CHECK dout1_16 Vdout1_16ck109 = 0 time = 550
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=550.025n

* CHECK dout1_17 Vdout1_17ck109 = 0 time = 550
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=550.025n

* CHECK dout1_18 Vdout1_18ck109 = 0 time = 550
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=550.025n

* CHECK dout1_19 Vdout1_19ck109 = 0.9 time = 550
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=550.025n

* CHECK dout1_20 Vdout1_20ck109 = 0 time = 550
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=550.025n

* CHECK dout1_21 Vdout1_21ck109 = 0 time = 550
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=550.025n

* CHECK dout1_22 Vdout1_22ck109 = 0 time = 550
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=550.025n

* CHECK dout1_23 Vdout1_23ck109 = 0 time = 550
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=550.025n

* CHECK dout1_24 Vdout1_24ck109 = 0 time = 550
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=550.025n

* CHECK dout1_25 Vdout1_25ck109 = 0.9 time = 550
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=550.025n

* CHECK dout1_26 Vdout1_26ck109 = 0 time = 550
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=550.025n

* CHECK dout1_27 Vdout1_27ck109 = 0 time = 550
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=550.025n

* CHECK dout1_28 Vdout1_28ck109 = 0.9 time = 550
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=550.025n

* CHECK dout1_29 Vdout1_29ck109 = 0.9 time = 550
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=550.025n

* CHECK dout1_30 Vdout1_30ck109 = 0 time = 550
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=550.025n

* CHECK dout1_31 Vdout1_31ck109 = 0 time = 550
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=550.025n

* CHECK dout1_32 Vdout1_32ck109 = 0 time = 550
.meas tran vdout1_32ck109 FIND v(dout1_32) AT=550.025n

* CHECK dout1_33 Vdout1_33ck109 = 0 time = 550
.meas tran vdout1_33ck109 FIND v(dout1_33) AT=550.025n

* CHECK dout1_34 Vdout1_34ck109 = 0 time = 550
.meas tran vdout1_34ck109 FIND v(dout1_34) AT=550.025n

* CHECK dout1_35 Vdout1_35ck109 = 0.9 time = 550
.meas tran vdout1_35ck109 FIND v(dout1_35) AT=550.025n

* CHECK dout1_36 Vdout1_36ck109 = 0.9 time = 550
.meas tran vdout1_36ck109 FIND v(dout1_36) AT=550.025n

* CHECK dout1_37 Vdout1_37ck109 = 0 time = 550
.meas tran vdout1_37ck109 FIND v(dout1_37) AT=550.025n

* CHECK dout1_38 Vdout1_38ck109 = 0 time = 550
.meas tran vdout1_38ck109 FIND v(dout1_38) AT=550.025n

* CHECK dout1_39 Vdout1_39ck109 = 0 time = 550
.meas tran vdout1_39ck109 FIND v(dout1_39) AT=550.025n

* CHECK dout1_40 Vdout1_40ck109 = 0 time = 550
.meas tran vdout1_40ck109 FIND v(dout1_40) AT=550.025n

* CHECK dout1_41 Vdout1_41ck109 = 0 time = 550
.meas tran vdout1_41ck109 FIND v(dout1_41) AT=550.025n

* CHECK dout1_42 Vdout1_42ck109 = 0 time = 550
.meas tran vdout1_42ck109 FIND v(dout1_42) AT=550.025n

* CHECK dout1_43 Vdout1_43ck109 = 0.9 time = 550
.meas tran vdout1_43ck109 FIND v(dout1_43) AT=550.025n

* CHECK dout1_44 Vdout1_44ck109 = 0 time = 550
.meas tran vdout1_44ck109 FIND v(dout1_44) AT=550.025n

* CHECK dout1_45 Vdout1_45ck109 = 0.9 time = 550
.meas tran vdout1_45ck109 FIND v(dout1_45) AT=550.025n

* CHECK dout1_46 Vdout1_46ck109 = 0.9 time = 550
.meas tran vdout1_46ck109 FIND v(dout1_46) AT=550.025n

* CHECK dout1_47 Vdout1_47ck109 = 0 time = 550
.meas tran vdout1_47ck109 FIND v(dout1_47) AT=550.025n

* CHECK dout1_48 Vdout1_48ck109 = 0 time = 550
.meas tran vdout1_48ck109 FIND v(dout1_48) AT=550.025n

* CHECK dout1_49 Vdout1_49ck109 = 0.9 time = 550
.meas tran vdout1_49ck109 FIND v(dout1_49) AT=550.025n

* CHECK dout1_50 Vdout1_50ck109 = 0.9 time = 550
.meas tran vdout1_50ck109 FIND v(dout1_50) AT=550.025n

* CHECK dout1_51 Vdout1_51ck109 = 0.9 time = 550
.meas tran vdout1_51ck109 FIND v(dout1_51) AT=550.025n

* CHECK dout1_52 Vdout1_52ck109 = 0.9 time = 550
.meas tran vdout1_52ck109 FIND v(dout1_52) AT=550.025n

* CHECK dout1_53 Vdout1_53ck109 = 0.9 time = 550
.meas tran vdout1_53ck109 FIND v(dout1_53) AT=550.025n

* CHECK dout1_54 Vdout1_54ck109 = 0.9 time = 550
.meas tran vdout1_54ck109 FIND v(dout1_54) AT=550.025n

* CHECK dout1_55 Vdout1_55ck109 = 0.9 time = 550
.meas tran vdout1_55ck109 FIND v(dout1_55) AT=550.025n

* CHECK dout1_56 Vdout1_56ck109 = 0.9 time = 550
.meas tran vdout1_56ck109 FIND v(dout1_56) AT=550.025n

* CHECK dout1_57 Vdout1_57ck109 = 0.9 time = 550
.meas tran vdout1_57ck109 FIND v(dout1_57) AT=550.025n

* CHECK dout1_58 Vdout1_58ck109 = 0 time = 550
.meas tran vdout1_58ck109 FIND v(dout1_58) AT=550.025n

* CHECK dout1_59 Vdout1_59ck109 = 0 time = 550
.meas tran vdout1_59ck109 FIND v(dout1_59) AT=550.025n

* CHECK dout1_60 Vdout1_60ck109 = 0.9 time = 550
.meas tran vdout1_60ck109 FIND v(dout1_60) AT=550.025n

* CHECK dout1_61 Vdout1_61ck109 = 0 time = 550
.meas tran vdout1_61ck109 FIND v(dout1_61) AT=550.025n

* CHECK dout1_62 Vdout1_62ck109 = 0.9 time = 550
.meas tran vdout1_62ck109 FIND v(dout1_62) AT=550.025n

* CHECK dout1_63 Vdout1_63ck109 = 0.9 time = 550
.meas tran vdout1_63ck109 FIND v(dout1_63) AT=550.025n

* CHECK dout1_64 Vdout1_64ck109 = 0 time = 550
.meas tran vdout1_64ck109 FIND v(dout1_64) AT=550.025n

* CHECK dout1_65 Vdout1_65ck109 = 0.9 time = 550
.meas tran vdout1_65ck109 FIND v(dout1_65) AT=550.025n

* CHECK dout1_66 Vdout1_66ck109 = 0 time = 550
.meas tran vdout1_66ck109 FIND v(dout1_66) AT=550.025n

* CHECK dout1_67 Vdout1_67ck109 = 0 time = 550
.meas tran vdout1_67ck109 FIND v(dout1_67) AT=550.025n

* CHECK dout1_68 Vdout1_68ck109 = 0 time = 550
.meas tran vdout1_68ck109 FIND v(dout1_68) AT=550.025n

* CHECK dout1_69 Vdout1_69ck109 = 0.9 time = 550
.meas tran vdout1_69ck109 FIND v(dout1_69) AT=550.025n

* CHECK dout1_70 Vdout1_70ck109 = 0 time = 550
.meas tran vdout1_70ck109 FIND v(dout1_70) AT=550.025n

* CHECK dout1_71 Vdout1_71ck109 = 0 time = 550
.meas tran vdout1_71ck109 FIND v(dout1_71) AT=550.025n

* CHECK dout1_72 Vdout1_72ck109 = 0.9 time = 550
.meas tran vdout1_72ck109 FIND v(dout1_72) AT=550.025n

* CHECK dout1_73 Vdout1_73ck109 = 0 time = 550
.meas tran vdout1_73ck109 FIND v(dout1_73) AT=550.025n

* CHECK dout1_74 Vdout1_74ck109 = 0.9 time = 550
.meas tran vdout1_74ck109 FIND v(dout1_74) AT=550.025n

* CHECK dout1_75 Vdout1_75ck109 = 0.9 time = 550
.meas tran vdout1_75ck109 FIND v(dout1_75) AT=550.025n

* CHECK dout1_76 Vdout1_76ck109 = 0 time = 550
.meas tran vdout1_76ck109 FIND v(dout1_76) AT=550.025n

* CHECK dout1_77 Vdout1_77ck109 = 0 time = 550
.meas tran vdout1_77ck109 FIND v(dout1_77) AT=550.025n

* CHECK dout1_78 Vdout1_78ck109 = 0 time = 550
.meas tran vdout1_78ck109 FIND v(dout1_78) AT=550.025n

* CHECK dout1_79 Vdout1_79ck109 = 0 time = 550
.meas tran vdout1_79ck109 FIND v(dout1_79) AT=550.025n

* CHECK dout1_80 Vdout1_80ck109 = 0.9 time = 550
.meas tran vdout1_80ck109 FIND v(dout1_80) AT=550.025n

* CHECK dout1_81 Vdout1_81ck109 = 0 time = 550
.meas tran vdout1_81ck109 FIND v(dout1_81) AT=550.025n

* CHECK dout1_82 Vdout1_82ck109 = 0 time = 550
.meas tran vdout1_82ck109 FIND v(dout1_82) AT=550.025n

* CHECK dout1_83 Vdout1_83ck109 = 0.9 time = 550
.meas tran vdout1_83ck109 FIND v(dout1_83) AT=550.025n

* CHECK dout1_84 Vdout1_84ck109 = 0 time = 550
.meas tran vdout1_84ck109 FIND v(dout1_84) AT=550.025n

* CHECK dout1_85 Vdout1_85ck109 = 0 time = 550
.meas tran vdout1_85ck109 FIND v(dout1_85) AT=550.025n

* CHECK dout1_86 Vdout1_86ck109 = 0.9 time = 550
.meas tran vdout1_86ck109 FIND v(dout1_86) AT=550.025n

* CHECK dout1_87 Vdout1_87ck109 = 0 time = 550
.meas tran vdout1_87ck109 FIND v(dout1_87) AT=550.025n

* CHECK dout1_88 Vdout1_88ck109 = 0.9 time = 550
.meas tran vdout1_88ck109 FIND v(dout1_88) AT=550.025n

* CHECK dout1_89 Vdout1_89ck109 = 0.9 time = 550
.meas tran vdout1_89ck109 FIND v(dout1_89) AT=550.025n

* CHECK dout1_90 Vdout1_90ck109 = 0 time = 550
.meas tran vdout1_90ck109 FIND v(dout1_90) AT=550.025n

* CHECK dout1_91 Vdout1_91ck109 = 0.9 time = 550
.meas tran vdout1_91ck109 FIND v(dout1_91) AT=550.025n

* CHECK dout1_92 Vdout1_92ck109 = 0 time = 550
.meas tran vdout1_92ck109 FIND v(dout1_92) AT=550.025n

* CHECK dout1_93 Vdout1_93ck109 = 0.9 time = 550
.meas tran vdout1_93ck109 FIND v(dout1_93) AT=550.025n

* CHECK dout1_94 Vdout1_94ck109 = 0 time = 550
.meas tran vdout1_94ck109 FIND v(dout1_94) AT=550.025n

* CHECK dout1_95 Vdout1_95ck109 = 0.9 time = 550
.meas tran vdout1_95ck109 FIND v(dout1_95) AT=550.025n

* CHECK dout1_96 Vdout1_96ck109 = 0 time = 550
.meas tran vdout1_96ck109 FIND v(dout1_96) AT=550.025n

* CHECK dout1_97 Vdout1_97ck109 = 0.9 time = 550
.meas tran vdout1_97ck109 FIND v(dout1_97) AT=550.025n

* CHECK dout1_98 Vdout1_98ck109 = 0 time = 550
.meas tran vdout1_98ck109 FIND v(dout1_98) AT=550.025n

* CHECK dout1_99 Vdout1_99ck109 = 0.9 time = 550
.meas tran vdout1_99ck109 FIND v(dout1_99) AT=550.025n

* CHECK dout1_100 Vdout1_100ck109 = 0 time = 550
.meas tran vdout1_100ck109 FIND v(dout1_100) AT=550.025n

* CHECK dout1_101 Vdout1_101ck109 = 0.9 time = 550
.meas tran vdout1_101ck109 FIND v(dout1_101) AT=550.025n

* CHECK dout1_102 Vdout1_102ck109 = 0.9 time = 550
.meas tran vdout1_102ck109 FIND v(dout1_102) AT=550.025n

* CHECK dout1_103 Vdout1_103ck109 = 0 time = 550
.meas tran vdout1_103ck109 FIND v(dout1_103) AT=550.025n

* CHECK dout1_104 Vdout1_104ck109 = 0 time = 550
.meas tran vdout1_104ck109 FIND v(dout1_104) AT=550.025n

* CHECK dout1_105 Vdout1_105ck109 = 0 time = 550
.meas tran vdout1_105ck109 FIND v(dout1_105) AT=550.025n

* CHECK dout1_106 Vdout1_106ck109 = 0.9 time = 550
.meas tran vdout1_106ck109 FIND v(dout1_106) AT=550.025n

* CHECK dout1_107 Vdout1_107ck109 = 0.9 time = 550
.meas tran vdout1_107ck109 FIND v(dout1_107) AT=550.025n

* CHECK dout1_108 Vdout1_108ck109 = 0 time = 550
.meas tran vdout1_108ck109 FIND v(dout1_108) AT=550.025n

* CHECK dout1_109 Vdout1_109ck109 = 0 time = 550
.meas tran vdout1_109ck109 FIND v(dout1_109) AT=550.025n

* CHECK dout1_110 Vdout1_110ck109 = 0 time = 550
.meas tran vdout1_110ck109 FIND v(dout1_110) AT=550.025n

* CHECK dout1_111 Vdout1_111ck109 = 0 time = 550
.meas tran vdout1_111ck109 FIND v(dout1_111) AT=550.025n

* CHECK dout1_112 Vdout1_112ck109 = 0.9 time = 550
.meas tran vdout1_112ck109 FIND v(dout1_112) AT=550.025n

* CHECK dout1_113 Vdout1_113ck109 = 0.9 time = 550
.meas tran vdout1_113ck109 FIND v(dout1_113) AT=550.025n

* CHECK dout1_114 Vdout1_114ck109 = 0.9 time = 550
.meas tran vdout1_114ck109 FIND v(dout1_114) AT=550.025n

* CHECK dout1_115 Vdout1_115ck109 = 0.9 time = 550
.meas tran vdout1_115ck109 FIND v(dout1_115) AT=550.025n

* CHECK dout1_116 Vdout1_116ck109 = 0 time = 550
.meas tran vdout1_116ck109 FIND v(dout1_116) AT=550.025n

* CHECK dout1_117 Vdout1_117ck109 = 0.9 time = 550
.meas tran vdout1_117ck109 FIND v(dout1_117) AT=550.025n

* CHECK dout1_118 Vdout1_118ck109 = 0 time = 550
.meas tran vdout1_118ck109 FIND v(dout1_118) AT=550.025n

* CHECK dout1_119 Vdout1_119ck109 = 0.9 time = 550
.meas tran vdout1_119ck109 FIND v(dout1_119) AT=550.025n

* CHECK dout1_0 Vdout1_0ck117 = 0 time = 590
.meas tran vdout1_0ck117 FIND v(dout1_0) AT=590.025n

* CHECK dout1_1 Vdout1_1ck117 = 0.9 time = 590
.meas tran vdout1_1ck117 FIND v(dout1_1) AT=590.025n

* CHECK dout1_2 Vdout1_2ck117 = 0 time = 590
.meas tran vdout1_2ck117 FIND v(dout1_2) AT=590.025n

* CHECK dout1_3 Vdout1_3ck117 = 0.9 time = 590
.meas tran vdout1_3ck117 FIND v(dout1_3) AT=590.025n

* CHECK dout1_4 Vdout1_4ck117 = 0 time = 590
.meas tran vdout1_4ck117 FIND v(dout1_4) AT=590.025n

* CHECK dout1_5 Vdout1_5ck117 = 0 time = 590
.meas tran vdout1_5ck117 FIND v(dout1_5) AT=590.025n

* CHECK dout1_6 Vdout1_6ck117 = 0.9 time = 590
.meas tran vdout1_6ck117 FIND v(dout1_6) AT=590.025n

* CHECK dout1_7 Vdout1_7ck117 = 0 time = 590
.meas tran vdout1_7ck117 FIND v(dout1_7) AT=590.025n

* CHECK dout1_8 Vdout1_8ck117 = 0.9 time = 590
.meas tran vdout1_8ck117 FIND v(dout1_8) AT=590.025n

* CHECK dout1_9 Vdout1_9ck117 = 0.9 time = 590
.meas tran vdout1_9ck117 FIND v(dout1_9) AT=590.025n

* CHECK dout1_10 Vdout1_10ck117 = 0.9 time = 590
.meas tran vdout1_10ck117 FIND v(dout1_10) AT=590.025n

* CHECK dout1_11 Vdout1_11ck117 = 0.9 time = 590
.meas tran vdout1_11ck117 FIND v(dout1_11) AT=590.025n

* CHECK dout1_12 Vdout1_12ck117 = 0 time = 590
.meas tran vdout1_12ck117 FIND v(dout1_12) AT=590.025n

* CHECK dout1_13 Vdout1_13ck117 = 0 time = 590
.meas tran vdout1_13ck117 FIND v(dout1_13) AT=590.025n

* CHECK dout1_14 Vdout1_14ck117 = 0 time = 590
.meas tran vdout1_14ck117 FIND v(dout1_14) AT=590.025n

* CHECK dout1_15 Vdout1_15ck117 = 0 time = 590
.meas tran vdout1_15ck117 FIND v(dout1_15) AT=590.025n

* CHECK dout1_16 Vdout1_16ck117 = 0 time = 590
.meas tran vdout1_16ck117 FIND v(dout1_16) AT=590.025n

* CHECK dout1_17 Vdout1_17ck117 = 0.9 time = 590
.meas tran vdout1_17ck117 FIND v(dout1_17) AT=590.025n

* CHECK dout1_18 Vdout1_18ck117 = 0 time = 590
.meas tran vdout1_18ck117 FIND v(dout1_18) AT=590.025n

* CHECK dout1_19 Vdout1_19ck117 = 0.9 time = 590
.meas tran vdout1_19ck117 FIND v(dout1_19) AT=590.025n

* CHECK dout1_20 Vdout1_20ck117 = 0.9 time = 590
.meas tran vdout1_20ck117 FIND v(dout1_20) AT=590.025n

* CHECK dout1_21 Vdout1_21ck117 = 0.9 time = 590
.meas tran vdout1_21ck117 FIND v(dout1_21) AT=590.025n

* CHECK dout1_22 Vdout1_22ck117 = 0 time = 590
.meas tran vdout1_22ck117 FIND v(dout1_22) AT=590.025n

* CHECK dout1_23 Vdout1_23ck117 = 0 time = 590
.meas tran vdout1_23ck117 FIND v(dout1_23) AT=590.025n

* CHECK dout1_24 Vdout1_24ck117 = 0 time = 590
.meas tran vdout1_24ck117 FIND v(dout1_24) AT=590.025n

* CHECK dout1_25 Vdout1_25ck117 = 0 time = 590
.meas tran vdout1_25ck117 FIND v(dout1_25) AT=590.025n

* CHECK dout1_26 Vdout1_26ck117 = 0 time = 590
.meas tran vdout1_26ck117 FIND v(dout1_26) AT=590.025n

* CHECK dout1_27 Vdout1_27ck117 = 0 time = 590
.meas tran vdout1_27ck117 FIND v(dout1_27) AT=590.025n

* CHECK dout1_28 Vdout1_28ck117 = 0 time = 590
.meas tran vdout1_28ck117 FIND v(dout1_28) AT=590.025n

* CHECK dout1_29 Vdout1_29ck117 = 0 time = 590
.meas tran vdout1_29ck117 FIND v(dout1_29) AT=590.025n

* CHECK dout1_30 Vdout1_30ck117 = 0 time = 590
.meas tran vdout1_30ck117 FIND v(dout1_30) AT=590.025n

* CHECK dout1_31 Vdout1_31ck117 = 0 time = 590
.meas tran vdout1_31ck117 FIND v(dout1_31) AT=590.025n

* CHECK dout1_32 Vdout1_32ck117 = 0.9 time = 590
.meas tran vdout1_32ck117 FIND v(dout1_32) AT=590.025n

* CHECK dout1_33 Vdout1_33ck117 = 0 time = 590
.meas tran vdout1_33ck117 FIND v(dout1_33) AT=590.025n

* CHECK dout1_34 Vdout1_34ck117 = 0 time = 590
.meas tran vdout1_34ck117 FIND v(dout1_34) AT=590.025n

* CHECK dout1_35 Vdout1_35ck117 = 0.9 time = 590
.meas tran vdout1_35ck117 FIND v(dout1_35) AT=590.025n

* CHECK dout1_36 Vdout1_36ck117 = 0.9 time = 590
.meas tran vdout1_36ck117 FIND v(dout1_36) AT=590.025n

* CHECK dout1_37 Vdout1_37ck117 = 0.9 time = 590
.meas tran vdout1_37ck117 FIND v(dout1_37) AT=590.025n

* CHECK dout1_38 Vdout1_38ck117 = 0 time = 590
.meas tran vdout1_38ck117 FIND v(dout1_38) AT=590.025n

* CHECK dout1_39 Vdout1_39ck117 = 0.9 time = 590
.meas tran vdout1_39ck117 FIND v(dout1_39) AT=590.025n

* CHECK dout1_40 Vdout1_40ck117 = 0 time = 590
.meas tran vdout1_40ck117 FIND v(dout1_40) AT=590.025n

* CHECK dout1_41 Vdout1_41ck117 = 0 time = 590
.meas tran vdout1_41ck117 FIND v(dout1_41) AT=590.025n

* CHECK dout1_42 Vdout1_42ck117 = 0 time = 590
.meas tran vdout1_42ck117 FIND v(dout1_42) AT=590.025n

* CHECK dout1_43 Vdout1_43ck117 = 0.9 time = 590
.meas tran vdout1_43ck117 FIND v(dout1_43) AT=590.025n

* CHECK dout1_44 Vdout1_44ck117 = 0.9 time = 590
.meas tran vdout1_44ck117 FIND v(dout1_44) AT=590.025n

* CHECK dout1_45 Vdout1_45ck117 = 0.9 time = 590
.meas tran vdout1_45ck117 FIND v(dout1_45) AT=590.025n

* CHECK dout1_46 Vdout1_46ck117 = 0 time = 590
.meas tran vdout1_46ck117 FIND v(dout1_46) AT=590.025n

* CHECK dout1_47 Vdout1_47ck117 = 0 time = 590
.meas tran vdout1_47ck117 FIND v(dout1_47) AT=590.025n

* CHECK dout1_48 Vdout1_48ck117 = 0.9 time = 590
.meas tran vdout1_48ck117 FIND v(dout1_48) AT=590.025n

* CHECK dout1_49 Vdout1_49ck117 = 0.9 time = 590
.meas tran vdout1_49ck117 FIND v(dout1_49) AT=590.025n

* CHECK dout1_50 Vdout1_50ck117 = 0.9 time = 590
.meas tran vdout1_50ck117 FIND v(dout1_50) AT=590.025n

* CHECK dout1_51 Vdout1_51ck117 = 0 time = 590
.meas tran vdout1_51ck117 FIND v(dout1_51) AT=590.025n

* CHECK dout1_52 Vdout1_52ck117 = 0.9 time = 590
.meas tran vdout1_52ck117 FIND v(dout1_52) AT=590.025n

* CHECK dout1_53 Vdout1_53ck117 = 0.9 time = 590
.meas tran vdout1_53ck117 FIND v(dout1_53) AT=590.025n

* CHECK dout1_54 Vdout1_54ck117 = 0 time = 590
.meas tran vdout1_54ck117 FIND v(dout1_54) AT=590.025n

* CHECK dout1_55 Vdout1_55ck117 = 0 time = 590
.meas tran vdout1_55ck117 FIND v(dout1_55) AT=590.025n

* CHECK dout1_56 Vdout1_56ck117 = 0.9 time = 590
.meas tran vdout1_56ck117 FIND v(dout1_56) AT=590.025n

* CHECK dout1_57 Vdout1_57ck117 = 0 time = 590
.meas tran vdout1_57ck117 FIND v(dout1_57) AT=590.025n

* CHECK dout1_58 Vdout1_58ck117 = 0 time = 590
.meas tran vdout1_58ck117 FIND v(dout1_58) AT=590.025n

* CHECK dout1_59 Vdout1_59ck117 = 0.9 time = 590
.meas tran vdout1_59ck117 FIND v(dout1_59) AT=590.025n

* CHECK dout1_60 Vdout1_60ck117 = 0.9 time = 590
.meas tran vdout1_60ck117 FIND v(dout1_60) AT=590.025n

* CHECK dout1_61 Vdout1_61ck117 = 0.9 time = 590
.meas tran vdout1_61ck117 FIND v(dout1_61) AT=590.025n

* CHECK dout1_62 Vdout1_62ck117 = 0.9 time = 590
.meas tran vdout1_62ck117 FIND v(dout1_62) AT=590.025n

* CHECK dout1_63 Vdout1_63ck117 = 0.9 time = 590
.meas tran vdout1_63ck117 FIND v(dout1_63) AT=590.025n

* CHECK dout1_64 Vdout1_64ck117 = 0.9 time = 590
.meas tran vdout1_64ck117 FIND v(dout1_64) AT=590.025n

* CHECK dout1_65 Vdout1_65ck117 = 0 time = 590
.meas tran vdout1_65ck117 FIND v(dout1_65) AT=590.025n

* CHECK dout1_66 Vdout1_66ck117 = 0 time = 590
.meas tran vdout1_66ck117 FIND v(dout1_66) AT=590.025n

* CHECK dout1_67 Vdout1_67ck117 = 0 time = 590
.meas tran vdout1_67ck117 FIND v(dout1_67) AT=590.025n

* CHECK dout1_68 Vdout1_68ck117 = 0 time = 590
.meas tran vdout1_68ck117 FIND v(dout1_68) AT=590.025n

* CHECK dout1_69 Vdout1_69ck117 = 0 time = 590
.meas tran vdout1_69ck117 FIND v(dout1_69) AT=590.025n

* CHECK dout1_70 Vdout1_70ck117 = 0.9 time = 590
.meas tran vdout1_70ck117 FIND v(dout1_70) AT=590.025n

* CHECK dout1_71 Vdout1_71ck117 = 0 time = 590
.meas tran vdout1_71ck117 FIND v(dout1_71) AT=590.025n

* CHECK dout1_72 Vdout1_72ck117 = 0 time = 590
.meas tran vdout1_72ck117 FIND v(dout1_72) AT=590.025n

* CHECK dout1_73 Vdout1_73ck117 = 0.9 time = 590
.meas tran vdout1_73ck117 FIND v(dout1_73) AT=590.025n

* CHECK dout1_74 Vdout1_74ck117 = 0 time = 590
.meas tran vdout1_74ck117 FIND v(dout1_74) AT=590.025n

* CHECK dout1_75 Vdout1_75ck117 = 0.9 time = 590
.meas tran vdout1_75ck117 FIND v(dout1_75) AT=590.025n

* CHECK dout1_76 Vdout1_76ck117 = 0 time = 590
.meas tran vdout1_76ck117 FIND v(dout1_76) AT=590.025n

* CHECK dout1_77 Vdout1_77ck117 = 0 time = 590
.meas tran vdout1_77ck117 FIND v(dout1_77) AT=590.025n

* CHECK dout1_78 Vdout1_78ck117 = 0.9 time = 590
.meas tran vdout1_78ck117 FIND v(dout1_78) AT=590.025n

* CHECK dout1_79 Vdout1_79ck117 = 0.9 time = 590
.meas tran vdout1_79ck117 FIND v(dout1_79) AT=590.025n

* CHECK dout1_80 Vdout1_80ck117 = 0.9 time = 590
.meas tran vdout1_80ck117 FIND v(dout1_80) AT=590.025n

* CHECK dout1_81 Vdout1_81ck117 = 0.9 time = 590
.meas tran vdout1_81ck117 FIND v(dout1_81) AT=590.025n

* CHECK dout1_82 Vdout1_82ck117 = 0 time = 590
.meas tran vdout1_82ck117 FIND v(dout1_82) AT=590.025n

* CHECK dout1_83 Vdout1_83ck117 = 0.9 time = 590
.meas tran vdout1_83ck117 FIND v(dout1_83) AT=590.025n

* CHECK dout1_84 Vdout1_84ck117 = 0 time = 590
.meas tran vdout1_84ck117 FIND v(dout1_84) AT=590.025n

* CHECK dout1_85 Vdout1_85ck117 = 0.9 time = 590
.meas tran vdout1_85ck117 FIND v(dout1_85) AT=590.025n

* CHECK dout1_86 Vdout1_86ck117 = 0 time = 590
.meas tran vdout1_86ck117 FIND v(dout1_86) AT=590.025n

* CHECK dout1_87 Vdout1_87ck117 = 0 time = 590
.meas tran vdout1_87ck117 FIND v(dout1_87) AT=590.025n

* CHECK dout1_88 Vdout1_88ck117 = 0.9 time = 590
.meas tran vdout1_88ck117 FIND v(dout1_88) AT=590.025n

* CHECK dout1_89 Vdout1_89ck117 = 0.9 time = 590
.meas tran vdout1_89ck117 FIND v(dout1_89) AT=590.025n

* CHECK dout1_90 Vdout1_90ck117 = 0 time = 590
.meas tran vdout1_90ck117 FIND v(dout1_90) AT=590.025n

* CHECK dout1_91 Vdout1_91ck117 = 0.9 time = 590
.meas tran vdout1_91ck117 FIND v(dout1_91) AT=590.025n

* CHECK dout1_92 Vdout1_92ck117 = 0 time = 590
.meas tran vdout1_92ck117 FIND v(dout1_92) AT=590.025n

* CHECK dout1_93 Vdout1_93ck117 = 0 time = 590
.meas tran vdout1_93ck117 FIND v(dout1_93) AT=590.025n

* CHECK dout1_94 Vdout1_94ck117 = 0.9 time = 590
.meas tran vdout1_94ck117 FIND v(dout1_94) AT=590.025n

* CHECK dout1_95 Vdout1_95ck117 = 0 time = 590
.meas tran vdout1_95ck117 FIND v(dout1_95) AT=590.025n

* CHECK dout1_96 Vdout1_96ck117 = 0.9 time = 590
.meas tran vdout1_96ck117 FIND v(dout1_96) AT=590.025n

* CHECK dout1_97 Vdout1_97ck117 = 0 time = 590
.meas tran vdout1_97ck117 FIND v(dout1_97) AT=590.025n

* CHECK dout1_98 Vdout1_98ck117 = 0 time = 590
.meas tran vdout1_98ck117 FIND v(dout1_98) AT=590.025n

* CHECK dout1_99 Vdout1_99ck117 = 0.9 time = 590
.meas tran vdout1_99ck117 FIND v(dout1_99) AT=590.025n

* CHECK dout1_100 Vdout1_100ck117 = 0 time = 590
.meas tran vdout1_100ck117 FIND v(dout1_100) AT=590.025n

* CHECK dout1_101 Vdout1_101ck117 = 0.9 time = 590
.meas tran vdout1_101ck117 FIND v(dout1_101) AT=590.025n

* CHECK dout1_102 Vdout1_102ck117 = 0 time = 590
.meas tran vdout1_102ck117 FIND v(dout1_102) AT=590.025n

* CHECK dout1_103 Vdout1_103ck117 = 0.9 time = 590
.meas tran vdout1_103ck117 FIND v(dout1_103) AT=590.025n

* CHECK dout1_104 Vdout1_104ck117 = 0 time = 590
.meas tran vdout1_104ck117 FIND v(dout1_104) AT=590.025n

* CHECK dout1_105 Vdout1_105ck117 = 0.9 time = 590
.meas tran vdout1_105ck117 FIND v(dout1_105) AT=590.025n

* CHECK dout1_106 Vdout1_106ck117 = 0 time = 590
.meas tran vdout1_106ck117 FIND v(dout1_106) AT=590.025n

* CHECK dout1_107 Vdout1_107ck117 = 0.9 time = 590
.meas tran vdout1_107ck117 FIND v(dout1_107) AT=590.025n

* CHECK dout1_108 Vdout1_108ck117 = 0 time = 590
.meas tran vdout1_108ck117 FIND v(dout1_108) AT=590.025n

* CHECK dout1_109 Vdout1_109ck117 = 0 time = 590
.meas tran vdout1_109ck117 FIND v(dout1_109) AT=590.025n

* CHECK dout1_110 Vdout1_110ck117 = 0.9 time = 590
.meas tran vdout1_110ck117 FIND v(dout1_110) AT=590.025n

* CHECK dout1_111 Vdout1_111ck117 = 0 time = 590
.meas tran vdout1_111ck117 FIND v(dout1_111) AT=590.025n

* CHECK dout1_112 Vdout1_112ck117 = 0 time = 590
.meas tran vdout1_112ck117 FIND v(dout1_112) AT=590.025n

* CHECK dout1_113 Vdout1_113ck117 = 0.9 time = 590
.meas tran vdout1_113ck117 FIND v(dout1_113) AT=590.025n

* CHECK dout1_114 Vdout1_114ck117 = 0 time = 590
.meas tran vdout1_114ck117 FIND v(dout1_114) AT=590.025n

* CHECK dout1_115 Vdout1_115ck117 = 0 time = 590
.meas tran vdout1_115ck117 FIND v(dout1_115) AT=590.025n

* CHECK dout1_116 Vdout1_116ck117 = 0 time = 590
.meas tran vdout1_116ck117 FIND v(dout1_116) AT=590.025n

* CHECK dout1_117 Vdout1_117ck117 = 0 time = 590
.meas tran vdout1_117ck117 FIND v(dout1_117) AT=590.025n

* CHECK dout1_118 Vdout1_118ck117 = 0.9 time = 590
.meas tran vdout1_118ck117 FIND v(dout1_118) AT=590.025n

* CHECK dout1_119 Vdout1_119ck117 = 0 time = 590
.meas tran vdout1_119ck117 FIND v(dout1_119) AT=590.025n

* CHECK dout1_0 Vdout1_0ck119 = 0.9 time = 600
.meas tran vdout1_0ck119 FIND v(dout1_0) AT=600.025n

* CHECK dout1_1 Vdout1_1ck119 = 0 time = 600
.meas tran vdout1_1ck119 FIND v(dout1_1) AT=600.025n

* CHECK dout1_2 Vdout1_2ck119 = 0 time = 600
.meas tran vdout1_2ck119 FIND v(dout1_2) AT=600.025n

* CHECK dout1_3 Vdout1_3ck119 = 0 time = 600
.meas tran vdout1_3ck119 FIND v(dout1_3) AT=600.025n

* CHECK dout1_4 Vdout1_4ck119 = 0.9 time = 600
.meas tran vdout1_4ck119 FIND v(dout1_4) AT=600.025n

* CHECK dout1_5 Vdout1_5ck119 = 0.9 time = 600
.meas tran vdout1_5ck119 FIND v(dout1_5) AT=600.025n

* CHECK dout1_6 Vdout1_6ck119 = 0.9 time = 600
.meas tran vdout1_6ck119 FIND v(dout1_6) AT=600.025n

* CHECK dout1_7 Vdout1_7ck119 = 0.9 time = 600
.meas tran vdout1_7ck119 FIND v(dout1_7) AT=600.025n

* CHECK dout1_8 Vdout1_8ck119 = 0.9 time = 600
.meas tran vdout1_8ck119 FIND v(dout1_8) AT=600.025n

* CHECK dout1_9 Vdout1_9ck119 = 0 time = 600
.meas tran vdout1_9ck119 FIND v(dout1_9) AT=600.025n

* CHECK dout1_10 Vdout1_10ck119 = 0 time = 600
.meas tran vdout1_10ck119 FIND v(dout1_10) AT=600.025n

* CHECK dout1_11 Vdout1_11ck119 = 0.9 time = 600
.meas tran vdout1_11ck119 FIND v(dout1_11) AT=600.025n

* CHECK dout1_12 Vdout1_12ck119 = 0.9 time = 600
.meas tran vdout1_12ck119 FIND v(dout1_12) AT=600.025n

* CHECK dout1_13 Vdout1_13ck119 = 0 time = 600
.meas tran vdout1_13ck119 FIND v(dout1_13) AT=600.025n

* CHECK dout1_14 Vdout1_14ck119 = 0 time = 600
.meas tran vdout1_14ck119 FIND v(dout1_14) AT=600.025n

* CHECK dout1_15 Vdout1_15ck119 = 0.9 time = 600
.meas tran vdout1_15ck119 FIND v(dout1_15) AT=600.025n

* CHECK dout1_16 Vdout1_16ck119 = 0 time = 600
.meas tran vdout1_16ck119 FIND v(dout1_16) AT=600.025n

* CHECK dout1_17 Vdout1_17ck119 = 0 time = 600
.meas tran vdout1_17ck119 FIND v(dout1_17) AT=600.025n

* CHECK dout1_18 Vdout1_18ck119 = 0 time = 600
.meas tran vdout1_18ck119 FIND v(dout1_18) AT=600.025n

* CHECK dout1_19 Vdout1_19ck119 = 0.9 time = 600
.meas tran vdout1_19ck119 FIND v(dout1_19) AT=600.025n

* CHECK dout1_20 Vdout1_20ck119 = 0 time = 600
.meas tran vdout1_20ck119 FIND v(dout1_20) AT=600.025n

* CHECK dout1_21 Vdout1_21ck119 = 0.9 time = 600
.meas tran vdout1_21ck119 FIND v(dout1_21) AT=600.025n

* CHECK dout1_22 Vdout1_22ck119 = 0.9 time = 600
.meas tran vdout1_22ck119 FIND v(dout1_22) AT=600.025n

* CHECK dout1_23 Vdout1_23ck119 = 0.9 time = 600
.meas tran vdout1_23ck119 FIND v(dout1_23) AT=600.025n

* CHECK dout1_24 Vdout1_24ck119 = 0 time = 600
.meas tran vdout1_24ck119 FIND v(dout1_24) AT=600.025n

* CHECK dout1_25 Vdout1_25ck119 = 0.9 time = 600
.meas tran vdout1_25ck119 FIND v(dout1_25) AT=600.025n

* CHECK dout1_26 Vdout1_26ck119 = 0.9 time = 600
.meas tran vdout1_26ck119 FIND v(dout1_26) AT=600.025n

* CHECK dout1_27 Vdout1_27ck119 = 0 time = 600
.meas tran vdout1_27ck119 FIND v(dout1_27) AT=600.025n

* CHECK dout1_28 Vdout1_28ck119 = 0.9 time = 600
.meas tran vdout1_28ck119 FIND v(dout1_28) AT=600.025n

* CHECK dout1_29 Vdout1_29ck119 = 0 time = 600
.meas tran vdout1_29ck119 FIND v(dout1_29) AT=600.025n

* CHECK dout1_30 Vdout1_30ck119 = 0.9 time = 600
.meas tran vdout1_30ck119 FIND v(dout1_30) AT=600.025n

* CHECK dout1_31 Vdout1_31ck119 = 0.9 time = 600
.meas tran vdout1_31ck119 FIND v(dout1_31) AT=600.025n

* CHECK dout1_32 Vdout1_32ck119 = 0.9 time = 600
.meas tran vdout1_32ck119 FIND v(dout1_32) AT=600.025n

* CHECK dout1_33 Vdout1_33ck119 = 0.9 time = 600
.meas tran vdout1_33ck119 FIND v(dout1_33) AT=600.025n

* CHECK dout1_34 Vdout1_34ck119 = 0.9 time = 600
.meas tran vdout1_34ck119 FIND v(dout1_34) AT=600.025n

* CHECK dout1_35 Vdout1_35ck119 = 0 time = 600
.meas tran vdout1_35ck119 FIND v(dout1_35) AT=600.025n

* CHECK dout1_36 Vdout1_36ck119 = 0 time = 600
.meas tran vdout1_36ck119 FIND v(dout1_36) AT=600.025n

* CHECK dout1_37 Vdout1_37ck119 = 0 time = 600
.meas tran vdout1_37ck119 FIND v(dout1_37) AT=600.025n

* CHECK dout1_38 Vdout1_38ck119 = 0 time = 600
.meas tran vdout1_38ck119 FIND v(dout1_38) AT=600.025n

* CHECK dout1_39 Vdout1_39ck119 = 0 time = 600
.meas tran vdout1_39ck119 FIND v(dout1_39) AT=600.025n

* CHECK dout1_40 Vdout1_40ck119 = 0.9 time = 600
.meas tran vdout1_40ck119 FIND v(dout1_40) AT=600.025n

* CHECK dout1_41 Vdout1_41ck119 = 0.9 time = 600
.meas tran vdout1_41ck119 FIND v(dout1_41) AT=600.025n

* CHECK dout1_42 Vdout1_42ck119 = 0.9 time = 600
.meas tran vdout1_42ck119 FIND v(dout1_42) AT=600.025n

* CHECK dout1_43 Vdout1_43ck119 = 0.9 time = 600
.meas tran vdout1_43ck119 FIND v(dout1_43) AT=600.025n

* CHECK dout1_44 Vdout1_44ck119 = 0 time = 600
.meas tran vdout1_44ck119 FIND v(dout1_44) AT=600.025n

* CHECK dout1_45 Vdout1_45ck119 = 0 time = 600
.meas tran vdout1_45ck119 FIND v(dout1_45) AT=600.025n

* CHECK dout1_46 Vdout1_46ck119 = 0.9 time = 600
.meas tran vdout1_46ck119 FIND v(dout1_46) AT=600.025n

* CHECK dout1_47 Vdout1_47ck119 = 0.9 time = 600
.meas tran vdout1_47ck119 FIND v(dout1_47) AT=600.025n

* CHECK dout1_48 Vdout1_48ck119 = 0.9 time = 600
.meas tran vdout1_48ck119 FIND v(dout1_48) AT=600.025n

* CHECK dout1_49 Vdout1_49ck119 = 0.9 time = 600
.meas tran vdout1_49ck119 FIND v(dout1_49) AT=600.025n

* CHECK dout1_50 Vdout1_50ck119 = 0.9 time = 600
.meas tran vdout1_50ck119 FIND v(dout1_50) AT=600.025n

* CHECK dout1_51 Vdout1_51ck119 = 0.9 time = 600
.meas tran vdout1_51ck119 FIND v(dout1_51) AT=600.025n

* CHECK dout1_52 Vdout1_52ck119 = 0 time = 600
.meas tran vdout1_52ck119 FIND v(dout1_52) AT=600.025n

* CHECK dout1_53 Vdout1_53ck119 = 0.9 time = 600
.meas tran vdout1_53ck119 FIND v(dout1_53) AT=600.025n

* CHECK dout1_54 Vdout1_54ck119 = 0.9 time = 600
.meas tran vdout1_54ck119 FIND v(dout1_54) AT=600.025n

* CHECK dout1_55 Vdout1_55ck119 = 0 time = 600
.meas tran vdout1_55ck119 FIND v(dout1_55) AT=600.025n

* CHECK dout1_56 Vdout1_56ck119 = 0 time = 600
.meas tran vdout1_56ck119 FIND v(dout1_56) AT=600.025n

* CHECK dout1_57 Vdout1_57ck119 = 0 time = 600
.meas tran vdout1_57ck119 FIND v(dout1_57) AT=600.025n

* CHECK dout1_58 Vdout1_58ck119 = 0 time = 600
.meas tran vdout1_58ck119 FIND v(dout1_58) AT=600.025n

* CHECK dout1_59 Vdout1_59ck119 = 0 time = 600
.meas tran vdout1_59ck119 FIND v(dout1_59) AT=600.025n

* CHECK dout1_60 Vdout1_60ck119 = 0.9 time = 600
.meas tran vdout1_60ck119 FIND v(dout1_60) AT=600.025n

* CHECK dout1_61 Vdout1_61ck119 = 0 time = 600
.meas tran vdout1_61ck119 FIND v(dout1_61) AT=600.025n

* CHECK dout1_62 Vdout1_62ck119 = 0.9 time = 600
.meas tran vdout1_62ck119 FIND v(dout1_62) AT=600.025n

* CHECK dout1_63 Vdout1_63ck119 = 0 time = 600
.meas tran vdout1_63ck119 FIND v(dout1_63) AT=600.025n

* CHECK dout1_64 Vdout1_64ck119 = 0.9 time = 600
.meas tran vdout1_64ck119 FIND v(dout1_64) AT=600.025n

* CHECK dout1_65 Vdout1_65ck119 = 0.9 time = 600
.meas tran vdout1_65ck119 FIND v(dout1_65) AT=600.025n

* CHECK dout1_66 Vdout1_66ck119 = 0 time = 600
.meas tran vdout1_66ck119 FIND v(dout1_66) AT=600.025n

* CHECK dout1_67 Vdout1_67ck119 = 0.9 time = 600
.meas tran vdout1_67ck119 FIND v(dout1_67) AT=600.025n

* CHECK dout1_68 Vdout1_68ck119 = 0.9 time = 600
.meas tran vdout1_68ck119 FIND v(dout1_68) AT=600.025n

* CHECK dout1_69 Vdout1_69ck119 = 0.9 time = 600
.meas tran vdout1_69ck119 FIND v(dout1_69) AT=600.025n

* CHECK dout1_70 Vdout1_70ck119 = 0 time = 600
.meas tran vdout1_70ck119 FIND v(dout1_70) AT=600.025n

* CHECK dout1_71 Vdout1_71ck119 = 0 time = 600
.meas tran vdout1_71ck119 FIND v(dout1_71) AT=600.025n

* CHECK dout1_72 Vdout1_72ck119 = 0 time = 600
.meas tran vdout1_72ck119 FIND v(dout1_72) AT=600.025n

* CHECK dout1_73 Vdout1_73ck119 = 0.9 time = 600
.meas tran vdout1_73ck119 FIND v(dout1_73) AT=600.025n

* CHECK dout1_74 Vdout1_74ck119 = 0 time = 600
.meas tran vdout1_74ck119 FIND v(dout1_74) AT=600.025n

* CHECK dout1_75 Vdout1_75ck119 = 0 time = 600
.meas tran vdout1_75ck119 FIND v(dout1_75) AT=600.025n

* CHECK dout1_76 Vdout1_76ck119 = 0.9 time = 600
.meas tran vdout1_76ck119 FIND v(dout1_76) AT=600.025n

* CHECK dout1_77 Vdout1_77ck119 = 0.9 time = 600
.meas tran vdout1_77ck119 FIND v(dout1_77) AT=600.025n

* CHECK dout1_78 Vdout1_78ck119 = 0.9 time = 600
.meas tran vdout1_78ck119 FIND v(dout1_78) AT=600.025n

* CHECK dout1_79 Vdout1_79ck119 = 0 time = 600
.meas tran vdout1_79ck119 FIND v(dout1_79) AT=600.025n

* CHECK dout1_80 Vdout1_80ck119 = 0.9 time = 600
.meas tran vdout1_80ck119 FIND v(dout1_80) AT=600.025n

* CHECK dout1_81 Vdout1_81ck119 = 0.9 time = 600
.meas tran vdout1_81ck119 FIND v(dout1_81) AT=600.025n

* CHECK dout1_82 Vdout1_82ck119 = 0 time = 600
.meas tran vdout1_82ck119 FIND v(dout1_82) AT=600.025n

* CHECK dout1_83 Vdout1_83ck119 = 0.9 time = 600
.meas tran vdout1_83ck119 FIND v(dout1_83) AT=600.025n

* CHECK dout1_84 Vdout1_84ck119 = 0 time = 600
.meas tran vdout1_84ck119 FIND v(dout1_84) AT=600.025n

* CHECK dout1_85 Vdout1_85ck119 = 0 time = 600
.meas tran vdout1_85ck119 FIND v(dout1_85) AT=600.025n

* CHECK dout1_86 Vdout1_86ck119 = 0 time = 600
.meas tran vdout1_86ck119 FIND v(dout1_86) AT=600.025n

* CHECK dout1_87 Vdout1_87ck119 = 0.9 time = 600
.meas tran vdout1_87ck119 FIND v(dout1_87) AT=600.025n

* CHECK dout1_88 Vdout1_88ck119 = 0 time = 600
.meas tran vdout1_88ck119 FIND v(dout1_88) AT=600.025n

* CHECK dout1_89 Vdout1_89ck119 = 0 time = 600
.meas tran vdout1_89ck119 FIND v(dout1_89) AT=600.025n

* CHECK dout1_90 Vdout1_90ck119 = 0 time = 600
.meas tran vdout1_90ck119 FIND v(dout1_90) AT=600.025n

* CHECK dout1_91 Vdout1_91ck119 = 0.9 time = 600
.meas tran vdout1_91ck119 FIND v(dout1_91) AT=600.025n

* CHECK dout1_92 Vdout1_92ck119 = 0 time = 600
.meas tran vdout1_92ck119 FIND v(dout1_92) AT=600.025n

* CHECK dout1_93 Vdout1_93ck119 = 0.9 time = 600
.meas tran vdout1_93ck119 FIND v(dout1_93) AT=600.025n

* CHECK dout1_94 Vdout1_94ck119 = 0.9 time = 600
.meas tran vdout1_94ck119 FIND v(dout1_94) AT=600.025n

* CHECK dout1_95 Vdout1_95ck119 = 0.9 time = 600
.meas tran vdout1_95ck119 FIND v(dout1_95) AT=600.025n

* CHECK dout1_96 Vdout1_96ck119 = 0.9 time = 600
.meas tran vdout1_96ck119 FIND v(dout1_96) AT=600.025n

* CHECK dout1_97 Vdout1_97ck119 = 0.9 time = 600
.meas tran vdout1_97ck119 FIND v(dout1_97) AT=600.025n

* CHECK dout1_98 Vdout1_98ck119 = 0.9 time = 600
.meas tran vdout1_98ck119 FIND v(dout1_98) AT=600.025n

* CHECK dout1_99 Vdout1_99ck119 = 0 time = 600
.meas tran vdout1_99ck119 FIND v(dout1_99) AT=600.025n

* CHECK dout1_100 Vdout1_100ck119 = 0.9 time = 600
.meas tran vdout1_100ck119 FIND v(dout1_100) AT=600.025n

* CHECK dout1_101 Vdout1_101ck119 = 0 time = 600
.meas tran vdout1_101ck119 FIND v(dout1_101) AT=600.025n

* CHECK dout1_102 Vdout1_102ck119 = 0.9 time = 600
.meas tran vdout1_102ck119 FIND v(dout1_102) AT=600.025n

* CHECK dout1_103 Vdout1_103ck119 = 0 time = 600
.meas tran vdout1_103ck119 FIND v(dout1_103) AT=600.025n

* CHECK dout1_104 Vdout1_104ck119 = 0 time = 600
.meas tran vdout1_104ck119 FIND v(dout1_104) AT=600.025n

* CHECK dout1_105 Vdout1_105ck119 = 0.9 time = 600
.meas tran vdout1_105ck119 FIND v(dout1_105) AT=600.025n

* CHECK dout1_106 Vdout1_106ck119 = 0.9 time = 600
.meas tran vdout1_106ck119 FIND v(dout1_106) AT=600.025n

* CHECK dout1_107 Vdout1_107ck119 = 0 time = 600
.meas tran vdout1_107ck119 FIND v(dout1_107) AT=600.025n

* CHECK dout1_108 Vdout1_108ck119 = 0 time = 600
.meas tran vdout1_108ck119 FIND v(dout1_108) AT=600.025n

* CHECK dout1_109 Vdout1_109ck119 = 0.9 time = 600
.meas tran vdout1_109ck119 FIND v(dout1_109) AT=600.025n

* CHECK dout1_110 Vdout1_110ck119 = 0.9 time = 600
.meas tran vdout1_110ck119 FIND v(dout1_110) AT=600.025n

* CHECK dout1_111 Vdout1_111ck119 = 0 time = 600
.meas tran vdout1_111ck119 FIND v(dout1_111) AT=600.025n

* CHECK dout1_112 Vdout1_112ck119 = 0.9 time = 600
.meas tran vdout1_112ck119 FIND v(dout1_112) AT=600.025n

* CHECK dout1_113 Vdout1_113ck119 = 0.9 time = 600
.meas tran vdout1_113ck119 FIND v(dout1_113) AT=600.025n

* CHECK dout1_114 Vdout1_114ck119 = 0.9 time = 600
.meas tran vdout1_114ck119 FIND v(dout1_114) AT=600.025n

* CHECK dout1_115 Vdout1_115ck119 = 0 time = 600
.meas tran vdout1_115ck119 FIND v(dout1_115) AT=600.025n

* CHECK dout1_116 Vdout1_116ck119 = 0 time = 600
.meas tran vdout1_116ck119 FIND v(dout1_116) AT=600.025n

* CHECK dout1_117 Vdout1_117ck119 = 0.9 time = 600
.meas tran vdout1_117ck119 FIND v(dout1_117) AT=600.025n

* CHECK dout1_118 Vdout1_118ck119 = 0.9 time = 600
.meas tran vdout1_118ck119 FIND v(dout1_118) AT=600.025n

* CHECK dout1_119 Vdout1_119ck119 = 0.9 time = 600
.meas tran vdout1_119ck119 FIND v(dout1_119) AT=600.025n

* CHECK dout1_0 Vdout1_0ck127 = 0.9 time = 640
.meas tran vdout1_0ck127 FIND v(dout1_0) AT=640.025n

* CHECK dout1_1 Vdout1_1ck127 = 0.9 time = 640
.meas tran vdout1_1ck127 FIND v(dout1_1) AT=640.025n

* CHECK dout1_2 Vdout1_2ck127 = 0.9 time = 640
.meas tran vdout1_2ck127 FIND v(dout1_2) AT=640.025n

* CHECK dout1_3 Vdout1_3ck127 = 0 time = 640
.meas tran vdout1_3ck127 FIND v(dout1_3) AT=640.025n

* CHECK dout1_4 Vdout1_4ck127 = 0 time = 640
.meas tran vdout1_4ck127 FIND v(dout1_4) AT=640.025n

* CHECK dout1_5 Vdout1_5ck127 = 0.9 time = 640
.meas tran vdout1_5ck127 FIND v(dout1_5) AT=640.025n

* CHECK dout1_6 Vdout1_6ck127 = 0.9 time = 640
.meas tran vdout1_6ck127 FIND v(dout1_6) AT=640.025n

* CHECK dout1_7 Vdout1_7ck127 = 0.9 time = 640
.meas tran vdout1_7ck127 FIND v(dout1_7) AT=640.025n

* CHECK dout1_8 Vdout1_8ck127 = 0 time = 640
.meas tran vdout1_8ck127 FIND v(dout1_8) AT=640.025n

* CHECK dout1_9 Vdout1_9ck127 = 0.9 time = 640
.meas tran vdout1_9ck127 FIND v(dout1_9) AT=640.025n

* CHECK dout1_10 Vdout1_10ck127 = 0.9 time = 640
.meas tran vdout1_10ck127 FIND v(dout1_10) AT=640.025n

* CHECK dout1_11 Vdout1_11ck127 = 0 time = 640
.meas tran vdout1_11ck127 FIND v(dout1_11) AT=640.025n

* CHECK dout1_12 Vdout1_12ck127 = 0.9 time = 640
.meas tran vdout1_12ck127 FIND v(dout1_12) AT=640.025n

* CHECK dout1_13 Vdout1_13ck127 = 0 time = 640
.meas tran vdout1_13ck127 FIND v(dout1_13) AT=640.025n

* CHECK dout1_14 Vdout1_14ck127 = 0 time = 640
.meas tran vdout1_14ck127 FIND v(dout1_14) AT=640.025n

* CHECK dout1_15 Vdout1_15ck127 = 0.9 time = 640
.meas tran vdout1_15ck127 FIND v(dout1_15) AT=640.025n

* CHECK dout1_16 Vdout1_16ck127 = 0.9 time = 640
.meas tran vdout1_16ck127 FIND v(dout1_16) AT=640.025n

* CHECK dout1_17 Vdout1_17ck127 = 0 time = 640
.meas tran vdout1_17ck127 FIND v(dout1_17) AT=640.025n

* CHECK dout1_18 Vdout1_18ck127 = 0 time = 640
.meas tran vdout1_18ck127 FIND v(dout1_18) AT=640.025n

* CHECK dout1_19 Vdout1_19ck127 = 0 time = 640
.meas tran vdout1_19ck127 FIND v(dout1_19) AT=640.025n

* CHECK dout1_20 Vdout1_20ck127 = 0.9 time = 640
.meas tran vdout1_20ck127 FIND v(dout1_20) AT=640.025n

* CHECK dout1_21 Vdout1_21ck127 = 0 time = 640
.meas tran vdout1_21ck127 FIND v(dout1_21) AT=640.025n

* CHECK dout1_22 Vdout1_22ck127 = 0 time = 640
.meas tran vdout1_22ck127 FIND v(dout1_22) AT=640.025n

* CHECK dout1_23 Vdout1_23ck127 = 0 time = 640
.meas tran vdout1_23ck127 FIND v(dout1_23) AT=640.025n

* CHECK dout1_24 Vdout1_24ck127 = 0 time = 640
.meas tran vdout1_24ck127 FIND v(dout1_24) AT=640.025n

* CHECK dout1_25 Vdout1_25ck127 = 0 time = 640
.meas tran vdout1_25ck127 FIND v(dout1_25) AT=640.025n

* CHECK dout1_26 Vdout1_26ck127 = 0.9 time = 640
.meas tran vdout1_26ck127 FIND v(dout1_26) AT=640.025n

* CHECK dout1_27 Vdout1_27ck127 = 0.9 time = 640
.meas tran vdout1_27ck127 FIND v(dout1_27) AT=640.025n

* CHECK dout1_28 Vdout1_28ck127 = 0 time = 640
.meas tran vdout1_28ck127 FIND v(dout1_28) AT=640.025n

* CHECK dout1_29 Vdout1_29ck127 = 0 time = 640
.meas tran vdout1_29ck127 FIND v(dout1_29) AT=640.025n

* CHECK dout1_30 Vdout1_30ck127 = 0 time = 640
.meas tran vdout1_30ck127 FIND v(dout1_30) AT=640.025n

* CHECK dout1_31 Vdout1_31ck127 = 0.9 time = 640
.meas tran vdout1_31ck127 FIND v(dout1_31) AT=640.025n

* CHECK dout1_32 Vdout1_32ck127 = 0.9 time = 640
.meas tran vdout1_32ck127 FIND v(dout1_32) AT=640.025n

* CHECK dout1_33 Vdout1_33ck127 = 0 time = 640
.meas tran vdout1_33ck127 FIND v(dout1_33) AT=640.025n

* CHECK dout1_34 Vdout1_34ck127 = 0.9 time = 640
.meas tran vdout1_34ck127 FIND v(dout1_34) AT=640.025n

* CHECK dout1_35 Vdout1_35ck127 = 0.9 time = 640
.meas tran vdout1_35ck127 FIND v(dout1_35) AT=640.025n

* CHECK dout1_36 Vdout1_36ck127 = 0 time = 640
.meas tran vdout1_36ck127 FIND v(dout1_36) AT=640.025n

* CHECK dout1_37 Vdout1_37ck127 = 0.9 time = 640
.meas tran vdout1_37ck127 FIND v(dout1_37) AT=640.025n

* CHECK dout1_38 Vdout1_38ck127 = 0.9 time = 640
.meas tran vdout1_38ck127 FIND v(dout1_38) AT=640.025n

* CHECK dout1_39 Vdout1_39ck127 = 0 time = 640
.meas tran vdout1_39ck127 FIND v(dout1_39) AT=640.025n

* CHECK dout1_40 Vdout1_40ck127 = 0.9 time = 640
.meas tran vdout1_40ck127 FIND v(dout1_40) AT=640.025n

* CHECK dout1_41 Vdout1_41ck127 = 0 time = 640
.meas tran vdout1_41ck127 FIND v(dout1_41) AT=640.025n

* CHECK dout1_42 Vdout1_42ck127 = 0.9 time = 640
.meas tran vdout1_42ck127 FIND v(dout1_42) AT=640.025n

* CHECK dout1_43 Vdout1_43ck127 = 0 time = 640
.meas tran vdout1_43ck127 FIND v(dout1_43) AT=640.025n

* CHECK dout1_44 Vdout1_44ck127 = 0 time = 640
.meas tran vdout1_44ck127 FIND v(dout1_44) AT=640.025n

* CHECK dout1_45 Vdout1_45ck127 = 0 time = 640
.meas tran vdout1_45ck127 FIND v(dout1_45) AT=640.025n

* CHECK dout1_46 Vdout1_46ck127 = 0.9 time = 640
.meas tran vdout1_46ck127 FIND v(dout1_46) AT=640.025n

* CHECK dout1_47 Vdout1_47ck127 = 0 time = 640
.meas tran vdout1_47ck127 FIND v(dout1_47) AT=640.025n

* CHECK dout1_48 Vdout1_48ck127 = 0 time = 640
.meas tran vdout1_48ck127 FIND v(dout1_48) AT=640.025n

* CHECK dout1_49 Vdout1_49ck127 = 0.9 time = 640
.meas tran vdout1_49ck127 FIND v(dout1_49) AT=640.025n

* CHECK dout1_50 Vdout1_50ck127 = 0 time = 640
.meas tran vdout1_50ck127 FIND v(dout1_50) AT=640.025n

* CHECK dout1_51 Vdout1_51ck127 = 0.9 time = 640
.meas tran vdout1_51ck127 FIND v(dout1_51) AT=640.025n

* CHECK dout1_52 Vdout1_52ck127 = 0 time = 640
.meas tran vdout1_52ck127 FIND v(dout1_52) AT=640.025n

* CHECK dout1_53 Vdout1_53ck127 = 0.9 time = 640
.meas tran vdout1_53ck127 FIND v(dout1_53) AT=640.025n

* CHECK dout1_54 Vdout1_54ck127 = 0.9 time = 640
.meas tran vdout1_54ck127 FIND v(dout1_54) AT=640.025n

* CHECK dout1_55 Vdout1_55ck127 = 0 time = 640
.meas tran vdout1_55ck127 FIND v(dout1_55) AT=640.025n

* CHECK dout1_56 Vdout1_56ck127 = 0.9 time = 640
.meas tran vdout1_56ck127 FIND v(dout1_56) AT=640.025n

* CHECK dout1_57 Vdout1_57ck127 = 0 time = 640
.meas tran vdout1_57ck127 FIND v(dout1_57) AT=640.025n

* CHECK dout1_58 Vdout1_58ck127 = 0.9 time = 640
.meas tran vdout1_58ck127 FIND v(dout1_58) AT=640.025n

* CHECK dout1_59 Vdout1_59ck127 = 0.9 time = 640
.meas tran vdout1_59ck127 FIND v(dout1_59) AT=640.025n

* CHECK dout1_60 Vdout1_60ck127 = 0 time = 640
.meas tran vdout1_60ck127 FIND v(dout1_60) AT=640.025n

* CHECK dout1_61 Vdout1_61ck127 = 0 time = 640
.meas tran vdout1_61ck127 FIND v(dout1_61) AT=640.025n

* CHECK dout1_62 Vdout1_62ck127 = 0.9 time = 640
.meas tran vdout1_62ck127 FIND v(dout1_62) AT=640.025n

* CHECK dout1_63 Vdout1_63ck127 = 0.9 time = 640
.meas tran vdout1_63ck127 FIND v(dout1_63) AT=640.025n

* CHECK dout1_64 Vdout1_64ck127 = 0 time = 640
.meas tran vdout1_64ck127 FIND v(dout1_64) AT=640.025n

* CHECK dout1_65 Vdout1_65ck127 = 0 time = 640
.meas tran vdout1_65ck127 FIND v(dout1_65) AT=640.025n

* CHECK dout1_66 Vdout1_66ck127 = 0.9 time = 640
.meas tran vdout1_66ck127 FIND v(dout1_66) AT=640.025n

* CHECK dout1_67 Vdout1_67ck127 = 0 time = 640
.meas tran vdout1_67ck127 FIND v(dout1_67) AT=640.025n

* CHECK dout1_68 Vdout1_68ck127 = 0 time = 640
.meas tran vdout1_68ck127 FIND v(dout1_68) AT=640.025n

* CHECK dout1_69 Vdout1_69ck127 = 0.9 time = 640
.meas tran vdout1_69ck127 FIND v(dout1_69) AT=640.025n

* CHECK dout1_70 Vdout1_70ck127 = 0.9 time = 640
.meas tran vdout1_70ck127 FIND v(dout1_70) AT=640.025n

* CHECK dout1_71 Vdout1_71ck127 = 0 time = 640
.meas tran vdout1_71ck127 FIND v(dout1_71) AT=640.025n

* CHECK dout1_72 Vdout1_72ck127 = 0 time = 640
.meas tran vdout1_72ck127 FIND v(dout1_72) AT=640.025n

* CHECK dout1_73 Vdout1_73ck127 = 0.9 time = 640
.meas tran vdout1_73ck127 FIND v(dout1_73) AT=640.025n

* CHECK dout1_74 Vdout1_74ck127 = 0.9 time = 640
.meas tran vdout1_74ck127 FIND v(dout1_74) AT=640.025n

* CHECK dout1_75 Vdout1_75ck127 = 0.9 time = 640
.meas tran vdout1_75ck127 FIND v(dout1_75) AT=640.025n

* CHECK dout1_76 Vdout1_76ck127 = 0.9 time = 640
.meas tran vdout1_76ck127 FIND v(dout1_76) AT=640.025n

* CHECK dout1_77 Vdout1_77ck127 = 0.9 time = 640
.meas tran vdout1_77ck127 FIND v(dout1_77) AT=640.025n

* CHECK dout1_78 Vdout1_78ck127 = 0.9 time = 640
.meas tran vdout1_78ck127 FIND v(dout1_78) AT=640.025n

* CHECK dout1_79 Vdout1_79ck127 = 0.9 time = 640
.meas tran vdout1_79ck127 FIND v(dout1_79) AT=640.025n

* CHECK dout1_80 Vdout1_80ck127 = 0 time = 640
.meas tran vdout1_80ck127 FIND v(dout1_80) AT=640.025n

* CHECK dout1_81 Vdout1_81ck127 = 0 time = 640
.meas tran vdout1_81ck127 FIND v(dout1_81) AT=640.025n

* CHECK dout1_82 Vdout1_82ck127 = 0.9 time = 640
.meas tran vdout1_82ck127 FIND v(dout1_82) AT=640.025n

* CHECK dout1_83 Vdout1_83ck127 = 0.9 time = 640
.meas tran vdout1_83ck127 FIND v(dout1_83) AT=640.025n

* CHECK dout1_84 Vdout1_84ck127 = 0 time = 640
.meas tran vdout1_84ck127 FIND v(dout1_84) AT=640.025n

* CHECK dout1_85 Vdout1_85ck127 = 0 time = 640
.meas tran vdout1_85ck127 FIND v(dout1_85) AT=640.025n

* CHECK dout1_86 Vdout1_86ck127 = 0.9 time = 640
.meas tran vdout1_86ck127 FIND v(dout1_86) AT=640.025n

* CHECK dout1_87 Vdout1_87ck127 = 0 time = 640
.meas tran vdout1_87ck127 FIND v(dout1_87) AT=640.025n

* CHECK dout1_88 Vdout1_88ck127 = 0.9 time = 640
.meas tran vdout1_88ck127 FIND v(dout1_88) AT=640.025n

* CHECK dout1_89 Vdout1_89ck127 = 0 time = 640
.meas tran vdout1_89ck127 FIND v(dout1_89) AT=640.025n

* CHECK dout1_90 Vdout1_90ck127 = 0.9 time = 640
.meas tran vdout1_90ck127 FIND v(dout1_90) AT=640.025n

* CHECK dout1_91 Vdout1_91ck127 = 0.9 time = 640
.meas tran vdout1_91ck127 FIND v(dout1_91) AT=640.025n

* CHECK dout1_92 Vdout1_92ck127 = 0 time = 640
.meas tran vdout1_92ck127 FIND v(dout1_92) AT=640.025n

* CHECK dout1_93 Vdout1_93ck127 = 0.9 time = 640
.meas tran vdout1_93ck127 FIND v(dout1_93) AT=640.025n

* CHECK dout1_94 Vdout1_94ck127 = 0.9 time = 640
.meas tran vdout1_94ck127 FIND v(dout1_94) AT=640.025n

* CHECK dout1_95 Vdout1_95ck127 = 0 time = 640
.meas tran vdout1_95ck127 FIND v(dout1_95) AT=640.025n

* CHECK dout1_96 Vdout1_96ck127 = 0 time = 640
.meas tran vdout1_96ck127 FIND v(dout1_96) AT=640.025n

* CHECK dout1_97 Vdout1_97ck127 = 0 time = 640
.meas tran vdout1_97ck127 FIND v(dout1_97) AT=640.025n

* CHECK dout1_98 Vdout1_98ck127 = 0.9 time = 640
.meas tran vdout1_98ck127 FIND v(dout1_98) AT=640.025n

* CHECK dout1_99 Vdout1_99ck127 = 0.9 time = 640
.meas tran vdout1_99ck127 FIND v(dout1_99) AT=640.025n

* CHECK dout1_100 Vdout1_100ck127 = 0 time = 640
.meas tran vdout1_100ck127 FIND v(dout1_100) AT=640.025n

* CHECK dout1_101 Vdout1_101ck127 = 0 time = 640
.meas tran vdout1_101ck127 FIND v(dout1_101) AT=640.025n

* CHECK dout1_102 Vdout1_102ck127 = 0.9 time = 640
.meas tran vdout1_102ck127 FIND v(dout1_102) AT=640.025n

* CHECK dout1_103 Vdout1_103ck127 = 0 time = 640
.meas tran vdout1_103ck127 FIND v(dout1_103) AT=640.025n

* CHECK dout1_104 Vdout1_104ck127 = 0.9 time = 640
.meas tran vdout1_104ck127 FIND v(dout1_104) AT=640.025n

* CHECK dout1_105 Vdout1_105ck127 = 0 time = 640
.meas tran vdout1_105ck127 FIND v(dout1_105) AT=640.025n

* CHECK dout1_106 Vdout1_106ck127 = 0.9 time = 640
.meas tran vdout1_106ck127 FIND v(dout1_106) AT=640.025n

* CHECK dout1_107 Vdout1_107ck127 = 0.9 time = 640
.meas tran vdout1_107ck127 FIND v(dout1_107) AT=640.025n

* CHECK dout1_108 Vdout1_108ck127 = 0.9 time = 640
.meas tran vdout1_108ck127 FIND v(dout1_108) AT=640.025n

* CHECK dout1_109 Vdout1_109ck127 = 0 time = 640
.meas tran vdout1_109ck127 FIND v(dout1_109) AT=640.025n

* CHECK dout1_110 Vdout1_110ck127 = 0.9 time = 640
.meas tran vdout1_110ck127 FIND v(dout1_110) AT=640.025n

* CHECK dout1_111 Vdout1_111ck127 = 0 time = 640
.meas tran vdout1_111ck127 FIND v(dout1_111) AT=640.025n

* CHECK dout1_112 Vdout1_112ck127 = 0 time = 640
.meas tran vdout1_112ck127 FIND v(dout1_112) AT=640.025n

* CHECK dout1_113 Vdout1_113ck127 = 0.9 time = 640
.meas tran vdout1_113ck127 FIND v(dout1_113) AT=640.025n

* CHECK dout1_114 Vdout1_114ck127 = 0.9 time = 640
.meas tran vdout1_114ck127 FIND v(dout1_114) AT=640.025n

* CHECK dout1_115 Vdout1_115ck127 = 0.9 time = 640
.meas tran vdout1_115ck127 FIND v(dout1_115) AT=640.025n

* CHECK dout1_116 Vdout1_116ck127 = 0 time = 640
.meas tran vdout1_116ck127 FIND v(dout1_116) AT=640.025n

* CHECK dout1_117 Vdout1_117ck127 = 0.9 time = 640
.meas tran vdout1_117ck127 FIND v(dout1_117) AT=640.025n

* CHECK dout1_118 Vdout1_118ck127 = 0 time = 640
.meas tran vdout1_118ck127 FIND v(dout1_118) AT=640.025n

* CHECK dout1_119 Vdout1_119ck127 = 0 time = 640
.meas tran vdout1_119ck127 FIND v(dout1_119) AT=640.025n

* CHECK dout1_0 Vdout1_0ck129 = 0.9 time = 650
.meas tran vdout1_0ck129 FIND v(dout1_0) AT=650.025n

* CHECK dout1_1 Vdout1_1ck129 = 0.9 time = 650
.meas tran vdout1_1ck129 FIND v(dout1_1) AT=650.025n

* CHECK dout1_2 Vdout1_2ck129 = 0 time = 650
.meas tran vdout1_2ck129 FIND v(dout1_2) AT=650.025n

* CHECK dout1_3 Vdout1_3ck129 = 0.9 time = 650
.meas tran vdout1_3ck129 FIND v(dout1_3) AT=650.025n

* CHECK dout1_4 Vdout1_4ck129 = 0.9 time = 650
.meas tran vdout1_4ck129 FIND v(dout1_4) AT=650.025n

* CHECK dout1_5 Vdout1_5ck129 = 0 time = 650
.meas tran vdout1_5ck129 FIND v(dout1_5) AT=650.025n

* CHECK dout1_6 Vdout1_6ck129 = 0.9 time = 650
.meas tran vdout1_6ck129 FIND v(dout1_6) AT=650.025n

* CHECK dout1_7 Vdout1_7ck129 = 0.9 time = 650
.meas tran vdout1_7ck129 FIND v(dout1_7) AT=650.025n

* CHECK dout1_8 Vdout1_8ck129 = 0 time = 650
.meas tran vdout1_8ck129 FIND v(dout1_8) AT=650.025n

* CHECK dout1_9 Vdout1_9ck129 = 0.9 time = 650
.meas tran vdout1_9ck129 FIND v(dout1_9) AT=650.025n

* CHECK dout1_10 Vdout1_10ck129 = 0.9 time = 650
.meas tran vdout1_10ck129 FIND v(dout1_10) AT=650.025n

* CHECK dout1_11 Vdout1_11ck129 = 0 time = 650
.meas tran vdout1_11ck129 FIND v(dout1_11) AT=650.025n

* CHECK dout1_12 Vdout1_12ck129 = 0 time = 650
.meas tran vdout1_12ck129 FIND v(dout1_12) AT=650.025n

* CHECK dout1_13 Vdout1_13ck129 = 0 time = 650
.meas tran vdout1_13ck129 FIND v(dout1_13) AT=650.025n

* CHECK dout1_14 Vdout1_14ck129 = 0 time = 650
.meas tran vdout1_14ck129 FIND v(dout1_14) AT=650.025n

* CHECK dout1_15 Vdout1_15ck129 = 0.9 time = 650
.meas tran vdout1_15ck129 FIND v(dout1_15) AT=650.025n

* CHECK dout1_16 Vdout1_16ck129 = 0 time = 650
.meas tran vdout1_16ck129 FIND v(dout1_16) AT=650.025n

* CHECK dout1_17 Vdout1_17ck129 = 0.9 time = 650
.meas tran vdout1_17ck129 FIND v(dout1_17) AT=650.025n

* CHECK dout1_18 Vdout1_18ck129 = 0 time = 650
.meas tran vdout1_18ck129 FIND v(dout1_18) AT=650.025n

* CHECK dout1_19 Vdout1_19ck129 = 0.9 time = 650
.meas tran vdout1_19ck129 FIND v(dout1_19) AT=650.025n

* CHECK dout1_20 Vdout1_20ck129 = 0 time = 650
.meas tran vdout1_20ck129 FIND v(dout1_20) AT=650.025n

* CHECK dout1_21 Vdout1_21ck129 = 0.9 time = 650
.meas tran vdout1_21ck129 FIND v(dout1_21) AT=650.025n

* CHECK dout1_22 Vdout1_22ck129 = 0.9 time = 650
.meas tran vdout1_22ck129 FIND v(dout1_22) AT=650.025n

* CHECK dout1_23 Vdout1_23ck129 = 0.9 time = 650
.meas tran vdout1_23ck129 FIND v(dout1_23) AT=650.025n

* CHECK dout1_24 Vdout1_24ck129 = 0.9 time = 650
.meas tran vdout1_24ck129 FIND v(dout1_24) AT=650.025n

* CHECK dout1_25 Vdout1_25ck129 = 0.9 time = 650
.meas tran vdout1_25ck129 FIND v(dout1_25) AT=650.025n

* CHECK dout1_26 Vdout1_26ck129 = 0 time = 650
.meas tran vdout1_26ck129 FIND v(dout1_26) AT=650.025n

* CHECK dout1_27 Vdout1_27ck129 = 0.9 time = 650
.meas tran vdout1_27ck129 FIND v(dout1_27) AT=650.025n

* CHECK dout1_28 Vdout1_28ck129 = 0 time = 650
.meas tran vdout1_28ck129 FIND v(dout1_28) AT=650.025n

* CHECK dout1_29 Vdout1_29ck129 = 0 time = 650
.meas tran vdout1_29ck129 FIND v(dout1_29) AT=650.025n

* CHECK dout1_30 Vdout1_30ck129 = 0.9 time = 650
.meas tran vdout1_30ck129 FIND v(dout1_30) AT=650.025n

* CHECK dout1_31 Vdout1_31ck129 = 0.9 time = 650
.meas tran vdout1_31ck129 FIND v(dout1_31) AT=650.025n

* CHECK dout1_32 Vdout1_32ck129 = 0.9 time = 650
.meas tran vdout1_32ck129 FIND v(dout1_32) AT=650.025n

* CHECK dout1_33 Vdout1_33ck129 = 0 time = 650
.meas tran vdout1_33ck129 FIND v(dout1_33) AT=650.025n

* CHECK dout1_34 Vdout1_34ck129 = 0.9 time = 650
.meas tran vdout1_34ck129 FIND v(dout1_34) AT=650.025n

* CHECK dout1_35 Vdout1_35ck129 = 0.9 time = 650
.meas tran vdout1_35ck129 FIND v(dout1_35) AT=650.025n

* CHECK dout1_36 Vdout1_36ck129 = 0.9 time = 650
.meas tran vdout1_36ck129 FIND v(dout1_36) AT=650.025n

* CHECK dout1_37 Vdout1_37ck129 = 0 time = 650
.meas tran vdout1_37ck129 FIND v(dout1_37) AT=650.025n

* CHECK dout1_38 Vdout1_38ck129 = 0.9 time = 650
.meas tran vdout1_38ck129 FIND v(dout1_38) AT=650.025n

* CHECK dout1_39 Vdout1_39ck129 = 0.9 time = 650
.meas tran vdout1_39ck129 FIND v(dout1_39) AT=650.025n

* CHECK dout1_40 Vdout1_40ck129 = 0.9 time = 650
.meas tran vdout1_40ck129 FIND v(dout1_40) AT=650.025n

* CHECK dout1_41 Vdout1_41ck129 = 0.9 time = 650
.meas tran vdout1_41ck129 FIND v(dout1_41) AT=650.025n

* CHECK dout1_42 Vdout1_42ck129 = 0.9 time = 650
.meas tran vdout1_42ck129 FIND v(dout1_42) AT=650.025n

* CHECK dout1_43 Vdout1_43ck129 = 0 time = 650
.meas tran vdout1_43ck129 FIND v(dout1_43) AT=650.025n

* CHECK dout1_44 Vdout1_44ck129 = 0 time = 650
.meas tran vdout1_44ck129 FIND v(dout1_44) AT=650.025n

* CHECK dout1_45 Vdout1_45ck129 = 0.9 time = 650
.meas tran vdout1_45ck129 FIND v(dout1_45) AT=650.025n

* CHECK dout1_46 Vdout1_46ck129 = 0 time = 650
.meas tran vdout1_46ck129 FIND v(dout1_46) AT=650.025n

* CHECK dout1_47 Vdout1_47ck129 = 0.9 time = 650
.meas tran vdout1_47ck129 FIND v(dout1_47) AT=650.025n

* CHECK dout1_48 Vdout1_48ck129 = 0.9 time = 650
.meas tran vdout1_48ck129 FIND v(dout1_48) AT=650.025n

* CHECK dout1_49 Vdout1_49ck129 = 0 time = 650
.meas tran vdout1_49ck129 FIND v(dout1_49) AT=650.025n

* CHECK dout1_50 Vdout1_50ck129 = 0.9 time = 650
.meas tran vdout1_50ck129 FIND v(dout1_50) AT=650.025n

* CHECK dout1_51 Vdout1_51ck129 = 0 time = 650
.meas tran vdout1_51ck129 FIND v(dout1_51) AT=650.025n

* CHECK dout1_52 Vdout1_52ck129 = 0.9 time = 650
.meas tran vdout1_52ck129 FIND v(dout1_52) AT=650.025n

* CHECK dout1_53 Vdout1_53ck129 = 0.9 time = 650
.meas tran vdout1_53ck129 FIND v(dout1_53) AT=650.025n

* CHECK dout1_54 Vdout1_54ck129 = 0.9 time = 650
.meas tran vdout1_54ck129 FIND v(dout1_54) AT=650.025n

* CHECK dout1_55 Vdout1_55ck129 = 0.9 time = 650
.meas tran vdout1_55ck129 FIND v(dout1_55) AT=650.025n

* CHECK dout1_56 Vdout1_56ck129 = 0.9 time = 650
.meas tran vdout1_56ck129 FIND v(dout1_56) AT=650.025n

* CHECK dout1_57 Vdout1_57ck129 = 0 time = 650
.meas tran vdout1_57ck129 FIND v(dout1_57) AT=650.025n

* CHECK dout1_58 Vdout1_58ck129 = 0 time = 650
.meas tran vdout1_58ck129 FIND v(dout1_58) AT=650.025n

* CHECK dout1_59 Vdout1_59ck129 = 0 time = 650
.meas tran vdout1_59ck129 FIND v(dout1_59) AT=650.025n

* CHECK dout1_60 Vdout1_60ck129 = 0 time = 650
.meas tran vdout1_60ck129 FIND v(dout1_60) AT=650.025n

* CHECK dout1_61 Vdout1_61ck129 = 0.9 time = 650
.meas tran vdout1_61ck129 FIND v(dout1_61) AT=650.025n

* CHECK dout1_62 Vdout1_62ck129 = 0.9 time = 650
.meas tran vdout1_62ck129 FIND v(dout1_62) AT=650.025n

* CHECK dout1_63 Vdout1_63ck129 = 0 time = 650
.meas tran vdout1_63ck129 FIND v(dout1_63) AT=650.025n

* CHECK dout1_64 Vdout1_64ck129 = 0 time = 650
.meas tran vdout1_64ck129 FIND v(dout1_64) AT=650.025n

* CHECK dout1_65 Vdout1_65ck129 = 0.9 time = 650
.meas tran vdout1_65ck129 FIND v(dout1_65) AT=650.025n

* CHECK dout1_66 Vdout1_66ck129 = 0 time = 650
.meas tran vdout1_66ck129 FIND v(dout1_66) AT=650.025n

* CHECK dout1_67 Vdout1_67ck129 = 0.9 time = 650
.meas tran vdout1_67ck129 FIND v(dout1_67) AT=650.025n

* CHECK dout1_68 Vdout1_68ck129 = 0.9 time = 650
.meas tran vdout1_68ck129 FIND v(dout1_68) AT=650.025n

* CHECK dout1_69 Vdout1_69ck129 = 0 time = 650
.meas tran vdout1_69ck129 FIND v(dout1_69) AT=650.025n

* CHECK dout1_70 Vdout1_70ck129 = 0 time = 650
.meas tran vdout1_70ck129 FIND v(dout1_70) AT=650.025n

* CHECK dout1_71 Vdout1_71ck129 = 0.9 time = 650
.meas tran vdout1_71ck129 FIND v(dout1_71) AT=650.025n

* CHECK dout1_72 Vdout1_72ck129 = 0.9 time = 650
.meas tran vdout1_72ck129 FIND v(dout1_72) AT=650.025n

* CHECK dout1_73 Vdout1_73ck129 = 0.9 time = 650
.meas tran vdout1_73ck129 FIND v(dout1_73) AT=650.025n

* CHECK dout1_74 Vdout1_74ck129 = 0 time = 650
.meas tran vdout1_74ck129 FIND v(dout1_74) AT=650.025n

* CHECK dout1_75 Vdout1_75ck129 = 0 time = 650
.meas tran vdout1_75ck129 FIND v(dout1_75) AT=650.025n

* CHECK dout1_76 Vdout1_76ck129 = 0.9 time = 650
.meas tran vdout1_76ck129 FIND v(dout1_76) AT=650.025n

* CHECK dout1_77 Vdout1_77ck129 = 0.9 time = 650
.meas tran vdout1_77ck129 FIND v(dout1_77) AT=650.025n

* CHECK dout1_78 Vdout1_78ck129 = 0 time = 650
.meas tran vdout1_78ck129 FIND v(dout1_78) AT=650.025n

* CHECK dout1_79 Vdout1_79ck129 = 0.9 time = 650
.meas tran vdout1_79ck129 FIND v(dout1_79) AT=650.025n

* CHECK dout1_80 Vdout1_80ck129 = 0.9 time = 650
.meas tran vdout1_80ck129 FIND v(dout1_80) AT=650.025n

* CHECK dout1_81 Vdout1_81ck129 = 0 time = 650
.meas tran vdout1_81ck129 FIND v(dout1_81) AT=650.025n

* CHECK dout1_82 Vdout1_82ck129 = 0 time = 650
.meas tran vdout1_82ck129 FIND v(dout1_82) AT=650.025n

* CHECK dout1_83 Vdout1_83ck129 = 0 time = 650
.meas tran vdout1_83ck129 FIND v(dout1_83) AT=650.025n

* CHECK dout1_84 Vdout1_84ck129 = 0 time = 650
.meas tran vdout1_84ck129 FIND v(dout1_84) AT=650.025n

* CHECK dout1_85 Vdout1_85ck129 = 0.9 time = 650
.meas tran vdout1_85ck129 FIND v(dout1_85) AT=650.025n

* CHECK dout1_86 Vdout1_86ck129 = 0.9 time = 650
.meas tran vdout1_86ck129 FIND v(dout1_86) AT=650.025n

* CHECK dout1_87 Vdout1_87ck129 = 0 time = 650
.meas tran vdout1_87ck129 FIND v(dout1_87) AT=650.025n

* CHECK dout1_88 Vdout1_88ck129 = 0 time = 650
.meas tran vdout1_88ck129 FIND v(dout1_88) AT=650.025n

* CHECK dout1_89 Vdout1_89ck129 = 0.9 time = 650
.meas tran vdout1_89ck129 FIND v(dout1_89) AT=650.025n

* CHECK dout1_90 Vdout1_90ck129 = 0.9 time = 650
.meas tran vdout1_90ck129 FIND v(dout1_90) AT=650.025n

* CHECK dout1_91 Vdout1_91ck129 = 0.9 time = 650
.meas tran vdout1_91ck129 FIND v(dout1_91) AT=650.025n

* CHECK dout1_92 Vdout1_92ck129 = 0 time = 650
.meas tran vdout1_92ck129 FIND v(dout1_92) AT=650.025n

* CHECK dout1_93 Vdout1_93ck129 = 0 time = 650
.meas tran vdout1_93ck129 FIND v(dout1_93) AT=650.025n

* CHECK dout1_94 Vdout1_94ck129 = 0 time = 650
.meas tran vdout1_94ck129 FIND v(dout1_94) AT=650.025n

* CHECK dout1_95 Vdout1_95ck129 = 0.9 time = 650
.meas tran vdout1_95ck129 FIND v(dout1_95) AT=650.025n

* CHECK dout1_96 Vdout1_96ck129 = 0 time = 650
.meas tran vdout1_96ck129 FIND v(dout1_96) AT=650.025n

* CHECK dout1_97 Vdout1_97ck129 = 0.9 time = 650
.meas tran vdout1_97ck129 FIND v(dout1_97) AT=650.025n

* CHECK dout1_98 Vdout1_98ck129 = 0.9 time = 650
.meas tran vdout1_98ck129 FIND v(dout1_98) AT=650.025n

* CHECK dout1_99 Vdout1_99ck129 = 0 time = 650
.meas tran vdout1_99ck129 FIND v(dout1_99) AT=650.025n

* CHECK dout1_100 Vdout1_100ck129 = 0.9 time = 650
.meas tran vdout1_100ck129 FIND v(dout1_100) AT=650.025n

* CHECK dout1_101 Vdout1_101ck129 = 0.9 time = 650
.meas tran vdout1_101ck129 FIND v(dout1_101) AT=650.025n

* CHECK dout1_102 Vdout1_102ck129 = 0 time = 650
.meas tran vdout1_102ck129 FIND v(dout1_102) AT=650.025n

* CHECK dout1_103 Vdout1_103ck129 = 0 time = 650
.meas tran vdout1_103ck129 FIND v(dout1_103) AT=650.025n

* CHECK dout1_104 Vdout1_104ck129 = 0.9 time = 650
.meas tran vdout1_104ck129 FIND v(dout1_104) AT=650.025n

* CHECK dout1_105 Vdout1_105ck129 = 0.9 time = 650
.meas tran vdout1_105ck129 FIND v(dout1_105) AT=650.025n

* CHECK dout1_106 Vdout1_106ck129 = 0.9 time = 650
.meas tran vdout1_106ck129 FIND v(dout1_106) AT=650.025n

* CHECK dout1_107 Vdout1_107ck129 = 0.9 time = 650
.meas tran vdout1_107ck129 FIND v(dout1_107) AT=650.025n

* CHECK dout1_108 Vdout1_108ck129 = 0.9 time = 650
.meas tran vdout1_108ck129 FIND v(dout1_108) AT=650.025n

* CHECK dout1_109 Vdout1_109ck129 = 0 time = 650
.meas tran vdout1_109ck129 FIND v(dout1_109) AT=650.025n

* CHECK dout1_110 Vdout1_110ck129 = 0.9 time = 650
.meas tran vdout1_110ck129 FIND v(dout1_110) AT=650.025n

* CHECK dout1_111 Vdout1_111ck129 = 0 time = 650
.meas tran vdout1_111ck129 FIND v(dout1_111) AT=650.025n

* CHECK dout1_112 Vdout1_112ck129 = 0.9 time = 650
.meas tran vdout1_112ck129 FIND v(dout1_112) AT=650.025n

* CHECK dout1_113 Vdout1_113ck129 = 0.9 time = 650
.meas tran vdout1_113ck129 FIND v(dout1_113) AT=650.025n

* CHECK dout1_114 Vdout1_114ck129 = 0 time = 650
.meas tran vdout1_114ck129 FIND v(dout1_114) AT=650.025n

* CHECK dout1_115 Vdout1_115ck129 = 0 time = 650
.meas tran vdout1_115ck129 FIND v(dout1_115) AT=650.025n

* CHECK dout1_116 Vdout1_116ck129 = 0 time = 650
.meas tran vdout1_116ck129 FIND v(dout1_116) AT=650.025n

* CHECK dout1_117 Vdout1_117ck129 = 0 time = 650
.meas tran vdout1_117ck129 FIND v(dout1_117) AT=650.025n

* CHECK dout1_118 Vdout1_118ck129 = 0.9 time = 650
.meas tran vdout1_118ck129 FIND v(dout1_118) AT=650.025n

* CHECK dout1_119 Vdout1_119ck129 = 0.9 time = 650
.meas tran vdout1_119ck129 FIND v(dout1_119) AT=650.025n

* CHECK dout1_0 Vdout1_0ck132 = 0.9 time = 665
.meas tran vdout1_0ck132 FIND v(dout1_0) AT=665.025n

* CHECK dout1_1 Vdout1_1ck132 = 0.9 time = 665
.meas tran vdout1_1ck132 FIND v(dout1_1) AT=665.025n

* CHECK dout1_2 Vdout1_2ck132 = 0 time = 665
.meas tran vdout1_2ck132 FIND v(dout1_2) AT=665.025n

* CHECK dout1_3 Vdout1_3ck132 = 0.9 time = 665
.meas tran vdout1_3ck132 FIND v(dout1_3) AT=665.025n

* CHECK dout1_4 Vdout1_4ck132 = 0.9 time = 665
.meas tran vdout1_4ck132 FIND v(dout1_4) AT=665.025n

* CHECK dout1_5 Vdout1_5ck132 = 0 time = 665
.meas tran vdout1_5ck132 FIND v(dout1_5) AT=665.025n

* CHECK dout1_6 Vdout1_6ck132 = 0.9 time = 665
.meas tran vdout1_6ck132 FIND v(dout1_6) AT=665.025n

* CHECK dout1_7 Vdout1_7ck132 = 0.9 time = 665
.meas tran vdout1_7ck132 FIND v(dout1_7) AT=665.025n

* CHECK dout1_8 Vdout1_8ck132 = 0 time = 665
.meas tran vdout1_8ck132 FIND v(dout1_8) AT=665.025n

* CHECK dout1_9 Vdout1_9ck132 = 0.9 time = 665
.meas tran vdout1_9ck132 FIND v(dout1_9) AT=665.025n

* CHECK dout1_10 Vdout1_10ck132 = 0.9 time = 665
.meas tran vdout1_10ck132 FIND v(dout1_10) AT=665.025n

* CHECK dout1_11 Vdout1_11ck132 = 0 time = 665
.meas tran vdout1_11ck132 FIND v(dout1_11) AT=665.025n

* CHECK dout1_12 Vdout1_12ck132 = 0 time = 665
.meas tran vdout1_12ck132 FIND v(dout1_12) AT=665.025n

* CHECK dout1_13 Vdout1_13ck132 = 0 time = 665
.meas tran vdout1_13ck132 FIND v(dout1_13) AT=665.025n

* CHECK dout1_14 Vdout1_14ck132 = 0 time = 665
.meas tran vdout1_14ck132 FIND v(dout1_14) AT=665.025n

* CHECK dout1_15 Vdout1_15ck132 = 0.9 time = 665
.meas tran vdout1_15ck132 FIND v(dout1_15) AT=665.025n

* CHECK dout1_16 Vdout1_16ck132 = 0 time = 665
.meas tran vdout1_16ck132 FIND v(dout1_16) AT=665.025n

* CHECK dout1_17 Vdout1_17ck132 = 0.9 time = 665
.meas tran vdout1_17ck132 FIND v(dout1_17) AT=665.025n

* CHECK dout1_18 Vdout1_18ck132 = 0 time = 665
.meas tran vdout1_18ck132 FIND v(dout1_18) AT=665.025n

* CHECK dout1_19 Vdout1_19ck132 = 0.9 time = 665
.meas tran vdout1_19ck132 FIND v(dout1_19) AT=665.025n

* CHECK dout1_20 Vdout1_20ck132 = 0 time = 665
.meas tran vdout1_20ck132 FIND v(dout1_20) AT=665.025n

* CHECK dout1_21 Vdout1_21ck132 = 0.9 time = 665
.meas tran vdout1_21ck132 FIND v(dout1_21) AT=665.025n

* CHECK dout1_22 Vdout1_22ck132 = 0.9 time = 665
.meas tran vdout1_22ck132 FIND v(dout1_22) AT=665.025n

* CHECK dout1_23 Vdout1_23ck132 = 0.9 time = 665
.meas tran vdout1_23ck132 FIND v(dout1_23) AT=665.025n

* CHECK dout1_24 Vdout1_24ck132 = 0.9 time = 665
.meas tran vdout1_24ck132 FIND v(dout1_24) AT=665.025n

* CHECK dout1_25 Vdout1_25ck132 = 0.9 time = 665
.meas tran vdout1_25ck132 FIND v(dout1_25) AT=665.025n

* CHECK dout1_26 Vdout1_26ck132 = 0 time = 665
.meas tran vdout1_26ck132 FIND v(dout1_26) AT=665.025n

* CHECK dout1_27 Vdout1_27ck132 = 0.9 time = 665
.meas tran vdout1_27ck132 FIND v(dout1_27) AT=665.025n

* CHECK dout1_28 Vdout1_28ck132 = 0 time = 665
.meas tran vdout1_28ck132 FIND v(dout1_28) AT=665.025n

* CHECK dout1_29 Vdout1_29ck132 = 0 time = 665
.meas tran vdout1_29ck132 FIND v(dout1_29) AT=665.025n

* CHECK dout1_30 Vdout1_30ck132 = 0.9 time = 665
.meas tran vdout1_30ck132 FIND v(dout1_30) AT=665.025n

* CHECK dout1_31 Vdout1_31ck132 = 0.9 time = 665
.meas tran vdout1_31ck132 FIND v(dout1_31) AT=665.025n

* CHECK dout1_32 Vdout1_32ck132 = 0.9 time = 665
.meas tran vdout1_32ck132 FIND v(dout1_32) AT=665.025n

* CHECK dout1_33 Vdout1_33ck132 = 0 time = 665
.meas tran vdout1_33ck132 FIND v(dout1_33) AT=665.025n

* CHECK dout1_34 Vdout1_34ck132 = 0.9 time = 665
.meas tran vdout1_34ck132 FIND v(dout1_34) AT=665.025n

* CHECK dout1_35 Vdout1_35ck132 = 0.9 time = 665
.meas tran vdout1_35ck132 FIND v(dout1_35) AT=665.025n

* CHECK dout1_36 Vdout1_36ck132 = 0.9 time = 665
.meas tran vdout1_36ck132 FIND v(dout1_36) AT=665.025n

* CHECK dout1_37 Vdout1_37ck132 = 0 time = 665
.meas tran vdout1_37ck132 FIND v(dout1_37) AT=665.025n

* CHECK dout1_38 Vdout1_38ck132 = 0.9 time = 665
.meas tran vdout1_38ck132 FIND v(dout1_38) AT=665.025n

* CHECK dout1_39 Vdout1_39ck132 = 0.9 time = 665
.meas tran vdout1_39ck132 FIND v(dout1_39) AT=665.025n

* CHECK dout1_40 Vdout1_40ck132 = 0.9 time = 665
.meas tran vdout1_40ck132 FIND v(dout1_40) AT=665.025n

* CHECK dout1_41 Vdout1_41ck132 = 0.9 time = 665
.meas tran vdout1_41ck132 FIND v(dout1_41) AT=665.025n

* CHECK dout1_42 Vdout1_42ck132 = 0.9 time = 665
.meas tran vdout1_42ck132 FIND v(dout1_42) AT=665.025n

* CHECK dout1_43 Vdout1_43ck132 = 0 time = 665
.meas tran vdout1_43ck132 FIND v(dout1_43) AT=665.025n

* CHECK dout1_44 Vdout1_44ck132 = 0 time = 665
.meas tran vdout1_44ck132 FIND v(dout1_44) AT=665.025n

* CHECK dout1_45 Vdout1_45ck132 = 0.9 time = 665
.meas tran vdout1_45ck132 FIND v(dout1_45) AT=665.025n

* CHECK dout1_46 Vdout1_46ck132 = 0 time = 665
.meas tran vdout1_46ck132 FIND v(dout1_46) AT=665.025n

* CHECK dout1_47 Vdout1_47ck132 = 0.9 time = 665
.meas tran vdout1_47ck132 FIND v(dout1_47) AT=665.025n

* CHECK dout1_48 Vdout1_48ck132 = 0.9 time = 665
.meas tran vdout1_48ck132 FIND v(dout1_48) AT=665.025n

* CHECK dout1_49 Vdout1_49ck132 = 0 time = 665
.meas tran vdout1_49ck132 FIND v(dout1_49) AT=665.025n

* CHECK dout1_50 Vdout1_50ck132 = 0.9 time = 665
.meas tran vdout1_50ck132 FIND v(dout1_50) AT=665.025n

* CHECK dout1_51 Vdout1_51ck132 = 0 time = 665
.meas tran vdout1_51ck132 FIND v(dout1_51) AT=665.025n

* CHECK dout1_52 Vdout1_52ck132 = 0.9 time = 665
.meas tran vdout1_52ck132 FIND v(dout1_52) AT=665.025n

* CHECK dout1_53 Vdout1_53ck132 = 0.9 time = 665
.meas tran vdout1_53ck132 FIND v(dout1_53) AT=665.025n

* CHECK dout1_54 Vdout1_54ck132 = 0.9 time = 665
.meas tran vdout1_54ck132 FIND v(dout1_54) AT=665.025n

* CHECK dout1_55 Vdout1_55ck132 = 0.9 time = 665
.meas tran vdout1_55ck132 FIND v(dout1_55) AT=665.025n

* CHECK dout1_56 Vdout1_56ck132 = 0.9 time = 665
.meas tran vdout1_56ck132 FIND v(dout1_56) AT=665.025n

* CHECK dout1_57 Vdout1_57ck132 = 0 time = 665
.meas tran vdout1_57ck132 FIND v(dout1_57) AT=665.025n

* CHECK dout1_58 Vdout1_58ck132 = 0 time = 665
.meas tran vdout1_58ck132 FIND v(dout1_58) AT=665.025n

* CHECK dout1_59 Vdout1_59ck132 = 0 time = 665
.meas tran vdout1_59ck132 FIND v(dout1_59) AT=665.025n

* CHECK dout1_60 Vdout1_60ck132 = 0 time = 665
.meas tran vdout1_60ck132 FIND v(dout1_60) AT=665.025n

* CHECK dout1_61 Vdout1_61ck132 = 0.9 time = 665
.meas tran vdout1_61ck132 FIND v(dout1_61) AT=665.025n

* CHECK dout1_62 Vdout1_62ck132 = 0.9 time = 665
.meas tran vdout1_62ck132 FIND v(dout1_62) AT=665.025n

* CHECK dout1_63 Vdout1_63ck132 = 0 time = 665
.meas tran vdout1_63ck132 FIND v(dout1_63) AT=665.025n

* CHECK dout1_64 Vdout1_64ck132 = 0 time = 665
.meas tran vdout1_64ck132 FIND v(dout1_64) AT=665.025n

* CHECK dout1_65 Vdout1_65ck132 = 0.9 time = 665
.meas tran vdout1_65ck132 FIND v(dout1_65) AT=665.025n

* CHECK dout1_66 Vdout1_66ck132 = 0 time = 665
.meas tran vdout1_66ck132 FIND v(dout1_66) AT=665.025n

* CHECK dout1_67 Vdout1_67ck132 = 0.9 time = 665
.meas tran vdout1_67ck132 FIND v(dout1_67) AT=665.025n

* CHECK dout1_68 Vdout1_68ck132 = 0.9 time = 665
.meas tran vdout1_68ck132 FIND v(dout1_68) AT=665.025n

* CHECK dout1_69 Vdout1_69ck132 = 0 time = 665
.meas tran vdout1_69ck132 FIND v(dout1_69) AT=665.025n

* CHECK dout1_70 Vdout1_70ck132 = 0 time = 665
.meas tran vdout1_70ck132 FIND v(dout1_70) AT=665.025n

* CHECK dout1_71 Vdout1_71ck132 = 0.9 time = 665
.meas tran vdout1_71ck132 FIND v(dout1_71) AT=665.025n

* CHECK dout1_72 Vdout1_72ck132 = 0.9 time = 665
.meas tran vdout1_72ck132 FIND v(dout1_72) AT=665.025n

* CHECK dout1_73 Vdout1_73ck132 = 0.9 time = 665
.meas tran vdout1_73ck132 FIND v(dout1_73) AT=665.025n

* CHECK dout1_74 Vdout1_74ck132 = 0 time = 665
.meas tran vdout1_74ck132 FIND v(dout1_74) AT=665.025n

* CHECK dout1_75 Vdout1_75ck132 = 0 time = 665
.meas tran vdout1_75ck132 FIND v(dout1_75) AT=665.025n

* CHECK dout1_76 Vdout1_76ck132 = 0.9 time = 665
.meas tran vdout1_76ck132 FIND v(dout1_76) AT=665.025n

* CHECK dout1_77 Vdout1_77ck132 = 0.9 time = 665
.meas tran vdout1_77ck132 FIND v(dout1_77) AT=665.025n

* CHECK dout1_78 Vdout1_78ck132 = 0 time = 665
.meas tran vdout1_78ck132 FIND v(dout1_78) AT=665.025n

* CHECK dout1_79 Vdout1_79ck132 = 0.9 time = 665
.meas tran vdout1_79ck132 FIND v(dout1_79) AT=665.025n

* CHECK dout1_80 Vdout1_80ck132 = 0.9 time = 665
.meas tran vdout1_80ck132 FIND v(dout1_80) AT=665.025n

* CHECK dout1_81 Vdout1_81ck132 = 0 time = 665
.meas tran vdout1_81ck132 FIND v(dout1_81) AT=665.025n

* CHECK dout1_82 Vdout1_82ck132 = 0 time = 665
.meas tran vdout1_82ck132 FIND v(dout1_82) AT=665.025n

* CHECK dout1_83 Vdout1_83ck132 = 0 time = 665
.meas tran vdout1_83ck132 FIND v(dout1_83) AT=665.025n

* CHECK dout1_84 Vdout1_84ck132 = 0 time = 665
.meas tran vdout1_84ck132 FIND v(dout1_84) AT=665.025n

* CHECK dout1_85 Vdout1_85ck132 = 0.9 time = 665
.meas tran vdout1_85ck132 FIND v(dout1_85) AT=665.025n

* CHECK dout1_86 Vdout1_86ck132 = 0.9 time = 665
.meas tran vdout1_86ck132 FIND v(dout1_86) AT=665.025n

* CHECK dout1_87 Vdout1_87ck132 = 0 time = 665
.meas tran vdout1_87ck132 FIND v(dout1_87) AT=665.025n

* CHECK dout1_88 Vdout1_88ck132 = 0 time = 665
.meas tran vdout1_88ck132 FIND v(dout1_88) AT=665.025n

* CHECK dout1_89 Vdout1_89ck132 = 0.9 time = 665
.meas tran vdout1_89ck132 FIND v(dout1_89) AT=665.025n

* CHECK dout1_90 Vdout1_90ck132 = 0.9 time = 665
.meas tran vdout1_90ck132 FIND v(dout1_90) AT=665.025n

* CHECK dout1_91 Vdout1_91ck132 = 0.9 time = 665
.meas tran vdout1_91ck132 FIND v(dout1_91) AT=665.025n

* CHECK dout1_92 Vdout1_92ck132 = 0 time = 665
.meas tran vdout1_92ck132 FIND v(dout1_92) AT=665.025n

* CHECK dout1_93 Vdout1_93ck132 = 0 time = 665
.meas tran vdout1_93ck132 FIND v(dout1_93) AT=665.025n

* CHECK dout1_94 Vdout1_94ck132 = 0 time = 665
.meas tran vdout1_94ck132 FIND v(dout1_94) AT=665.025n

* CHECK dout1_95 Vdout1_95ck132 = 0.9 time = 665
.meas tran vdout1_95ck132 FIND v(dout1_95) AT=665.025n

* CHECK dout1_96 Vdout1_96ck132 = 0 time = 665
.meas tran vdout1_96ck132 FIND v(dout1_96) AT=665.025n

* CHECK dout1_97 Vdout1_97ck132 = 0.9 time = 665
.meas tran vdout1_97ck132 FIND v(dout1_97) AT=665.025n

* CHECK dout1_98 Vdout1_98ck132 = 0.9 time = 665
.meas tran vdout1_98ck132 FIND v(dout1_98) AT=665.025n

* CHECK dout1_99 Vdout1_99ck132 = 0 time = 665
.meas tran vdout1_99ck132 FIND v(dout1_99) AT=665.025n

* CHECK dout1_100 Vdout1_100ck132 = 0.9 time = 665
.meas tran vdout1_100ck132 FIND v(dout1_100) AT=665.025n

* CHECK dout1_101 Vdout1_101ck132 = 0.9 time = 665
.meas tran vdout1_101ck132 FIND v(dout1_101) AT=665.025n

* CHECK dout1_102 Vdout1_102ck132 = 0 time = 665
.meas tran vdout1_102ck132 FIND v(dout1_102) AT=665.025n

* CHECK dout1_103 Vdout1_103ck132 = 0 time = 665
.meas tran vdout1_103ck132 FIND v(dout1_103) AT=665.025n

* CHECK dout1_104 Vdout1_104ck132 = 0.9 time = 665
.meas tran vdout1_104ck132 FIND v(dout1_104) AT=665.025n

* CHECK dout1_105 Vdout1_105ck132 = 0.9 time = 665
.meas tran vdout1_105ck132 FIND v(dout1_105) AT=665.025n

* CHECK dout1_106 Vdout1_106ck132 = 0.9 time = 665
.meas tran vdout1_106ck132 FIND v(dout1_106) AT=665.025n

* CHECK dout1_107 Vdout1_107ck132 = 0.9 time = 665
.meas tran vdout1_107ck132 FIND v(dout1_107) AT=665.025n

* CHECK dout1_108 Vdout1_108ck132 = 0.9 time = 665
.meas tran vdout1_108ck132 FIND v(dout1_108) AT=665.025n

* CHECK dout1_109 Vdout1_109ck132 = 0 time = 665
.meas tran vdout1_109ck132 FIND v(dout1_109) AT=665.025n

* CHECK dout1_110 Vdout1_110ck132 = 0.9 time = 665
.meas tran vdout1_110ck132 FIND v(dout1_110) AT=665.025n

* CHECK dout1_111 Vdout1_111ck132 = 0 time = 665
.meas tran vdout1_111ck132 FIND v(dout1_111) AT=665.025n

* CHECK dout1_112 Vdout1_112ck132 = 0.9 time = 665
.meas tran vdout1_112ck132 FIND v(dout1_112) AT=665.025n

* CHECK dout1_113 Vdout1_113ck132 = 0.9 time = 665
.meas tran vdout1_113ck132 FIND v(dout1_113) AT=665.025n

* CHECK dout1_114 Vdout1_114ck132 = 0 time = 665
.meas tran vdout1_114ck132 FIND v(dout1_114) AT=665.025n

* CHECK dout1_115 Vdout1_115ck132 = 0 time = 665
.meas tran vdout1_115ck132 FIND v(dout1_115) AT=665.025n

* CHECK dout1_116 Vdout1_116ck132 = 0 time = 665
.meas tran vdout1_116ck132 FIND v(dout1_116) AT=665.025n

* CHECK dout1_117 Vdout1_117ck132 = 0 time = 665
.meas tran vdout1_117ck132 FIND v(dout1_117) AT=665.025n

* CHECK dout1_118 Vdout1_118ck132 = 0.9 time = 665
.meas tran vdout1_118ck132 FIND v(dout1_118) AT=665.025n

* CHECK dout1_119 Vdout1_119ck132 = 0.9 time = 665
.meas tran vdout1_119ck132 FIND v(dout1_119) AT=665.025n

* CHECK dout1_0 Vdout1_0ck134 = 0 time = 675
.meas tran vdout1_0ck134 FIND v(dout1_0) AT=675.025n

* CHECK dout1_1 Vdout1_1ck134 = 0.9 time = 675
.meas tran vdout1_1ck134 FIND v(dout1_1) AT=675.025n

* CHECK dout1_2 Vdout1_2ck134 = 0 time = 675
.meas tran vdout1_2ck134 FIND v(dout1_2) AT=675.025n

* CHECK dout1_3 Vdout1_3ck134 = 0 time = 675
.meas tran vdout1_3ck134 FIND v(dout1_3) AT=675.025n

* CHECK dout1_4 Vdout1_4ck134 = 0 time = 675
.meas tran vdout1_4ck134 FIND v(dout1_4) AT=675.025n

* CHECK dout1_5 Vdout1_5ck134 = 0.9 time = 675
.meas tran vdout1_5ck134 FIND v(dout1_5) AT=675.025n

* CHECK dout1_6 Vdout1_6ck134 = 0 time = 675
.meas tran vdout1_6ck134 FIND v(dout1_6) AT=675.025n

* CHECK dout1_7 Vdout1_7ck134 = 0 time = 675
.meas tran vdout1_7ck134 FIND v(dout1_7) AT=675.025n

* CHECK dout1_8 Vdout1_8ck134 = 0.9 time = 675
.meas tran vdout1_8ck134 FIND v(dout1_8) AT=675.025n

* CHECK dout1_9 Vdout1_9ck134 = 0 time = 675
.meas tran vdout1_9ck134 FIND v(dout1_9) AT=675.025n

* CHECK dout1_10 Vdout1_10ck134 = 0.9 time = 675
.meas tran vdout1_10ck134 FIND v(dout1_10) AT=675.025n

* CHECK dout1_11 Vdout1_11ck134 = 0.9 time = 675
.meas tran vdout1_11ck134 FIND v(dout1_11) AT=675.025n

* CHECK dout1_12 Vdout1_12ck134 = 0.9 time = 675
.meas tran vdout1_12ck134 FIND v(dout1_12) AT=675.025n

* CHECK dout1_13 Vdout1_13ck134 = 0.9 time = 675
.meas tran vdout1_13ck134 FIND v(dout1_13) AT=675.025n

* CHECK dout1_14 Vdout1_14ck134 = 0.9 time = 675
.meas tran vdout1_14ck134 FIND v(dout1_14) AT=675.025n

* CHECK dout1_15 Vdout1_15ck134 = 0.9 time = 675
.meas tran vdout1_15ck134 FIND v(dout1_15) AT=675.025n

* CHECK dout1_16 Vdout1_16ck134 = 0.9 time = 675
.meas tran vdout1_16ck134 FIND v(dout1_16) AT=675.025n

* CHECK dout1_17 Vdout1_17ck134 = 0.9 time = 675
.meas tran vdout1_17ck134 FIND v(dout1_17) AT=675.025n

* CHECK dout1_18 Vdout1_18ck134 = 0 time = 675
.meas tran vdout1_18ck134 FIND v(dout1_18) AT=675.025n

* CHECK dout1_19 Vdout1_19ck134 = 0 time = 675
.meas tran vdout1_19ck134 FIND v(dout1_19) AT=675.025n

* CHECK dout1_20 Vdout1_20ck134 = 0.9 time = 675
.meas tran vdout1_20ck134 FIND v(dout1_20) AT=675.025n

* CHECK dout1_21 Vdout1_21ck134 = 0 time = 675
.meas tran vdout1_21ck134 FIND v(dout1_21) AT=675.025n

* CHECK dout1_22 Vdout1_22ck134 = 0 time = 675
.meas tran vdout1_22ck134 FIND v(dout1_22) AT=675.025n

* CHECK dout1_23 Vdout1_23ck134 = 0.9 time = 675
.meas tran vdout1_23ck134 FIND v(dout1_23) AT=675.025n

* CHECK dout1_24 Vdout1_24ck134 = 0.9 time = 675
.meas tran vdout1_24ck134 FIND v(dout1_24) AT=675.025n

* CHECK dout1_25 Vdout1_25ck134 = 0.9 time = 675
.meas tran vdout1_25ck134 FIND v(dout1_25) AT=675.025n

* CHECK dout1_26 Vdout1_26ck134 = 0 time = 675
.meas tran vdout1_26ck134 FIND v(dout1_26) AT=675.025n

* CHECK dout1_27 Vdout1_27ck134 = 0.9 time = 675
.meas tran vdout1_27ck134 FIND v(dout1_27) AT=675.025n

* CHECK dout1_28 Vdout1_28ck134 = 0.9 time = 675
.meas tran vdout1_28ck134 FIND v(dout1_28) AT=675.025n

* CHECK dout1_29 Vdout1_29ck134 = 0.9 time = 675
.meas tran vdout1_29ck134 FIND v(dout1_29) AT=675.025n

* CHECK dout1_30 Vdout1_30ck134 = 0.9 time = 675
.meas tran vdout1_30ck134 FIND v(dout1_30) AT=675.025n

* CHECK dout1_31 Vdout1_31ck134 = 0.9 time = 675
.meas tran vdout1_31ck134 FIND v(dout1_31) AT=675.025n

* CHECK dout1_32 Vdout1_32ck134 = 0 time = 675
.meas tran vdout1_32ck134 FIND v(dout1_32) AT=675.025n

* CHECK dout1_33 Vdout1_33ck134 = 0 time = 675
.meas tran vdout1_33ck134 FIND v(dout1_33) AT=675.025n

* CHECK dout1_34 Vdout1_34ck134 = 0.9 time = 675
.meas tran vdout1_34ck134 FIND v(dout1_34) AT=675.025n

* CHECK dout1_35 Vdout1_35ck134 = 0 time = 675
.meas tran vdout1_35ck134 FIND v(dout1_35) AT=675.025n

* CHECK dout1_36 Vdout1_36ck134 = 0 time = 675
.meas tran vdout1_36ck134 FIND v(dout1_36) AT=675.025n

* CHECK dout1_37 Vdout1_37ck134 = 0.9 time = 675
.meas tran vdout1_37ck134 FIND v(dout1_37) AT=675.025n

* CHECK dout1_38 Vdout1_38ck134 = 0 time = 675
.meas tran vdout1_38ck134 FIND v(dout1_38) AT=675.025n

* CHECK dout1_39 Vdout1_39ck134 = 0 time = 675
.meas tran vdout1_39ck134 FIND v(dout1_39) AT=675.025n

* CHECK dout1_40 Vdout1_40ck134 = 0 time = 675
.meas tran vdout1_40ck134 FIND v(dout1_40) AT=675.025n

* CHECK dout1_41 Vdout1_41ck134 = 0 time = 675
.meas tran vdout1_41ck134 FIND v(dout1_41) AT=675.025n

* CHECK dout1_42 Vdout1_42ck134 = 0 time = 675
.meas tran vdout1_42ck134 FIND v(dout1_42) AT=675.025n

* CHECK dout1_43 Vdout1_43ck134 = 0.9 time = 675
.meas tran vdout1_43ck134 FIND v(dout1_43) AT=675.025n

* CHECK dout1_44 Vdout1_44ck134 = 0 time = 675
.meas tran vdout1_44ck134 FIND v(dout1_44) AT=675.025n

* CHECK dout1_45 Vdout1_45ck134 = 0.9 time = 675
.meas tran vdout1_45ck134 FIND v(dout1_45) AT=675.025n

* CHECK dout1_46 Vdout1_46ck134 = 0 time = 675
.meas tran vdout1_46ck134 FIND v(dout1_46) AT=675.025n

* CHECK dout1_47 Vdout1_47ck134 = 0 time = 675
.meas tran vdout1_47ck134 FIND v(dout1_47) AT=675.025n

* CHECK dout1_48 Vdout1_48ck134 = 0 time = 675
.meas tran vdout1_48ck134 FIND v(dout1_48) AT=675.025n

* CHECK dout1_49 Vdout1_49ck134 = 0.9 time = 675
.meas tran vdout1_49ck134 FIND v(dout1_49) AT=675.025n

* CHECK dout1_50 Vdout1_50ck134 = 0.9 time = 675
.meas tran vdout1_50ck134 FIND v(dout1_50) AT=675.025n

* CHECK dout1_51 Vdout1_51ck134 = 0 time = 675
.meas tran vdout1_51ck134 FIND v(dout1_51) AT=675.025n

* CHECK dout1_52 Vdout1_52ck134 = 0.9 time = 675
.meas tran vdout1_52ck134 FIND v(dout1_52) AT=675.025n

* CHECK dout1_53 Vdout1_53ck134 = 0.9 time = 675
.meas tran vdout1_53ck134 FIND v(dout1_53) AT=675.025n

* CHECK dout1_54 Vdout1_54ck134 = 0 time = 675
.meas tran vdout1_54ck134 FIND v(dout1_54) AT=675.025n

* CHECK dout1_55 Vdout1_55ck134 = 0 time = 675
.meas tran vdout1_55ck134 FIND v(dout1_55) AT=675.025n

* CHECK dout1_56 Vdout1_56ck134 = 0 time = 675
.meas tran vdout1_56ck134 FIND v(dout1_56) AT=675.025n

* CHECK dout1_57 Vdout1_57ck134 = 0 time = 675
.meas tran vdout1_57ck134 FIND v(dout1_57) AT=675.025n

* CHECK dout1_58 Vdout1_58ck134 = 0.9 time = 675
.meas tran vdout1_58ck134 FIND v(dout1_58) AT=675.025n

* CHECK dout1_59 Vdout1_59ck134 = 0 time = 675
.meas tran vdout1_59ck134 FIND v(dout1_59) AT=675.025n

* CHECK dout1_60 Vdout1_60ck134 = 0.9 time = 675
.meas tran vdout1_60ck134 FIND v(dout1_60) AT=675.025n

* CHECK dout1_61 Vdout1_61ck134 = 0 time = 675
.meas tran vdout1_61ck134 FIND v(dout1_61) AT=675.025n

* CHECK dout1_62 Vdout1_62ck134 = 0.9 time = 675
.meas tran vdout1_62ck134 FIND v(dout1_62) AT=675.025n

* CHECK dout1_63 Vdout1_63ck134 = 0 time = 675
.meas tran vdout1_63ck134 FIND v(dout1_63) AT=675.025n

* CHECK dout1_64 Vdout1_64ck134 = 0 time = 675
.meas tran vdout1_64ck134 FIND v(dout1_64) AT=675.025n

* CHECK dout1_65 Vdout1_65ck134 = 0 time = 675
.meas tran vdout1_65ck134 FIND v(dout1_65) AT=675.025n

* CHECK dout1_66 Vdout1_66ck134 = 0.9 time = 675
.meas tran vdout1_66ck134 FIND v(dout1_66) AT=675.025n

* CHECK dout1_67 Vdout1_67ck134 = 0.9 time = 675
.meas tran vdout1_67ck134 FIND v(dout1_67) AT=675.025n

* CHECK dout1_68 Vdout1_68ck134 = 0.9 time = 675
.meas tran vdout1_68ck134 FIND v(dout1_68) AT=675.025n

* CHECK dout1_69 Vdout1_69ck134 = 0 time = 675
.meas tran vdout1_69ck134 FIND v(dout1_69) AT=675.025n

* CHECK dout1_70 Vdout1_70ck134 = 0 time = 675
.meas tran vdout1_70ck134 FIND v(dout1_70) AT=675.025n

* CHECK dout1_71 Vdout1_71ck134 = 0 time = 675
.meas tran vdout1_71ck134 FIND v(dout1_71) AT=675.025n

* CHECK dout1_72 Vdout1_72ck134 = 0 time = 675
.meas tran vdout1_72ck134 FIND v(dout1_72) AT=675.025n

* CHECK dout1_73 Vdout1_73ck134 = 0.9 time = 675
.meas tran vdout1_73ck134 FIND v(dout1_73) AT=675.025n

* CHECK dout1_74 Vdout1_74ck134 = 0.9 time = 675
.meas tran vdout1_74ck134 FIND v(dout1_74) AT=675.025n

* CHECK dout1_75 Vdout1_75ck134 = 0 time = 675
.meas tran vdout1_75ck134 FIND v(dout1_75) AT=675.025n

* CHECK dout1_76 Vdout1_76ck134 = 0 time = 675
.meas tran vdout1_76ck134 FIND v(dout1_76) AT=675.025n

* CHECK dout1_77 Vdout1_77ck134 = 0.9 time = 675
.meas tran vdout1_77ck134 FIND v(dout1_77) AT=675.025n

* CHECK dout1_78 Vdout1_78ck134 = 0 time = 675
.meas tran vdout1_78ck134 FIND v(dout1_78) AT=675.025n

* CHECK dout1_79 Vdout1_79ck134 = 0 time = 675
.meas tran vdout1_79ck134 FIND v(dout1_79) AT=675.025n

* CHECK dout1_80 Vdout1_80ck134 = 0 time = 675
.meas tran vdout1_80ck134 FIND v(dout1_80) AT=675.025n

* CHECK dout1_81 Vdout1_81ck134 = 0 time = 675
.meas tran vdout1_81ck134 FIND v(dout1_81) AT=675.025n

* CHECK dout1_82 Vdout1_82ck134 = 0.9 time = 675
.meas tran vdout1_82ck134 FIND v(dout1_82) AT=675.025n

* CHECK dout1_83 Vdout1_83ck134 = 0.9 time = 675
.meas tran vdout1_83ck134 FIND v(dout1_83) AT=675.025n

* CHECK dout1_84 Vdout1_84ck134 = 0.9 time = 675
.meas tran vdout1_84ck134 FIND v(dout1_84) AT=675.025n

* CHECK dout1_85 Vdout1_85ck134 = 0.9 time = 675
.meas tran vdout1_85ck134 FIND v(dout1_85) AT=675.025n

* CHECK dout1_86 Vdout1_86ck134 = 0.9 time = 675
.meas tran vdout1_86ck134 FIND v(dout1_86) AT=675.025n

* CHECK dout1_87 Vdout1_87ck134 = 0.9 time = 675
.meas tran vdout1_87ck134 FIND v(dout1_87) AT=675.025n

* CHECK dout1_88 Vdout1_88ck134 = 0 time = 675
.meas tran vdout1_88ck134 FIND v(dout1_88) AT=675.025n

* CHECK dout1_89 Vdout1_89ck134 = 0 time = 675
.meas tran vdout1_89ck134 FIND v(dout1_89) AT=675.025n

* CHECK dout1_90 Vdout1_90ck134 = 0 time = 675
.meas tran vdout1_90ck134 FIND v(dout1_90) AT=675.025n

* CHECK dout1_91 Vdout1_91ck134 = 0.9 time = 675
.meas tran vdout1_91ck134 FIND v(dout1_91) AT=675.025n

* CHECK dout1_92 Vdout1_92ck134 = 0.9 time = 675
.meas tran vdout1_92ck134 FIND v(dout1_92) AT=675.025n

* CHECK dout1_93 Vdout1_93ck134 = 0.9 time = 675
.meas tran vdout1_93ck134 FIND v(dout1_93) AT=675.025n

* CHECK dout1_94 Vdout1_94ck134 = 0.9 time = 675
.meas tran vdout1_94ck134 FIND v(dout1_94) AT=675.025n

* CHECK dout1_95 Vdout1_95ck134 = 0 time = 675
.meas tran vdout1_95ck134 FIND v(dout1_95) AT=675.025n

* CHECK dout1_96 Vdout1_96ck134 = 0.9 time = 675
.meas tran vdout1_96ck134 FIND v(dout1_96) AT=675.025n

* CHECK dout1_97 Vdout1_97ck134 = 0.9 time = 675
.meas tran vdout1_97ck134 FIND v(dout1_97) AT=675.025n

* CHECK dout1_98 Vdout1_98ck134 = 0 time = 675
.meas tran vdout1_98ck134 FIND v(dout1_98) AT=675.025n

* CHECK dout1_99 Vdout1_99ck134 = 0.9 time = 675
.meas tran vdout1_99ck134 FIND v(dout1_99) AT=675.025n

* CHECK dout1_100 Vdout1_100ck134 = 0.9 time = 675
.meas tran vdout1_100ck134 FIND v(dout1_100) AT=675.025n

* CHECK dout1_101 Vdout1_101ck134 = 0 time = 675
.meas tran vdout1_101ck134 FIND v(dout1_101) AT=675.025n

* CHECK dout1_102 Vdout1_102ck134 = 0.9 time = 675
.meas tran vdout1_102ck134 FIND v(dout1_102) AT=675.025n

* CHECK dout1_103 Vdout1_103ck134 = 0 time = 675
.meas tran vdout1_103ck134 FIND v(dout1_103) AT=675.025n

* CHECK dout1_104 Vdout1_104ck134 = 0.9 time = 675
.meas tran vdout1_104ck134 FIND v(dout1_104) AT=675.025n

* CHECK dout1_105 Vdout1_105ck134 = 0.9 time = 675
.meas tran vdout1_105ck134 FIND v(dout1_105) AT=675.025n

* CHECK dout1_106 Vdout1_106ck134 = 0 time = 675
.meas tran vdout1_106ck134 FIND v(dout1_106) AT=675.025n

* CHECK dout1_107 Vdout1_107ck134 = 0.9 time = 675
.meas tran vdout1_107ck134 FIND v(dout1_107) AT=675.025n

* CHECK dout1_108 Vdout1_108ck134 = 0 time = 675
.meas tran vdout1_108ck134 FIND v(dout1_108) AT=675.025n

* CHECK dout1_109 Vdout1_109ck134 = 0 time = 675
.meas tran vdout1_109ck134 FIND v(dout1_109) AT=675.025n

* CHECK dout1_110 Vdout1_110ck134 = 0.9 time = 675
.meas tran vdout1_110ck134 FIND v(dout1_110) AT=675.025n

* CHECK dout1_111 Vdout1_111ck134 = 0 time = 675
.meas tran vdout1_111ck134 FIND v(dout1_111) AT=675.025n

* CHECK dout1_112 Vdout1_112ck134 = 0.9 time = 675
.meas tran vdout1_112ck134 FIND v(dout1_112) AT=675.025n

* CHECK dout1_113 Vdout1_113ck134 = 0.9 time = 675
.meas tran vdout1_113ck134 FIND v(dout1_113) AT=675.025n

* CHECK dout1_114 Vdout1_114ck134 = 0.9 time = 675
.meas tran vdout1_114ck134 FIND v(dout1_114) AT=675.025n

* CHECK dout1_115 Vdout1_115ck134 = 0.9 time = 675
.meas tran vdout1_115ck134 FIND v(dout1_115) AT=675.025n

* CHECK dout1_116 Vdout1_116ck134 = 0.9 time = 675
.meas tran vdout1_116ck134 FIND v(dout1_116) AT=675.025n

* CHECK dout1_117 Vdout1_117ck134 = 0 time = 675
.meas tran vdout1_117ck134 FIND v(dout1_117) AT=675.025n

* CHECK dout1_118 Vdout1_118ck134 = 0.9 time = 675
.meas tran vdout1_118ck134 FIND v(dout1_118) AT=675.025n

* CHECK dout1_119 Vdout1_119ck134 = 0 time = 675
.meas tran vdout1_119ck134 FIND v(dout1_119) AT=675.025n

* CHECK dout1_0 Vdout1_0ck135 = 0 time = 680
.meas tran vdout1_0ck135 FIND v(dout1_0) AT=680.025n

* CHECK dout1_1 Vdout1_1ck135 = 0.9 time = 680
.meas tran vdout1_1ck135 FIND v(dout1_1) AT=680.025n

* CHECK dout1_2 Vdout1_2ck135 = 0 time = 680
.meas tran vdout1_2ck135 FIND v(dout1_2) AT=680.025n

* CHECK dout1_3 Vdout1_3ck135 = 0 time = 680
.meas tran vdout1_3ck135 FIND v(dout1_3) AT=680.025n

* CHECK dout1_4 Vdout1_4ck135 = 0 time = 680
.meas tran vdout1_4ck135 FIND v(dout1_4) AT=680.025n

* CHECK dout1_5 Vdout1_5ck135 = 0.9 time = 680
.meas tran vdout1_5ck135 FIND v(dout1_5) AT=680.025n

* CHECK dout1_6 Vdout1_6ck135 = 0 time = 680
.meas tran vdout1_6ck135 FIND v(dout1_6) AT=680.025n

* CHECK dout1_7 Vdout1_7ck135 = 0 time = 680
.meas tran vdout1_7ck135 FIND v(dout1_7) AT=680.025n

* CHECK dout1_8 Vdout1_8ck135 = 0.9 time = 680
.meas tran vdout1_8ck135 FIND v(dout1_8) AT=680.025n

* CHECK dout1_9 Vdout1_9ck135 = 0 time = 680
.meas tran vdout1_9ck135 FIND v(dout1_9) AT=680.025n

* CHECK dout1_10 Vdout1_10ck135 = 0.9 time = 680
.meas tran vdout1_10ck135 FIND v(dout1_10) AT=680.025n

* CHECK dout1_11 Vdout1_11ck135 = 0.9 time = 680
.meas tran vdout1_11ck135 FIND v(dout1_11) AT=680.025n

* CHECK dout1_12 Vdout1_12ck135 = 0.9 time = 680
.meas tran vdout1_12ck135 FIND v(dout1_12) AT=680.025n

* CHECK dout1_13 Vdout1_13ck135 = 0.9 time = 680
.meas tran vdout1_13ck135 FIND v(dout1_13) AT=680.025n

* CHECK dout1_14 Vdout1_14ck135 = 0.9 time = 680
.meas tran vdout1_14ck135 FIND v(dout1_14) AT=680.025n

* CHECK dout1_15 Vdout1_15ck135 = 0.9 time = 680
.meas tran vdout1_15ck135 FIND v(dout1_15) AT=680.025n

* CHECK dout1_16 Vdout1_16ck135 = 0.9 time = 680
.meas tran vdout1_16ck135 FIND v(dout1_16) AT=680.025n

* CHECK dout1_17 Vdout1_17ck135 = 0.9 time = 680
.meas tran vdout1_17ck135 FIND v(dout1_17) AT=680.025n

* CHECK dout1_18 Vdout1_18ck135 = 0 time = 680
.meas tran vdout1_18ck135 FIND v(dout1_18) AT=680.025n

* CHECK dout1_19 Vdout1_19ck135 = 0 time = 680
.meas tran vdout1_19ck135 FIND v(dout1_19) AT=680.025n

* CHECK dout1_20 Vdout1_20ck135 = 0.9 time = 680
.meas tran vdout1_20ck135 FIND v(dout1_20) AT=680.025n

* CHECK dout1_21 Vdout1_21ck135 = 0 time = 680
.meas tran vdout1_21ck135 FIND v(dout1_21) AT=680.025n

* CHECK dout1_22 Vdout1_22ck135 = 0 time = 680
.meas tran vdout1_22ck135 FIND v(dout1_22) AT=680.025n

* CHECK dout1_23 Vdout1_23ck135 = 0.9 time = 680
.meas tran vdout1_23ck135 FIND v(dout1_23) AT=680.025n

* CHECK dout1_24 Vdout1_24ck135 = 0.9 time = 680
.meas tran vdout1_24ck135 FIND v(dout1_24) AT=680.025n

* CHECK dout1_25 Vdout1_25ck135 = 0.9 time = 680
.meas tran vdout1_25ck135 FIND v(dout1_25) AT=680.025n

* CHECK dout1_26 Vdout1_26ck135 = 0 time = 680
.meas tran vdout1_26ck135 FIND v(dout1_26) AT=680.025n

* CHECK dout1_27 Vdout1_27ck135 = 0.9 time = 680
.meas tran vdout1_27ck135 FIND v(dout1_27) AT=680.025n

* CHECK dout1_28 Vdout1_28ck135 = 0.9 time = 680
.meas tran vdout1_28ck135 FIND v(dout1_28) AT=680.025n

* CHECK dout1_29 Vdout1_29ck135 = 0.9 time = 680
.meas tran vdout1_29ck135 FIND v(dout1_29) AT=680.025n

* CHECK dout1_30 Vdout1_30ck135 = 0.9 time = 680
.meas tran vdout1_30ck135 FIND v(dout1_30) AT=680.025n

* CHECK dout1_31 Vdout1_31ck135 = 0.9 time = 680
.meas tran vdout1_31ck135 FIND v(dout1_31) AT=680.025n

* CHECK dout1_32 Vdout1_32ck135 = 0 time = 680
.meas tran vdout1_32ck135 FIND v(dout1_32) AT=680.025n

* CHECK dout1_33 Vdout1_33ck135 = 0 time = 680
.meas tran vdout1_33ck135 FIND v(dout1_33) AT=680.025n

* CHECK dout1_34 Vdout1_34ck135 = 0.9 time = 680
.meas tran vdout1_34ck135 FIND v(dout1_34) AT=680.025n

* CHECK dout1_35 Vdout1_35ck135 = 0 time = 680
.meas tran vdout1_35ck135 FIND v(dout1_35) AT=680.025n

* CHECK dout1_36 Vdout1_36ck135 = 0 time = 680
.meas tran vdout1_36ck135 FIND v(dout1_36) AT=680.025n

* CHECK dout1_37 Vdout1_37ck135 = 0.9 time = 680
.meas tran vdout1_37ck135 FIND v(dout1_37) AT=680.025n

* CHECK dout1_38 Vdout1_38ck135 = 0 time = 680
.meas tran vdout1_38ck135 FIND v(dout1_38) AT=680.025n

* CHECK dout1_39 Vdout1_39ck135 = 0 time = 680
.meas tran vdout1_39ck135 FIND v(dout1_39) AT=680.025n

* CHECK dout1_40 Vdout1_40ck135 = 0 time = 680
.meas tran vdout1_40ck135 FIND v(dout1_40) AT=680.025n

* CHECK dout1_41 Vdout1_41ck135 = 0 time = 680
.meas tran vdout1_41ck135 FIND v(dout1_41) AT=680.025n

* CHECK dout1_42 Vdout1_42ck135 = 0 time = 680
.meas tran vdout1_42ck135 FIND v(dout1_42) AT=680.025n

* CHECK dout1_43 Vdout1_43ck135 = 0.9 time = 680
.meas tran vdout1_43ck135 FIND v(dout1_43) AT=680.025n

* CHECK dout1_44 Vdout1_44ck135 = 0 time = 680
.meas tran vdout1_44ck135 FIND v(dout1_44) AT=680.025n

* CHECK dout1_45 Vdout1_45ck135 = 0.9 time = 680
.meas tran vdout1_45ck135 FIND v(dout1_45) AT=680.025n

* CHECK dout1_46 Vdout1_46ck135 = 0 time = 680
.meas tran vdout1_46ck135 FIND v(dout1_46) AT=680.025n

* CHECK dout1_47 Vdout1_47ck135 = 0 time = 680
.meas tran vdout1_47ck135 FIND v(dout1_47) AT=680.025n

* CHECK dout1_48 Vdout1_48ck135 = 0 time = 680
.meas tran vdout1_48ck135 FIND v(dout1_48) AT=680.025n

* CHECK dout1_49 Vdout1_49ck135 = 0.9 time = 680
.meas tran vdout1_49ck135 FIND v(dout1_49) AT=680.025n

* CHECK dout1_50 Vdout1_50ck135 = 0.9 time = 680
.meas tran vdout1_50ck135 FIND v(dout1_50) AT=680.025n

* CHECK dout1_51 Vdout1_51ck135 = 0 time = 680
.meas tran vdout1_51ck135 FIND v(dout1_51) AT=680.025n

* CHECK dout1_52 Vdout1_52ck135 = 0.9 time = 680
.meas tran vdout1_52ck135 FIND v(dout1_52) AT=680.025n

* CHECK dout1_53 Vdout1_53ck135 = 0.9 time = 680
.meas tran vdout1_53ck135 FIND v(dout1_53) AT=680.025n

* CHECK dout1_54 Vdout1_54ck135 = 0 time = 680
.meas tran vdout1_54ck135 FIND v(dout1_54) AT=680.025n

* CHECK dout1_55 Vdout1_55ck135 = 0 time = 680
.meas tran vdout1_55ck135 FIND v(dout1_55) AT=680.025n

* CHECK dout1_56 Vdout1_56ck135 = 0 time = 680
.meas tran vdout1_56ck135 FIND v(dout1_56) AT=680.025n

* CHECK dout1_57 Vdout1_57ck135 = 0 time = 680
.meas tran vdout1_57ck135 FIND v(dout1_57) AT=680.025n

* CHECK dout1_58 Vdout1_58ck135 = 0.9 time = 680
.meas tran vdout1_58ck135 FIND v(dout1_58) AT=680.025n

* CHECK dout1_59 Vdout1_59ck135 = 0 time = 680
.meas tran vdout1_59ck135 FIND v(dout1_59) AT=680.025n

* CHECK dout1_60 Vdout1_60ck135 = 0.9 time = 680
.meas tran vdout1_60ck135 FIND v(dout1_60) AT=680.025n

* CHECK dout1_61 Vdout1_61ck135 = 0 time = 680
.meas tran vdout1_61ck135 FIND v(dout1_61) AT=680.025n

* CHECK dout1_62 Vdout1_62ck135 = 0.9 time = 680
.meas tran vdout1_62ck135 FIND v(dout1_62) AT=680.025n

* CHECK dout1_63 Vdout1_63ck135 = 0 time = 680
.meas tran vdout1_63ck135 FIND v(dout1_63) AT=680.025n

* CHECK dout1_64 Vdout1_64ck135 = 0 time = 680
.meas tran vdout1_64ck135 FIND v(dout1_64) AT=680.025n

* CHECK dout1_65 Vdout1_65ck135 = 0 time = 680
.meas tran vdout1_65ck135 FIND v(dout1_65) AT=680.025n

* CHECK dout1_66 Vdout1_66ck135 = 0.9 time = 680
.meas tran vdout1_66ck135 FIND v(dout1_66) AT=680.025n

* CHECK dout1_67 Vdout1_67ck135 = 0.9 time = 680
.meas tran vdout1_67ck135 FIND v(dout1_67) AT=680.025n

* CHECK dout1_68 Vdout1_68ck135 = 0.9 time = 680
.meas tran vdout1_68ck135 FIND v(dout1_68) AT=680.025n

* CHECK dout1_69 Vdout1_69ck135 = 0 time = 680
.meas tran vdout1_69ck135 FIND v(dout1_69) AT=680.025n

* CHECK dout1_70 Vdout1_70ck135 = 0 time = 680
.meas tran vdout1_70ck135 FIND v(dout1_70) AT=680.025n

* CHECK dout1_71 Vdout1_71ck135 = 0 time = 680
.meas tran vdout1_71ck135 FIND v(dout1_71) AT=680.025n

* CHECK dout1_72 Vdout1_72ck135 = 0 time = 680
.meas tran vdout1_72ck135 FIND v(dout1_72) AT=680.025n

* CHECK dout1_73 Vdout1_73ck135 = 0.9 time = 680
.meas tran vdout1_73ck135 FIND v(dout1_73) AT=680.025n

* CHECK dout1_74 Vdout1_74ck135 = 0.9 time = 680
.meas tran vdout1_74ck135 FIND v(dout1_74) AT=680.025n

* CHECK dout1_75 Vdout1_75ck135 = 0 time = 680
.meas tran vdout1_75ck135 FIND v(dout1_75) AT=680.025n

* CHECK dout1_76 Vdout1_76ck135 = 0 time = 680
.meas tran vdout1_76ck135 FIND v(dout1_76) AT=680.025n

* CHECK dout1_77 Vdout1_77ck135 = 0.9 time = 680
.meas tran vdout1_77ck135 FIND v(dout1_77) AT=680.025n

* CHECK dout1_78 Vdout1_78ck135 = 0 time = 680
.meas tran vdout1_78ck135 FIND v(dout1_78) AT=680.025n

* CHECK dout1_79 Vdout1_79ck135 = 0 time = 680
.meas tran vdout1_79ck135 FIND v(dout1_79) AT=680.025n

* CHECK dout1_80 Vdout1_80ck135 = 0 time = 680
.meas tran vdout1_80ck135 FIND v(dout1_80) AT=680.025n

* CHECK dout1_81 Vdout1_81ck135 = 0 time = 680
.meas tran vdout1_81ck135 FIND v(dout1_81) AT=680.025n

* CHECK dout1_82 Vdout1_82ck135 = 0.9 time = 680
.meas tran vdout1_82ck135 FIND v(dout1_82) AT=680.025n

* CHECK dout1_83 Vdout1_83ck135 = 0.9 time = 680
.meas tran vdout1_83ck135 FIND v(dout1_83) AT=680.025n

* CHECK dout1_84 Vdout1_84ck135 = 0.9 time = 680
.meas tran vdout1_84ck135 FIND v(dout1_84) AT=680.025n

* CHECK dout1_85 Vdout1_85ck135 = 0.9 time = 680
.meas tran vdout1_85ck135 FIND v(dout1_85) AT=680.025n

* CHECK dout1_86 Vdout1_86ck135 = 0.9 time = 680
.meas tran vdout1_86ck135 FIND v(dout1_86) AT=680.025n

* CHECK dout1_87 Vdout1_87ck135 = 0.9 time = 680
.meas tran vdout1_87ck135 FIND v(dout1_87) AT=680.025n

* CHECK dout1_88 Vdout1_88ck135 = 0 time = 680
.meas tran vdout1_88ck135 FIND v(dout1_88) AT=680.025n

* CHECK dout1_89 Vdout1_89ck135 = 0 time = 680
.meas tran vdout1_89ck135 FIND v(dout1_89) AT=680.025n

* CHECK dout1_90 Vdout1_90ck135 = 0 time = 680
.meas tran vdout1_90ck135 FIND v(dout1_90) AT=680.025n

* CHECK dout1_91 Vdout1_91ck135 = 0.9 time = 680
.meas tran vdout1_91ck135 FIND v(dout1_91) AT=680.025n

* CHECK dout1_92 Vdout1_92ck135 = 0.9 time = 680
.meas tran vdout1_92ck135 FIND v(dout1_92) AT=680.025n

* CHECK dout1_93 Vdout1_93ck135 = 0.9 time = 680
.meas tran vdout1_93ck135 FIND v(dout1_93) AT=680.025n

* CHECK dout1_94 Vdout1_94ck135 = 0.9 time = 680
.meas tran vdout1_94ck135 FIND v(dout1_94) AT=680.025n

* CHECK dout1_95 Vdout1_95ck135 = 0 time = 680
.meas tran vdout1_95ck135 FIND v(dout1_95) AT=680.025n

* CHECK dout1_96 Vdout1_96ck135 = 0.9 time = 680
.meas tran vdout1_96ck135 FIND v(dout1_96) AT=680.025n

* CHECK dout1_97 Vdout1_97ck135 = 0.9 time = 680
.meas tran vdout1_97ck135 FIND v(dout1_97) AT=680.025n

* CHECK dout1_98 Vdout1_98ck135 = 0 time = 680
.meas tran vdout1_98ck135 FIND v(dout1_98) AT=680.025n

* CHECK dout1_99 Vdout1_99ck135 = 0.9 time = 680
.meas tran vdout1_99ck135 FIND v(dout1_99) AT=680.025n

* CHECK dout1_100 Vdout1_100ck135 = 0.9 time = 680
.meas tran vdout1_100ck135 FIND v(dout1_100) AT=680.025n

* CHECK dout1_101 Vdout1_101ck135 = 0 time = 680
.meas tran vdout1_101ck135 FIND v(dout1_101) AT=680.025n

* CHECK dout1_102 Vdout1_102ck135 = 0.9 time = 680
.meas tran vdout1_102ck135 FIND v(dout1_102) AT=680.025n

* CHECK dout1_103 Vdout1_103ck135 = 0 time = 680
.meas tran vdout1_103ck135 FIND v(dout1_103) AT=680.025n

* CHECK dout1_104 Vdout1_104ck135 = 0.9 time = 680
.meas tran vdout1_104ck135 FIND v(dout1_104) AT=680.025n

* CHECK dout1_105 Vdout1_105ck135 = 0.9 time = 680
.meas tran vdout1_105ck135 FIND v(dout1_105) AT=680.025n

* CHECK dout1_106 Vdout1_106ck135 = 0 time = 680
.meas tran vdout1_106ck135 FIND v(dout1_106) AT=680.025n

* CHECK dout1_107 Vdout1_107ck135 = 0.9 time = 680
.meas tran vdout1_107ck135 FIND v(dout1_107) AT=680.025n

* CHECK dout1_108 Vdout1_108ck135 = 0 time = 680
.meas tran vdout1_108ck135 FIND v(dout1_108) AT=680.025n

* CHECK dout1_109 Vdout1_109ck135 = 0 time = 680
.meas tran vdout1_109ck135 FIND v(dout1_109) AT=680.025n

* CHECK dout1_110 Vdout1_110ck135 = 0.9 time = 680
.meas tran vdout1_110ck135 FIND v(dout1_110) AT=680.025n

* CHECK dout1_111 Vdout1_111ck135 = 0 time = 680
.meas tran vdout1_111ck135 FIND v(dout1_111) AT=680.025n

* CHECK dout1_112 Vdout1_112ck135 = 0.9 time = 680
.meas tran vdout1_112ck135 FIND v(dout1_112) AT=680.025n

* CHECK dout1_113 Vdout1_113ck135 = 0.9 time = 680
.meas tran vdout1_113ck135 FIND v(dout1_113) AT=680.025n

* CHECK dout1_114 Vdout1_114ck135 = 0.9 time = 680
.meas tran vdout1_114ck135 FIND v(dout1_114) AT=680.025n

* CHECK dout1_115 Vdout1_115ck135 = 0.9 time = 680
.meas tran vdout1_115ck135 FIND v(dout1_115) AT=680.025n

* CHECK dout1_116 Vdout1_116ck135 = 0.9 time = 680
.meas tran vdout1_116ck135 FIND v(dout1_116) AT=680.025n

* CHECK dout1_117 Vdout1_117ck135 = 0 time = 680
.meas tran vdout1_117ck135 FIND v(dout1_117) AT=680.025n

* CHECK dout1_118 Vdout1_118ck135 = 0.9 time = 680
.meas tran vdout1_118ck135 FIND v(dout1_118) AT=680.025n

* CHECK dout1_119 Vdout1_119ck135 = 0 time = 680
.meas tran vdout1_119ck135 FIND v(dout1_119) AT=680.025n

* CHECK dout1_0 Vdout1_0ck137 = 0.9 time = 690
.meas tran vdout1_0ck137 FIND v(dout1_0) AT=690.025n

* CHECK dout1_1 Vdout1_1ck137 = 0.9 time = 690
.meas tran vdout1_1ck137 FIND v(dout1_1) AT=690.025n

* CHECK dout1_2 Vdout1_2ck137 = 0.9 time = 690
.meas tran vdout1_2ck137 FIND v(dout1_2) AT=690.025n

* CHECK dout1_3 Vdout1_3ck137 = 0 time = 690
.meas tran vdout1_3ck137 FIND v(dout1_3) AT=690.025n

* CHECK dout1_4 Vdout1_4ck137 = 0 time = 690
.meas tran vdout1_4ck137 FIND v(dout1_4) AT=690.025n

* CHECK dout1_5 Vdout1_5ck137 = 0.9 time = 690
.meas tran vdout1_5ck137 FIND v(dout1_5) AT=690.025n

* CHECK dout1_6 Vdout1_6ck137 = 0 time = 690
.meas tran vdout1_6ck137 FIND v(dout1_6) AT=690.025n

* CHECK dout1_7 Vdout1_7ck137 = 0 time = 690
.meas tran vdout1_7ck137 FIND v(dout1_7) AT=690.025n

* CHECK dout1_8 Vdout1_8ck137 = 0 time = 690
.meas tran vdout1_8ck137 FIND v(dout1_8) AT=690.025n

* CHECK dout1_9 Vdout1_9ck137 = 0.9 time = 690
.meas tran vdout1_9ck137 FIND v(dout1_9) AT=690.025n

* CHECK dout1_10 Vdout1_10ck137 = 0.9 time = 690
.meas tran vdout1_10ck137 FIND v(dout1_10) AT=690.025n

* CHECK dout1_11 Vdout1_11ck137 = 0 time = 690
.meas tran vdout1_11ck137 FIND v(dout1_11) AT=690.025n

* CHECK dout1_12 Vdout1_12ck137 = 0.9 time = 690
.meas tran vdout1_12ck137 FIND v(dout1_12) AT=690.025n

* CHECK dout1_13 Vdout1_13ck137 = 0 time = 690
.meas tran vdout1_13ck137 FIND v(dout1_13) AT=690.025n

* CHECK dout1_14 Vdout1_14ck137 = 0.9 time = 690
.meas tran vdout1_14ck137 FIND v(dout1_14) AT=690.025n

* CHECK dout1_15 Vdout1_15ck137 = 0 time = 690
.meas tran vdout1_15ck137 FIND v(dout1_15) AT=690.025n

* CHECK dout1_16 Vdout1_16ck137 = 0 time = 690
.meas tran vdout1_16ck137 FIND v(dout1_16) AT=690.025n

* CHECK dout1_17 Vdout1_17ck137 = 0.9 time = 690
.meas tran vdout1_17ck137 FIND v(dout1_17) AT=690.025n

* CHECK dout1_18 Vdout1_18ck137 = 0.9 time = 690
.meas tran vdout1_18ck137 FIND v(dout1_18) AT=690.025n

* CHECK dout1_19 Vdout1_19ck137 = 0 time = 690
.meas tran vdout1_19ck137 FIND v(dout1_19) AT=690.025n

* CHECK dout1_20 Vdout1_20ck137 = 0.9 time = 690
.meas tran vdout1_20ck137 FIND v(dout1_20) AT=690.025n

* CHECK dout1_21 Vdout1_21ck137 = 0.9 time = 690
.meas tran vdout1_21ck137 FIND v(dout1_21) AT=690.025n

* CHECK dout1_22 Vdout1_22ck137 = 0 time = 690
.meas tran vdout1_22ck137 FIND v(dout1_22) AT=690.025n

* CHECK dout1_23 Vdout1_23ck137 = 0 time = 690
.meas tran vdout1_23ck137 FIND v(dout1_23) AT=690.025n

* CHECK dout1_24 Vdout1_24ck137 = 0.9 time = 690
.meas tran vdout1_24ck137 FIND v(dout1_24) AT=690.025n

* CHECK dout1_25 Vdout1_25ck137 = 0 time = 690
.meas tran vdout1_25ck137 FIND v(dout1_25) AT=690.025n

* CHECK dout1_26 Vdout1_26ck137 = 0.9 time = 690
.meas tran vdout1_26ck137 FIND v(dout1_26) AT=690.025n

* CHECK dout1_27 Vdout1_27ck137 = 0 time = 690
.meas tran vdout1_27ck137 FIND v(dout1_27) AT=690.025n

* CHECK dout1_28 Vdout1_28ck137 = 0 time = 690
.meas tran vdout1_28ck137 FIND v(dout1_28) AT=690.025n

* CHECK dout1_29 Vdout1_29ck137 = 0.9 time = 690
.meas tran vdout1_29ck137 FIND v(dout1_29) AT=690.025n

* CHECK dout1_30 Vdout1_30ck137 = 0.9 time = 690
.meas tran vdout1_30ck137 FIND v(dout1_30) AT=690.025n

* CHECK dout1_31 Vdout1_31ck137 = 0 time = 690
.meas tran vdout1_31ck137 FIND v(dout1_31) AT=690.025n

* CHECK dout1_32 Vdout1_32ck137 = 0 time = 690
.meas tran vdout1_32ck137 FIND v(dout1_32) AT=690.025n

* CHECK dout1_33 Vdout1_33ck137 = 0.9 time = 690
.meas tran vdout1_33ck137 FIND v(dout1_33) AT=690.025n

* CHECK dout1_34 Vdout1_34ck137 = 0.9 time = 690
.meas tran vdout1_34ck137 FIND v(dout1_34) AT=690.025n

* CHECK dout1_35 Vdout1_35ck137 = 0.9 time = 690
.meas tran vdout1_35ck137 FIND v(dout1_35) AT=690.025n

* CHECK dout1_36 Vdout1_36ck137 = 0 time = 690
.meas tran vdout1_36ck137 FIND v(dout1_36) AT=690.025n

* CHECK dout1_37 Vdout1_37ck137 = 0.9 time = 690
.meas tran vdout1_37ck137 FIND v(dout1_37) AT=690.025n

* CHECK dout1_38 Vdout1_38ck137 = 0 time = 690
.meas tran vdout1_38ck137 FIND v(dout1_38) AT=690.025n

* CHECK dout1_39 Vdout1_39ck137 = 0.9 time = 690
.meas tran vdout1_39ck137 FIND v(dout1_39) AT=690.025n

* CHECK dout1_40 Vdout1_40ck137 = 0.9 time = 690
.meas tran vdout1_40ck137 FIND v(dout1_40) AT=690.025n

* CHECK dout1_41 Vdout1_41ck137 = 0 time = 690
.meas tran vdout1_41ck137 FIND v(dout1_41) AT=690.025n

* CHECK dout1_42 Vdout1_42ck137 = 0.9 time = 690
.meas tran vdout1_42ck137 FIND v(dout1_42) AT=690.025n

* CHECK dout1_43 Vdout1_43ck137 = 0.9 time = 690
.meas tran vdout1_43ck137 FIND v(dout1_43) AT=690.025n

* CHECK dout1_44 Vdout1_44ck137 = 0 time = 690
.meas tran vdout1_44ck137 FIND v(dout1_44) AT=690.025n

* CHECK dout1_45 Vdout1_45ck137 = 0.9 time = 690
.meas tran vdout1_45ck137 FIND v(dout1_45) AT=690.025n

* CHECK dout1_46 Vdout1_46ck137 = 0 time = 690
.meas tran vdout1_46ck137 FIND v(dout1_46) AT=690.025n

* CHECK dout1_47 Vdout1_47ck137 = 0.9 time = 690
.meas tran vdout1_47ck137 FIND v(dout1_47) AT=690.025n

* CHECK dout1_48 Vdout1_48ck137 = 0.9 time = 690
.meas tran vdout1_48ck137 FIND v(dout1_48) AT=690.025n

* CHECK dout1_49 Vdout1_49ck137 = 0.9 time = 690
.meas tran vdout1_49ck137 FIND v(dout1_49) AT=690.025n

* CHECK dout1_50 Vdout1_50ck137 = 0.9 time = 690
.meas tran vdout1_50ck137 FIND v(dout1_50) AT=690.025n

* CHECK dout1_51 Vdout1_51ck137 = 0 time = 690
.meas tran vdout1_51ck137 FIND v(dout1_51) AT=690.025n

* CHECK dout1_52 Vdout1_52ck137 = 0.9 time = 690
.meas tran vdout1_52ck137 FIND v(dout1_52) AT=690.025n

* CHECK dout1_53 Vdout1_53ck137 = 0.9 time = 690
.meas tran vdout1_53ck137 FIND v(dout1_53) AT=690.025n

* CHECK dout1_54 Vdout1_54ck137 = 0.9 time = 690
.meas tran vdout1_54ck137 FIND v(dout1_54) AT=690.025n

* CHECK dout1_55 Vdout1_55ck137 = 0.9 time = 690
.meas tran vdout1_55ck137 FIND v(dout1_55) AT=690.025n

* CHECK dout1_56 Vdout1_56ck137 = 0 time = 690
.meas tran vdout1_56ck137 FIND v(dout1_56) AT=690.025n

* CHECK dout1_57 Vdout1_57ck137 = 0.9 time = 690
.meas tran vdout1_57ck137 FIND v(dout1_57) AT=690.025n

* CHECK dout1_58 Vdout1_58ck137 = 0.9 time = 690
.meas tran vdout1_58ck137 FIND v(dout1_58) AT=690.025n

* CHECK dout1_59 Vdout1_59ck137 = 0 time = 690
.meas tran vdout1_59ck137 FIND v(dout1_59) AT=690.025n

* CHECK dout1_60 Vdout1_60ck137 = 0 time = 690
.meas tran vdout1_60ck137 FIND v(dout1_60) AT=690.025n

* CHECK dout1_61 Vdout1_61ck137 = 0 time = 690
.meas tran vdout1_61ck137 FIND v(dout1_61) AT=690.025n

* CHECK dout1_62 Vdout1_62ck137 = 0 time = 690
.meas tran vdout1_62ck137 FIND v(dout1_62) AT=690.025n

* CHECK dout1_63 Vdout1_63ck137 = 0.9 time = 690
.meas tran vdout1_63ck137 FIND v(dout1_63) AT=690.025n

* CHECK dout1_64 Vdout1_64ck137 = 0.9 time = 690
.meas tran vdout1_64ck137 FIND v(dout1_64) AT=690.025n

* CHECK dout1_65 Vdout1_65ck137 = 0.9 time = 690
.meas tran vdout1_65ck137 FIND v(dout1_65) AT=690.025n

* CHECK dout1_66 Vdout1_66ck137 = 0.9 time = 690
.meas tran vdout1_66ck137 FIND v(dout1_66) AT=690.025n

* CHECK dout1_67 Vdout1_67ck137 = 0.9 time = 690
.meas tran vdout1_67ck137 FIND v(dout1_67) AT=690.025n

* CHECK dout1_68 Vdout1_68ck137 = 0.9 time = 690
.meas tran vdout1_68ck137 FIND v(dout1_68) AT=690.025n

* CHECK dout1_69 Vdout1_69ck137 = 0.9 time = 690
.meas tran vdout1_69ck137 FIND v(dout1_69) AT=690.025n

* CHECK dout1_70 Vdout1_70ck137 = 0.9 time = 690
.meas tran vdout1_70ck137 FIND v(dout1_70) AT=690.025n

* CHECK dout1_71 Vdout1_71ck137 = 0.9 time = 690
.meas tran vdout1_71ck137 FIND v(dout1_71) AT=690.025n

* CHECK dout1_72 Vdout1_72ck137 = 0 time = 690
.meas tran vdout1_72ck137 FIND v(dout1_72) AT=690.025n

* CHECK dout1_73 Vdout1_73ck137 = 0 time = 690
.meas tran vdout1_73ck137 FIND v(dout1_73) AT=690.025n

* CHECK dout1_74 Vdout1_74ck137 = 0 time = 690
.meas tran vdout1_74ck137 FIND v(dout1_74) AT=690.025n

* CHECK dout1_75 Vdout1_75ck137 = 0 time = 690
.meas tran vdout1_75ck137 FIND v(dout1_75) AT=690.025n

* CHECK dout1_76 Vdout1_76ck137 = 0.9 time = 690
.meas tran vdout1_76ck137 FIND v(dout1_76) AT=690.025n

* CHECK dout1_77 Vdout1_77ck137 = 0 time = 690
.meas tran vdout1_77ck137 FIND v(dout1_77) AT=690.025n

* CHECK dout1_78 Vdout1_78ck137 = 0.9 time = 690
.meas tran vdout1_78ck137 FIND v(dout1_78) AT=690.025n

* CHECK dout1_79 Vdout1_79ck137 = 0 time = 690
.meas tran vdout1_79ck137 FIND v(dout1_79) AT=690.025n

* CHECK dout1_80 Vdout1_80ck137 = 0 time = 690
.meas tran vdout1_80ck137 FIND v(dout1_80) AT=690.025n

* CHECK dout1_81 Vdout1_81ck137 = 0 time = 690
.meas tran vdout1_81ck137 FIND v(dout1_81) AT=690.025n

* CHECK dout1_82 Vdout1_82ck137 = 0 time = 690
.meas tran vdout1_82ck137 FIND v(dout1_82) AT=690.025n

* CHECK dout1_83 Vdout1_83ck137 = 0.9 time = 690
.meas tran vdout1_83ck137 FIND v(dout1_83) AT=690.025n

* CHECK dout1_84 Vdout1_84ck137 = 0 time = 690
.meas tran vdout1_84ck137 FIND v(dout1_84) AT=690.025n

* CHECK dout1_85 Vdout1_85ck137 = 0 time = 690
.meas tran vdout1_85ck137 FIND v(dout1_85) AT=690.025n

* CHECK dout1_86 Vdout1_86ck137 = 0 time = 690
.meas tran vdout1_86ck137 FIND v(dout1_86) AT=690.025n

* CHECK dout1_87 Vdout1_87ck137 = 0.9 time = 690
.meas tran vdout1_87ck137 FIND v(dout1_87) AT=690.025n

* CHECK dout1_88 Vdout1_88ck137 = 0 time = 690
.meas tran vdout1_88ck137 FIND v(dout1_88) AT=690.025n

* CHECK dout1_89 Vdout1_89ck137 = 0 time = 690
.meas tran vdout1_89ck137 FIND v(dout1_89) AT=690.025n

* CHECK dout1_90 Vdout1_90ck137 = 0.9 time = 690
.meas tran vdout1_90ck137 FIND v(dout1_90) AT=690.025n

* CHECK dout1_91 Vdout1_91ck137 = 0.9 time = 690
.meas tran vdout1_91ck137 FIND v(dout1_91) AT=690.025n

* CHECK dout1_92 Vdout1_92ck137 = 0.9 time = 690
.meas tran vdout1_92ck137 FIND v(dout1_92) AT=690.025n

* CHECK dout1_93 Vdout1_93ck137 = 0 time = 690
.meas tran vdout1_93ck137 FIND v(dout1_93) AT=690.025n

* CHECK dout1_94 Vdout1_94ck137 = 0.9 time = 690
.meas tran vdout1_94ck137 FIND v(dout1_94) AT=690.025n

* CHECK dout1_95 Vdout1_95ck137 = 0.9 time = 690
.meas tran vdout1_95ck137 FIND v(dout1_95) AT=690.025n

* CHECK dout1_96 Vdout1_96ck137 = 0 time = 690
.meas tran vdout1_96ck137 FIND v(dout1_96) AT=690.025n

* CHECK dout1_97 Vdout1_97ck137 = 0 time = 690
.meas tran vdout1_97ck137 FIND v(dout1_97) AT=690.025n

* CHECK dout1_98 Vdout1_98ck137 = 0.9 time = 690
.meas tran vdout1_98ck137 FIND v(dout1_98) AT=690.025n

* CHECK dout1_99 Vdout1_99ck137 = 0.9 time = 690
.meas tran vdout1_99ck137 FIND v(dout1_99) AT=690.025n

* CHECK dout1_100 Vdout1_100ck137 = 0.9 time = 690
.meas tran vdout1_100ck137 FIND v(dout1_100) AT=690.025n

* CHECK dout1_101 Vdout1_101ck137 = 0.9 time = 690
.meas tran vdout1_101ck137 FIND v(dout1_101) AT=690.025n

* CHECK dout1_102 Vdout1_102ck137 = 0.9 time = 690
.meas tran vdout1_102ck137 FIND v(dout1_102) AT=690.025n

* CHECK dout1_103 Vdout1_103ck137 = 0 time = 690
.meas tran vdout1_103ck137 FIND v(dout1_103) AT=690.025n

* CHECK dout1_104 Vdout1_104ck137 = 0.9 time = 690
.meas tran vdout1_104ck137 FIND v(dout1_104) AT=690.025n

* CHECK dout1_105 Vdout1_105ck137 = 0 time = 690
.meas tran vdout1_105ck137 FIND v(dout1_105) AT=690.025n

* CHECK dout1_106 Vdout1_106ck137 = 0.9 time = 690
.meas tran vdout1_106ck137 FIND v(dout1_106) AT=690.025n

* CHECK dout1_107 Vdout1_107ck137 = 0.9 time = 690
.meas tran vdout1_107ck137 FIND v(dout1_107) AT=690.025n

* CHECK dout1_108 Vdout1_108ck137 = 0.9 time = 690
.meas tran vdout1_108ck137 FIND v(dout1_108) AT=690.025n

* CHECK dout1_109 Vdout1_109ck137 = 0 time = 690
.meas tran vdout1_109ck137 FIND v(dout1_109) AT=690.025n

* CHECK dout1_110 Vdout1_110ck137 = 0 time = 690
.meas tran vdout1_110ck137 FIND v(dout1_110) AT=690.025n

* CHECK dout1_111 Vdout1_111ck137 = 0.9 time = 690
.meas tran vdout1_111ck137 FIND v(dout1_111) AT=690.025n

* CHECK dout1_112 Vdout1_112ck137 = 0 time = 690
.meas tran vdout1_112ck137 FIND v(dout1_112) AT=690.025n

* CHECK dout1_113 Vdout1_113ck137 = 0.9 time = 690
.meas tran vdout1_113ck137 FIND v(dout1_113) AT=690.025n

* CHECK dout1_114 Vdout1_114ck137 = 0 time = 690
.meas tran vdout1_114ck137 FIND v(dout1_114) AT=690.025n

* CHECK dout1_115 Vdout1_115ck137 = 0.9 time = 690
.meas tran vdout1_115ck137 FIND v(dout1_115) AT=690.025n

* CHECK dout1_116 Vdout1_116ck137 = 0 time = 690
.meas tran vdout1_116ck137 FIND v(dout1_116) AT=690.025n

* CHECK dout1_117 Vdout1_117ck137 = 0.9 time = 690
.meas tran vdout1_117ck137 FIND v(dout1_117) AT=690.025n

* CHECK dout1_118 Vdout1_118ck137 = 0 time = 690
.meas tran vdout1_118ck137 FIND v(dout1_118) AT=690.025n

* CHECK dout1_119 Vdout1_119ck137 = 0 time = 690
.meas tran vdout1_119ck137 FIND v(dout1_119) AT=690.025n

* CHECK dout1_0 Vdout1_0ck146 = 0.9 time = 735
.meas tran vdout1_0ck146 FIND v(dout1_0) AT=735.025n

* CHECK dout1_1 Vdout1_1ck146 = 0 time = 735
.meas tran vdout1_1ck146 FIND v(dout1_1) AT=735.025n

* CHECK dout1_2 Vdout1_2ck146 = 0 time = 735
.meas tran vdout1_2ck146 FIND v(dout1_2) AT=735.025n

* CHECK dout1_3 Vdout1_3ck146 = 0.9 time = 735
.meas tran vdout1_3ck146 FIND v(dout1_3) AT=735.025n

* CHECK dout1_4 Vdout1_4ck146 = 0 time = 735
.meas tran vdout1_4ck146 FIND v(dout1_4) AT=735.025n

* CHECK dout1_5 Vdout1_5ck146 = 0.9 time = 735
.meas tran vdout1_5ck146 FIND v(dout1_5) AT=735.025n

* CHECK dout1_6 Vdout1_6ck146 = 0.9 time = 735
.meas tran vdout1_6ck146 FIND v(dout1_6) AT=735.025n

* CHECK dout1_7 Vdout1_7ck146 = 0 time = 735
.meas tran vdout1_7ck146 FIND v(dout1_7) AT=735.025n

* CHECK dout1_8 Vdout1_8ck146 = 0 time = 735
.meas tran vdout1_8ck146 FIND v(dout1_8) AT=735.025n

* CHECK dout1_9 Vdout1_9ck146 = 0 time = 735
.meas tran vdout1_9ck146 FIND v(dout1_9) AT=735.025n

* CHECK dout1_10 Vdout1_10ck146 = 0.9 time = 735
.meas tran vdout1_10ck146 FIND v(dout1_10) AT=735.025n

* CHECK dout1_11 Vdout1_11ck146 = 0 time = 735
.meas tran vdout1_11ck146 FIND v(dout1_11) AT=735.025n

* CHECK dout1_12 Vdout1_12ck146 = 0.9 time = 735
.meas tran vdout1_12ck146 FIND v(dout1_12) AT=735.025n

* CHECK dout1_13 Vdout1_13ck146 = 0 time = 735
.meas tran vdout1_13ck146 FIND v(dout1_13) AT=735.025n

* CHECK dout1_14 Vdout1_14ck146 = 0 time = 735
.meas tran vdout1_14ck146 FIND v(dout1_14) AT=735.025n

* CHECK dout1_15 Vdout1_15ck146 = 0 time = 735
.meas tran vdout1_15ck146 FIND v(dout1_15) AT=735.025n

* CHECK dout1_16 Vdout1_16ck146 = 0 time = 735
.meas tran vdout1_16ck146 FIND v(dout1_16) AT=735.025n

* CHECK dout1_17 Vdout1_17ck146 = 0.9 time = 735
.meas tran vdout1_17ck146 FIND v(dout1_17) AT=735.025n

* CHECK dout1_18 Vdout1_18ck146 = 0.9 time = 735
.meas tran vdout1_18ck146 FIND v(dout1_18) AT=735.025n

* CHECK dout1_19 Vdout1_19ck146 = 0 time = 735
.meas tran vdout1_19ck146 FIND v(dout1_19) AT=735.025n

* CHECK dout1_20 Vdout1_20ck146 = 0 time = 735
.meas tran vdout1_20ck146 FIND v(dout1_20) AT=735.025n

* CHECK dout1_21 Vdout1_21ck146 = 0 time = 735
.meas tran vdout1_21ck146 FIND v(dout1_21) AT=735.025n

* CHECK dout1_22 Vdout1_22ck146 = 0.9 time = 735
.meas tran vdout1_22ck146 FIND v(dout1_22) AT=735.025n

* CHECK dout1_23 Vdout1_23ck146 = 0 time = 735
.meas tran vdout1_23ck146 FIND v(dout1_23) AT=735.025n

* CHECK dout1_24 Vdout1_24ck146 = 0.9 time = 735
.meas tran vdout1_24ck146 FIND v(dout1_24) AT=735.025n

* CHECK dout1_25 Vdout1_25ck146 = 0.9 time = 735
.meas tran vdout1_25ck146 FIND v(dout1_25) AT=735.025n

* CHECK dout1_26 Vdout1_26ck146 = 0.9 time = 735
.meas tran vdout1_26ck146 FIND v(dout1_26) AT=735.025n

* CHECK dout1_27 Vdout1_27ck146 = 0 time = 735
.meas tran vdout1_27ck146 FIND v(dout1_27) AT=735.025n

* CHECK dout1_28 Vdout1_28ck146 = 0 time = 735
.meas tran vdout1_28ck146 FIND v(dout1_28) AT=735.025n

* CHECK dout1_29 Vdout1_29ck146 = 0 time = 735
.meas tran vdout1_29ck146 FIND v(dout1_29) AT=735.025n

* CHECK dout1_30 Vdout1_30ck146 = 0 time = 735
.meas tran vdout1_30ck146 FIND v(dout1_30) AT=735.025n

* CHECK dout1_31 Vdout1_31ck146 = 0.9 time = 735
.meas tran vdout1_31ck146 FIND v(dout1_31) AT=735.025n

* CHECK dout1_32 Vdout1_32ck146 = 0 time = 735
.meas tran vdout1_32ck146 FIND v(dout1_32) AT=735.025n

* CHECK dout1_33 Vdout1_33ck146 = 0 time = 735
.meas tran vdout1_33ck146 FIND v(dout1_33) AT=735.025n

* CHECK dout1_34 Vdout1_34ck146 = 0.9 time = 735
.meas tran vdout1_34ck146 FIND v(dout1_34) AT=735.025n

* CHECK dout1_35 Vdout1_35ck146 = 0.9 time = 735
.meas tran vdout1_35ck146 FIND v(dout1_35) AT=735.025n

* CHECK dout1_36 Vdout1_36ck146 = 0 time = 735
.meas tran vdout1_36ck146 FIND v(dout1_36) AT=735.025n

* CHECK dout1_37 Vdout1_37ck146 = 0.9 time = 735
.meas tran vdout1_37ck146 FIND v(dout1_37) AT=735.025n

* CHECK dout1_38 Vdout1_38ck146 = 0 time = 735
.meas tran vdout1_38ck146 FIND v(dout1_38) AT=735.025n

* CHECK dout1_39 Vdout1_39ck146 = 0.9 time = 735
.meas tran vdout1_39ck146 FIND v(dout1_39) AT=735.025n

* CHECK dout1_40 Vdout1_40ck146 = 0.9 time = 735
.meas tran vdout1_40ck146 FIND v(dout1_40) AT=735.025n

* CHECK dout1_41 Vdout1_41ck146 = 0 time = 735
.meas tran vdout1_41ck146 FIND v(dout1_41) AT=735.025n

* CHECK dout1_42 Vdout1_42ck146 = 0 time = 735
.meas tran vdout1_42ck146 FIND v(dout1_42) AT=735.025n

* CHECK dout1_43 Vdout1_43ck146 = 0 time = 735
.meas tran vdout1_43ck146 FIND v(dout1_43) AT=735.025n

* CHECK dout1_44 Vdout1_44ck146 = 0 time = 735
.meas tran vdout1_44ck146 FIND v(dout1_44) AT=735.025n

* CHECK dout1_45 Vdout1_45ck146 = 0 time = 735
.meas tran vdout1_45ck146 FIND v(dout1_45) AT=735.025n

* CHECK dout1_46 Vdout1_46ck146 = 0.9 time = 735
.meas tran vdout1_46ck146 FIND v(dout1_46) AT=735.025n

* CHECK dout1_47 Vdout1_47ck146 = 0 time = 735
.meas tran vdout1_47ck146 FIND v(dout1_47) AT=735.025n

* CHECK dout1_48 Vdout1_48ck146 = 0.9 time = 735
.meas tran vdout1_48ck146 FIND v(dout1_48) AT=735.025n

* CHECK dout1_49 Vdout1_49ck146 = 0.9 time = 735
.meas tran vdout1_49ck146 FIND v(dout1_49) AT=735.025n

* CHECK dout1_50 Vdout1_50ck146 = 0 time = 735
.meas tran vdout1_50ck146 FIND v(dout1_50) AT=735.025n

* CHECK dout1_51 Vdout1_51ck146 = 0.9 time = 735
.meas tran vdout1_51ck146 FIND v(dout1_51) AT=735.025n

* CHECK dout1_52 Vdout1_52ck146 = 0.9 time = 735
.meas tran vdout1_52ck146 FIND v(dout1_52) AT=735.025n

* CHECK dout1_53 Vdout1_53ck146 = 0 time = 735
.meas tran vdout1_53ck146 FIND v(dout1_53) AT=735.025n

* CHECK dout1_54 Vdout1_54ck146 = 0 time = 735
.meas tran vdout1_54ck146 FIND v(dout1_54) AT=735.025n

* CHECK dout1_55 Vdout1_55ck146 = 0 time = 735
.meas tran vdout1_55ck146 FIND v(dout1_55) AT=735.025n

* CHECK dout1_56 Vdout1_56ck146 = 0 time = 735
.meas tran vdout1_56ck146 FIND v(dout1_56) AT=735.025n

* CHECK dout1_57 Vdout1_57ck146 = 0 time = 735
.meas tran vdout1_57ck146 FIND v(dout1_57) AT=735.025n

* CHECK dout1_58 Vdout1_58ck146 = 0.9 time = 735
.meas tran vdout1_58ck146 FIND v(dout1_58) AT=735.025n

* CHECK dout1_59 Vdout1_59ck146 = 0.9 time = 735
.meas tran vdout1_59ck146 FIND v(dout1_59) AT=735.025n

* CHECK dout1_60 Vdout1_60ck146 = 0.9 time = 735
.meas tran vdout1_60ck146 FIND v(dout1_60) AT=735.025n

* CHECK dout1_61 Vdout1_61ck146 = 0.9 time = 735
.meas tran vdout1_61ck146 FIND v(dout1_61) AT=735.025n

* CHECK dout1_62 Vdout1_62ck146 = 0.9 time = 735
.meas tran vdout1_62ck146 FIND v(dout1_62) AT=735.025n

* CHECK dout1_63 Vdout1_63ck146 = 0 time = 735
.meas tran vdout1_63ck146 FIND v(dout1_63) AT=735.025n

* CHECK dout1_64 Vdout1_64ck146 = 0.9 time = 735
.meas tran vdout1_64ck146 FIND v(dout1_64) AT=735.025n

* CHECK dout1_65 Vdout1_65ck146 = 0 time = 735
.meas tran vdout1_65ck146 FIND v(dout1_65) AT=735.025n

* CHECK dout1_66 Vdout1_66ck146 = 0 time = 735
.meas tran vdout1_66ck146 FIND v(dout1_66) AT=735.025n

* CHECK dout1_67 Vdout1_67ck146 = 0.9 time = 735
.meas tran vdout1_67ck146 FIND v(dout1_67) AT=735.025n

* CHECK dout1_68 Vdout1_68ck146 = 0.9 time = 735
.meas tran vdout1_68ck146 FIND v(dout1_68) AT=735.025n

* CHECK dout1_69 Vdout1_69ck146 = 0.9 time = 735
.meas tran vdout1_69ck146 FIND v(dout1_69) AT=735.025n

* CHECK dout1_70 Vdout1_70ck146 = 0 time = 735
.meas tran vdout1_70ck146 FIND v(dout1_70) AT=735.025n

* CHECK dout1_71 Vdout1_71ck146 = 0.9 time = 735
.meas tran vdout1_71ck146 FIND v(dout1_71) AT=735.025n

* CHECK dout1_72 Vdout1_72ck146 = 0 time = 735
.meas tran vdout1_72ck146 FIND v(dout1_72) AT=735.025n

* CHECK dout1_73 Vdout1_73ck146 = 0 time = 735
.meas tran vdout1_73ck146 FIND v(dout1_73) AT=735.025n

* CHECK dout1_74 Vdout1_74ck146 = 0.9 time = 735
.meas tran vdout1_74ck146 FIND v(dout1_74) AT=735.025n

* CHECK dout1_75 Vdout1_75ck146 = 0 time = 735
.meas tran vdout1_75ck146 FIND v(dout1_75) AT=735.025n

* CHECK dout1_76 Vdout1_76ck146 = 0.9 time = 735
.meas tran vdout1_76ck146 FIND v(dout1_76) AT=735.025n

* CHECK dout1_77 Vdout1_77ck146 = 0.9 time = 735
.meas tran vdout1_77ck146 FIND v(dout1_77) AT=735.025n

* CHECK dout1_78 Vdout1_78ck146 = 0.9 time = 735
.meas tran vdout1_78ck146 FIND v(dout1_78) AT=735.025n

* CHECK dout1_79 Vdout1_79ck146 = 0 time = 735
.meas tran vdout1_79ck146 FIND v(dout1_79) AT=735.025n

* CHECK dout1_80 Vdout1_80ck146 = 0.9 time = 735
.meas tran vdout1_80ck146 FIND v(dout1_80) AT=735.025n

* CHECK dout1_81 Vdout1_81ck146 = 0.9 time = 735
.meas tran vdout1_81ck146 FIND v(dout1_81) AT=735.025n

* CHECK dout1_82 Vdout1_82ck146 = 0 time = 735
.meas tran vdout1_82ck146 FIND v(dout1_82) AT=735.025n

* CHECK dout1_83 Vdout1_83ck146 = 0 time = 735
.meas tran vdout1_83ck146 FIND v(dout1_83) AT=735.025n

* CHECK dout1_84 Vdout1_84ck146 = 0.9 time = 735
.meas tran vdout1_84ck146 FIND v(dout1_84) AT=735.025n

* CHECK dout1_85 Vdout1_85ck146 = 0.9 time = 735
.meas tran vdout1_85ck146 FIND v(dout1_85) AT=735.025n

* CHECK dout1_86 Vdout1_86ck146 = 0 time = 735
.meas tran vdout1_86ck146 FIND v(dout1_86) AT=735.025n

* CHECK dout1_87 Vdout1_87ck146 = 0.9 time = 735
.meas tran vdout1_87ck146 FIND v(dout1_87) AT=735.025n

* CHECK dout1_88 Vdout1_88ck146 = 0 time = 735
.meas tran vdout1_88ck146 FIND v(dout1_88) AT=735.025n

* CHECK dout1_89 Vdout1_89ck146 = 0.9 time = 735
.meas tran vdout1_89ck146 FIND v(dout1_89) AT=735.025n

* CHECK dout1_90 Vdout1_90ck146 = 0 time = 735
.meas tran vdout1_90ck146 FIND v(dout1_90) AT=735.025n

* CHECK dout1_91 Vdout1_91ck146 = 0 time = 735
.meas tran vdout1_91ck146 FIND v(dout1_91) AT=735.025n

* CHECK dout1_92 Vdout1_92ck146 = 0 time = 735
.meas tran vdout1_92ck146 FIND v(dout1_92) AT=735.025n

* CHECK dout1_93 Vdout1_93ck146 = 0.9 time = 735
.meas tran vdout1_93ck146 FIND v(dout1_93) AT=735.025n

* CHECK dout1_94 Vdout1_94ck146 = 0 time = 735
.meas tran vdout1_94ck146 FIND v(dout1_94) AT=735.025n

* CHECK dout1_95 Vdout1_95ck146 = 0 time = 735
.meas tran vdout1_95ck146 FIND v(dout1_95) AT=735.025n

* CHECK dout1_96 Vdout1_96ck146 = 0.9 time = 735
.meas tran vdout1_96ck146 FIND v(dout1_96) AT=735.025n

* CHECK dout1_97 Vdout1_97ck146 = 0 time = 735
.meas tran vdout1_97ck146 FIND v(dout1_97) AT=735.025n

* CHECK dout1_98 Vdout1_98ck146 = 0.9 time = 735
.meas tran vdout1_98ck146 FIND v(dout1_98) AT=735.025n

* CHECK dout1_99 Vdout1_99ck146 = 0.9 time = 735
.meas tran vdout1_99ck146 FIND v(dout1_99) AT=735.025n

* CHECK dout1_100 Vdout1_100ck146 = 0 time = 735
.meas tran vdout1_100ck146 FIND v(dout1_100) AT=735.025n

* CHECK dout1_101 Vdout1_101ck146 = 0 time = 735
.meas tran vdout1_101ck146 FIND v(dout1_101) AT=735.025n

* CHECK dout1_102 Vdout1_102ck146 = 0 time = 735
.meas tran vdout1_102ck146 FIND v(dout1_102) AT=735.025n

* CHECK dout1_103 Vdout1_103ck146 = 0.9 time = 735
.meas tran vdout1_103ck146 FIND v(dout1_103) AT=735.025n

* CHECK dout1_104 Vdout1_104ck146 = 0 time = 735
.meas tran vdout1_104ck146 FIND v(dout1_104) AT=735.025n

* CHECK dout1_105 Vdout1_105ck146 = 0 time = 735
.meas tran vdout1_105ck146 FIND v(dout1_105) AT=735.025n

* CHECK dout1_106 Vdout1_106ck146 = 0 time = 735
.meas tran vdout1_106ck146 FIND v(dout1_106) AT=735.025n

* CHECK dout1_107 Vdout1_107ck146 = 0 time = 735
.meas tran vdout1_107ck146 FIND v(dout1_107) AT=735.025n

* CHECK dout1_108 Vdout1_108ck146 = 0 time = 735
.meas tran vdout1_108ck146 FIND v(dout1_108) AT=735.025n

* CHECK dout1_109 Vdout1_109ck146 = 0.9 time = 735
.meas tran vdout1_109ck146 FIND v(dout1_109) AT=735.025n

* CHECK dout1_110 Vdout1_110ck146 = 0 time = 735
.meas tran vdout1_110ck146 FIND v(dout1_110) AT=735.025n

* CHECK dout1_111 Vdout1_111ck146 = 0.9 time = 735
.meas tran vdout1_111ck146 FIND v(dout1_111) AT=735.025n

* CHECK dout1_112 Vdout1_112ck146 = 0.9 time = 735
.meas tran vdout1_112ck146 FIND v(dout1_112) AT=735.025n

* CHECK dout1_113 Vdout1_113ck146 = 0.9 time = 735
.meas tran vdout1_113ck146 FIND v(dout1_113) AT=735.025n

* CHECK dout1_114 Vdout1_114ck146 = 0 time = 735
.meas tran vdout1_114ck146 FIND v(dout1_114) AT=735.025n

* CHECK dout1_115 Vdout1_115ck146 = 0.9 time = 735
.meas tran vdout1_115ck146 FIND v(dout1_115) AT=735.025n

* CHECK dout1_116 Vdout1_116ck146 = 0.9 time = 735
.meas tran vdout1_116ck146 FIND v(dout1_116) AT=735.025n

* CHECK dout1_117 Vdout1_117ck146 = 0 time = 735
.meas tran vdout1_117ck146 FIND v(dout1_117) AT=735.025n

* CHECK dout1_118 Vdout1_118ck146 = 0.9 time = 735
.meas tran vdout1_118ck146 FIND v(dout1_118) AT=735.025n

* CHECK dout1_119 Vdout1_119ck146 = 0 time = 735
.meas tran vdout1_119ck146 FIND v(dout1_119) AT=735.025n

* CHECK dout1_0 Vdout1_0ck148 = 0.9 time = 745
.meas tran vdout1_0ck148 FIND v(dout1_0) AT=745.025n

* CHECK dout1_1 Vdout1_1ck148 = 0 time = 745
.meas tran vdout1_1ck148 FIND v(dout1_1) AT=745.025n

* CHECK dout1_2 Vdout1_2ck148 = 0 time = 745
.meas tran vdout1_2ck148 FIND v(dout1_2) AT=745.025n

* CHECK dout1_3 Vdout1_3ck148 = 0.9 time = 745
.meas tran vdout1_3ck148 FIND v(dout1_3) AT=745.025n

* CHECK dout1_4 Vdout1_4ck148 = 0.9 time = 745
.meas tran vdout1_4ck148 FIND v(dout1_4) AT=745.025n

* CHECK dout1_5 Vdout1_5ck148 = 0.9 time = 745
.meas tran vdout1_5ck148 FIND v(dout1_5) AT=745.025n

* CHECK dout1_6 Vdout1_6ck148 = 0 time = 745
.meas tran vdout1_6ck148 FIND v(dout1_6) AT=745.025n

* CHECK dout1_7 Vdout1_7ck148 = 0 time = 745
.meas tran vdout1_7ck148 FIND v(dout1_7) AT=745.025n

* CHECK dout1_8 Vdout1_8ck148 = 0 time = 745
.meas tran vdout1_8ck148 FIND v(dout1_8) AT=745.025n

* CHECK dout1_9 Vdout1_9ck148 = 0 time = 745
.meas tran vdout1_9ck148 FIND v(dout1_9) AT=745.025n

* CHECK dout1_10 Vdout1_10ck148 = 0.9 time = 745
.meas tran vdout1_10ck148 FIND v(dout1_10) AT=745.025n

* CHECK dout1_11 Vdout1_11ck148 = 0.9 time = 745
.meas tran vdout1_11ck148 FIND v(dout1_11) AT=745.025n

* CHECK dout1_12 Vdout1_12ck148 = 0 time = 745
.meas tran vdout1_12ck148 FIND v(dout1_12) AT=745.025n

* CHECK dout1_13 Vdout1_13ck148 = 0 time = 745
.meas tran vdout1_13ck148 FIND v(dout1_13) AT=745.025n

* CHECK dout1_14 Vdout1_14ck148 = 0 time = 745
.meas tran vdout1_14ck148 FIND v(dout1_14) AT=745.025n

* CHECK dout1_15 Vdout1_15ck148 = 0.9 time = 745
.meas tran vdout1_15ck148 FIND v(dout1_15) AT=745.025n

* CHECK dout1_16 Vdout1_16ck148 = 0 time = 745
.meas tran vdout1_16ck148 FIND v(dout1_16) AT=745.025n

* CHECK dout1_17 Vdout1_17ck148 = 0.9 time = 745
.meas tran vdout1_17ck148 FIND v(dout1_17) AT=745.025n

* CHECK dout1_18 Vdout1_18ck148 = 0.9 time = 745
.meas tran vdout1_18ck148 FIND v(dout1_18) AT=745.025n

* CHECK dout1_19 Vdout1_19ck148 = 0 time = 745
.meas tran vdout1_19ck148 FIND v(dout1_19) AT=745.025n

* CHECK dout1_20 Vdout1_20ck148 = 0.9 time = 745
.meas tran vdout1_20ck148 FIND v(dout1_20) AT=745.025n

* CHECK dout1_21 Vdout1_21ck148 = 0.9 time = 745
.meas tran vdout1_21ck148 FIND v(dout1_21) AT=745.025n

* CHECK dout1_22 Vdout1_22ck148 = 0.9 time = 745
.meas tran vdout1_22ck148 FIND v(dout1_22) AT=745.025n

* CHECK dout1_23 Vdout1_23ck148 = 0 time = 745
.meas tran vdout1_23ck148 FIND v(dout1_23) AT=745.025n

* CHECK dout1_24 Vdout1_24ck148 = 0.9 time = 745
.meas tran vdout1_24ck148 FIND v(dout1_24) AT=745.025n

* CHECK dout1_25 Vdout1_25ck148 = 0.9 time = 745
.meas tran vdout1_25ck148 FIND v(dout1_25) AT=745.025n

* CHECK dout1_26 Vdout1_26ck148 = 0 time = 745
.meas tran vdout1_26ck148 FIND v(dout1_26) AT=745.025n

* CHECK dout1_27 Vdout1_27ck148 = 0 time = 745
.meas tran vdout1_27ck148 FIND v(dout1_27) AT=745.025n

* CHECK dout1_28 Vdout1_28ck148 = 0.9 time = 745
.meas tran vdout1_28ck148 FIND v(dout1_28) AT=745.025n

* CHECK dout1_29 Vdout1_29ck148 = 0 time = 745
.meas tran vdout1_29ck148 FIND v(dout1_29) AT=745.025n

* CHECK dout1_30 Vdout1_30ck148 = 0.9 time = 745
.meas tran vdout1_30ck148 FIND v(dout1_30) AT=745.025n

* CHECK dout1_31 Vdout1_31ck148 = 0.9 time = 745
.meas tran vdout1_31ck148 FIND v(dout1_31) AT=745.025n

* CHECK dout1_32 Vdout1_32ck148 = 0 time = 745
.meas tran vdout1_32ck148 FIND v(dout1_32) AT=745.025n

* CHECK dout1_33 Vdout1_33ck148 = 0 time = 745
.meas tran vdout1_33ck148 FIND v(dout1_33) AT=745.025n

* CHECK dout1_34 Vdout1_34ck148 = 0 time = 745
.meas tran vdout1_34ck148 FIND v(dout1_34) AT=745.025n

* CHECK dout1_35 Vdout1_35ck148 = 0 time = 745
.meas tran vdout1_35ck148 FIND v(dout1_35) AT=745.025n

* CHECK dout1_36 Vdout1_36ck148 = 0 time = 745
.meas tran vdout1_36ck148 FIND v(dout1_36) AT=745.025n

* CHECK dout1_37 Vdout1_37ck148 = 0 time = 745
.meas tran vdout1_37ck148 FIND v(dout1_37) AT=745.025n

* CHECK dout1_38 Vdout1_38ck148 = 0 time = 745
.meas tran vdout1_38ck148 FIND v(dout1_38) AT=745.025n

* CHECK dout1_39 Vdout1_39ck148 = 0.9 time = 745
.meas tran vdout1_39ck148 FIND v(dout1_39) AT=745.025n

* CHECK dout1_40 Vdout1_40ck148 = 0.9 time = 745
.meas tran vdout1_40ck148 FIND v(dout1_40) AT=745.025n

* CHECK dout1_41 Vdout1_41ck148 = 0 time = 745
.meas tran vdout1_41ck148 FIND v(dout1_41) AT=745.025n

* CHECK dout1_42 Vdout1_42ck148 = 0 time = 745
.meas tran vdout1_42ck148 FIND v(dout1_42) AT=745.025n

* CHECK dout1_43 Vdout1_43ck148 = 0 time = 745
.meas tran vdout1_43ck148 FIND v(dout1_43) AT=745.025n

* CHECK dout1_44 Vdout1_44ck148 = 0 time = 745
.meas tran vdout1_44ck148 FIND v(dout1_44) AT=745.025n

* CHECK dout1_45 Vdout1_45ck148 = 0.9 time = 745
.meas tran vdout1_45ck148 FIND v(dout1_45) AT=745.025n

* CHECK dout1_46 Vdout1_46ck148 = 0.9 time = 745
.meas tran vdout1_46ck148 FIND v(dout1_46) AT=745.025n

* CHECK dout1_47 Vdout1_47ck148 = 0 time = 745
.meas tran vdout1_47ck148 FIND v(dout1_47) AT=745.025n

* CHECK dout1_48 Vdout1_48ck148 = 0.9 time = 745
.meas tran vdout1_48ck148 FIND v(dout1_48) AT=745.025n

* CHECK dout1_49 Vdout1_49ck148 = 0 time = 745
.meas tran vdout1_49ck148 FIND v(dout1_49) AT=745.025n

* CHECK dout1_50 Vdout1_50ck148 = 0.9 time = 745
.meas tran vdout1_50ck148 FIND v(dout1_50) AT=745.025n

* CHECK dout1_51 Vdout1_51ck148 = 0 time = 745
.meas tran vdout1_51ck148 FIND v(dout1_51) AT=745.025n

* CHECK dout1_52 Vdout1_52ck148 = 0 time = 745
.meas tran vdout1_52ck148 FIND v(dout1_52) AT=745.025n

* CHECK dout1_53 Vdout1_53ck148 = 0 time = 745
.meas tran vdout1_53ck148 FIND v(dout1_53) AT=745.025n

* CHECK dout1_54 Vdout1_54ck148 = 0.9 time = 745
.meas tran vdout1_54ck148 FIND v(dout1_54) AT=745.025n

* CHECK dout1_55 Vdout1_55ck148 = 0 time = 745
.meas tran vdout1_55ck148 FIND v(dout1_55) AT=745.025n

* CHECK dout1_56 Vdout1_56ck148 = 0 time = 745
.meas tran vdout1_56ck148 FIND v(dout1_56) AT=745.025n

* CHECK dout1_57 Vdout1_57ck148 = 0.9 time = 745
.meas tran vdout1_57ck148 FIND v(dout1_57) AT=745.025n

* CHECK dout1_58 Vdout1_58ck148 = 0 time = 745
.meas tran vdout1_58ck148 FIND v(dout1_58) AT=745.025n

* CHECK dout1_59 Vdout1_59ck148 = 0 time = 745
.meas tran vdout1_59ck148 FIND v(dout1_59) AT=745.025n

* CHECK dout1_60 Vdout1_60ck148 = 0.9 time = 745
.meas tran vdout1_60ck148 FIND v(dout1_60) AT=745.025n

* CHECK dout1_61 Vdout1_61ck148 = 0.9 time = 745
.meas tran vdout1_61ck148 FIND v(dout1_61) AT=745.025n

* CHECK dout1_62 Vdout1_62ck148 = 0.9 time = 745
.meas tran vdout1_62ck148 FIND v(dout1_62) AT=745.025n

* CHECK dout1_63 Vdout1_63ck148 = 0 time = 745
.meas tran vdout1_63ck148 FIND v(dout1_63) AT=745.025n

* CHECK dout1_64 Vdout1_64ck148 = 0 time = 745
.meas tran vdout1_64ck148 FIND v(dout1_64) AT=745.025n

* CHECK dout1_65 Vdout1_65ck148 = 0.9 time = 745
.meas tran vdout1_65ck148 FIND v(dout1_65) AT=745.025n

* CHECK dout1_66 Vdout1_66ck148 = 0 time = 745
.meas tran vdout1_66ck148 FIND v(dout1_66) AT=745.025n

* CHECK dout1_67 Vdout1_67ck148 = 0 time = 745
.meas tran vdout1_67ck148 FIND v(dout1_67) AT=745.025n

* CHECK dout1_68 Vdout1_68ck148 = 0 time = 745
.meas tran vdout1_68ck148 FIND v(dout1_68) AT=745.025n

* CHECK dout1_69 Vdout1_69ck148 = 0.9 time = 745
.meas tran vdout1_69ck148 FIND v(dout1_69) AT=745.025n

* CHECK dout1_70 Vdout1_70ck148 = 0.9 time = 745
.meas tran vdout1_70ck148 FIND v(dout1_70) AT=745.025n

* CHECK dout1_71 Vdout1_71ck148 = 0 time = 745
.meas tran vdout1_71ck148 FIND v(dout1_71) AT=745.025n

* CHECK dout1_72 Vdout1_72ck148 = 0.9 time = 745
.meas tran vdout1_72ck148 FIND v(dout1_72) AT=745.025n

* CHECK dout1_73 Vdout1_73ck148 = 0 time = 745
.meas tran vdout1_73ck148 FIND v(dout1_73) AT=745.025n

* CHECK dout1_74 Vdout1_74ck148 = 0 time = 745
.meas tran vdout1_74ck148 FIND v(dout1_74) AT=745.025n

* CHECK dout1_75 Vdout1_75ck148 = 0 time = 745
.meas tran vdout1_75ck148 FIND v(dout1_75) AT=745.025n

* CHECK dout1_76 Vdout1_76ck148 = 0 time = 745
.meas tran vdout1_76ck148 FIND v(dout1_76) AT=745.025n

* CHECK dout1_77 Vdout1_77ck148 = 0 time = 745
.meas tran vdout1_77ck148 FIND v(dout1_77) AT=745.025n

* CHECK dout1_78 Vdout1_78ck148 = 0.9 time = 745
.meas tran vdout1_78ck148 FIND v(dout1_78) AT=745.025n

* CHECK dout1_79 Vdout1_79ck148 = 0.9 time = 745
.meas tran vdout1_79ck148 FIND v(dout1_79) AT=745.025n

* CHECK dout1_80 Vdout1_80ck148 = 0.9 time = 745
.meas tran vdout1_80ck148 FIND v(dout1_80) AT=745.025n

* CHECK dout1_81 Vdout1_81ck148 = 0 time = 745
.meas tran vdout1_81ck148 FIND v(dout1_81) AT=745.025n

* CHECK dout1_82 Vdout1_82ck148 = 0 time = 745
.meas tran vdout1_82ck148 FIND v(dout1_82) AT=745.025n

* CHECK dout1_83 Vdout1_83ck148 = 0.9 time = 745
.meas tran vdout1_83ck148 FIND v(dout1_83) AT=745.025n

* CHECK dout1_84 Vdout1_84ck148 = 0.9 time = 745
.meas tran vdout1_84ck148 FIND v(dout1_84) AT=745.025n

* CHECK dout1_85 Vdout1_85ck148 = 0.9 time = 745
.meas tran vdout1_85ck148 FIND v(dout1_85) AT=745.025n

* CHECK dout1_86 Vdout1_86ck148 = 0.9 time = 745
.meas tran vdout1_86ck148 FIND v(dout1_86) AT=745.025n

* CHECK dout1_87 Vdout1_87ck148 = 0 time = 745
.meas tran vdout1_87ck148 FIND v(dout1_87) AT=745.025n

* CHECK dout1_88 Vdout1_88ck148 = 0 time = 745
.meas tran vdout1_88ck148 FIND v(dout1_88) AT=745.025n

* CHECK dout1_89 Vdout1_89ck148 = 0.9 time = 745
.meas tran vdout1_89ck148 FIND v(dout1_89) AT=745.025n

* CHECK dout1_90 Vdout1_90ck148 = 0 time = 745
.meas tran vdout1_90ck148 FIND v(dout1_90) AT=745.025n

* CHECK dout1_91 Vdout1_91ck148 = 0.9 time = 745
.meas tran vdout1_91ck148 FIND v(dout1_91) AT=745.025n

* CHECK dout1_92 Vdout1_92ck148 = 0 time = 745
.meas tran vdout1_92ck148 FIND v(dout1_92) AT=745.025n

* CHECK dout1_93 Vdout1_93ck148 = 0 time = 745
.meas tran vdout1_93ck148 FIND v(dout1_93) AT=745.025n

* CHECK dout1_94 Vdout1_94ck148 = 0.9 time = 745
.meas tran vdout1_94ck148 FIND v(dout1_94) AT=745.025n

* CHECK dout1_95 Vdout1_95ck148 = 0 time = 745
.meas tran vdout1_95ck148 FIND v(dout1_95) AT=745.025n

* CHECK dout1_96 Vdout1_96ck148 = 0 time = 745
.meas tran vdout1_96ck148 FIND v(dout1_96) AT=745.025n

* CHECK dout1_97 Vdout1_97ck148 = 0.9 time = 745
.meas tran vdout1_97ck148 FIND v(dout1_97) AT=745.025n

* CHECK dout1_98 Vdout1_98ck148 = 0 time = 745
.meas tran vdout1_98ck148 FIND v(dout1_98) AT=745.025n

* CHECK dout1_99 Vdout1_99ck148 = 0.9 time = 745
.meas tran vdout1_99ck148 FIND v(dout1_99) AT=745.025n

* CHECK dout1_100 Vdout1_100ck148 = 0 time = 745
.meas tran vdout1_100ck148 FIND v(dout1_100) AT=745.025n

* CHECK dout1_101 Vdout1_101ck148 = 0.9 time = 745
.meas tran vdout1_101ck148 FIND v(dout1_101) AT=745.025n

* CHECK dout1_102 Vdout1_102ck148 = 0 time = 745
.meas tran vdout1_102ck148 FIND v(dout1_102) AT=745.025n

* CHECK dout1_103 Vdout1_103ck148 = 0 time = 745
.meas tran vdout1_103ck148 FIND v(dout1_103) AT=745.025n

* CHECK dout1_104 Vdout1_104ck148 = 0.9 time = 745
.meas tran vdout1_104ck148 FIND v(dout1_104) AT=745.025n

* CHECK dout1_105 Vdout1_105ck148 = 0 time = 745
.meas tran vdout1_105ck148 FIND v(dout1_105) AT=745.025n

* CHECK dout1_106 Vdout1_106ck148 = 0 time = 745
.meas tran vdout1_106ck148 FIND v(dout1_106) AT=745.025n

* CHECK dout1_107 Vdout1_107ck148 = 0 time = 745
.meas tran vdout1_107ck148 FIND v(dout1_107) AT=745.025n

* CHECK dout1_108 Vdout1_108ck148 = 0 time = 745
.meas tran vdout1_108ck148 FIND v(dout1_108) AT=745.025n

* CHECK dout1_109 Vdout1_109ck148 = 0.9 time = 745
.meas tran vdout1_109ck148 FIND v(dout1_109) AT=745.025n

* CHECK dout1_110 Vdout1_110ck148 = 0 time = 745
.meas tran vdout1_110ck148 FIND v(dout1_110) AT=745.025n

* CHECK dout1_111 Vdout1_111ck148 = 0 time = 745
.meas tran vdout1_111ck148 FIND v(dout1_111) AT=745.025n

* CHECK dout1_112 Vdout1_112ck148 = 0.9 time = 745
.meas tran vdout1_112ck148 FIND v(dout1_112) AT=745.025n

* CHECK dout1_113 Vdout1_113ck148 = 0.9 time = 745
.meas tran vdout1_113ck148 FIND v(dout1_113) AT=745.025n

* CHECK dout1_114 Vdout1_114ck148 = 0.9 time = 745
.meas tran vdout1_114ck148 FIND v(dout1_114) AT=745.025n

* CHECK dout1_115 Vdout1_115ck148 = 0.9 time = 745
.meas tran vdout1_115ck148 FIND v(dout1_115) AT=745.025n

* CHECK dout1_116 Vdout1_116ck148 = 0 time = 745
.meas tran vdout1_116ck148 FIND v(dout1_116) AT=745.025n

* CHECK dout1_117 Vdout1_117ck148 = 0.9 time = 745
.meas tran vdout1_117ck148 FIND v(dout1_117) AT=745.025n

* CHECK dout1_118 Vdout1_118ck148 = 0 time = 745
.meas tran vdout1_118ck148 FIND v(dout1_118) AT=745.025n

* CHECK dout1_119 Vdout1_119ck148 = 0 time = 745
.meas tran vdout1_119ck148 FIND v(dout1_119) AT=745.025n

* CHECK dout1_0 Vdout1_0ck152 = 0.9 time = 765
.meas tran vdout1_0ck152 FIND v(dout1_0) AT=765.025n

* CHECK dout1_1 Vdout1_1ck152 = 0.9 time = 765
.meas tran vdout1_1ck152 FIND v(dout1_1) AT=765.025n

* CHECK dout1_2 Vdout1_2ck152 = 0.9 time = 765
.meas tran vdout1_2ck152 FIND v(dout1_2) AT=765.025n

* CHECK dout1_3 Vdout1_3ck152 = 0.9 time = 765
.meas tran vdout1_3ck152 FIND v(dout1_3) AT=765.025n

* CHECK dout1_4 Vdout1_4ck152 = 0.9 time = 765
.meas tran vdout1_4ck152 FIND v(dout1_4) AT=765.025n

* CHECK dout1_5 Vdout1_5ck152 = 0 time = 765
.meas tran vdout1_5ck152 FIND v(dout1_5) AT=765.025n

* CHECK dout1_6 Vdout1_6ck152 = 0.9 time = 765
.meas tran vdout1_6ck152 FIND v(dout1_6) AT=765.025n

* CHECK dout1_7 Vdout1_7ck152 = 0 time = 765
.meas tran vdout1_7ck152 FIND v(dout1_7) AT=765.025n

* CHECK dout1_8 Vdout1_8ck152 = 0 time = 765
.meas tran vdout1_8ck152 FIND v(dout1_8) AT=765.025n

* CHECK dout1_9 Vdout1_9ck152 = 0 time = 765
.meas tran vdout1_9ck152 FIND v(dout1_9) AT=765.025n

* CHECK dout1_10 Vdout1_10ck152 = 0.9 time = 765
.meas tran vdout1_10ck152 FIND v(dout1_10) AT=765.025n

* CHECK dout1_11 Vdout1_11ck152 = 0.9 time = 765
.meas tran vdout1_11ck152 FIND v(dout1_11) AT=765.025n

* CHECK dout1_12 Vdout1_12ck152 = 0 time = 765
.meas tran vdout1_12ck152 FIND v(dout1_12) AT=765.025n

* CHECK dout1_13 Vdout1_13ck152 = 0.9 time = 765
.meas tran vdout1_13ck152 FIND v(dout1_13) AT=765.025n

* CHECK dout1_14 Vdout1_14ck152 = 0 time = 765
.meas tran vdout1_14ck152 FIND v(dout1_14) AT=765.025n

* CHECK dout1_15 Vdout1_15ck152 = 0.9 time = 765
.meas tran vdout1_15ck152 FIND v(dout1_15) AT=765.025n

* CHECK dout1_16 Vdout1_16ck152 = 0 time = 765
.meas tran vdout1_16ck152 FIND v(dout1_16) AT=765.025n

* CHECK dout1_17 Vdout1_17ck152 = 0.9 time = 765
.meas tran vdout1_17ck152 FIND v(dout1_17) AT=765.025n

* CHECK dout1_18 Vdout1_18ck152 = 0 time = 765
.meas tran vdout1_18ck152 FIND v(dout1_18) AT=765.025n

* CHECK dout1_19 Vdout1_19ck152 = 0 time = 765
.meas tran vdout1_19ck152 FIND v(dout1_19) AT=765.025n

* CHECK dout1_20 Vdout1_20ck152 = 0.9 time = 765
.meas tran vdout1_20ck152 FIND v(dout1_20) AT=765.025n

* CHECK dout1_21 Vdout1_21ck152 = 0.9 time = 765
.meas tran vdout1_21ck152 FIND v(dout1_21) AT=765.025n

* CHECK dout1_22 Vdout1_22ck152 = 0.9 time = 765
.meas tran vdout1_22ck152 FIND v(dout1_22) AT=765.025n

* CHECK dout1_23 Vdout1_23ck152 = 0 time = 765
.meas tran vdout1_23ck152 FIND v(dout1_23) AT=765.025n

* CHECK dout1_24 Vdout1_24ck152 = 0.9 time = 765
.meas tran vdout1_24ck152 FIND v(dout1_24) AT=765.025n

* CHECK dout1_25 Vdout1_25ck152 = 0.9 time = 765
.meas tran vdout1_25ck152 FIND v(dout1_25) AT=765.025n

* CHECK dout1_26 Vdout1_26ck152 = 0 time = 765
.meas tran vdout1_26ck152 FIND v(dout1_26) AT=765.025n

* CHECK dout1_27 Vdout1_27ck152 = 0.9 time = 765
.meas tran vdout1_27ck152 FIND v(dout1_27) AT=765.025n

* CHECK dout1_28 Vdout1_28ck152 = 0.9 time = 765
.meas tran vdout1_28ck152 FIND v(dout1_28) AT=765.025n

* CHECK dout1_29 Vdout1_29ck152 = 0.9 time = 765
.meas tran vdout1_29ck152 FIND v(dout1_29) AT=765.025n

* CHECK dout1_30 Vdout1_30ck152 = 0 time = 765
.meas tran vdout1_30ck152 FIND v(dout1_30) AT=765.025n

* CHECK dout1_31 Vdout1_31ck152 = 0.9 time = 765
.meas tran vdout1_31ck152 FIND v(dout1_31) AT=765.025n

* CHECK dout1_32 Vdout1_32ck152 = 0.9 time = 765
.meas tran vdout1_32ck152 FIND v(dout1_32) AT=765.025n

* CHECK dout1_33 Vdout1_33ck152 = 0 time = 765
.meas tran vdout1_33ck152 FIND v(dout1_33) AT=765.025n

* CHECK dout1_34 Vdout1_34ck152 = 0 time = 765
.meas tran vdout1_34ck152 FIND v(dout1_34) AT=765.025n

* CHECK dout1_35 Vdout1_35ck152 = 0.9 time = 765
.meas tran vdout1_35ck152 FIND v(dout1_35) AT=765.025n

* CHECK dout1_36 Vdout1_36ck152 = 0 time = 765
.meas tran vdout1_36ck152 FIND v(dout1_36) AT=765.025n

* CHECK dout1_37 Vdout1_37ck152 = 0.9 time = 765
.meas tran vdout1_37ck152 FIND v(dout1_37) AT=765.025n

* CHECK dout1_38 Vdout1_38ck152 = 0.9 time = 765
.meas tran vdout1_38ck152 FIND v(dout1_38) AT=765.025n

* CHECK dout1_39 Vdout1_39ck152 = 0.9 time = 765
.meas tran vdout1_39ck152 FIND v(dout1_39) AT=765.025n

* CHECK dout1_40 Vdout1_40ck152 = 0.9 time = 765
.meas tran vdout1_40ck152 FIND v(dout1_40) AT=765.025n

* CHECK dout1_41 Vdout1_41ck152 = 0 time = 765
.meas tran vdout1_41ck152 FIND v(dout1_41) AT=765.025n

* CHECK dout1_42 Vdout1_42ck152 = 0 time = 765
.meas tran vdout1_42ck152 FIND v(dout1_42) AT=765.025n

* CHECK dout1_43 Vdout1_43ck152 = 0 time = 765
.meas tran vdout1_43ck152 FIND v(dout1_43) AT=765.025n

* CHECK dout1_44 Vdout1_44ck152 = 0 time = 765
.meas tran vdout1_44ck152 FIND v(dout1_44) AT=765.025n

* CHECK dout1_45 Vdout1_45ck152 = 0 time = 765
.meas tran vdout1_45ck152 FIND v(dout1_45) AT=765.025n

* CHECK dout1_46 Vdout1_46ck152 = 0 time = 765
.meas tran vdout1_46ck152 FIND v(dout1_46) AT=765.025n

* CHECK dout1_47 Vdout1_47ck152 = 0 time = 765
.meas tran vdout1_47ck152 FIND v(dout1_47) AT=765.025n

* CHECK dout1_48 Vdout1_48ck152 = 0 time = 765
.meas tran vdout1_48ck152 FIND v(dout1_48) AT=765.025n

* CHECK dout1_49 Vdout1_49ck152 = 0 time = 765
.meas tran vdout1_49ck152 FIND v(dout1_49) AT=765.025n

* CHECK dout1_50 Vdout1_50ck152 = 0 time = 765
.meas tran vdout1_50ck152 FIND v(dout1_50) AT=765.025n

* CHECK dout1_51 Vdout1_51ck152 = 0 time = 765
.meas tran vdout1_51ck152 FIND v(dout1_51) AT=765.025n

* CHECK dout1_52 Vdout1_52ck152 = 0 time = 765
.meas tran vdout1_52ck152 FIND v(dout1_52) AT=765.025n

* CHECK dout1_53 Vdout1_53ck152 = 0.9 time = 765
.meas tran vdout1_53ck152 FIND v(dout1_53) AT=765.025n

* CHECK dout1_54 Vdout1_54ck152 = 0.9 time = 765
.meas tran vdout1_54ck152 FIND v(dout1_54) AT=765.025n

* CHECK dout1_55 Vdout1_55ck152 = 0.9 time = 765
.meas tran vdout1_55ck152 FIND v(dout1_55) AT=765.025n

* CHECK dout1_56 Vdout1_56ck152 = 0 time = 765
.meas tran vdout1_56ck152 FIND v(dout1_56) AT=765.025n

* CHECK dout1_57 Vdout1_57ck152 = 0 time = 765
.meas tran vdout1_57ck152 FIND v(dout1_57) AT=765.025n

* CHECK dout1_58 Vdout1_58ck152 = 0 time = 765
.meas tran vdout1_58ck152 FIND v(dout1_58) AT=765.025n

* CHECK dout1_59 Vdout1_59ck152 = 0 time = 765
.meas tran vdout1_59ck152 FIND v(dout1_59) AT=765.025n

* CHECK dout1_60 Vdout1_60ck152 = 0 time = 765
.meas tran vdout1_60ck152 FIND v(dout1_60) AT=765.025n

* CHECK dout1_61 Vdout1_61ck152 = 0 time = 765
.meas tran vdout1_61ck152 FIND v(dout1_61) AT=765.025n

* CHECK dout1_62 Vdout1_62ck152 = 0 time = 765
.meas tran vdout1_62ck152 FIND v(dout1_62) AT=765.025n

* CHECK dout1_63 Vdout1_63ck152 = 0.9 time = 765
.meas tran vdout1_63ck152 FIND v(dout1_63) AT=765.025n

* CHECK dout1_64 Vdout1_64ck152 = 0.9 time = 765
.meas tran vdout1_64ck152 FIND v(dout1_64) AT=765.025n

* CHECK dout1_65 Vdout1_65ck152 = 0 time = 765
.meas tran vdout1_65ck152 FIND v(dout1_65) AT=765.025n

* CHECK dout1_66 Vdout1_66ck152 = 0 time = 765
.meas tran vdout1_66ck152 FIND v(dout1_66) AT=765.025n

* CHECK dout1_67 Vdout1_67ck152 = 0.9 time = 765
.meas tran vdout1_67ck152 FIND v(dout1_67) AT=765.025n

* CHECK dout1_68 Vdout1_68ck152 = 0 time = 765
.meas tran vdout1_68ck152 FIND v(dout1_68) AT=765.025n

* CHECK dout1_69 Vdout1_69ck152 = 0.9 time = 765
.meas tran vdout1_69ck152 FIND v(dout1_69) AT=765.025n

* CHECK dout1_70 Vdout1_70ck152 = 0.9 time = 765
.meas tran vdout1_70ck152 FIND v(dout1_70) AT=765.025n

* CHECK dout1_71 Vdout1_71ck152 = 0 time = 765
.meas tran vdout1_71ck152 FIND v(dout1_71) AT=765.025n

* CHECK dout1_72 Vdout1_72ck152 = 0.9 time = 765
.meas tran vdout1_72ck152 FIND v(dout1_72) AT=765.025n

* CHECK dout1_73 Vdout1_73ck152 = 0 time = 765
.meas tran vdout1_73ck152 FIND v(dout1_73) AT=765.025n

* CHECK dout1_74 Vdout1_74ck152 = 0.9 time = 765
.meas tran vdout1_74ck152 FIND v(dout1_74) AT=765.025n

* CHECK dout1_75 Vdout1_75ck152 = 0.9 time = 765
.meas tran vdout1_75ck152 FIND v(dout1_75) AT=765.025n

* CHECK dout1_76 Vdout1_76ck152 = 0 time = 765
.meas tran vdout1_76ck152 FIND v(dout1_76) AT=765.025n

* CHECK dout1_77 Vdout1_77ck152 = 0.9 time = 765
.meas tran vdout1_77ck152 FIND v(dout1_77) AT=765.025n

* CHECK dout1_78 Vdout1_78ck152 = 0.9 time = 765
.meas tran vdout1_78ck152 FIND v(dout1_78) AT=765.025n

* CHECK dout1_79 Vdout1_79ck152 = 0.9 time = 765
.meas tran vdout1_79ck152 FIND v(dout1_79) AT=765.025n

* CHECK dout1_80 Vdout1_80ck152 = 0.9 time = 765
.meas tran vdout1_80ck152 FIND v(dout1_80) AT=765.025n

* CHECK dout1_81 Vdout1_81ck152 = 0.9 time = 765
.meas tran vdout1_81ck152 FIND v(dout1_81) AT=765.025n

* CHECK dout1_82 Vdout1_82ck152 = 0 time = 765
.meas tran vdout1_82ck152 FIND v(dout1_82) AT=765.025n

* CHECK dout1_83 Vdout1_83ck152 = 0 time = 765
.meas tran vdout1_83ck152 FIND v(dout1_83) AT=765.025n

* CHECK dout1_84 Vdout1_84ck152 = 0.9 time = 765
.meas tran vdout1_84ck152 FIND v(dout1_84) AT=765.025n

* CHECK dout1_85 Vdout1_85ck152 = 0 time = 765
.meas tran vdout1_85ck152 FIND v(dout1_85) AT=765.025n

* CHECK dout1_86 Vdout1_86ck152 = 0 time = 765
.meas tran vdout1_86ck152 FIND v(dout1_86) AT=765.025n

* CHECK dout1_87 Vdout1_87ck152 = 0.9 time = 765
.meas tran vdout1_87ck152 FIND v(dout1_87) AT=765.025n

* CHECK dout1_88 Vdout1_88ck152 = 0.9 time = 765
.meas tran vdout1_88ck152 FIND v(dout1_88) AT=765.025n

* CHECK dout1_89 Vdout1_89ck152 = 0 time = 765
.meas tran vdout1_89ck152 FIND v(dout1_89) AT=765.025n

* CHECK dout1_90 Vdout1_90ck152 = 0.9 time = 765
.meas tran vdout1_90ck152 FIND v(dout1_90) AT=765.025n

* CHECK dout1_91 Vdout1_91ck152 = 0.9 time = 765
.meas tran vdout1_91ck152 FIND v(dout1_91) AT=765.025n

* CHECK dout1_92 Vdout1_92ck152 = 0.9 time = 765
.meas tran vdout1_92ck152 FIND v(dout1_92) AT=765.025n

* CHECK dout1_93 Vdout1_93ck152 = 0 time = 765
.meas tran vdout1_93ck152 FIND v(dout1_93) AT=765.025n

* CHECK dout1_94 Vdout1_94ck152 = 0.9 time = 765
.meas tran vdout1_94ck152 FIND v(dout1_94) AT=765.025n

* CHECK dout1_95 Vdout1_95ck152 = 0 time = 765
.meas tran vdout1_95ck152 FIND v(dout1_95) AT=765.025n

* CHECK dout1_96 Vdout1_96ck152 = 0.9 time = 765
.meas tran vdout1_96ck152 FIND v(dout1_96) AT=765.025n

* CHECK dout1_97 Vdout1_97ck152 = 0 time = 765
.meas tran vdout1_97ck152 FIND v(dout1_97) AT=765.025n

* CHECK dout1_98 Vdout1_98ck152 = 0.9 time = 765
.meas tran vdout1_98ck152 FIND v(dout1_98) AT=765.025n

* CHECK dout1_99 Vdout1_99ck152 = 0.9 time = 765
.meas tran vdout1_99ck152 FIND v(dout1_99) AT=765.025n

* CHECK dout1_100 Vdout1_100ck152 = 0 time = 765
.meas tran vdout1_100ck152 FIND v(dout1_100) AT=765.025n

* CHECK dout1_101 Vdout1_101ck152 = 0 time = 765
.meas tran vdout1_101ck152 FIND v(dout1_101) AT=765.025n

* CHECK dout1_102 Vdout1_102ck152 = 0.9 time = 765
.meas tran vdout1_102ck152 FIND v(dout1_102) AT=765.025n

* CHECK dout1_103 Vdout1_103ck152 = 0.9 time = 765
.meas tran vdout1_103ck152 FIND v(dout1_103) AT=765.025n

* CHECK dout1_104 Vdout1_104ck152 = 0 time = 765
.meas tran vdout1_104ck152 FIND v(dout1_104) AT=765.025n

* CHECK dout1_105 Vdout1_105ck152 = 0.9 time = 765
.meas tran vdout1_105ck152 FIND v(dout1_105) AT=765.025n

* CHECK dout1_106 Vdout1_106ck152 = 0.9 time = 765
.meas tran vdout1_106ck152 FIND v(dout1_106) AT=765.025n

* CHECK dout1_107 Vdout1_107ck152 = 0.9 time = 765
.meas tran vdout1_107ck152 FIND v(dout1_107) AT=765.025n

* CHECK dout1_108 Vdout1_108ck152 = 0 time = 765
.meas tran vdout1_108ck152 FIND v(dout1_108) AT=765.025n

* CHECK dout1_109 Vdout1_109ck152 = 0 time = 765
.meas tran vdout1_109ck152 FIND v(dout1_109) AT=765.025n

* CHECK dout1_110 Vdout1_110ck152 = 0 time = 765
.meas tran vdout1_110ck152 FIND v(dout1_110) AT=765.025n

* CHECK dout1_111 Vdout1_111ck152 = 0 time = 765
.meas tran vdout1_111ck152 FIND v(dout1_111) AT=765.025n

* CHECK dout1_112 Vdout1_112ck152 = 0 time = 765
.meas tran vdout1_112ck152 FIND v(dout1_112) AT=765.025n

* CHECK dout1_113 Vdout1_113ck152 = 0 time = 765
.meas tran vdout1_113ck152 FIND v(dout1_113) AT=765.025n

* CHECK dout1_114 Vdout1_114ck152 = 0 time = 765
.meas tran vdout1_114ck152 FIND v(dout1_114) AT=765.025n

* CHECK dout1_115 Vdout1_115ck152 = 0.9 time = 765
.meas tran vdout1_115ck152 FIND v(dout1_115) AT=765.025n

* CHECK dout1_116 Vdout1_116ck152 = 0.9 time = 765
.meas tran vdout1_116ck152 FIND v(dout1_116) AT=765.025n

* CHECK dout1_117 Vdout1_117ck152 = 0 time = 765
.meas tran vdout1_117ck152 FIND v(dout1_117) AT=765.025n

* CHECK dout1_118 Vdout1_118ck152 = 0 time = 765
.meas tran vdout1_118ck152 FIND v(dout1_118) AT=765.025n

* CHECK dout1_119 Vdout1_119ck152 = 0.9 time = 765
.meas tran vdout1_119ck152 FIND v(dout1_119) AT=765.025n

* CHECK dout1_0 Vdout1_0ck153 = 0.9 time = 770
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=770.025n

* CHECK dout1_1 Vdout1_1ck153 = 0.9 time = 770
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=770.025n

* CHECK dout1_2 Vdout1_2ck153 = 0.9 time = 770
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=770.025n

* CHECK dout1_3 Vdout1_3ck153 = 0.9 time = 770
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=770.025n

* CHECK dout1_4 Vdout1_4ck153 = 0.9 time = 770
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=770.025n

* CHECK dout1_5 Vdout1_5ck153 = 0 time = 770
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=770.025n

* CHECK dout1_6 Vdout1_6ck153 = 0.9 time = 770
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=770.025n

* CHECK dout1_7 Vdout1_7ck153 = 0 time = 770
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=770.025n

* CHECK dout1_8 Vdout1_8ck153 = 0 time = 770
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=770.025n

* CHECK dout1_9 Vdout1_9ck153 = 0 time = 770
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=770.025n

* CHECK dout1_10 Vdout1_10ck153 = 0.9 time = 770
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=770.025n

* CHECK dout1_11 Vdout1_11ck153 = 0.9 time = 770
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=770.025n

* CHECK dout1_12 Vdout1_12ck153 = 0 time = 770
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=770.025n

* CHECK dout1_13 Vdout1_13ck153 = 0.9 time = 770
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=770.025n

* CHECK dout1_14 Vdout1_14ck153 = 0 time = 770
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=770.025n

* CHECK dout1_15 Vdout1_15ck153 = 0.9 time = 770
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=770.025n

* CHECK dout1_16 Vdout1_16ck153 = 0 time = 770
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=770.025n

* CHECK dout1_17 Vdout1_17ck153 = 0.9 time = 770
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=770.025n

* CHECK dout1_18 Vdout1_18ck153 = 0 time = 770
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=770.025n

* CHECK dout1_19 Vdout1_19ck153 = 0 time = 770
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=770.025n

* CHECK dout1_20 Vdout1_20ck153 = 0.9 time = 770
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=770.025n

* CHECK dout1_21 Vdout1_21ck153 = 0.9 time = 770
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=770.025n

* CHECK dout1_22 Vdout1_22ck153 = 0.9 time = 770
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=770.025n

* CHECK dout1_23 Vdout1_23ck153 = 0 time = 770
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=770.025n

* CHECK dout1_24 Vdout1_24ck153 = 0.9 time = 770
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=770.025n

* CHECK dout1_25 Vdout1_25ck153 = 0.9 time = 770
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=770.025n

* CHECK dout1_26 Vdout1_26ck153 = 0 time = 770
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=770.025n

* CHECK dout1_27 Vdout1_27ck153 = 0.9 time = 770
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=770.025n

* CHECK dout1_28 Vdout1_28ck153 = 0.9 time = 770
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=770.025n

* CHECK dout1_29 Vdout1_29ck153 = 0.9 time = 770
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=770.025n

* CHECK dout1_30 Vdout1_30ck153 = 0 time = 770
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=770.025n

* CHECK dout1_31 Vdout1_31ck153 = 0.9 time = 770
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=770.025n

* CHECK dout1_32 Vdout1_32ck153 = 0.9 time = 770
.meas tran vdout1_32ck153 FIND v(dout1_32) AT=770.025n

* CHECK dout1_33 Vdout1_33ck153 = 0 time = 770
.meas tran vdout1_33ck153 FIND v(dout1_33) AT=770.025n

* CHECK dout1_34 Vdout1_34ck153 = 0 time = 770
.meas tran vdout1_34ck153 FIND v(dout1_34) AT=770.025n

* CHECK dout1_35 Vdout1_35ck153 = 0.9 time = 770
.meas tran vdout1_35ck153 FIND v(dout1_35) AT=770.025n

* CHECK dout1_36 Vdout1_36ck153 = 0 time = 770
.meas tran vdout1_36ck153 FIND v(dout1_36) AT=770.025n

* CHECK dout1_37 Vdout1_37ck153 = 0.9 time = 770
.meas tran vdout1_37ck153 FIND v(dout1_37) AT=770.025n

* CHECK dout1_38 Vdout1_38ck153 = 0.9 time = 770
.meas tran vdout1_38ck153 FIND v(dout1_38) AT=770.025n

* CHECK dout1_39 Vdout1_39ck153 = 0.9 time = 770
.meas tran vdout1_39ck153 FIND v(dout1_39) AT=770.025n

* CHECK dout1_40 Vdout1_40ck153 = 0.9 time = 770
.meas tran vdout1_40ck153 FIND v(dout1_40) AT=770.025n

* CHECK dout1_41 Vdout1_41ck153 = 0 time = 770
.meas tran vdout1_41ck153 FIND v(dout1_41) AT=770.025n

* CHECK dout1_42 Vdout1_42ck153 = 0 time = 770
.meas tran vdout1_42ck153 FIND v(dout1_42) AT=770.025n

* CHECK dout1_43 Vdout1_43ck153 = 0 time = 770
.meas tran vdout1_43ck153 FIND v(dout1_43) AT=770.025n

* CHECK dout1_44 Vdout1_44ck153 = 0 time = 770
.meas tran vdout1_44ck153 FIND v(dout1_44) AT=770.025n

* CHECK dout1_45 Vdout1_45ck153 = 0 time = 770
.meas tran vdout1_45ck153 FIND v(dout1_45) AT=770.025n

* CHECK dout1_46 Vdout1_46ck153 = 0 time = 770
.meas tran vdout1_46ck153 FIND v(dout1_46) AT=770.025n

* CHECK dout1_47 Vdout1_47ck153 = 0 time = 770
.meas tran vdout1_47ck153 FIND v(dout1_47) AT=770.025n

* CHECK dout1_48 Vdout1_48ck153 = 0 time = 770
.meas tran vdout1_48ck153 FIND v(dout1_48) AT=770.025n

* CHECK dout1_49 Vdout1_49ck153 = 0 time = 770
.meas tran vdout1_49ck153 FIND v(dout1_49) AT=770.025n

* CHECK dout1_50 Vdout1_50ck153 = 0 time = 770
.meas tran vdout1_50ck153 FIND v(dout1_50) AT=770.025n

* CHECK dout1_51 Vdout1_51ck153 = 0 time = 770
.meas tran vdout1_51ck153 FIND v(dout1_51) AT=770.025n

* CHECK dout1_52 Vdout1_52ck153 = 0 time = 770
.meas tran vdout1_52ck153 FIND v(dout1_52) AT=770.025n

* CHECK dout1_53 Vdout1_53ck153 = 0.9 time = 770
.meas tran vdout1_53ck153 FIND v(dout1_53) AT=770.025n

* CHECK dout1_54 Vdout1_54ck153 = 0.9 time = 770
.meas tran vdout1_54ck153 FIND v(dout1_54) AT=770.025n

* CHECK dout1_55 Vdout1_55ck153 = 0.9 time = 770
.meas tran vdout1_55ck153 FIND v(dout1_55) AT=770.025n

* CHECK dout1_56 Vdout1_56ck153 = 0 time = 770
.meas tran vdout1_56ck153 FIND v(dout1_56) AT=770.025n

* CHECK dout1_57 Vdout1_57ck153 = 0 time = 770
.meas tran vdout1_57ck153 FIND v(dout1_57) AT=770.025n

* CHECK dout1_58 Vdout1_58ck153 = 0 time = 770
.meas tran vdout1_58ck153 FIND v(dout1_58) AT=770.025n

* CHECK dout1_59 Vdout1_59ck153 = 0 time = 770
.meas tran vdout1_59ck153 FIND v(dout1_59) AT=770.025n

* CHECK dout1_60 Vdout1_60ck153 = 0 time = 770
.meas tran vdout1_60ck153 FIND v(dout1_60) AT=770.025n

* CHECK dout1_61 Vdout1_61ck153 = 0 time = 770
.meas tran vdout1_61ck153 FIND v(dout1_61) AT=770.025n

* CHECK dout1_62 Vdout1_62ck153 = 0 time = 770
.meas tran vdout1_62ck153 FIND v(dout1_62) AT=770.025n

* CHECK dout1_63 Vdout1_63ck153 = 0.9 time = 770
.meas tran vdout1_63ck153 FIND v(dout1_63) AT=770.025n

* CHECK dout1_64 Vdout1_64ck153 = 0.9 time = 770
.meas tran vdout1_64ck153 FIND v(dout1_64) AT=770.025n

* CHECK dout1_65 Vdout1_65ck153 = 0 time = 770
.meas tran vdout1_65ck153 FIND v(dout1_65) AT=770.025n

* CHECK dout1_66 Vdout1_66ck153 = 0 time = 770
.meas tran vdout1_66ck153 FIND v(dout1_66) AT=770.025n

* CHECK dout1_67 Vdout1_67ck153 = 0.9 time = 770
.meas tran vdout1_67ck153 FIND v(dout1_67) AT=770.025n

* CHECK dout1_68 Vdout1_68ck153 = 0 time = 770
.meas tran vdout1_68ck153 FIND v(dout1_68) AT=770.025n

* CHECK dout1_69 Vdout1_69ck153 = 0.9 time = 770
.meas tran vdout1_69ck153 FIND v(dout1_69) AT=770.025n

* CHECK dout1_70 Vdout1_70ck153 = 0.9 time = 770
.meas tran vdout1_70ck153 FIND v(dout1_70) AT=770.025n

* CHECK dout1_71 Vdout1_71ck153 = 0 time = 770
.meas tran vdout1_71ck153 FIND v(dout1_71) AT=770.025n

* CHECK dout1_72 Vdout1_72ck153 = 0.9 time = 770
.meas tran vdout1_72ck153 FIND v(dout1_72) AT=770.025n

* CHECK dout1_73 Vdout1_73ck153 = 0 time = 770
.meas tran vdout1_73ck153 FIND v(dout1_73) AT=770.025n

* CHECK dout1_74 Vdout1_74ck153 = 0.9 time = 770
.meas tran vdout1_74ck153 FIND v(dout1_74) AT=770.025n

* CHECK dout1_75 Vdout1_75ck153 = 0.9 time = 770
.meas tran vdout1_75ck153 FIND v(dout1_75) AT=770.025n

* CHECK dout1_76 Vdout1_76ck153 = 0 time = 770
.meas tran vdout1_76ck153 FIND v(dout1_76) AT=770.025n

* CHECK dout1_77 Vdout1_77ck153 = 0.9 time = 770
.meas tran vdout1_77ck153 FIND v(dout1_77) AT=770.025n

* CHECK dout1_78 Vdout1_78ck153 = 0.9 time = 770
.meas tran vdout1_78ck153 FIND v(dout1_78) AT=770.025n

* CHECK dout1_79 Vdout1_79ck153 = 0.9 time = 770
.meas tran vdout1_79ck153 FIND v(dout1_79) AT=770.025n

* CHECK dout1_80 Vdout1_80ck153 = 0.9 time = 770
.meas tran vdout1_80ck153 FIND v(dout1_80) AT=770.025n

* CHECK dout1_81 Vdout1_81ck153 = 0.9 time = 770
.meas tran vdout1_81ck153 FIND v(dout1_81) AT=770.025n

* CHECK dout1_82 Vdout1_82ck153 = 0 time = 770
.meas tran vdout1_82ck153 FIND v(dout1_82) AT=770.025n

* CHECK dout1_83 Vdout1_83ck153 = 0 time = 770
.meas tran vdout1_83ck153 FIND v(dout1_83) AT=770.025n

* CHECK dout1_84 Vdout1_84ck153 = 0.9 time = 770
.meas tran vdout1_84ck153 FIND v(dout1_84) AT=770.025n

* CHECK dout1_85 Vdout1_85ck153 = 0 time = 770
.meas tran vdout1_85ck153 FIND v(dout1_85) AT=770.025n

* CHECK dout1_86 Vdout1_86ck153 = 0 time = 770
.meas tran vdout1_86ck153 FIND v(dout1_86) AT=770.025n

* CHECK dout1_87 Vdout1_87ck153 = 0.9 time = 770
.meas tran vdout1_87ck153 FIND v(dout1_87) AT=770.025n

* CHECK dout1_88 Vdout1_88ck153 = 0.9 time = 770
.meas tran vdout1_88ck153 FIND v(dout1_88) AT=770.025n

* CHECK dout1_89 Vdout1_89ck153 = 0 time = 770
.meas tran vdout1_89ck153 FIND v(dout1_89) AT=770.025n

* CHECK dout1_90 Vdout1_90ck153 = 0.9 time = 770
.meas tran vdout1_90ck153 FIND v(dout1_90) AT=770.025n

* CHECK dout1_91 Vdout1_91ck153 = 0.9 time = 770
.meas tran vdout1_91ck153 FIND v(dout1_91) AT=770.025n

* CHECK dout1_92 Vdout1_92ck153 = 0.9 time = 770
.meas tran vdout1_92ck153 FIND v(dout1_92) AT=770.025n

* CHECK dout1_93 Vdout1_93ck153 = 0 time = 770
.meas tran vdout1_93ck153 FIND v(dout1_93) AT=770.025n

* CHECK dout1_94 Vdout1_94ck153 = 0.9 time = 770
.meas tran vdout1_94ck153 FIND v(dout1_94) AT=770.025n

* CHECK dout1_95 Vdout1_95ck153 = 0 time = 770
.meas tran vdout1_95ck153 FIND v(dout1_95) AT=770.025n

* CHECK dout1_96 Vdout1_96ck153 = 0.9 time = 770
.meas tran vdout1_96ck153 FIND v(dout1_96) AT=770.025n

* CHECK dout1_97 Vdout1_97ck153 = 0 time = 770
.meas tran vdout1_97ck153 FIND v(dout1_97) AT=770.025n

* CHECK dout1_98 Vdout1_98ck153 = 0.9 time = 770
.meas tran vdout1_98ck153 FIND v(dout1_98) AT=770.025n

* CHECK dout1_99 Vdout1_99ck153 = 0.9 time = 770
.meas tran vdout1_99ck153 FIND v(dout1_99) AT=770.025n

* CHECK dout1_100 Vdout1_100ck153 = 0 time = 770
.meas tran vdout1_100ck153 FIND v(dout1_100) AT=770.025n

* CHECK dout1_101 Vdout1_101ck153 = 0 time = 770
.meas tran vdout1_101ck153 FIND v(dout1_101) AT=770.025n

* CHECK dout1_102 Vdout1_102ck153 = 0.9 time = 770
.meas tran vdout1_102ck153 FIND v(dout1_102) AT=770.025n

* CHECK dout1_103 Vdout1_103ck153 = 0.9 time = 770
.meas tran vdout1_103ck153 FIND v(dout1_103) AT=770.025n

* CHECK dout1_104 Vdout1_104ck153 = 0 time = 770
.meas tran vdout1_104ck153 FIND v(dout1_104) AT=770.025n

* CHECK dout1_105 Vdout1_105ck153 = 0.9 time = 770
.meas tran vdout1_105ck153 FIND v(dout1_105) AT=770.025n

* CHECK dout1_106 Vdout1_106ck153 = 0.9 time = 770
.meas tran vdout1_106ck153 FIND v(dout1_106) AT=770.025n

* CHECK dout1_107 Vdout1_107ck153 = 0.9 time = 770
.meas tran vdout1_107ck153 FIND v(dout1_107) AT=770.025n

* CHECK dout1_108 Vdout1_108ck153 = 0 time = 770
.meas tran vdout1_108ck153 FIND v(dout1_108) AT=770.025n

* CHECK dout1_109 Vdout1_109ck153 = 0 time = 770
.meas tran vdout1_109ck153 FIND v(dout1_109) AT=770.025n

* CHECK dout1_110 Vdout1_110ck153 = 0 time = 770
.meas tran vdout1_110ck153 FIND v(dout1_110) AT=770.025n

* CHECK dout1_111 Vdout1_111ck153 = 0 time = 770
.meas tran vdout1_111ck153 FIND v(dout1_111) AT=770.025n

* CHECK dout1_112 Vdout1_112ck153 = 0 time = 770
.meas tran vdout1_112ck153 FIND v(dout1_112) AT=770.025n

* CHECK dout1_113 Vdout1_113ck153 = 0 time = 770
.meas tran vdout1_113ck153 FIND v(dout1_113) AT=770.025n

* CHECK dout1_114 Vdout1_114ck153 = 0 time = 770
.meas tran vdout1_114ck153 FIND v(dout1_114) AT=770.025n

* CHECK dout1_115 Vdout1_115ck153 = 0.9 time = 770
.meas tran vdout1_115ck153 FIND v(dout1_115) AT=770.025n

* CHECK dout1_116 Vdout1_116ck153 = 0.9 time = 770
.meas tran vdout1_116ck153 FIND v(dout1_116) AT=770.025n

* CHECK dout1_117 Vdout1_117ck153 = 0 time = 770
.meas tran vdout1_117ck153 FIND v(dout1_117) AT=770.025n

* CHECK dout1_118 Vdout1_118ck153 = 0 time = 770
.meas tran vdout1_118ck153 FIND v(dout1_118) AT=770.025n

* CHECK dout1_119 Vdout1_119ck153 = 0.9 time = 770
.meas tran vdout1_119ck153 FIND v(dout1_119) AT=770.025n

* CHECK dout1_0 Vdout1_0ck154 = 0 time = 775
.meas tran vdout1_0ck154 FIND v(dout1_0) AT=775.025n

* CHECK dout1_1 Vdout1_1ck154 = 0.9 time = 775
.meas tran vdout1_1ck154 FIND v(dout1_1) AT=775.025n

* CHECK dout1_2 Vdout1_2ck154 = 0 time = 775
.meas tran vdout1_2ck154 FIND v(dout1_2) AT=775.025n

* CHECK dout1_3 Vdout1_3ck154 = 0.9 time = 775
.meas tran vdout1_3ck154 FIND v(dout1_3) AT=775.025n

* CHECK dout1_4 Vdout1_4ck154 = 0 time = 775
.meas tran vdout1_4ck154 FIND v(dout1_4) AT=775.025n

* CHECK dout1_5 Vdout1_5ck154 = 0 time = 775
.meas tran vdout1_5ck154 FIND v(dout1_5) AT=775.025n

* CHECK dout1_6 Vdout1_6ck154 = 0 time = 775
.meas tran vdout1_6ck154 FIND v(dout1_6) AT=775.025n

* CHECK dout1_7 Vdout1_7ck154 = 0.9 time = 775
.meas tran vdout1_7ck154 FIND v(dout1_7) AT=775.025n

* CHECK dout1_8 Vdout1_8ck154 = 0.9 time = 775
.meas tran vdout1_8ck154 FIND v(dout1_8) AT=775.025n

* CHECK dout1_9 Vdout1_9ck154 = 0.9 time = 775
.meas tran vdout1_9ck154 FIND v(dout1_9) AT=775.025n

* CHECK dout1_10 Vdout1_10ck154 = 0 time = 775
.meas tran vdout1_10ck154 FIND v(dout1_10) AT=775.025n

* CHECK dout1_11 Vdout1_11ck154 = 0.9 time = 775
.meas tran vdout1_11ck154 FIND v(dout1_11) AT=775.025n

* CHECK dout1_12 Vdout1_12ck154 = 0.9 time = 775
.meas tran vdout1_12ck154 FIND v(dout1_12) AT=775.025n

* CHECK dout1_13 Vdout1_13ck154 = 0.9 time = 775
.meas tran vdout1_13ck154 FIND v(dout1_13) AT=775.025n

* CHECK dout1_14 Vdout1_14ck154 = 0.9 time = 775
.meas tran vdout1_14ck154 FIND v(dout1_14) AT=775.025n

* CHECK dout1_15 Vdout1_15ck154 = 0.9 time = 775
.meas tran vdout1_15ck154 FIND v(dout1_15) AT=775.025n

* CHECK dout1_16 Vdout1_16ck154 = 0.9 time = 775
.meas tran vdout1_16ck154 FIND v(dout1_16) AT=775.025n

* CHECK dout1_17 Vdout1_17ck154 = 0 time = 775
.meas tran vdout1_17ck154 FIND v(dout1_17) AT=775.025n

* CHECK dout1_18 Vdout1_18ck154 = 0 time = 775
.meas tran vdout1_18ck154 FIND v(dout1_18) AT=775.025n

* CHECK dout1_19 Vdout1_19ck154 = 0.9 time = 775
.meas tran vdout1_19ck154 FIND v(dout1_19) AT=775.025n

* CHECK dout1_20 Vdout1_20ck154 = 0 time = 775
.meas tran vdout1_20ck154 FIND v(dout1_20) AT=775.025n

* CHECK dout1_21 Vdout1_21ck154 = 0 time = 775
.meas tran vdout1_21ck154 FIND v(dout1_21) AT=775.025n

* CHECK dout1_22 Vdout1_22ck154 = 0.9 time = 775
.meas tran vdout1_22ck154 FIND v(dout1_22) AT=775.025n

* CHECK dout1_23 Vdout1_23ck154 = 0 time = 775
.meas tran vdout1_23ck154 FIND v(dout1_23) AT=775.025n

* CHECK dout1_24 Vdout1_24ck154 = 0.9 time = 775
.meas tran vdout1_24ck154 FIND v(dout1_24) AT=775.025n

* CHECK dout1_25 Vdout1_25ck154 = 0.9 time = 775
.meas tran vdout1_25ck154 FIND v(dout1_25) AT=775.025n

* CHECK dout1_26 Vdout1_26ck154 = 0.9 time = 775
.meas tran vdout1_26ck154 FIND v(dout1_26) AT=775.025n

* CHECK dout1_27 Vdout1_27ck154 = 0.9 time = 775
.meas tran vdout1_27ck154 FIND v(dout1_27) AT=775.025n

* CHECK dout1_28 Vdout1_28ck154 = 0.9 time = 775
.meas tran vdout1_28ck154 FIND v(dout1_28) AT=775.025n

* CHECK dout1_29 Vdout1_29ck154 = 0 time = 775
.meas tran vdout1_29ck154 FIND v(dout1_29) AT=775.025n

* CHECK dout1_30 Vdout1_30ck154 = 0.9 time = 775
.meas tran vdout1_30ck154 FIND v(dout1_30) AT=775.025n

* CHECK dout1_31 Vdout1_31ck154 = 0.9 time = 775
.meas tran vdout1_31ck154 FIND v(dout1_31) AT=775.025n

* CHECK dout1_32 Vdout1_32ck154 = 0 time = 775
.meas tran vdout1_32ck154 FIND v(dout1_32) AT=775.025n

* CHECK dout1_33 Vdout1_33ck154 = 0.9 time = 775
.meas tran vdout1_33ck154 FIND v(dout1_33) AT=775.025n

* CHECK dout1_34 Vdout1_34ck154 = 0 time = 775
.meas tran vdout1_34ck154 FIND v(dout1_34) AT=775.025n

* CHECK dout1_35 Vdout1_35ck154 = 0 time = 775
.meas tran vdout1_35ck154 FIND v(dout1_35) AT=775.025n

* CHECK dout1_36 Vdout1_36ck154 = 0 time = 775
.meas tran vdout1_36ck154 FIND v(dout1_36) AT=775.025n

* CHECK dout1_37 Vdout1_37ck154 = 0.9 time = 775
.meas tran vdout1_37ck154 FIND v(dout1_37) AT=775.025n

* CHECK dout1_38 Vdout1_38ck154 = 0.9 time = 775
.meas tran vdout1_38ck154 FIND v(dout1_38) AT=775.025n

* CHECK dout1_39 Vdout1_39ck154 = 0 time = 775
.meas tran vdout1_39ck154 FIND v(dout1_39) AT=775.025n

* CHECK dout1_40 Vdout1_40ck154 = 0.9 time = 775
.meas tran vdout1_40ck154 FIND v(dout1_40) AT=775.025n

* CHECK dout1_41 Vdout1_41ck154 = 0.9 time = 775
.meas tran vdout1_41ck154 FIND v(dout1_41) AT=775.025n

* CHECK dout1_42 Vdout1_42ck154 = 0.9 time = 775
.meas tran vdout1_42ck154 FIND v(dout1_42) AT=775.025n

* CHECK dout1_43 Vdout1_43ck154 = 0 time = 775
.meas tran vdout1_43ck154 FIND v(dout1_43) AT=775.025n

* CHECK dout1_44 Vdout1_44ck154 = 0 time = 775
.meas tran vdout1_44ck154 FIND v(dout1_44) AT=775.025n

* CHECK dout1_45 Vdout1_45ck154 = 0 time = 775
.meas tran vdout1_45ck154 FIND v(dout1_45) AT=775.025n

* CHECK dout1_46 Vdout1_46ck154 = 0.9 time = 775
.meas tran vdout1_46ck154 FIND v(dout1_46) AT=775.025n

* CHECK dout1_47 Vdout1_47ck154 = 0 time = 775
.meas tran vdout1_47ck154 FIND v(dout1_47) AT=775.025n

* CHECK dout1_48 Vdout1_48ck154 = 0 time = 775
.meas tran vdout1_48ck154 FIND v(dout1_48) AT=775.025n

* CHECK dout1_49 Vdout1_49ck154 = 0.9 time = 775
.meas tran vdout1_49ck154 FIND v(dout1_49) AT=775.025n

* CHECK dout1_50 Vdout1_50ck154 = 0.9 time = 775
.meas tran vdout1_50ck154 FIND v(dout1_50) AT=775.025n

* CHECK dout1_51 Vdout1_51ck154 = 0.9 time = 775
.meas tran vdout1_51ck154 FIND v(dout1_51) AT=775.025n

* CHECK dout1_52 Vdout1_52ck154 = 0.9 time = 775
.meas tran vdout1_52ck154 FIND v(dout1_52) AT=775.025n

* CHECK dout1_53 Vdout1_53ck154 = 0 time = 775
.meas tran vdout1_53ck154 FIND v(dout1_53) AT=775.025n

* CHECK dout1_54 Vdout1_54ck154 = 0.9 time = 775
.meas tran vdout1_54ck154 FIND v(dout1_54) AT=775.025n

* CHECK dout1_55 Vdout1_55ck154 = 0 time = 775
.meas tran vdout1_55ck154 FIND v(dout1_55) AT=775.025n

* CHECK dout1_56 Vdout1_56ck154 = 0 time = 775
.meas tran vdout1_56ck154 FIND v(dout1_56) AT=775.025n

* CHECK dout1_57 Vdout1_57ck154 = 0 time = 775
.meas tran vdout1_57ck154 FIND v(dout1_57) AT=775.025n

* CHECK dout1_58 Vdout1_58ck154 = 0.9 time = 775
.meas tran vdout1_58ck154 FIND v(dout1_58) AT=775.025n

* CHECK dout1_59 Vdout1_59ck154 = 0.9 time = 775
.meas tran vdout1_59ck154 FIND v(dout1_59) AT=775.025n

* CHECK dout1_60 Vdout1_60ck154 = 0.9 time = 775
.meas tran vdout1_60ck154 FIND v(dout1_60) AT=775.025n

* CHECK dout1_61 Vdout1_61ck154 = 0 time = 775
.meas tran vdout1_61ck154 FIND v(dout1_61) AT=775.025n

* CHECK dout1_62 Vdout1_62ck154 = 0.9 time = 775
.meas tran vdout1_62ck154 FIND v(dout1_62) AT=775.025n

* CHECK dout1_63 Vdout1_63ck154 = 0.9 time = 775
.meas tran vdout1_63ck154 FIND v(dout1_63) AT=775.025n

* CHECK dout1_64 Vdout1_64ck154 = 0.9 time = 775
.meas tran vdout1_64ck154 FIND v(dout1_64) AT=775.025n

* CHECK dout1_65 Vdout1_65ck154 = 0 time = 775
.meas tran vdout1_65ck154 FIND v(dout1_65) AT=775.025n

* CHECK dout1_66 Vdout1_66ck154 = 0.9 time = 775
.meas tran vdout1_66ck154 FIND v(dout1_66) AT=775.025n

* CHECK dout1_67 Vdout1_67ck154 = 0.9 time = 775
.meas tran vdout1_67ck154 FIND v(dout1_67) AT=775.025n

* CHECK dout1_68 Vdout1_68ck154 = 0 time = 775
.meas tran vdout1_68ck154 FIND v(dout1_68) AT=775.025n

* CHECK dout1_69 Vdout1_69ck154 = 0 time = 775
.meas tran vdout1_69ck154 FIND v(dout1_69) AT=775.025n

* CHECK dout1_70 Vdout1_70ck154 = 0.9 time = 775
.meas tran vdout1_70ck154 FIND v(dout1_70) AT=775.025n

* CHECK dout1_71 Vdout1_71ck154 = 0.9 time = 775
.meas tran vdout1_71ck154 FIND v(dout1_71) AT=775.025n

* CHECK dout1_72 Vdout1_72ck154 = 0 time = 775
.meas tran vdout1_72ck154 FIND v(dout1_72) AT=775.025n

* CHECK dout1_73 Vdout1_73ck154 = 0 time = 775
.meas tran vdout1_73ck154 FIND v(dout1_73) AT=775.025n

* CHECK dout1_74 Vdout1_74ck154 = 0 time = 775
.meas tran vdout1_74ck154 FIND v(dout1_74) AT=775.025n

* CHECK dout1_75 Vdout1_75ck154 = 0.9 time = 775
.meas tran vdout1_75ck154 FIND v(dout1_75) AT=775.025n

* CHECK dout1_76 Vdout1_76ck154 = 0 time = 775
.meas tran vdout1_76ck154 FIND v(dout1_76) AT=775.025n

* CHECK dout1_77 Vdout1_77ck154 = 0.9 time = 775
.meas tran vdout1_77ck154 FIND v(dout1_77) AT=775.025n

* CHECK dout1_78 Vdout1_78ck154 = 0.9 time = 775
.meas tran vdout1_78ck154 FIND v(dout1_78) AT=775.025n

* CHECK dout1_79 Vdout1_79ck154 = 0 time = 775
.meas tran vdout1_79ck154 FIND v(dout1_79) AT=775.025n

* CHECK dout1_80 Vdout1_80ck154 = 0.9 time = 775
.meas tran vdout1_80ck154 FIND v(dout1_80) AT=775.025n

* CHECK dout1_81 Vdout1_81ck154 = 0 time = 775
.meas tran vdout1_81ck154 FIND v(dout1_81) AT=775.025n

* CHECK dout1_82 Vdout1_82ck154 = 0.9 time = 775
.meas tran vdout1_82ck154 FIND v(dout1_82) AT=775.025n

* CHECK dout1_83 Vdout1_83ck154 = 0.9 time = 775
.meas tran vdout1_83ck154 FIND v(dout1_83) AT=775.025n

* CHECK dout1_84 Vdout1_84ck154 = 0.9 time = 775
.meas tran vdout1_84ck154 FIND v(dout1_84) AT=775.025n

* CHECK dout1_85 Vdout1_85ck154 = 0.9 time = 775
.meas tran vdout1_85ck154 FIND v(dout1_85) AT=775.025n

* CHECK dout1_86 Vdout1_86ck154 = 0 time = 775
.meas tran vdout1_86ck154 FIND v(dout1_86) AT=775.025n

* CHECK dout1_87 Vdout1_87ck154 = 0 time = 775
.meas tran vdout1_87ck154 FIND v(dout1_87) AT=775.025n

* CHECK dout1_88 Vdout1_88ck154 = 0 time = 775
.meas tran vdout1_88ck154 FIND v(dout1_88) AT=775.025n

* CHECK dout1_89 Vdout1_89ck154 = 0 time = 775
.meas tran vdout1_89ck154 FIND v(dout1_89) AT=775.025n

* CHECK dout1_90 Vdout1_90ck154 = 0.9 time = 775
.meas tran vdout1_90ck154 FIND v(dout1_90) AT=775.025n

* CHECK dout1_91 Vdout1_91ck154 = 0 time = 775
.meas tran vdout1_91ck154 FIND v(dout1_91) AT=775.025n

* CHECK dout1_92 Vdout1_92ck154 = 0 time = 775
.meas tran vdout1_92ck154 FIND v(dout1_92) AT=775.025n

* CHECK dout1_93 Vdout1_93ck154 = 0.9 time = 775
.meas tran vdout1_93ck154 FIND v(dout1_93) AT=775.025n

* CHECK dout1_94 Vdout1_94ck154 = 0 time = 775
.meas tran vdout1_94ck154 FIND v(dout1_94) AT=775.025n

* CHECK dout1_95 Vdout1_95ck154 = 0 time = 775
.meas tran vdout1_95ck154 FIND v(dout1_95) AT=775.025n

* CHECK dout1_96 Vdout1_96ck154 = 0 time = 775
.meas tran vdout1_96ck154 FIND v(dout1_96) AT=775.025n

* CHECK dout1_97 Vdout1_97ck154 = 0.9 time = 775
.meas tran vdout1_97ck154 FIND v(dout1_97) AT=775.025n

* CHECK dout1_98 Vdout1_98ck154 = 0 time = 775
.meas tran vdout1_98ck154 FIND v(dout1_98) AT=775.025n

* CHECK dout1_99 Vdout1_99ck154 = 0 time = 775
.meas tran vdout1_99ck154 FIND v(dout1_99) AT=775.025n

* CHECK dout1_100 Vdout1_100ck154 = 0 time = 775
.meas tran vdout1_100ck154 FIND v(dout1_100) AT=775.025n

* CHECK dout1_101 Vdout1_101ck154 = 0 time = 775
.meas tran vdout1_101ck154 FIND v(dout1_101) AT=775.025n

* CHECK dout1_102 Vdout1_102ck154 = 0.9 time = 775
.meas tran vdout1_102ck154 FIND v(dout1_102) AT=775.025n

* CHECK dout1_103 Vdout1_103ck154 = 0 time = 775
.meas tran vdout1_103ck154 FIND v(dout1_103) AT=775.025n

* CHECK dout1_104 Vdout1_104ck154 = 0.9 time = 775
.meas tran vdout1_104ck154 FIND v(dout1_104) AT=775.025n

* CHECK dout1_105 Vdout1_105ck154 = 0.9 time = 775
.meas tran vdout1_105ck154 FIND v(dout1_105) AT=775.025n

* CHECK dout1_106 Vdout1_106ck154 = 0 time = 775
.meas tran vdout1_106ck154 FIND v(dout1_106) AT=775.025n

* CHECK dout1_107 Vdout1_107ck154 = 0 time = 775
.meas tran vdout1_107ck154 FIND v(dout1_107) AT=775.025n

* CHECK dout1_108 Vdout1_108ck154 = 0 time = 775
.meas tran vdout1_108ck154 FIND v(dout1_108) AT=775.025n

* CHECK dout1_109 Vdout1_109ck154 = 0.9 time = 775
.meas tran vdout1_109ck154 FIND v(dout1_109) AT=775.025n

* CHECK dout1_110 Vdout1_110ck154 = 0 time = 775
.meas tran vdout1_110ck154 FIND v(dout1_110) AT=775.025n

* CHECK dout1_111 Vdout1_111ck154 = 0.9 time = 775
.meas tran vdout1_111ck154 FIND v(dout1_111) AT=775.025n

* CHECK dout1_112 Vdout1_112ck154 = 0.9 time = 775
.meas tran vdout1_112ck154 FIND v(dout1_112) AT=775.025n

* CHECK dout1_113 Vdout1_113ck154 = 0 time = 775
.meas tran vdout1_113ck154 FIND v(dout1_113) AT=775.025n

* CHECK dout1_114 Vdout1_114ck154 = 0 time = 775
.meas tran vdout1_114ck154 FIND v(dout1_114) AT=775.025n

* CHECK dout1_115 Vdout1_115ck154 = 0 time = 775
.meas tran vdout1_115ck154 FIND v(dout1_115) AT=775.025n

* CHECK dout1_116 Vdout1_116ck154 = 0.9 time = 775
.meas tran vdout1_116ck154 FIND v(dout1_116) AT=775.025n

* CHECK dout1_117 Vdout1_117ck154 = 0.9 time = 775
.meas tran vdout1_117ck154 FIND v(dout1_117) AT=775.025n

* CHECK dout1_118 Vdout1_118ck154 = 0 time = 775
.meas tran vdout1_118ck154 FIND v(dout1_118) AT=775.025n

* CHECK dout1_119 Vdout1_119ck154 = 0 time = 775
.meas tran vdout1_119ck154 FIND v(dout1_119) AT=775.025n

* CHECK dout1_0 Vdout1_0ck155 = 0 time = 780
.meas tran vdout1_0ck155 FIND v(dout1_0) AT=780.025n

* CHECK dout1_1 Vdout1_1ck155 = 0.9 time = 780
.meas tran vdout1_1ck155 FIND v(dout1_1) AT=780.025n

* CHECK dout1_2 Vdout1_2ck155 = 0 time = 780
.meas tran vdout1_2ck155 FIND v(dout1_2) AT=780.025n

* CHECK dout1_3 Vdout1_3ck155 = 0.9 time = 780
.meas tran vdout1_3ck155 FIND v(dout1_3) AT=780.025n

* CHECK dout1_4 Vdout1_4ck155 = 0 time = 780
.meas tran vdout1_4ck155 FIND v(dout1_4) AT=780.025n

* CHECK dout1_5 Vdout1_5ck155 = 0 time = 780
.meas tran vdout1_5ck155 FIND v(dout1_5) AT=780.025n

* CHECK dout1_6 Vdout1_6ck155 = 0 time = 780
.meas tran vdout1_6ck155 FIND v(dout1_6) AT=780.025n

* CHECK dout1_7 Vdout1_7ck155 = 0.9 time = 780
.meas tran vdout1_7ck155 FIND v(dout1_7) AT=780.025n

* CHECK dout1_8 Vdout1_8ck155 = 0.9 time = 780
.meas tran vdout1_8ck155 FIND v(dout1_8) AT=780.025n

* CHECK dout1_9 Vdout1_9ck155 = 0.9 time = 780
.meas tran vdout1_9ck155 FIND v(dout1_9) AT=780.025n

* CHECK dout1_10 Vdout1_10ck155 = 0 time = 780
.meas tran vdout1_10ck155 FIND v(dout1_10) AT=780.025n

* CHECK dout1_11 Vdout1_11ck155 = 0.9 time = 780
.meas tran vdout1_11ck155 FIND v(dout1_11) AT=780.025n

* CHECK dout1_12 Vdout1_12ck155 = 0.9 time = 780
.meas tran vdout1_12ck155 FIND v(dout1_12) AT=780.025n

* CHECK dout1_13 Vdout1_13ck155 = 0.9 time = 780
.meas tran vdout1_13ck155 FIND v(dout1_13) AT=780.025n

* CHECK dout1_14 Vdout1_14ck155 = 0.9 time = 780
.meas tran vdout1_14ck155 FIND v(dout1_14) AT=780.025n

* CHECK dout1_15 Vdout1_15ck155 = 0.9 time = 780
.meas tran vdout1_15ck155 FIND v(dout1_15) AT=780.025n

* CHECK dout1_16 Vdout1_16ck155 = 0.9 time = 780
.meas tran vdout1_16ck155 FIND v(dout1_16) AT=780.025n

* CHECK dout1_17 Vdout1_17ck155 = 0 time = 780
.meas tran vdout1_17ck155 FIND v(dout1_17) AT=780.025n

* CHECK dout1_18 Vdout1_18ck155 = 0 time = 780
.meas tran vdout1_18ck155 FIND v(dout1_18) AT=780.025n

* CHECK dout1_19 Vdout1_19ck155 = 0.9 time = 780
.meas tran vdout1_19ck155 FIND v(dout1_19) AT=780.025n

* CHECK dout1_20 Vdout1_20ck155 = 0 time = 780
.meas tran vdout1_20ck155 FIND v(dout1_20) AT=780.025n

* CHECK dout1_21 Vdout1_21ck155 = 0 time = 780
.meas tran vdout1_21ck155 FIND v(dout1_21) AT=780.025n

* CHECK dout1_22 Vdout1_22ck155 = 0.9 time = 780
.meas tran vdout1_22ck155 FIND v(dout1_22) AT=780.025n

* CHECK dout1_23 Vdout1_23ck155 = 0 time = 780
.meas tran vdout1_23ck155 FIND v(dout1_23) AT=780.025n

* CHECK dout1_24 Vdout1_24ck155 = 0.9 time = 780
.meas tran vdout1_24ck155 FIND v(dout1_24) AT=780.025n

* CHECK dout1_25 Vdout1_25ck155 = 0.9 time = 780
.meas tran vdout1_25ck155 FIND v(dout1_25) AT=780.025n

* CHECK dout1_26 Vdout1_26ck155 = 0.9 time = 780
.meas tran vdout1_26ck155 FIND v(dout1_26) AT=780.025n

* CHECK dout1_27 Vdout1_27ck155 = 0.9 time = 780
.meas tran vdout1_27ck155 FIND v(dout1_27) AT=780.025n

* CHECK dout1_28 Vdout1_28ck155 = 0.9 time = 780
.meas tran vdout1_28ck155 FIND v(dout1_28) AT=780.025n

* CHECK dout1_29 Vdout1_29ck155 = 0 time = 780
.meas tran vdout1_29ck155 FIND v(dout1_29) AT=780.025n

* CHECK dout1_30 Vdout1_30ck155 = 0.9 time = 780
.meas tran vdout1_30ck155 FIND v(dout1_30) AT=780.025n

* CHECK dout1_31 Vdout1_31ck155 = 0.9 time = 780
.meas tran vdout1_31ck155 FIND v(dout1_31) AT=780.025n

* CHECK dout1_32 Vdout1_32ck155 = 0 time = 780
.meas tran vdout1_32ck155 FIND v(dout1_32) AT=780.025n

* CHECK dout1_33 Vdout1_33ck155 = 0.9 time = 780
.meas tran vdout1_33ck155 FIND v(dout1_33) AT=780.025n

* CHECK dout1_34 Vdout1_34ck155 = 0 time = 780
.meas tran vdout1_34ck155 FIND v(dout1_34) AT=780.025n

* CHECK dout1_35 Vdout1_35ck155 = 0 time = 780
.meas tran vdout1_35ck155 FIND v(dout1_35) AT=780.025n

* CHECK dout1_36 Vdout1_36ck155 = 0 time = 780
.meas tran vdout1_36ck155 FIND v(dout1_36) AT=780.025n

* CHECK dout1_37 Vdout1_37ck155 = 0.9 time = 780
.meas tran vdout1_37ck155 FIND v(dout1_37) AT=780.025n

* CHECK dout1_38 Vdout1_38ck155 = 0.9 time = 780
.meas tran vdout1_38ck155 FIND v(dout1_38) AT=780.025n

* CHECK dout1_39 Vdout1_39ck155 = 0 time = 780
.meas tran vdout1_39ck155 FIND v(dout1_39) AT=780.025n

* CHECK dout1_40 Vdout1_40ck155 = 0.9 time = 780
.meas tran vdout1_40ck155 FIND v(dout1_40) AT=780.025n

* CHECK dout1_41 Vdout1_41ck155 = 0.9 time = 780
.meas tran vdout1_41ck155 FIND v(dout1_41) AT=780.025n

* CHECK dout1_42 Vdout1_42ck155 = 0.9 time = 780
.meas tran vdout1_42ck155 FIND v(dout1_42) AT=780.025n

* CHECK dout1_43 Vdout1_43ck155 = 0 time = 780
.meas tran vdout1_43ck155 FIND v(dout1_43) AT=780.025n

* CHECK dout1_44 Vdout1_44ck155 = 0 time = 780
.meas tran vdout1_44ck155 FIND v(dout1_44) AT=780.025n

* CHECK dout1_45 Vdout1_45ck155 = 0 time = 780
.meas tran vdout1_45ck155 FIND v(dout1_45) AT=780.025n

* CHECK dout1_46 Vdout1_46ck155 = 0.9 time = 780
.meas tran vdout1_46ck155 FIND v(dout1_46) AT=780.025n

* CHECK dout1_47 Vdout1_47ck155 = 0 time = 780
.meas tran vdout1_47ck155 FIND v(dout1_47) AT=780.025n

* CHECK dout1_48 Vdout1_48ck155 = 0 time = 780
.meas tran vdout1_48ck155 FIND v(dout1_48) AT=780.025n

* CHECK dout1_49 Vdout1_49ck155 = 0.9 time = 780
.meas tran vdout1_49ck155 FIND v(dout1_49) AT=780.025n

* CHECK dout1_50 Vdout1_50ck155 = 0.9 time = 780
.meas tran vdout1_50ck155 FIND v(dout1_50) AT=780.025n

* CHECK dout1_51 Vdout1_51ck155 = 0.9 time = 780
.meas tran vdout1_51ck155 FIND v(dout1_51) AT=780.025n

* CHECK dout1_52 Vdout1_52ck155 = 0.9 time = 780
.meas tran vdout1_52ck155 FIND v(dout1_52) AT=780.025n

* CHECK dout1_53 Vdout1_53ck155 = 0 time = 780
.meas tran vdout1_53ck155 FIND v(dout1_53) AT=780.025n

* CHECK dout1_54 Vdout1_54ck155 = 0.9 time = 780
.meas tran vdout1_54ck155 FIND v(dout1_54) AT=780.025n

* CHECK dout1_55 Vdout1_55ck155 = 0 time = 780
.meas tran vdout1_55ck155 FIND v(dout1_55) AT=780.025n

* CHECK dout1_56 Vdout1_56ck155 = 0 time = 780
.meas tran vdout1_56ck155 FIND v(dout1_56) AT=780.025n

* CHECK dout1_57 Vdout1_57ck155 = 0 time = 780
.meas tran vdout1_57ck155 FIND v(dout1_57) AT=780.025n

* CHECK dout1_58 Vdout1_58ck155 = 0.9 time = 780
.meas tran vdout1_58ck155 FIND v(dout1_58) AT=780.025n

* CHECK dout1_59 Vdout1_59ck155 = 0.9 time = 780
.meas tran vdout1_59ck155 FIND v(dout1_59) AT=780.025n

* CHECK dout1_60 Vdout1_60ck155 = 0.9 time = 780
.meas tran vdout1_60ck155 FIND v(dout1_60) AT=780.025n

* CHECK dout1_61 Vdout1_61ck155 = 0 time = 780
.meas tran vdout1_61ck155 FIND v(dout1_61) AT=780.025n

* CHECK dout1_62 Vdout1_62ck155 = 0.9 time = 780
.meas tran vdout1_62ck155 FIND v(dout1_62) AT=780.025n

* CHECK dout1_63 Vdout1_63ck155 = 0.9 time = 780
.meas tran vdout1_63ck155 FIND v(dout1_63) AT=780.025n

* CHECK dout1_64 Vdout1_64ck155 = 0.9 time = 780
.meas tran vdout1_64ck155 FIND v(dout1_64) AT=780.025n

* CHECK dout1_65 Vdout1_65ck155 = 0 time = 780
.meas tran vdout1_65ck155 FIND v(dout1_65) AT=780.025n

* CHECK dout1_66 Vdout1_66ck155 = 0.9 time = 780
.meas tran vdout1_66ck155 FIND v(dout1_66) AT=780.025n

* CHECK dout1_67 Vdout1_67ck155 = 0.9 time = 780
.meas tran vdout1_67ck155 FIND v(dout1_67) AT=780.025n

* CHECK dout1_68 Vdout1_68ck155 = 0 time = 780
.meas tran vdout1_68ck155 FIND v(dout1_68) AT=780.025n

* CHECK dout1_69 Vdout1_69ck155 = 0 time = 780
.meas tran vdout1_69ck155 FIND v(dout1_69) AT=780.025n

* CHECK dout1_70 Vdout1_70ck155 = 0.9 time = 780
.meas tran vdout1_70ck155 FIND v(dout1_70) AT=780.025n

* CHECK dout1_71 Vdout1_71ck155 = 0.9 time = 780
.meas tran vdout1_71ck155 FIND v(dout1_71) AT=780.025n

* CHECK dout1_72 Vdout1_72ck155 = 0 time = 780
.meas tran vdout1_72ck155 FIND v(dout1_72) AT=780.025n

* CHECK dout1_73 Vdout1_73ck155 = 0 time = 780
.meas tran vdout1_73ck155 FIND v(dout1_73) AT=780.025n

* CHECK dout1_74 Vdout1_74ck155 = 0 time = 780
.meas tran vdout1_74ck155 FIND v(dout1_74) AT=780.025n

* CHECK dout1_75 Vdout1_75ck155 = 0.9 time = 780
.meas tran vdout1_75ck155 FIND v(dout1_75) AT=780.025n

* CHECK dout1_76 Vdout1_76ck155 = 0 time = 780
.meas tran vdout1_76ck155 FIND v(dout1_76) AT=780.025n

* CHECK dout1_77 Vdout1_77ck155 = 0.9 time = 780
.meas tran vdout1_77ck155 FIND v(dout1_77) AT=780.025n

* CHECK dout1_78 Vdout1_78ck155 = 0.9 time = 780
.meas tran vdout1_78ck155 FIND v(dout1_78) AT=780.025n

* CHECK dout1_79 Vdout1_79ck155 = 0 time = 780
.meas tran vdout1_79ck155 FIND v(dout1_79) AT=780.025n

* CHECK dout1_80 Vdout1_80ck155 = 0.9 time = 780
.meas tran vdout1_80ck155 FIND v(dout1_80) AT=780.025n

* CHECK dout1_81 Vdout1_81ck155 = 0 time = 780
.meas tran vdout1_81ck155 FIND v(dout1_81) AT=780.025n

* CHECK dout1_82 Vdout1_82ck155 = 0.9 time = 780
.meas tran vdout1_82ck155 FIND v(dout1_82) AT=780.025n

* CHECK dout1_83 Vdout1_83ck155 = 0.9 time = 780
.meas tran vdout1_83ck155 FIND v(dout1_83) AT=780.025n

* CHECK dout1_84 Vdout1_84ck155 = 0.9 time = 780
.meas tran vdout1_84ck155 FIND v(dout1_84) AT=780.025n

* CHECK dout1_85 Vdout1_85ck155 = 0.9 time = 780
.meas tran vdout1_85ck155 FIND v(dout1_85) AT=780.025n

* CHECK dout1_86 Vdout1_86ck155 = 0 time = 780
.meas tran vdout1_86ck155 FIND v(dout1_86) AT=780.025n

* CHECK dout1_87 Vdout1_87ck155 = 0 time = 780
.meas tran vdout1_87ck155 FIND v(dout1_87) AT=780.025n

* CHECK dout1_88 Vdout1_88ck155 = 0 time = 780
.meas tran vdout1_88ck155 FIND v(dout1_88) AT=780.025n

* CHECK dout1_89 Vdout1_89ck155 = 0 time = 780
.meas tran vdout1_89ck155 FIND v(dout1_89) AT=780.025n

* CHECK dout1_90 Vdout1_90ck155 = 0.9 time = 780
.meas tran vdout1_90ck155 FIND v(dout1_90) AT=780.025n

* CHECK dout1_91 Vdout1_91ck155 = 0 time = 780
.meas tran vdout1_91ck155 FIND v(dout1_91) AT=780.025n

* CHECK dout1_92 Vdout1_92ck155 = 0 time = 780
.meas tran vdout1_92ck155 FIND v(dout1_92) AT=780.025n

* CHECK dout1_93 Vdout1_93ck155 = 0.9 time = 780
.meas tran vdout1_93ck155 FIND v(dout1_93) AT=780.025n

* CHECK dout1_94 Vdout1_94ck155 = 0 time = 780
.meas tran vdout1_94ck155 FIND v(dout1_94) AT=780.025n

* CHECK dout1_95 Vdout1_95ck155 = 0 time = 780
.meas tran vdout1_95ck155 FIND v(dout1_95) AT=780.025n

* CHECK dout1_96 Vdout1_96ck155 = 0 time = 780
.meas tran vdout1_96ck155 FIND v(dout1_96) AT=780.025n

* CHECK dout1_97 Vdout1_97ck155 = 0.9 time = 780
.meas tran vdout1_97ck155 FIND v(dout1_97) AT=780.025n

* CHECK dout1_98 Vdout1_98ck155 = 0 time = 780
.meas tran vdout1_98ck155 FIND v(dout1_98) AT=780.025n

* CHECK dout1_99 Vdout1_99ck155 = 0 time = 780
.meas tran vdout1_99ck155 FIND v(dout1_99) AT=780.025n

* CHECK dout1_100 Vdout1_100ck155 = 0 time = 780
.meas tran vdout1_100ck155 FIND v(dout1_100) AT=780.025n

* CHECK dout1_101 Vdout1_101ck155 = 0 time = 780
.meas tran vdout1_101ck155 FIND v(dout1_101) AT=780.025n

* CHECK dout1_102 Vdout1_102ck155 = 0.9 time = 780
.meas tran vdout1_102ck155 FIND v(dout1_102) AT=780.025n

* CHECK dout1_103 Vdout1_103ck155 = 0 time = 780
.meas tran vdout1_103ck155 FIND v(dout1_103) AT=780.025n

* CHECK dout1_104 Vdout1_104ck155 = 0.9 time = 780
.meas tran vdout1_104ck155 FIND v(dout1_104) AT=780.025n

* CHECK dout1_105 Vdout1_105ck155 = 0.9 time = 780
.meas tran vdout1_105ck155 FIND v(dout1_105) AT=780.025n

* CHECK dout1_106 Vdout1_106ck155 = 0 time = 780
.meas tran vdout1_106ck155 FIND v(dout1_106) AT=780.025n

* CHECK dout1_107 Vdout1_107ck155 = 0 time = 780
.meas tran vdout1_107ck155 FIND v(dout1_107) AT=780.025n

* CHECK dout1_108 Vdout1_108ck155 = 0 time = 780
.meas tran vdout1_108ck155 FIND v(dout1_108) AT=780.025n

* CHECK dout1_109 Vdout1_109ck155 = 0.9 time = 780
.meas tran vdout1_109ck155 FIND v(dout1_109) AT=780.025n

* CHECK dout1_110 Vdout1_110ck155 = 0 time = 780
.meas tran vdout1_110ck155 FIND v(dout1_110) AT=780.025n

* CHECK dout1_111 Vdout1_111ck155 = 0.9 time = 780
.meas tran vdout1_111ck155 FIND v(dout1_111) AT=780.025n

* CHECK dout1_112 Vdout1_112ck155 = 0.9 time = 780
.meas tran vdout1_112ck155 FIND v(dout1_112) AT=780.025n

* CHECK dout1_113 Vdout1_113ck155 = 0 time = 780
.meas tran vdout1_113ck155 FIND v(dout1_113) AT=780.025n

* CHECK dout1_114 Vdout1_114ck155 = 0 time = 780
.meas tran vdout1_114ck155 FIND v(dout1_114) AT=780.025n

* CHECK dout1_115 Vdout1_115ck155 = 0 time = 780
.meas tran vdout1_115ck155 FIND v(dout1_115) AT=780.025n

* CHECK dout1_116 Vdout1_116ck155 = 0.9 time = 780
.meas tran vdout1_116ck155 FIND v(dout1_116) AT=780.025n

* CHECK dout1_117 Vdout1_117ck155 = 0.9 time = 780
.meas tran vdout1_117ck155 FIND v(dout1_117) AT=780.025n

* CHECK dout1_118 Vdout1_118ck155 = 0 time = 780
.meas tran vdout1_118ck155 FIND v(dout1_118) AT=780.025n

* CHECK dout1_119 Vdout1_119ck155 = 0 time = 780
.meas tran vdout1_119ck155 FIND v(dout1_119) AT=780.025n

* CHECK dout1_0 Vdout1_0ck156 = 0.9 time = 785
.meas tran vdout1_0ck156 FIND v(dout1_0) AT=785.025n

* CHECK dout1_1 Vdout1_1ck156 = 0.9 time = 785
.meas tran vdout1_1ck156 FIND v(dout1_1) AT=785.025n

* CHECK dout1_2 Vdout1_2ck156 = 0 time = 785
.meas tran vdout1_2ck156 FIND v(dout1_2) AT=785.025n

* CHECK dout1_3 Vdout1_3ck156 = 0 time = 785
.meas tran vdout1_3ck156 FIND v(dout1_3) AT=785.025n

* CHECK dout1_4 Vdout1_4ck156 = 0 time = 785
.meas tran vdout1_4ck156 FIND v(dout1_4) AT=785.025n

* CHECK dout1_5 Vdout1_5ck156 = 0.9 time = 785
.meas tran vdout1_5ck156 FIND v(dout1_5) AT=785.025n

* CHECK dout1_6 Vdout1_6ck156 = 0 time = 785
.meas tran vdout1_6ck156 FIND v(dout1_6) AT=785.025n

* CHECK dout1_7 Vdout1_7ck156 = 0 time = 785
.meas tran vdout1_7ck156 FIND v(dout1_7) AT=785.025n

* CHECK dout1_8 Vdout1_8ck156 = 0 time = 785
.meas tran vdout1_8ck156 FIND v(dout1_8) AT=785.025n

* CHECK dout1_9 Vdout1_9ck156 = 0 time = 785
.meas tran vdout1_9ck156 FIND v(dout1_9) AT=785.025n

* CHECK dout1_10 Vdout1_10ck156 = 0 time = 785
.meas tran vdout1_10ck156 FIND v(dout1_10) AT=785.025n

* CHECK dout1_11 Vdout1_11ck156 = 0.9 time = 785
.meas tran vdout1_11ck156 FIND v(dout1_11) AT=785.025n

* CHECK dout1_12 Vdout1_12ck156 = 0 time = 785
.meas tran vdout1_12ck156 FIND v(dout1_12) AT=785.025n

* CHECK dout1_13 Vdout1_13ck156 = 0 time = 785
.meas tran vdout1_13ck156 FIND v(dout1_13) AT=785.025n

* CHECK dout1_14 Vdout1_14ck156 = 0 time = 785
.meas tran vdout1_14ck156 FIND v(dout1_14) AT=785.025n

* CHECK dout1_15 Vdout1_15ck156 = 0 time = 785
.meas tran vdout1_15ck156 FIND v(dout1_15) AT=785.025n

* CHECK dout1_16 Vdout1_16ck156 = 0.9 time = 785
.meas tran vdout1_16ck156 FIND v(dout1_16) AT=785.025n

* CHECK dout1_17 Vdout1_17ck156 = 0.9 time = 785
.meas tran vdout1_17ck156 FIND v(dout1_17) AT=785.025n

* CHECK dout1_18 Vdout1_18ck156 = 0 time = 785
.meas tran vdout1_18ck156 FIND v(dout1_18) AT=785.025n

* CHECK dout1_19 Vdout1_19ck156 = 0.9 time = 785
.meas tran vdout1_19ck156 FIND v(dout1_19) AT=785.025n

* CHECK dout1_20 Vdout1_20ck156 = 0.9 time = 785
.meas tran vdout1_20ck156 FIND v(dout1_20) AT=785.025n

* CHECK dout1_21 Vdout1_21ck156 = 0 time = 785
.meas tran vdout1_21ck156 FIND v(dout1_21) AT=785.025n

* CHECK dout1_22 Vdout1_22ck156 = 0 time = 785
.meas tran vdout1_22ck156 FIND v(dout1_22) AT=785.025n

* CHECK dout1_23 Vdout1_23ck156 = 0 time = 785
.meas tran vdout1_23ck156 FIND v(dout1_23) AT=785.025n

* CHECK dout1_24 Vdout1_24ck156 = 0.9 time = 785
.meas tran vdout1_24ck156 FIND v(dout1_24) AT=785.025n

* CHECK dout1_25 Vdout1_25ck156 = 0 time = 785
.meas tran vdout1_25ck156 FIND v(dout1_25) AT=785.025n

* CHECK dout1_26 Vdout1_26ck156 = 0 time = 785
.meas tran vdout1_26ck156 FIND v(dout1_26) AT=785.025n

* CHECK dout1_27 Vdout1_27ck156 = 0.9 time = 785
.meas tran vdout1_27ck156 FIND v(dout1_27) AT=785.025n

* CHECK dout1_28 Vdout1_28ck156 = 0 time = 785
.meas tran vdout1_28ck156 FIND v(dout1_28) AT=785.025n

* CHECK dout1_29 Vdout1_29ck156 = 0 time = 785
.meas tran vdout1_29ck156 FIND v(dout1_29) AT=785.025n

* CHECK dout1_30 Vdout1_30ck156 = 0 time = 785
.meas tran vdout1_30ck156 FIND v(dout1_30) AT=785.025n

* CHECK dout1_31 Vdout1_31ck156 = 0.9 time = 785
.meas tran vdout1_31ck156 FIND v(dout1_31) AT=785.025n

* CHECK dout1_32 Vdout1_32ck156 = 0 time = 785
.meas tran vdout1_32ck156 FIND v(dout1_32) AT=785.025n

* CHECK dout1_33 Vdout1_33ck156 = 0 time = 785
.meas tran vdout1_33ck156 FIND v(dout1_33) AT=785.025n

* CHECK dout1_34 Vdout1_34ck156 = 0 time = 785
.meas tran vdout1_34ck156 FIND v(dout1_34) AT=785.025n

* CHECK dout1_35 Vdout1_35ck156 = 0.9 time = 785
.meas tran vdout1_35ck156 FIND v(dout1_35) AT=785.025n

* CHECK dout1_36 Vdout1_36ck156 = 0 time = 785
.meas tran vdout1_36ck156 FIND v(dout1_36) AT=785.025n

* CHECK dout1_37 Vdout1_37ck156 = 0 time = 785
.meas tran vdout1_37ck156 FIND v(dout1_37) AT=785.025n

* CHECK dout1_38 Vdout1_38ck156 = 0 time = 785
.meas tran vdout1_38ck156 FIND v(dout1_38) AT=785.025n

* CHECK dout1_39 Vdout1_39ck156 = 0.9 time = 785
.meas tran vdout1_39ck156 FIND v(dout1_39) AT=785.025n

* CHECK dout1_40 Vdout1_40ck156 = 0 time = 785
.meas tran vdout1_40ck156 FIND v(dout1_40) AT=785.025n

* CHECK dout1_41 Vdout1_41ck156 = 0.9 time = 785
.meas tran vdout1_41ck156 FIND v(dout1_41) AT=785.025n

* CHECK dout1_42 Vdout1_42ck156 = 0 time = 785
.meas tran vdout1_42ck156 FIND v(dout1_42) AT=785.025n

* CHECK dout1_43 Vdout1_43ck156 = 0 time = 785
.meas tran vdout1_43ck156 FIND v(dout1_43) AT=785.025n

* CHECK dout1_44 Vdout1_44ck156 = 0 time = 785
.meas tran vdout1_44ck156 FIND v(dout1_44) AT=785.025n

* CHECK dout1_45 Vdout1_45ck156 = 0.9 time = 785
.meas tran vdout1_45ck156 FIND v(dout1_45) AT=785.025n

* CHECK dout1_46 Vdout1_46ck156 = 0.9 time = 785
.meas tran vdout1_46ck156 FIND v(dout1_46) AT=785.025n

* CHECK dout1_47 Vdout1_47ck156 = 0 time = 785
.meas tran vdout1_47ck156 FIND v(dout1_47) AT=785.025n

* CHECK dout1_48 Vdout1_48ck156 = 0.9 time = 785
.meas tran vdout1_48ck156 FIND v(dout1_48) AT=785.025n

* CHECK dout1_49 Vdout1_49ck156 = 0 time = 785
.meas tran vdout1_49ck156 FIND v(dout1_49) AT=785.025n

* CHECK dout1_50 Vdout1_50ck156 = 0 time = 785
.meas tran vdout1_50ck156 FIND v(dout1_50) AT=785.025n

* CHECK dout1_51 Vdout1_51ck156 = 0.9 time = 785
.meas tran vdout1_51ck156 FIND v(dout1_51) AT=785.025n

* CHECK dout1_52 Vdout1_52ck156 = 0.9 time = 785
.meas tran vdout1_52ck156 FIND v(dout1_52) AT=785.025n

* CHECK dout1_53 Vdout1_53ck156 = 0.9 time = 785
.meas tran vdout1_53ck156 FIND v(dout1_53) AT=785.025n

* CHECK dout1_54 Vdout1_54ck156 = 0 time = 785
.meas tran vdout1_54ck156 FIND v(dout1_54) AT=785.025n

* CHECK dout1_55 Vdout1_55ck156 = 0 time = 785
.meas tran vdout1_55ck156 FIND v(dout1_55) AT=785.025n

* CHECK dout1_56 Vdout1_56ck156 = 0.9 time = 785
.meas tran vdout1_56ck156 FIND v(dout1_56) AT=785.025n

* CHECK dout1_57 Vdout1_57ck156 = 0 time = 785
.meas tran vdout1_57ck156 FIND v(dout1_57) AT=785.025n

* CHECK dout1_58 Vdout1_58ck156 = 0.9 time = 785
.meas tran vdout1_58ck156 FIND v(dout1_58) AT=785.025n

* CHECK dout1_59 Vdout1_59ck156 = 0 time = 785
.meas tran vdout1_59ck156 FIND v(dout1_59) AT=785.025n

* CHECK dout1_60 Vdout1_60ck156 = 0.9 time = 785
.meas tran vdout1_60ck156 FIND v(dout1_60) AT=785.025n

* CHECK dout1_61 Vdout1_61ck156 = 0 time = 785
.meas tran vdout1_61ck156 FIND v(dout1_61) AT=785.025n

* CHECK dout1_62 Vdout1_62ck156 = 0 time = 785
.meas tran vdout1_62ck156 FIND v(dout1_62) AT=785.025n

* CHECK dout1_63 Vdout1_63ck156 = 0 time = 785
.meas tran vdout1_63ck156 FIND v(dout1_63) AT=785.025n

* CHECK dout1_64 Vdout1_64ck156 = 0 time = 785
.meas tran vdout1_64ck156 FIND v(dout1_64) AT=785.025n

* CHECK dout1_65 Vdout1_65ck156 = 0 time = 785
.meas tran vdout1_65ck156 FIND v(dout1_65) AT=785.025n

* CHECK dout1_66 Vdout1_66ck156 = 0.9 time = 785
.meas tran vdout1_66ck156 FIND v(dout1_66) AT=785.025n

* CHECK dout1_67 Vdout1_67ck156 = 0 time = 785
.meas tran vdout1_67ck156 FIND v(dout1_67) AT=785.025n

* CHECK dout1_68 Vdout1_68ck156 = 0.9 time = 785
.meas tran vdout1_68ck156 FIND v(dout1_68) AT=785.025n

* CHECK dout1_69 Vdout1_69ck156 = 0 time = 785
.meas tran vdout1_69ck156 FIND v(dout1_69) AT=785.025n

* CHECK dout1_70 Vdout1_70ck156 = 0 time = 785
.meas tran vdout1_70ck156 FIND v(dout1_70) AT=785.025n

* CHECK dout1_71 Vdout1_71ck156 = 0 time = 785
.meas tran vdout1_71ck156 FIND v(dout1_71) AT=785.025n

* CHECK dout1_72 Vdout1_72ck156 = 0 time = 785
.meas tran vdout1_72ck156 FIND v(dout1_72) AT=785.025n

* CHECK dout1_73 Vdout1_73ck156 = 0 time = 785
.meas tran vdout1_73ck156 FIND v(dout1_73) AT=785.025n

* CHECK dout1_74 Vdout1_74ck156 = 0.9 time = 785
.meas tran vdout1_74ck156 FIND v(dout1_74) AT=785.025n

* CHECK dout1_75 Vdout1_75ck156 = 0 time = 785
.meas tran vdout1_75ck156 FIND v(dout1_75) AT=785.025n

* CHECK dout1_76 Vdout1_76ck156 = 0 time = 785
.meas tran vdout1_76ck156 FIND v(dout1_76) AT=785.025n

* CHECK dout1_77 Vdout1_77ck156 = 0 time = 785
.meas tran vdout1_77ck156 FIND v(dout1_77) AT=785.025n

* CHECK dout1_78 Vdout1_78ck156 = 0.9 time = 785
.meas tran vdout1_78ck156 FIND v(dout1_78) AT=785.025n

* CHECK dout1_79 Vdout1_79ck156 = 0 time = 785
.meas tran vdout1_79ck156 FIND v(dout1_79) AT=785.025n

* CHECK dout1_80 Vdout1_80ck156 = 0.9 time = 785
.meas tran vdout1_80ck156 FIND v(dout1_80) AT=785.025n

* CHECK dout1_81 Vdout1_81ck156 = 0 time = 785
.meas tran vdout1_81ck156 FIND v(dout1_81) AT=785.025n

* CHECK dout1_82 Vdout1_82ck156 = 0.9 time = 785
.meas tran vdout1_82ck156 FIND v(dout1_82) AT=785.025n

* CHECK dout1_83 Vdout1_83ck156 = 0.9 time = 785
.meas tran vdout1_83ck156 FIND v(dout1_83) AT=785.025n

* CHECK dout1_84 Vdout1_84ck156 = 0.9 time = 785
.meas tran vdout1_84ck156 FIND v(dout1_84) AT=785.025n

* CHECK dout1_85 Vdout1_85ck156 = 0.9 time = 785
.meas tran vdout1_85ck156 FIND v(dout1_85) AT=785.025n

* CHECK dout1_86 Vdout1_86ck156 = 0.9 time = 785
.meas tran vdout1_86ck156 FIND v(dout1_86) AT=785.025n

* CHECK dout1_87 Vdout1_87ck156 = 0.9 time = 785
.meas tran vdout1_87ck156 FIND v(dout1_87) AT=785.025n

* CHECK dout1_88 Vdout1_88ck156 = 0 time = 785
.meas tran vdout1_88ck156 FIND v(dout1_88) AT=785.025n

* CHECK dout1_89 Vdout1_89ck156 = 0.9 time = 785
.meas tran vdout1_89ck156 FIND v(dout1_89) AT=785.025n

* CHECK dout1_90 Vdout1_90ck156 = 0 time = 785
.meas tran vdout1_90ck156 FIND v(dout1_90) AT=785.025n

* CHECK dout1_91 Vdout1_91ck156 = 0.9 time = 785
.meas tran vdout1_91ck156 FIND v(dout1_91) AT=785.025n

* CHECK dout1_92 Vdout1_92ck156 = 0.9 time = 785
.meas tran vdout1_92ck156 FIND v(dout1_92) AT=785.025n

* CHECK dout1_93 Vdout1_93ck156 = 0 time = 785
.meas tran vdout1_93ck156 FIND v(dout1_93) AT=785.025n

* CHECK dout1_94 Vdout1_94ck156 = 0.9 time = 785
.meas tran vdout1_94ck156 FIND v(dout1_94) AT=785.025n

* CHECK dout1_95 Vdout1_95ck156 = 0.9 time = 785
.meas tran vdout1_95ck156 FIND v(dout1_95) AT=785.025n

* CHECK dout1_96 Vdout1_96ck156 = 0.9 time = 785
.meas tran vdout1_96ck156 FIND v(dout1_96) AT=785.025n

* CHECK dout1_97 Vdout1_97ck156 = 0.9 time = 785
.meas tran vdout1_97ck156 FIND v(dout1_97) AT=785.025n

* CHECK dout1_98 Vdout1_98ck156 = 0 time = 785
.meas tran vdout1_98ck156 FIND v(dout1_98) AT=785.025n

* CHECK dout1_99 Vdout1_99ck156 = 0.9 time = 785
.meas tran vdout1_99ck156 FIND v(dout1_99) AT=785.025n

* CHECK dout1_100 Vdout1_100ck156 = 0 time = 785
.meas tran vdout1_100ck156 FIND v(dout1_100) AT=785.025n

* CHECK dout1_101 Vdout1_101ck156 = 0.9 time = 785
.meas tran vdout1_101ck156 FIND v(dout1_101) AT=785.025n

* CHECK dout1_102 Vdout1_102ck156 = 0 time = 785
.meas tran vdout1_102ck156 FIND v(dout1_102) AT=785.025n

* CHECK dout1_103 Vdout1_103ck156 = 0 time = 785
.meas tran vdout1_103ck156 FIND v(dout1_103) AT=785.025n

* CHECK dout1_104 Vdout1_104ck156 = 0.9 time = 785
.meas tran vdout1_104ck156 FIND v(dout1_104) AT=785.025n

* CHECK dout1_105 Vdout1_105ck156 = 0.9 time = 785
.meas tran vdout1_105ck156 FIND v(dout1_105) AT=785.025n

* CHECK dout1_106 Vdout1_106ck156 = 0.9 time = 785
.meas tran vdout1_106ck156 FIND v(dout1_106) AT=785.025n

* CHECK dout1_107 Vdout1_107ck156 = 0.9 time = 785
.meas tran vdout1_107ck156 FIND v(dout1_107) AT=785.025n

* CHECK dout1_108 Vdout1_108ck156 = 0 time = 785
.meas tran vdout1_108ck156 FIND v(dout1_108) AT=785.025n

* CHECK dout1_109 Vdout1_109ck156 = 0.9 time = 785
.meas tran vdout1_109ck156 FIND v(dout1_109) AT=785.025n

* CHECK dout1_110 Vdout1_110ck156 = 0 time = 785
.meas tran vdout1_110ck156 FIND v(dout1_110) AT=785.025n

* CHECK dout1_111 Vdout1_111ck156 = 0 time = 785
.meas tran vdout1_111ck156 FIND v(dout1_111) AT=785.025n

* CHECK dout1_112 Vdout1_112ck156 = 0 time = 785
.meas tran vdout1_112ck156 FIND v(dout1_112) AT=785.025n

* CHECK dout1_113 Vdout1_113ck156 = 0 time = 785
.meas tran vdout1_113ck156 FIND v(dout1_113) AT=785.025n

* CHECK dout1_114 Vdout1_114ck156 = 0.9 time = 785
.meas tran vdout1_114ck156 FIND v(dout1_114) AT=785.025n

* CHECK dout1_115 Vdout1_115ck156 = 0 time = 785
.meas tran vdout1_115ck156 FIND v(dout1_115) AT=785.025n

* CHECK dout1_116 Vdout1_116ck156 = 0.9 time = 785
.meas tran vdout1_116ck156 FIND v(dout1_116) AT=785.025n

* CHECK dout1_117 Vdout1_117ck156 = 0 time = 785
.meas tran vdout1_117ck156 FIND v(dout1_117) AT=785.025n

* CHECK dout1_118 Vdout1_118ck156 = 0.9 time = 785
.meas tran vdout1_118ck156 FIND v(dout1_118) AT=785.025n

* CHECK dout1_119 Vdout1_119ck156 = 0.9 time = 785
.meas tran vdout1_119ck156 FIND v(dout1_119) AT=785.025n

* CHECK dout1_0 Vdout1_0ck157 = 0 time = 790
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=790.025n

* CHECK dout1_1 Vdout1_1ck157 = 0 time = 790
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=790.025n

* CHECK dout1_2 Vdout1_2ck157 = 0.9 time = 790
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=790.025n

* CHECK dout1_3 Vdout1_3ck157 = 0 time = 790
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=790.025n

* CHECK dout1_4 Vdout1_4ck157 = 0.9 time = 790
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=790.025n

* CHECK dout1_5 Vdout1_5ck157 = 0 time = 790
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=790.025n

* CHECK dout1_6 Vdout1_6ck157 = 0.9 time = 790
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=790.025n

* CHECK dout1_7 Vdout1_7ck157 = 0 time = 790
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=790.025n

* CHECK dout1_8 Vdout1_8ck157 = 0 time = 790
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=790.025n

* CHECK dout1_9 Vdout1_9ck157 = 0 time = 790
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=790.025n

* CHECK dout1_10 Vdout1_10ck157 = 0.9 time = 790
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=790.025n

* CHECK dout1_11 Vdout1_11ck157 = 0.9 time = 790
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=790.025n

* CHECK dout1_12 Vdout1_12ck157 = 0 time = 790
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=790.025n

* CHECK dout1_13 Vdout1_13ck157 = 0 time = 790
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=790.025n

* CHECK dout1_14 Vdout1_14ck157 = 0 time = 790
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=790.025n

* CHECK dout1_15 Vdout1_15ck157 = 0 time = 790
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=790.025n

* CHECK dout1_16 Vdout1_16ck157 = 0 time = 790
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=790.025n

* CHECK dout1_17 Vdout1_17ck157 = 0.9 time = 790
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=790.025n

* CHECK dout1_18 Vdout1_18ck157 = 0.9 time = 790
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=790.025n

* CHECK dout1_19 Vdout1_19ck157 = 0 time = 790
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=790.025n

* CHECK dout1_20 Vdout1_20ck157 = 0.9 time = 790
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=790.025n

* CHECK dout1_21 Vdout1_21ck157 = 0 time = 790
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=790.025n

* CHECK dout1_22 Vdout1_22ck157 = 0.9 time = 790
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=790.025n

* CHECK dout1_23 Vdout1_23ck157 = 0 time = 790
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=790.025n

* CHECK dout1_24 Vdout1_24ck157 = 0 time = 790
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=790.025n

* CHECK dout1_25 Vdout1_25ck157 = 0 time = 790
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=790.025n

* CHECK dout1_26 Vdout1_26ck157 = 0.9 time = 790
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=790.025n

* CHECK dout1_27 Vdout1_27ck157 = 0.9 time = 790
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=790.025n

* CHECK dout1_28 Vdout1_28ck157 = 0 time = 790
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=790.025n

* CHECK dout1_29 Vdout1_29ck157 = 0 time = 790
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=790.025n

* CHECK dout1_30 Vdout1_30ck157 = 0 time = 790
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=790.025n

* CHECK dout1_31 Vdout1_31ck157 = 0.9 time = 790
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=790.025n

* CHECK dout1_32 Vdout1_32ck157 = 0 time = 790
.meas tran vdout1_32ck157 FIND v(dout1_32) AT=790.025n

* CHECK dout1_33 Vdout1_33ck157 = 0.9 time = 790
.meas tran vdout1_33ck157 FIND v(dout1_33) AT=790.025n

* CHECK dout1_34 Vdout1_34ck157 = 0.9 time = 790
.meas tran vdout1_34ck157 FIND v(dout1_34) AT=790.025n

* CHECK dout1_35 Vdout1_35ck157 = 0 time = 790
.meas tran vdout1_35ck157 FIND v(dout1_35) AT=790.025n

* CHECK dout1_36 Vdout1_36ck157 = 0 time = 790
.meas tran vdout1_36ck157 FIND v(dout1_36) AT=790.025n

* CHECK dout1_37 Vdout1_37ck157 = 0.9 time = 790
.meas tran vdout1_37ck157 FIND v(dout1_37) AT=790.025n

* CHECK dout1_38 Vdout1_38ck157 = 0.9 time = 790
.meas tran vdout1_38ck157 FIND v(dout1_38) AT=790.025n

* CHECK dout1_39 Vdout1_39ck157 = 0 time = 790
.meas tran vdout1_39ck157 FIND v(dout1_39) AT=790.025n

* CHECK dout1_40 Vdout1_40ck157 = 0 time = 790
.meas tran vdout1_40ck157 FIND v(dout1_40) AT=790.025n

* CHECK dout1_41 Vdout1_41ck157 = 0 time = 790
.meas tran vdout1_41ck157 FIND v(dout1_41) AT=790.025n

* CHECK dout1_42 Vdout1_42ck157 = 0.9 time = 790
.meas tran vdout1_42ck157 FIND v(dout1_42) AT=790.025n

* CHECK dout1_43 Vdout1_43ck157 = 0.9 time = 790
.meas tran vdout1_43ck157 FIND v(dout1_43) AT=790.025n

* CHECK dout1_44 Vdout1_44ck157 = 0 time = 790
.meas tran vdout1_44ck157 FIND v(dout1_44) AT=790.025n

* CHECK dout1_45 Vdout1_45ck157 = 0 time = 790
.meas tran vdout1_45ck157 FIND v(dout1_45) AT=790.025n

* CHECK dout1_46 Vdout1_46ck157 = 0.9 time = 790
.meas tran vdout1_46ck157 FIND v(dout1_46) AT=790.025n

* CHECK dout1_47 Vdout1_47ck157 = 0 time = 790
.meas tran vdout1_47ck157 FIND v(dout1_47) AT=790.025n

* CHECK dout1_48 Vdout1_48ck157 = 0 time = 790
.meas tran vdout1_48ck157 FIND v(dout1_48) AT=790.025n

* CHECK dout1_49 Vdout1_49ck157 = 0.9 time = 790
.meas tran vdout1_49ck157 FIND v(dout1_49) AT=790.025n

* CHECK dout1_50 Vdout1_50ck157 = 0 time = 790
.meas tran vdout1_50ck157 FIND v(dout1_50) AT=790.025n

* CHECK dout1_51 Vdout1_51ck157 = 0.9 time = 790
.meas tran vdout1_51ck157 FIND v(dout1_51) AT=790.025n

* CHECK dout1_52 Vdout1_52ck157 = 0.9 time = 790
.meas tran vdout1_52ck157 FIND v(dout1_52) AT=790.025n

* CHECK dout1_53 Vdout1_53ck157 = 0.9 time = 790
.meas tran vdout1_53ck157 FIND v(dout1_53) AT=790.025n

* CHECK dout1_54 Vdout1_54ck157 = 0.9 time = 790
.meas tran vdout1_54ck157 FIND v(dout1_54) AT=790.025n

* CHECK dout1_55 Vdout1_55ck157 = 0.9 time = 790
.meas tran vdout1_55ck157 FIND v(dout1_55) AT=790.025n

* CHECK dout1_56 Vdout1_56ck157 = 0.9 time = 790
.meas tran vdout1_56ck157 FIND v(dout1_56) AT=790.025n

* CHECK dout1_57 Vdout1_57ck157 = 0 time = 790
.meas tran vdout1_57ck157 FIND v(dout1_57) AT=790.025n

* CHECK dout1_58 Vdout1_58ck157 = 0.9 time = 790
.meas tran vdout1_58ck157 FIND v(dout1_58) AT=790.025n

* CHECK dout1_59 Vdout1_59ck157 = 0.9 time = 790
.meas tran vdout1_59ck157 FIND v(dout1_59) AT=790.025n

* CHECK dout1_60 Vdout1_60ck157 = 0 time = 790
.meas tran vdout1_60ck157 FIND v(dout1_60) AT=790.025n

* CHECK dout1_61 Vdout1_61ck157 = 0 time = 790
.meas tran vdout1_61ck157 FIND v(dout1_61) AT=790.025n

* CHECK dout1_62 Vdout1_62ck157 = 0 time = 790
.meas tran vdout1_62ck157 FIND v(dout1_62) AT=790.025n

* CHECK dout1_63 Vdout1_63ck157 = 0 time = 790
.meas tran vdout1_63ck157 FIND v(dout1_63) AT=790.025n

* CHECK dout1_64 Vdout1_64ck157 = 0.9 time = 790
.meas tran vdout1_64ck157 FIND v(dout1_64) AT=790.025n

* CHECK dout1_65 Vdout1_65ck157 = 0 time = 790
.meas tran vdout1_65ck157 FIND v(dout1_65) AT=790.025n

* CHECK dout1_66 Vdout1_66ck157 = 0.9 time = 790
.meas tran vdout1_66ck157 FIND v(dout1_66) AT=790.025n

* CHECK dout1_67 Vdout1_67ck157 = 0 time = 790
.meas tran vdout1_67ck157 FIND v(dout1_67) AT=790.025n

* CHECK dout1_68 Vdout1_68ck157 = 0 time = 790
.meas tran vdout1_68ck157 FIND v(dout1_68) AT=790.025n

* CHECK dout1_69 Vdout1_69ck157 = 0 time = 790
.meas tran vdout1_69ck157 FIND v(dout1_69) AT=790.025n

* CHECK dout1_70 Vdout1_70ck157 = 0.9 time = 790
.meas tran vdout1_70ck157 FIND v(dout1_70) AT=790.025n

* CHECK dout1_71 Vdout1_71ck157 = 0 time = 790
.meas tran vdout1_71ck157 FIND v(dout1_71) AT=790.025n

* CHECK dout1_72 Vdout1_72ck157 = 0.9 time = 790
.meas tran vdout1_72ck157 FIND v(dout1_72) AT=790.025n

* CHECK dout1_73 Vdout1_73ck157 = 0.9 time = 790
.meas tran vdout1_73ck157 FIND v(dout1_73) AT=790.025n

* CHECK dout1_74 Vdout1_74ck157 = 0 time = 790
.meas tran vdout1_74ck157 FIND v(dout1_74) AT=790.025n

* CHECK dout1_75 Vdout1_75ck157 = 0.9 time = 790
.meas tran vdout1_75ck157 FIND v(dout1_75) AT=790.025n

* CHECK dout1_76 Vdout1_76ck157 = 0 time = 790
.meas tran vdout1_76ck157 FIND v(dout1_76) AT=790.025n

* CHECK dout1_77 Vdout1_77ck157 = 0.9 time = 790
.meas tran vdout1_77ck157 FIND v(dout1_77) AT=790.025n

* CHECK dout1_78 Vdout1_78ck157 = 0 time = 790
.meas tran vdout1_78ck157 FIND v(dout1_78) AT=790.025n

* CHECK dout1_79 Vdout1_79ck157 = 0 time = 790
.meas tran vdout1_79ck157 FIND v(dout1_79) AT=790.025n

* CHECK dout1_80 Vdout1_80ck157 = 0.9 time = 790
.meas tran vdout1_80ck157 FIND v(dout1_80) AT=790.025n

* CHECK dout1_81 Vdout1_81ck157 = 0.9 time = 790
.meas tran vdout1_81ck157 FIND v(dout1_81) AT=790.025n

* CHECK dout1_82 Vdout1_82ck157 = 0 time = 790
.meas tran vdout1_82ck157 FIND v(dout1_82) AT=790.025n

* CHECK dout1_83 Vdout1_83ck157 = 0.9 time = 790
.meas tran vdout1_83ck157 FIND v(dout1_83) AT=790.025n

* CHECK dout1_84 Vdout1_84ck157 = 0 time = 790
.meas tran vdout1_84ck157 FIND v(dout1_84) AT=790.025n

* CHECK dout1_85 Vdout1_85ck157 = 0.9 time = 790
.meas tran vdout1_85ck157 FIND v(dout1_85) AT=790.025n

* CHECK dout1_86 Vdout1_86ck157 = 0.9 time = 790
.meas tran vdout1_86ck157 FIND v(dout1_86) AT=790.025n

* CHECK dout1_87 Vdout1_87ck157 = 0 time = 790
.meas tran vdout1_87ck157 FIND v(dout1_87) AT=790.025n

* CHECK dout1_88 Vdout1_88ck157 = 0 time = 790
.meas tran vdout1_88ck157 FIND v(dout1_88) AT=790.025n

* CHECK dout1_89 Vdout1_89ck157 = 0.9 time = 790
.meas tran vdout1_89ck157 FIND v(dout1_89) AT=790.025n

* CHECK dout1_90 Vdout1_90ck157 = 0.9 time = 790
.meas tran vdout1_90ck157 FIND v(dout1_90) AT=790.025n

* CHECK dout1_91 Vdout1_91ck157 = 0 time = 790
.meas tran vdout1_91ck157 FIND v(dout1_91) AT=790.025n

* CHECK dout1_92 Vdout1_92ck157 = 0.9 time = 790
.meas tran vdout1_92ck157 FIND v(dout1_92) AT=790.025n

* CHECK dout1_93 Vdout1_93ck157 = 0 time = 790
.meas tran vdout1_93ck157 FIND v(dout1_93) AT=790.025n

* CHECK dout1_94 Vdout1_94ck157 = 0.9 time = 790
.meas tran vdout1_94ck157 FIND v(dout1_94) AT=790.025n

* CHECK dout1_95 Vdout1_95ck157 = 0.9 time = 790
.meas tran vdout1_95ck157 FIND v(dout1_95) AT=790.025n

* CHECK dout1_96 Vdout1_96ck157 = 0 time = 790
.meas tran vdout1_96ck157 FIND v(dout1_96) AT=790.025n

* CHECK dout1_97 Vdout1_97ck157 = 0.9 time = 790
.meas tran vdout1_97ck157 FIND v(dout1_97) AT=790.025n

* CHECK dout1_98 Vdout1_98ck157 = 0 time = 790
.meas tran vdout1_98ck157 FIND v(dout1_98) AT=790.025n

* CHECK dout1_99 Vdout1_99ck157 = 0 time = 790
.meas tran vdout1_99ck157 FIND v(dout1_99) AT=790.025n

* CHECK dout1_100 Vdout1_100ck157 = 0 time = 790
.meas tran vdout1_100ck157 FIND v(dout1_100) AT=790.025n

* CHECK dout1_101 Vdout1_101ck157 = 0 time = 790
.meas tran vdout1_101ck157 FIND v(dout1_101) AT=790.025n

* CHECK dout1_102 Vdout1_102ck157 = 0 time = 790
.meas tran vdout1_102ck157 FIND v(dout1_102) AT=790.025n

* CHECK dout1_103 Vdout1_103ck157 = 0 time = 790
.meas tran vdout1_103ck157 FIND v(dout1_103) AT=790.025n

* CHECK dout1_104 Vdout1_104ck157 = 0.9 time = 790
.meas tran vdout1_104ck157 FIND v(dout1_104) AT=790.025n

* CHECK dout1_105 Vdout1_105ck157 = 0.9 time = 790
.meas tran vdout1_105ck157 FIND v(dout1_105) AT=790.025n

* CHECK dout1_106 Vdout1_106ck157 = 0.9 time = 790
.meas tran vdout1_106ck157 FIND v(dout1_106) AT=790.025n

* CHECK dout1_107 Vdout1_107ck157 = 0.9 time = 790
.meas tran vdout1_107ck157 FIND v(dout1_107) AT=790.025n

* CHECK dout1_108 Vdout1_108ck157 = 0.9 time = 790
.meas tran vdout1_108ck157 FIND v(dout1_108) AT=790.025n

* CHECK dout1_109 Vdout1_109ck157 = 0 time = 790
.meas tran vdout1_109ck157 FIND v(dout1_109) AT=790.025n

* CHECK dout1_110 Vdout1_110ck157 = 0 time = 790
.meas tran vdout1_110ck157 FIND v(dout1_110) AT=790.025n

* CHECK dout1_111 Vdout1_111ck157 = 0.9 time = 790
.meas tran vdout1_111ck157 FIND v(dout1_111) AT=790.025n

* CHECK dout1_112 Vdout1_112ck157 = 0 time = 790
.meas tran vdout1_112ck157 FIND v(dout1_112) AT=790.025n

* CHECK dout1_113 Vdout1_113ck157 = 0.9 time = 790
.meas tran vdout1_113ck157 FIND v(dout1_113) AT=790.025n

* CHECK dout1_114 Vdout1_114ck157 = 0 time = 790
.meas tran vdout1_114ck157 FIND v(dout1_114) AT=790.025n

* CHECK dout1_115 Vdout1_115ck157 = 0.9 time = 790
.meas tran vdout1_115ck157 FIND v(dout1_115) AT=790.025n

* CHECK dout1_116 Vdout1_116ck157 = 0 time = 790
.meas tran vdout1_116ck157 FIND v(dout1_116) AT=790.025n

* CHECK dout1_117 Vdout1_117ck157 = 0 time = 790
.meas tran vdout1_117ck157 FIND v(dout1_117) AT=790.025n

* CHECK dout1_118 Vdout1_118ck157 = 0.9 time = 790
.meas tran vdout1_118ck157 FIND v(dout1_118) AT=790.025n

* CHECK dout1_119 Vdout1_119ck157 = 0 time = 790
.meas tran vdout1_119ck157 FIND v(dout1_119) AT=790.025n

* CHECK dout1_0 Vdout1_0ck158 = 0 time = 795
.meas tran vdout1_0ck158 FIND v(dout1_0) AT=795.025n

* CHECK dout1_1 Vdout1_1ck158 = 0 time = 795
.meas tran vdout1_1ck158 FIND v(dout1_1) AT=795.025n

* CHECK dout1_2 Vdout1_2ck158 = 0.9 time = 795
.meas tran vdout1_2ck158 FIND v(dout1_2) AT=795.025n

* CHECK dout1_3 Vdout1_3ck158 = 0 time = 795
.meas tran vdout1_3ck158 FIND v(dout1_3) AT=795.025n

* CHECK dout1_4 Vdout1_4ck158 = 0.9 time = 795
.meas tran vdout1_4ck158 FIND v(dout1_4) AT=795.025n

* CHECK dout1_5 Vdout1_5ck158 = 0 time = 795
.meas tran vdout1_5ck158 FIND v(dout1_5) AT=795.025n

* CHECK dout1_6 Vdout1_6ck158 = 0.9 time = 795
.meas tran vdout1_6ck158 FIND v(dout1_6) AT=795.025n

* CHECK dout1_7 Vdout1_7ck158 = 0 time = 795
.meas tran vdout1_7ck158 FIND v(dout1_7) AT=795.025n

* CHECK dout1_8 Vdout1_8ck158 = 0 time = 795
.meas tran vdout1_8ck158 FIND v(dout1_8) AT=795.025n

* CHECK dout1_9 Vdout1_9ck158 = 0 time = 795
.meas tran vdout1_9ck158 FIND v(dout1_9) AT=795.025n

* CHECK dout1_10 Vdout1_10ck158 = 0.9 time = 795
.meas tran vdout1_10ck158 FIND v(dout1_10) AT=795.025n

* CHECK dout1_11 Vdout1_11ck158 = 0.9 time = 795
.meas tran vdout1_11ck158 FIND v(dout1_11) AT=795.025n

* CHECK dout1_12 Vdout1_12ck158 = 0 time = 795
.meas tran vdout1_12ck158 FIND v(dout1_12) AT=795.025n

* CHECK dout1_13 Vdout1_13ck158 = 0 time = 795
.meas tran vdout1_13ck158 FIND v(dout1_13) AT=795.025n

* CHECK dout1_14 Vdout1_14ck158 = 0 time = 795
.meas tran vdout1_14ck158 FIND v(dout1_14) AT=795.025n

* CHECK dout1_15 Vdout1_15ck158 = 0 time = 795
.meas tran vdout1_15ck158 FIND v(dout1_15) AT=795.025n

* CHECK dout1_16 Vdout1_16ck158 = 0 time = 795
.meas tran vdout1_16ck158 FIND v(dout1_16) AT=795.025n

* CHECK dout1_17 Vdout1_17ck158 = 0.9 time = 795
.meas tran vdout1_17ck158 FIND v(dout1_17) AT=795.025n

* CHECK dout1_18 Vdout1_18ck158 = 0.9 time = 795
.meas tran vdout1_18ck158 FIND v(dout1_18) AT=795.025n

* CHECK dout1_19 Vdout1_19ck158 = 0 time = 795
.meas tran vdout1_19ck158 FIND v(dout1_19) AT=795.025n

* CHECK dout1_20 Vdout1_20ck158 = 0.9 time = 795
.meas tran vdout1_20ck158 FIND v(dout1_20) AT=795.025n

* CHECK dout1_21 Vdout1_21ck158 = 0 time = 795
.meas tran vdout1_21ck158 FIND v(dout1_21) AT=795.025n

* CHECK dout1_22 Vdout1_22ck158 = 0.9 time = 795
.meas tran vdout1_22ck158 FIND v(dout1_22) AT=795.025n

* CHECK dout1_23 Vdout1_23ck158 = 0 time = 795
.meas tran vdout1_23ck158 FIND v(dout1_23) AT=795.025n

* CHECK dout1_24 Vdout1_24ck158 = 0 time = 795
.meas tran vdout1_24ck158 FIND v(dout1_24) AT=795.025n

* CHECK dout1_25 Vdout1_25ck158 = 0 time = 795
.meas tran vdout1_25ck158 FIND v(dout1_25) AT=795.025n

* CHECK dout1_26 Vdout1_26ck158 = 0.9 time = 795
.meas tran vdout1_26ck158 FIND v(dout1_26) AT=795.025n

* CHECK dout1_27 Vdout1_27ck158 = 0.9 time = 795
.meas tran vdout1_27ck158 FIND v(dout1_27) AT=795.025n

* CHECK dout1_28 Vdout1_28ck158 = 0 time = 795
.meas tran vdout1_28ck158 FIND v(dout1_28) AT=795.025n

* CHECK dout1_29 Vdout1_29ck158 = 0 time = 795
.meas tran vdout1_29ck158 FIND v(dout1_29) AT=795.025n

* CHECK dout1_30 Vdout1_30ck158 = 0 time = 795
.meas tran vdout1_30ck158 FIND v(dout1_30) AT=795.025n

* CHECK dout1_31 Vdout1_31ck158 = 0.9 time = 795
.meas tran vdout1_31ck158 FIND v(dout1_31) AT=795.025n

* CHECK dout1_32 Vdout1_32ck158 = 0 time = 795
.meas tran vdout1_32ck158 FIND v(dout1_32) AT=795.025n

* CHECK dout1_33 Vdout1_33ck158 = 0.9 time = 795
.meas tran vdout1_33ck158 FIND v(dout1_33) AT=795.025n

* CHECK dout1_34 Vdout1_34ck158 = 0.9 time = 795
.meas tran vdout1_34ck158 FIND v(dout1_34) AT=795.025n

* CHECK dout1_35 Vdout1_35ck158 = 0 time = 795
.meas tran vdout1_35ck158 FIND v(dout1_35) AT=795.025n

* CHECK dout1_36 Vdout1_36ck158 = 0 time = 795
.meas tran vdout1_36ck158 FIND v(dout1_36) AT=795.025n

* CHECK dout1_37 Vdout1_37ck158 = 0.9 time = 795
.meas tran vdout1_37ck158 FIND v(dout1_37) AT=795.025n

* CHECK dout1_38 Vdout1_38ck158 = 0.9 time = 795
.meas tran vdout1_38ck158 FIND v(dout1_38) AT=795.025n

* CHECK dout1_39 Vdout1_39ck158 = 0 time = 795
.meas tran vdout1_39ck158 FIND v(dout1_39) AT=795.025n

* CHECK dout1_40 Vdout1_40ck158 = 0 time = 795
.meas tran vdout1_40ck158 FIND v(dout1_40) AT=795.025n

* CHECK dout1_41 Vdout1_41ck158 = 0 time = 795
.meas tran vdout1_41ck158 FIND v(dout1_41) AT=795.025n

* CHECK dout1_42 Vdout1_42ck158 = 0.9 time = 795
.meas tran vdout1_42ck158 FIND v(dout1_42) AT=795.025n

* CHECK dout1_43 Vdout1_43ck158 = 0.9 time = 795
.meas tran vdout1_43ck158 FIND v(dout1_43) AT=795.025n

* CHECK dout1_44 Vdout1_44ck158 = 0 time = 795
.meas tran vdout1_44ck158 FIND v(dout1_44) AT=795.025n

* CHECK dout1_45 Vdout1_45ck158 = 0 time = 795
.meas tran vdout1_45ck158 FIND v(dout1_45) AT=795.025n

* CHECK dout1_46 Vdout1_46ck158 = 0.9 time = 795
.meas tran vdout1_46ck158 FIND v(dout1_46) AT=795.025n

* CHECK dout1_47 Vdout1_47ck158 = 0 time = 795
.meas tran vdout1_47ck158 FIND v(dout1_47) AT=795.025n

* CHECK dout1_48 Vdout1_48ck158 = 0 time = 795
.meas tran vdout1_48ck158 FIND v(dout1_48) AT=795.025n

* CHECK dout1_49 Vdout1_49ck158 = 0.9 time = 795
.meas tran vdout1_49ck158 FIND v(dout1_49) AT=795.025n

* CHECK dout1_50 Vdout1_50ck158 = 0 time = 795
.meas tran vdout1_50ck158 FIND v(dout1_50) AT=795.025n

* CHECK dout1_51 Vdout1_51ck158 = 0.9 time = 795
.meas tran vdout1_51ck158 FIND v(dout1_51) AT=795.025n

* CHECK dout1_52 Vdout1_52ck158 = 0.9 time = 795
.meas tran vdout1_52ck158 FIND v(dout1_52) AT=795.025n

* CHECK dout1_53 Vdout1_53ck158 = 0.9 time = 795
.meas tran vdout1_53ck158 FIND v(dout1_53) AT=795.025n

* CHECK dout1_54 Vdout1_54ck158 = 0.9 time = 795
.meas tran vdout1_54ck158 FIND v(dout1_54) AT=795.025n

* CHECK dout1_55 Vdout1_55ck158 = 0.9 time = 795
.meas tran vdout1_55ck158 FIND v(dout1_55) AT=795.025n

* CHECK dout1_56 Vdout1_56ck158 = 0.9 time = 795
.meas tran vdout1_56ck158 FIND v(dout1_56) AT=795.025n

* CHECK dout1_57 Vdout1_57ck158 = 0 time = 795
.meas tran vdout1_57ck158 FIND v(dout1_57) AT=795.025n

* CHECK dout1_58 Vdout1_58ck158 = 0.9 time = 795
.meas tran vdout1_58ck158 FIND v(dout1_58) AT=795.025n

* CHECK dout1_59 Vdout1_59ck158 = 0.9 time = 795
.meas tran vdout1_59ck158 FIND v(dout1_59) AT=795.025n

* CHECK dout1_60 Vdout1_60ck158 = 0 time = 795
.meas tran vdout1_60ck158 FIND v(dout1_60) AT=795.025n

* CHECK dout1_61 Vdout1_61ck158 = 0 time = 795
.meas tran vdout1_61ck158 FIND v(dout1_61) AT=795.025n

* CHECK dout1_62 Vdout1_62ck158 = 0 time = 795
.meas tran vdout1_62ck158 FIND v(dout1_62) AT=795.025n

* CHECK dout1_63 Vdout1_63ck158 = 0 time = 795
.meas tran vdout1_63ck158 FIND v(dout1_63) AT=795.025n

* CHECK dout1_64 Vdout1_64ck158 = 0.9 time = 795
.meas tran vdout1_64ck158 FIND v(dout1_64) AT=795.025n

* CHECK dout1_65 Vdout1_65ck158 = 0 time = 795
.meas tran vdout1_65ck158 FIND v(dout1_65) AT=795.025n

* CHECK dout1_66 Vdout1_66ck158 = 0.9 time = 795
.meas tran vdout1_66ck158 FIND v(dout1_66) AT=795.025n

* CHECK dout1_67 Vdout1_67ck158 = 0 time = 795
.meas tran vdout1_67ck158 FIND v(dout1_67) AT=795.025n

* CHECK dout1_68 Vdout1_68ck158 = 0 time = 795
.meas tran vdout1_68ck158 FIND v(dout1_68) AT=795.025n

* CHECK dout1_69 Vdout1_69ck158 = 0 time = 795
.meas tran vdout1_69ck158 FIND v(dout1_69) AT=795.025n

* CHECK dout1_70 Vdout1_70ck158 = 0.9 time = 795
.meas tran vdout1_70ck158 FIND v(dout1_70) AT=795.025n

* CHECK dout1_71 Vdout1_71ck158 = 0 time = 795
.meas tran vdout1_71ck158 FIND v(dout1_71) AT=795.025n

* CHECK dout1_72 Vdout1_72ck158 = 0.9 time = 795
.meas tran vdout1_72ck158 FIND v(dout1_72) AT=795.025n

* CHECK dout1_73 Vdout1_73ck158 = 0.9 time = 795
.meas tran vdout1_73ck158 FIND v(dout1_73) AT=795.025n

* CHECK dout1_74 Vdout1_74ck158 = 0 time = 795
.meas tran vdout1_74ck158 FIND v(dout1_74) AT=795.025n

* CHECK dout1_75 Vdout1_75ck158 = 0.9 time = 795
.meas tran vdout1_75ck158 FIND v(dout1_75) AT=795.025n

* CHECK dout1_76 Vdout1_76ck158 = 0 time = 795
.meas tran vdout1_76ck158 FIND v(dout1_76) AT=795.025n

* CHECK dout1_77 Vdout1_77ck158 = 0.9 time = 795
.meas tran vdout1_77ck158 FIND v(dout1_77) AT=795.025n

* CHECK dout1_78 Vdout1_78ck158 = 0 time = 795
.meas tran vdout1_78ck158 FIND v(dout1_78) AT=795.025n

* CHECK dout1_79 Vdout1_79ck158 = 0 time = 795
.meas tran vdout1_79ck158 FIND v(dout1_79) AT=795.025n

* CHECK dout1_80 Vdout1_80ck158 = 0.9 time = 795
.meas tran vdout1_80ck158 FIND v(dout1_80) AT=795.025n

* CHECK dout1_81 Vdout1_81ck158 = 0.9 time = 795
.meas tran vdout1_81ck158 FIND v(dout1_81) AT=795.025n

* CHECK dout1_82 Vdout1_82ck158 = 0 time = 795
.meas tran vdout1_82ck158 FIND v(dout1_82) AT=795.025n

* CHECK dout1_83 Vdout1_83ck158 = 0.9 time = 795
.meas tran vdout1_83ck158 FIND v(dout1_83) AT=795.025n

* CHECK dout1_84 Vdout1_84ck158 = 0 time = 795
.meas tran vdout1_84ck158 FIND v(dout1_84) AT=795.025n

* CHECK dout1_85 Vdout1_85ck158 = 0.9 time = 795
.meas tran vdout1_85ck158 FIND v(dout1_85) AT=795.025n

* CHECK dout1_86 Vdout1_86ck158 = 0.9 time = 795
.meas tran vdout1_86ck158 FIND v(dout1_86) AT=795.025n

* CHECK dout1_87 Vdout1_87ck158 = 0 time = 795
.meas tran vdout1_87ck158 FIND v(dout1_87) AT=795.025n

* CHECK dout1_88 Vdout1_88ck158 = 0 time = 795
.meas tran vdout1_88ck158 FIND v(dout1_88) AT=795.025n

* CHECK dout1_89 Vdout1_89ck158 = 0.9 time = 795
.meas tran vdout1_89ck158 FIND v(dout1_89) AT=795.025n

* CHECK dout1_90 Vdout1_90ck158 = 0.9 time = 795
.meas tran vdout1_90ck158 FIND v(dout1_90) AT=795.025n

* CHECK dout1_91 Vdout1_91ck158 = 0 time = 795
.meas tran vdout1_91ck158 FIND v(dout1_91) AT=795.025n

* CHECK dout1_92 Vdout1_92ck158 = 0.9 time = 795
.meas tran vdout1_92ck158 FIND v(dout1_92) AT=795.025n

* CHECK dout1_93 Vdout1_93ck158 = 0 time = 795
.meas tran vdout1_93ck158 FIND v(dout1_93) AT=795.025n

* CHECK dout1_94 Vdout1_94ck158 = 0.9 time = 795
.meas tran vdout1_94ck158 FIND v(dout1_94) AT=795.025n

* CHECK dout1_95 Vdout1_95ck158 = 0.9 time = 795
.meas tran vdout1_95ck158 FIND v(dout1_95) AT=795.025n

* CHECK dout1_96 Vdout1_96ck158 = 0 time = 795
.meas tran vdout1_96ck158 FIND v(dout1_96) AT=795.025n

* CHECK dout1_97 Vdout1_97ck158 = 0.9 time = 795
.meas tran vdout1_97ck158 FIND v(dout1_97) AT=795.025n

* CHECK dout1_98 Vdout1_98ck158 = 0 time = 795
.meas tran vdout1_98ck158 FIND v(dout1_98) AT=795.025n

* CHECK dout1_99 Vdout1_99ck158 = 0 time = 795
.meas tran vdout1_99ck158 FIND v(dout1_99) AT=795.025n

* CHECK dout1_100 Vdout1_100ck158 = 0 time = 795
.meas tran vdout1_100ck158 FIND v(dout1_100) AT=795.025n

* CHECK dout1_101 Vdout1_101ck158 = 0 time = 795
.meas tran vdout1_101ck158 FIND v(dout1_101) AT=795.025n

* CHECK dout1_102 Vdout1_102ck158 = 0 time = 795
.meas tran vdout1_102ck158 FIND v(dout1_102) AT=795.025n

* CHECK dout1_103 Vdout1_103ck158 = 0 time = 795
.meas tran vdout1_103ck158 FIND v(dout1_103) AT=795.025n

* CHECK dout1_104 Vdout1_104ck158 = 0.9 time = 795
.meas tran vdout1_104ck158 FIND v(dout1_104) AT=795.025n

* CHECK dout1_105 Vdout1_105ck158 = 0.9 time = 795
.meas tran vdout1_105ck158 FIND v(dout1_105) AT=795.025n

* CHECK dout1_106 Vdout1_106ck158 = 0.9 time = 795
.meas tran vdout1_106ck158 FIND v(dout1_106) AT=795.025n

* CHECK dout1_107 Vdout1_107ck158 = 0.9 time = 795
.meas tran vdout1_107ck158 FIND v(dout1_107) AT=795.025n

* CHECK dout1_108 Vdout1_108ck158 = 0.9 time = 795
.meas tran vdout1_108ck158 FIND v(dout1_108) AT=795.025n

* CHECK dout1_109 Vdout1_109ck158 = 0 time = 795
.meas tran vdout1_109ck158 FIND v(dout1_109) AT=795.025n

* CHECK dout1_110 Vdout1_110ck158 = 0 time = 795
.meas tran vdout1_110ck158 FIND v(dout1_110) AT=795.025n

* CHECK dout1_111 Vdout1_111ck158 = 0.9 time = 795
.meas tran vdout1_111ck158 FIND v(dout1_111) AT=795.025n

* CHECK dout1_112 Vdout1_112ck158 = 0 time = 795
.meas tran vdout1_112ck158 FIND v(dout1_112) AT=795.025n

* CHECK dout1_113 Vdout1_113ck158 = 0.9 time = 795
.meas tran vdout1_113ck158 FIND v(dout1_113) AT=795.025n

* CHECK dout1_114 Vdout1_114ck158 = 0 time = 795
.meas tran vdout1_114ck158 FIND v(dout1_114) AT=795.025n

* CHECK dout1_115 Vdout1_115ck158 = 0.9 time = 795
.meas tran vdout1_115ck158 FIND v(dout1_115) AT=795.025n

* CHECK dout1_116 Vdout1_116ck158 = 0 time = 795
.meas tran vdout1_116ck158 FIND v(dout1_116) AT=795.025n

* CHECK dout1_117 Vdout1_117ck158 = 0 time = 795
.meas tran vdout1_117ck158 FIND v(dout1_117) AT=795.025n

* CHECK dout1_118 Vdout1_118ck158 = 0.9 time = 795
.meas tran vdout1_118ck158 FIND v(dout1_118) AT=795.025n

* CHECK dout1_119 Vdout1_119ck158 = 0 time = 795
.meas tran vdout1_119ck158 FIND v(dout1_119) AT=795.025n

* CHECK dout1_0 Vdout1_0ck162 = 0 time = 815
.meas tran vdout1_0ck162 FIND v(dout1_0) AT=815.025n

* CHECK dout1_1 Vdout1_1ck162 = 0 time = 815
.meas tran vdout1_1ck162 FIND v(dout1_1) AT=815.025n

* CHECK dout1_2 Vdout1_2ck162 = 0.9 time = 815
.meas tran vdout1_2ck162 FIND v(dout1_2) AT=815.025n

* CHECK dout1_3 Vdout1_3ck162 = 0 time = 815
.meas tran vdout1_3ck162 FIND v(dout1_3) AT=815.025n

* CHECK dout1_4 Vdout1_4ck162 = 0.9 time = 815
.meas tran vdout1_4ck162 FIND v(dout1_4) AT=815.025n

* CHECK dout1_5 Vdout1_5ck162 = 0 time = 815
.meas tran vdout1_5ck162 FIND v(dout1_5) AT=815.025n

* CHECK dout1_6 Vdout1_6ck162 = 0.9 time = 815
.meas tran vdout1_6ck162 FIND v(dout1_6) AT=815.025n

* CHECK dout1_7 Vdout1_7ck162 = 0 time = 815
.meas tran vdout1_7ck162 FIND v(dout1_7) AT=815.025n

* CHECK dout1_8 Vdout1_8ck162 = 0 time = 815
.meas tran vdout1_8ck162 FIND v(dout1_8) AT=815.025n

* CHECK dout1_9 Vdout1_9ck162 = 0 time = 815
.meas tran vdout1_9ck162 FIND v(dout1_9) AT=815.025n

* CHECK dout1_10 Vdout1_10ck162 = 0.9 time = 815
.meas tran vdout1_10ck162 FIND v(dout1_10) AT=815.025n

* CHECK dout1_11 Vdout1_11ck162 = 0.9 time = 815
.meas tran vdout1_11ck162 FIND v(dout1_11) AT=815.025n

* CHECK dout1_12 Vdout1_12ck162 = 0 time = 815
.meas tran vdout1_12ck162 FIND v(dout1_12) AT=815.025n

* CHECK dout1_13 Vdout1_13ck162 = 0 time = 815
.meas tran vdout1_13ck162 FIND v(dout1_13) AT=815.025n

* CHECK dout1_14 Vdout1_14ck162 = 0 time = 815
.meas tran vdout1_14ck162 FIND v(dout1_14) AT=815.025n

* CHECK dout1_15 Vdout1_15ck162 = 0 time = 815
.meas tran vdout1_15ck162 FIND v(dout1_15) AT=815.025n

* CHECK dout1_16 Vdout1_16ck162 = 0 time = 815
.meas tran vdout1_16ck162 FIND v(dout1_16) AT=815.025n

* CHECK dout1_17 Vdout1_17ck162 = 0.9 time = 815
.meas tran vdout1_17ck162 FIND v(dout1_17) AT=815.025n

* CHECK dout1_18 Vdout1_18ck162 = 0.9 time = 815
.meas tran vdout1_18ck162 FIND v(dout1_18) AT=815.025n

* CHECK dout1_19 Vdout1_19ck162 = 0 time = 815
.meas tran vdout1_19ck162 FIND v(dout1_19) AT=815.025n

* CHECK dout1_20 Vdout1_20ck162 = 0.9 time = 815
.meas tran vdout1_20ck162 FIND v(dout1_20) AT=815.025n

* CHECK dout1_21 Vdout1_21ck162 = 0 time = 815
.meas tran vdout1_21ck162 FIND v(dout1_21) AT=815.025n

* CHECK dout1_22 Vdout1_22ck162 = 0.9 time = 815
.meas tran vdout1_22ck162 FIND v(dout1_22) AT=815.025n

* CHECK dout1_23 Vdout1_23ck162 = 0 time = 815
.meas tran vdout1_23ck162 FIND v(dout1_23) AT=815.025n

* CHECK dout1_24 Vdout1_24ck162 = 0 time = 815
.meas tran vdout1_24ck162 FIND v(dout1_24) AT=815.025n

* CHECK dout1_25 Vdout1_25ck162 = 0 time = 815
.meas tran vdout1_25ck162 FIND v(dout1_25) AT=815.025n

* CHECK dout1_26 Vdout1_26ck162 = 0.9 time = 815
.meas tran vdout1_26ck162 FIND v(dout1_26) AT=815.025n

* CHECK dout1_27 Vdout1_27ck162 = 0.9 time = 815
.meas tran vdout1_27ck162 FIND v(dout1_27) AT=815.025n

* CHECK dout1_28 Vdout1_28ck162 = 0 time = 815
.meas tran vdout1_28ck162 FIND v(dout1_28) AT=815.025n

* CHECK dout1_29 Vdout1_29ck162 = 0 time = 815
.meas tran vdout1_29ck162 FIND v(dout1_29) AT=815.025n

* CHECK dout1_30 Vdout1_30ck162 = 0 time = 815
.meas tran vdout1_30ck162 FIND v(dout1_30) AT=815.025n

* CHECK dout1_31 Vdout1_31ck162 = 0.9 time = 815
.meas tran vdout1_31ck162 FIND v(dout1_31) AT=815.025n

* CHECK dout1_32 Vdout1_32ck162 = 0 time = 815
.meas tran vdout1_32ck162 FIND v(dout1_32) AT=815.025n

* CHECK dout1_33 Vdout1_33ck162 = 0.9 time = 815
.meas tran vdout1_33ck162 FIND v(dout1_33) AT=815.025n

* CHECK dout1_34 Vdout1_34ck162 = 0.9 time = 815
.meas tran vdout1_34ck162 FIND v(dout1_34) AT=815.025n

* CHECK dout1_35 Vdout1_35ck162 = 0 time = 815
.meas tran vdout1_35ck162 FIND v(dout1_35) AT=815.025n

* CHECK dout1_36 Vdout1_36ck162 = 0 time = 815
.meas tran vdout1_36ck162 FIND v(dout1_36) AT=815.025n

* CHECK dout1_37 Vdout1_37ck162 = 0.9 time = 815
.meas tran vdout1_37ck162 FIND v(dout1_37) AT=815.025n

* CHECK dout1_38 Vdout1_38ck162 = 0.9 time = 815
.meas tran vdout1_38ck162 FIND v(dout1_38) AT=815.025n

* CHECK dout1_39 Vdout1_39ck162 = 0 time = 815
.meas tran vdout1_39ck162 FIND v(dout1_39) AT=815.025n

* CHECK dout1_40 Vdout1_40ck162 = 0 time = 815
.meas tran vdout1_40ck162 FIND v(dout1_40) AT=815.025n

* CHECK dout1_41 Vdout1_41ck162 = 0 time = 815
.meas tran vdout1_41ck162 FIND v(dout1_41) AT=815.025n

* CHECK dout1_42 Vdout1_42ck162 = 0.9 time = 815
.meas tran vdout1_42ck162 FIND v(dout1_42) AT=815.025n

* CHECK dout1_43 Vdout1_43ck162 = 0.9 time = 815
.meas tran vdout1_43ck162 FIND v(dout1_43) AT=815.025n

* CHECK dout1_44 Vdout1_44ck162 = 0 time = 815
.meas tran vdout1_44ck162 FIND v(dout1_44) AT=815.025n

* CHECK dout1_45 Vdout1_45ck162 = 0 time = 815
.meas tran vdout1_45ck162 FIND v(dout1_45) AT=815.025n

* CHECK dout1_46 Vdout1_46ck162 = 0.9 time = 815
.meas tran vdout1_46ck162 FIND v(dout1_46) AT=815.025n

* CHECK dout1_47 Vdout1_47ck162 = 0 time = 815
.meas tran vdout1_47ck162 FIND v(dout1_47) AT=815.025n

* CHECK dout1_48 Vdout1_48ck162 = 0 time = 815
.meas tran vdout1_48ck162 FIND v(dout1_48) AT=815.025n

* CHECK dout1_49 Vdout1_49ck162 = 0.9 time = 815
.meas tran vdout1_49ck162 FIND v(dout1_49) AT=815.025n

* CHECK dout1_50 Vdout1_50ck162 = 0 time = 815
.meas tran vdout1_50ck162 FIND v(dout1_50) AT=815.025n

* CHECK dout1_51 Vdout1_51ck162 = 0.9 time = 815
.meas tran vdout1_51ck162 FIND v(dout1_51) AT=815.025n

* CHECK dout1_52 Vdout1_52ck162 = 0.9 time = 815
.meas tran vdout1_52ck162 FIND v(dout1_52) AT=815.025n

* CHECK dout1_53 Vdout1_53ck162 = 0.9 time = 815
.meas tran vdout1_53ck162 FIND v(dout1_53) AT=815.025n

* CHECK dout1_54 Vdout1_54ck162 = 0.9 time = 815
.meas tran vdout1_54ck162 FIND v(dout1_54) AT=815.025n

* CHECK dout1_55 Vdout1_55ck162 = 0.9 time = 815
.meas tran vdout1_55ck162 FIND v(dout1_55) AT=815.025n

* CHECK dout1_56 Vdout1_56ck162 = 0.9 time = 815
.meas tran vdout1_56ck162 FIND v(dout1_56) AT=815.025n

* CHECK dout1_57 Vdout1_57ck162 = 0 time = 815
.meas tran vdout1_57ck162 FIND v(dout1_57) AT=815.025n

* CHECK dout1_58 Vdout1_58ck162 = 0.9 time = 815
.meas tran vdout1_58ck162 FIND v(dout1_58) AT=815.025n

* CHECK dout1_59 Vdout1_59ck162 = 0.9 time = 815
.meas tran vdout1_59ck162 FIND v(dout1_59) AT=815.025n

* CHECK dout1_60 Vdout1_60ck162 = 0 time = 815
.meas tran vdout1_60ck162 FIND v(dout1_60) AT=815.025n

* CHECK dout1_61 Vdout1_61ck162 = 0 time = 815
.meas tran vdout1_61ck162 FIND v(dout1_61) AT=815.025n

* CHECK dout1_62 Vdout1_62ck162 = 0 time = 815
.meas tran vdout1_62ck162 FIND v(dout1_62) AT=815.025n

* CHECK dout1_63 Vdout1_63ck162 = 0 time = 815
.meas tran vdout1_63ck162 FIND v(dout1_63) AT=815.025n

* CHECK dout1_64 Vdout1_64ck162 = 0.9 time = 815
.meas tran vdout1_64ck162 FIND v(dout1_64) AT=815.025n

* CHECK dout1_65 Vdout1_65ck162 = 0 time = 815
.meas tran vdout1_65ck162 FIND v(dout1_65) AT=815.025n

* CHECK dout1_66 Vdout1_66ck162 = 0.9 time = 815
.meas tran vdout1_66ck162 FIND v(dout1_66) AT=815.025n

* CHECK dout1_67 Vdout1_67ck162 = 0 time = 815
.meas tran vdout1_67ck162 FIND v(dout1_67) AT=815.025n

* CHECK dout1_68 Vdout1_68ck162 = 0 time = 815
.meas tran vdout1_68ck162 FIND v(dout1_68) AT=815.025n

* CHECK dout1_69 Vdout1_69ck162 = 0 time = 815
.meas tran vdout1_69ck162 FIND v(dout1_69) AT=815.025n

* CHECK dout1_70 Vdout1_70ck162 = 0.9 time = 815
.meas tran vdout1_70ck162 FIND v(dout1_70) AT=815.025n

* CHECK dout1_71 Vdout1_71ck162 = 0 time = 815
.meas tran vdout1_71ck162 FIND v(dout1_71) AT=815.025n

* CHECK dout1_72 Vdout1_72ck162 = 0.9 time = 815
.meas tran vdout1_72ck162 FIND v(dout1_72) AT=815.025n

* CHECK dout1_73 Vdout1_73ck162 = 0.9 time = 815
.meas tran vdout1_73ck162 FIND v(dout1_73) AT=815.025n

* CHECK dout1_74 Vdout1_74ck162 = 0 time = 815
.meas tran vdout1_74ck162 FIND v(dout1_74) AT=815.025n

* CHECK dout1_75 Vdout1_75ck162 = 0.9 time = 815
.meas tran vdout1_75ck162 FIND v(dout1_75) AT=815.025n

* CHECK dout1_76 Vdout1_76ck162 = 0 time = 815
.meas tran vdout1_76ck162 FIND v(dout1_76) AT=815.025n

* CHECK dout1_77 Vdout1_77ck162 = 0.9 time = 815
.meas tran vdout1_77ck162 FIND v(dout1_77) AT=815.025n

* CHECK dout1_78 Vdout1_78ck162 = 0 time = 815
.meas tran vdout1_78ck162 FIND v(dout1_78) AT=815.025n

* CHECK dout1_79 Vdout1_79ck162 = 0 time = 815
.meas tran vdout1_79ck162 FIND v(dout1_79) AT=815.025n

* CHECK dout1_80 Vdout1_80ck162 = 0.9 time = 815
.meas tran vdout1_80ck162 FIND v(dout1_80) AT=815.025n

* CHECK dout1_81 Vdout1_81ck162 = 0.9 time = 815
.meas tran vdout1_81ck162 FIND v(dout1_81) AT=815.025n

* CHECK dout1_82 Vdout1_82ck162 = 0 time = 815
.meas tran vdout1_82ck162 FIND v(dout1_82) AT=815.025n

* CHECK dout1_83 Vdout1_83ck162 = 0.9 time = 815
.meas tran vdout1_83ck162 FIND v(dout1_83) AT=815.025n

* CHECK dout1_84 Vdout1_84ck162 = 0 time = 815
.meas tran vdout1_84ck162 FIND v(dout1_84) AT=815.025n

* CHECK dout1_85 Vdout1_85ck162 = 0.9 time = 815
.meas tran vdout1_85ck162 FIND v(dout1_85) AT=815.025n

* CHECK dout1_86 Vdout1_86ck162 = 0.9 time = 815
.meas tran vdout1_86ck162 FIND v(dout1_86) AT=815.025n

* CHECK dout1_87 Vdout1_87ck162 = 0 time = 815
.meas tran vdout1_87ck162 FIND v(dout1_87) AT=815.025n

* CHECK dout1_88 Vdout1_88ck162 = 0 time = 815
.meas tran vdout1_88ck162 FIND v(dout1_88) AT=815.025n

* CHECK dout1_89 Vdout1_89ck162 = 0.9 time = 815
.meas tran vdout1_89ck162 FIND v(dout1_89) AT=815.025n

* CHECK dout1_90 Vdout1_90ck162 = 0.9 time = 815
.meas tran vdout1_90ck162 FIND v(dout1_90) AT=815.025n

* CHECK dout1_91 Vdout1_91ck162 = 0 time = 815
.meas tran vdout1_91ck162 FIND v(dout1_91) AT=815.025n

* CHECK dout1_92 Vdout1_92ck162 = 0.9 time = 815
.meas tran vdout1_92ck162 FIND v(dout1_92) AT=815.025n

* CHECK dout1_93 Vdout1_93ck162 = 0 time = 815
.meas tran vdout1_93ck162 FIND v(dout1_93) AT=815.025n

* CHECK dout1_94 Vdout1_94ck162 = 0.9 time = 815
.meas tran vdout1_94ck162 FIND v(dout1_94) AT=815.025n

* CHECK dout1_95 Vdout1_95ck162 = 0.9 time = 815
.meas tran vdout1_95ck162 FIND v(dout1_95) AT=815.025n

* CHECK dout1_96 Vdout1_96ck162 = 0 time = 815
.meas tran vdout1_96ck162 FIND v(dout1_96) AT=815.025n

* CHECK dout1_97 Vdout1_97ck162 = 0.9 time = 815
.meas tran vdout1_97ck162 FIND v(dout1_97) AT=815.025n

* CHECK dout1_98 Vdout1_98ck162 = 0 time = 815
.meas tran vdout1_98ck162 FIND v(dout1_98) AT=815.025n

* CHECK dout1_99 Vdout1_99ck162 = 0 time = 815
.meas tran vdout1_99ck162 FIND v(dout1_99) AT=815.025n

* CHECK dout1_100 Vdout1_100ck162 = 0 time = 815
.meas tran vdout1_100ck162 FIND v(dout1_100) AT=815.025n

* CHECK dout1_101 Vdout1_101ck162 = 0 time = 815
.meas tran vdout1_101ck162 FIND v(dout1_101) AT=815.025n

* CHECK dout1_102 Vdout1_102ck162 = 0 time = 815
.meas tran vdout1_102ck162 FIND v(dout1_102) AT=815.025n

* CHECK dout1_103 Vdout1_103ck162 = 0 time = 815
.meas tran vdout1_103ck162 FIND v(dout1_103) AT=815.025n

* CHECK dout1_104 Vdout1_104ck162 = 0.9 time = 815
.meas tran vdout1_104ck162 FIND v(dout1_104) AT=815.025n

* CHECK dout1_105 Vdout1_105ck162 = 0.9 time = 815
.meas tran vdout1_105ck162 FIND v(dout1_105) AT=815.025n

* CHECK dout1_106 Vdout1_106ck162 = 0.9 time = 815
.meas tran vdout1_106ck162 FIND v(dout1_106) AT=815.025n

* CHECK dout1_107 Vdout1_107ck162 = 0.9 time = 815
.meas tran vdout1_107ck162 FIND v(dout1_107) AT=815.025n

* CHECK dout1_108 Vdout1_108ck162 = 0.9 time = 815
.meas tran vdout1_108ck162 FIND v(dout1_108) AT=815.025n

* CHECK dout1_109 Vdout1_109ck162 = 0 time = 815
.meas tran vdout1_109ck162 FIND v(dout1_109) AT=815.025n

* CHECK dout1_110 Vdout1_110ck162 = 0 time = 815
.meas tran vdout1_110ck162 FIND v(dout1_110) AT=815.025n

* CHECK dout1_111 Vdout1_111ck162 = 0.9 time = 815
.meas tran vdout1_111ck162 FIND v(dout1_111) AT=815.025n

* CHECK dout1_112 Vdout1_112ck162 = 0 time = 815
.meas tran vdout1_112ck162 FIND v(dout1_112) AT=815.025n

* CHECK dout1_113 Vdout1_113ck162 = 0.9 time = 815
.meas tran vdout1_113ck162 FIND v(dout1_113) AT=815.025n

* CHECK dout1_114 Vdout1_114ck162 = 0 time = 815
.meas tran vdout1_114ck162 FIND v(dout1_114) AT=815.025n

* CHECK dout1_115 Vdout1_115ck162 = 0.9 time = 815
.meas tran vdout1_115ck162 FIND v(dout1_115) AT=815.025n

* CHECK dout1_116 Vdout1_116ck162 = 0 time = 815
.meas tran vdout1_116ck162 FIND v(dout1_116) AT=815.025n

* CHECK dout1_117 Vdout1_117ck162 = 0 time = 815
.meas tran vdout1_117ck162 FIND v(dout1_117) AT=815.025n

* CHECK dout1_118 Vdout1_118ck162 = 0.9 time = 815
.meas tran vdout1_118ck162 FIND v(dout1_118) AT=815.025n

* CHECK dout1_119 Vdout1_119ck162 = 0 time = 815
.meas tran vdout1_119ck162 FIND v(dout1_119) AT=815.025n

* CHECK dout1_0 Vdout1_0ck166 = 0 time = 835
.meas tran vdout1_0ck166 FIND v(dout1_0) AT=835.025n

* CHECK dout1_1 Vdout1_1ck166 = 0 time = 835
.meas tran vdout1_1ck166 FIND v(dout1_1) AT=835.025n

* CHECK dout1_2 Vdout1_2ck166 = 0.9 time = 835
.meas tran vdout1_2ck166 FIND v(dout1_2) AT=835.025n

* CHECK dout1_3 Vdout1_3ck166 = 0 time = 835
.meas tran vdout1_3ck166 FIND v(dout1_3) AT=835.025n

* CHECK dout1_4 Vdout1_4ck166 = 0 time = 835
.meas tran vdout1_4ck166 FIND v(dout1_4) AT=835.025n

* CHECK dout1_5 Vdout1_5ck166 = 0.9 time = 835
.meas tran vdout1_5ck166 FIND v(dout1_5) AT=835.025n

* CHECK dout1_6 Vdout1_6ck166 = 0 time = 835
.meas tran vdout1_6ck166 FIND v(dout1_6) AT=835.025n

* CHECK dout1_7 Vdout1_7ck166 = 0 time = 835
.meas tran vdout1_7ck166 FIND v(dout1_7) AT=835.025n

* CHECK dout1_8 Vdout1_8ck166 = 0 time = 835
.meas tran vdout1_8ck166 FIND v(dout1_8) AT=835.025n

* CHECK dout1_9 Vdout1_9ck166 = 0 time = 835
.meas tran vdout1_9ck166 FIND v(dout1_9) AT=835.025n

* CHECK dout1_10 Vdout1_10ck166 = 0 time = 835
.meas tran vdout1_10ck166 FIND v(dout1_10) AT=835.025n

* CHECK dout1_11 Vdout1_11ck166 = 0 time = 835
.meas tran vdout1_11ck166 FIND v(dout1_11) AT=835.025n

* CHECK dout1_12 Vdout1_12ck166 = 0.9 time = 835
.meas tran vdout1_12ck166 FIND v(dout1_12) AT=835.025n

* CHECK dout1_13 Vdout1_13ck166 = 0.9 time = 835
.meas tran vdout1_13ck166 FIND v(dout1_13) AT=835.025n

* CHECK dout1_14 Vdout1_14ck166 = 0.9 time = 835
.meas tran vdout1_14ck166 FIND v(dout1_14) AT=835.025n

* CHECK dout1_15 Vdout1_15ck166 = 0.9 time = 835
.meas tran vdout1_15ck166 FIND v(dout1_15) AT=835.025n

* CHECK dout1_16 Vdout1_16ck166 = 0 time = 835
.meas tran vdout1_16ck166 FIND v(dout1_16) AT=835.025n

* CHECK dout1_17 Vdout1_17ck166 = 0.9 time = 835
.meas tran vdout1_17ck166 FIND v(dout1_17) AT=835.025n

* CHECK dout1_18 Vdout1_18ck166 = 0 time = 835
.meas tran vdout1_18ck166 FIND v(dout1_18) AT=835.025n

* CHECK dout1_19 Vdout1_19ck166 = 0.9 time = 835
.meas tran vdout1_19ck166 FIND v(dout1_19) AT=835.025n

* CHECK dout1_20 Vdout1_20ck166 = 0.9 time = 835
.meas tran vdout1_20ck166 FIND v(dout1_20) AT=835.025n

* CHECK dout1_21 Vdout1_21ck166 = 0.9 time = 835
.meas tran vdout1_21ck166 FIND v(dout1_21) AT=835.025n

* CHECK dout1_22 Vdout1_22ck166 = 0.9 time = 835
.meas tran vdout1_22ck166 FIND v(dout1_22) AT=835.025n

* CHECK dout1_23 Vdout1_23ck166 = 0.9 time = 835
.meas tran vdout1_23ck166 FIND v(dout1_23) AT=835.025n

* CHECK dout1_24 Vdout1_24ck166 = 0 time = 835
.meas tran vdout1_24ck166 FIND v(dout1_24) AT=835.025n

* CHECK dout1_25 Vdout1_25ck166 = 0 time = 835
.meas tran vdout1_25ck166 FIND v(dout1_25) AT=835.025n

* CHECK dout1_26 Vdout1_26ck166 = 0 time = 835
.meas tran vdout1_26ck166 FIND v(dout1_26) AT=835.025n

* CHECK dout1_27 Vdout1_27ck166 = 0 time = 835
.meas tran vdout1_27ck166 FIND v(dout1_27) AT=835.025n

* CHECK dout1_28 Vdout1_28ck166 = 0.9 time = 835
.meas tran vdout1_28ck166 FIND v(dout1_28) AT=835.025n

* CHECK dout1_29 Vdout1_29ck166 = 0.9 time = 835
.meas tran vdout1_29ck166 FIND v(dout1_29) AT=835.025n

* CHECK dout1_30 Vdout1_30ck166 = 0 time = 835
.meas tran vdout1_30ck166 FIND v(dout1_30) AT=835.025n

* CHECK dout1_31 Vdout1_31ck166 = 0.9 time = 835
.meas tran vdout1_31ck166 FIND v(dout1_31) AT=835.025n

* CHECK dout1_32 Vdout1_32ck166 = 0 time = 835
.meas tran vdout1_32ck166 FIND v(dout1_32) AT=835.025n

* CHECK dout1_33 Vdout1_33ck166 = 0 time = 835
.meas tran vdout1_33ck166 FIND v(dout1_33) AT=835.025n

* CHECK dout1_34 Vdout1_34ck166 = 0 time = 835
.meas tran vdout1_34ck166 FIND v(dout1_34) AT=835.025n

* CHECK dout1_35 Vdout1_35ck166 = 0 time = 835
.meas tran vdout1_35ck166 FIND v(dout1_35) AT=835.025n

* CHECK dout1_36 Vdout1_36ck166 = 0 time = 835
.meas tran vdout1_36ck166 FIND v(dout1_36) AT=835.025n

* CHECK dout1_37 Vdout1_37ck166 = 0 time = 835
.meas tran vdout1_37ck166 FIND v(dout1_37) AT=835.025n

* CHECK dout1_38 Vdout1_38ck166 = 0.9 time = 835
.meas tran vdout1_38ck166 FIND v(dout1_38) AT=835.025n

* CHECK dout1_39 Vdout1_39ck166 = 0.9 time = 835
.meas tran vdout1_39ck166 FIND v(dout1_39) AT=835.025n

* CHECK dout1_40 Vdout1_40ck166 = 0.9 time = 835
.meas tran vdout1_40ck166 FIND v(dout1_40) AT=835.025n

* CHECK dout1_41 Vdout1_41ck166 = 0 time = 835
.meas tran vdout1_41ck166 FIND v(dout1_41) AT=835.025n

* CHECK dout1_42 Vdout1_42ck166 = 0.9 time = 835
.meas tran vdout1_42ck166 FIND v(dout1_42) AT=835.025n

* CHECK dout1_43 Vdout1_43ck166 = 0 time = 835
.meas tran vdout1_43ck166 FIND v(dout1_43) AT=835.025n

* CHECK dout1_44 Vdout1_44ck166 = 0 time = 835
.meas tran vdout1_44ck166 FIND v(dout1_44) AT=835.025n

* CHECK dout1_45 Vdout1_45ck166 = 0.9 time = 835
.meas tran vdout1_45ck166 FIND v(dout1_45) AT=835.025n

* CHECK dout1_46 Vdout1_46ck166 = 0 time = 835
.meas tran vdout1_46ck166 FIND v(dout1_46) AT=835.025n

* CHECK dout1_47 Vdout1_47ck166 = 0 time = 835
.meas tran vdout1_47ck166 FIND v(dout1_47) AT=835.025n

* CHECK dout1_48 Vdout1_48ck166 = 0 time = 835
.meas tran vdout1_48ck166 FIND v(dout1_48) AT=835.025n

* CHECK dout1_49 Vdout1_49ck166 = 0.9 time = 835
.meas tran vdout1_49ck166 FIND v(dout1_49) AT=835.025n

* CHECK dout1_50 Vdout1_50ck166 = 0.9 time = 835
.meas tran vdout1_50ck166 FIND v(dout1_50) AT=835.025n

* CHECK dout1_51 Vdout1_51ck166 = 0 time = 835
.meas tran vdout1_51ck166 FIND v(dout1_51) AT=835.025n

* CHECK dout1_52 Vdout1_52ck166 = 0.9 time = 835
.meas tran vdout1_52ck166 FIND v(dout1_52) AT=835.025n

* CHECK dout1_53 Vdout1_53ck166 = 0.9 time = 835
.meas tran vdout1_53ck166 FIND v(dout1_53) AT=835.025n

* CHECK dout1_54 Vdout1_54ck166 = 0.9 time = 835
.meas tran vdout1_54ck166 FIND v(dout1_54) AT=835.025n

* CHECK dout1_55 Vdout1_55ck166 = 0.9 time = 835
.meas tran vdout1_55ck166 FIND v(dout1_55) AT=835.025n

* CHECK dout1_56 Vdout1_56ck166 = 0 time = 835
.meas tran vdout1_56ck166 FIND v(dout1_56) AT=835.025n

* CHECK dout1_57 Vdout1_57ck166 = 0.9 time = 835
.meas tran vdout1_57ck166 FIND v(dout1_57) AT=835.025n

* CHECK dout1_58 Vdout1_58ck166 = 0.9 time = 835
.meas tran vdout1_58ck166 FIND v(dout1_58) AT=835.025n

* CHECK dout1_59 Vdout1_59ck166 = 0 time = 835
.meas tran vdout1_59ck166 FIND v(dout1_59) AT=835.025n

* CHECK dout1_60 Vdout1_60ck166 = 0 time = 835
.meas tran vdout1_60ck166 FIND v(dout1_60) AT=835.025n

* CHECK dout1_61 Vdout1_61ck166 = 0.9 time = 835
.meas tran vdout1_61ck166 FIND v(dout1_61) AT=835.025n

* CHECK dout1_62 Vdout1_62ck166 = 0.9 time = 835
.meas tran vdout1_62ck166 FIND v(dout1_62) AT=835.025n

* CHECK dout1_63 Vdout1_63ck166 = 0.9 time = 835
.meas tran vdout1_63ck166 FIND v(dout1_63) AT=835.025n

* CHECK dout1_64 Vdout1_64ck166 = 0 time = 835
.meas tran vdout1_64ck166 FIND v(dout1_64) AT=835.025n

* CHECK dout1_65 Vdout1_65ck166 = 0 time = 835
.meas tran vdout1_65ck166 FIND v(dout1_65) AT=835.025n

* CHECK dout1_66 Vdout1_66ck166 = 0.9 time = 835
.meas tran vdout1_66ck166 FIND v(dout1_66) AT=835.025n

* CHECK dout1_67 Vdout1_67ck166 = 0.9 time = 835
.meas tran vdout1_67ck166 FIND v(dout1_67) AT=835.025n

* CHECK dout1_68 Vdout1_68ck166 = 0 time = 835
.meas tran vdout1_68ck166 FIND v(dout1_68) AT=835.025n

* CHECK dout1_69 Vdout1_69ck166 = 0 time = 835
.meas tran vdout1_69ck166 FIND v(dout1_69) AT=835.025n

* CHECK dout1_70 Vdout1_70ck166 = 0 time = 835
.meas tran vdout1_70ck166 FIND v(dout1_70) AT=835.025n

* CHECK dout1_71 Vdout1_71ck166 = 0 time = 835
.meas tran vdout1_71ck166 FIND v(dout1_71) AT=835.025n

* CHECK dout1_72 Vdout1_72ck166 = 0 time = 835
.meas tran vdout1_72ck166 FIND v(dout1_72) AT=835.025n

* CHECK dout1_73 Vdout1_73ck166 = 0.9 time = 835
.meas tran vdout1_73ck166 FIND v(dout1_73) AT=835.025n

* CHECK dout1_74 Vdout1_74ck166 = 0.9 time = 835
.meas tran vdout1_74ck166 FIND v(dout1_74) AT=835.025n

* CHECK dout1_75 Vdout1_75ck166 = 0 time = 835
.meas tran vdout1_75ck166 FIND v(dout1_75) AT=835.025n

* CHECK dout1_76 Vdout1_76ck166 = 0.9 time = 835
.meas tran vdout1_76ck166 FIND v(dout1_76) AT=835.025n

* CHECK dout1_77 Vdout1_77ck166 = 0.9 time = 835
.meas tran vdout1_77ck166 FIND v(dout1_77) AT=835.025n

* CHECK dout1_78 Vdout1_78ck166 = 0 time = 835
.meas tran vdout1_78ck166 FIND v(dout1_78) AT=835.025n

* CHECK dout1_79 Vdout1_79ck166 = 0.9 time = 835
.meas tran vdout1_79ck166 FIND v(dout1_79) AT=835.025n

* CHECK dout1_80 Vdout1_80ck166 = 0 time = 835
.meas tran vdout1_80ck166 FIND v(dout1_80) AT=835.025n

* CHECK dout1_81 Vdout1_81ck166 = 0.9 time = 835
.meas tran vdout1_81ck166 FIND v(dout1_81) AT=835.025n

* CHECK dout1_82 Vdout1_82ck166 = 0 time = 835
.meas tran vdout1_82ck166 FIND v(dout1_82) AT=835.025n

* CHECK dout1_83 Vdout1_83ck166 = 0.9 time = 835
.meas tran vdout1_83ck166 FIND v(dout1_83) AT=835.025n

* CHECK dout1_84 Vdout1_84ck166 = 0.9 time = 835
.meas tran vdout1_84ck166 FIND v(dout1_84) AT=835.025n

* CHECK dout1_85 Vdout1_85ck166 = 0.9 time = 835
.meas tran vdout1_85ck166 FIND v(dout1_85) AT=835.025n

* CHECK dout1_86 Vdout1_86ck166 = 0.9 time = 835
.meas tran vdout1_86ck166 FIND v(dout1_86) AT=835.025n

* CHECK dout1_87 Vdout1_87ck166 = 0.9 time = 835
.meas tran vdout1_87ck166 FIND v(dout1_87) AT=835.025n

* CHECK dout1_88 Vdout1_88ck166 = 0 time = 835
.meas tran vdout1_88ck166 FIND v(dout1_88) AT=835.025n

* CHECK dout1_89 Vdout1_89ck166 = 0.9 time = 835
.meas tran vdout1_89ck166 FIND v(dout1_89) AT=835.025n

* CHECK dout1_90 Vdout1_90ck166 = 0 time = 835
.meas tran vdout1_90ck166 FIND v(dout1_90) AT=835.025n

* CHECK dout1_91 Vdout1_91ck166 = 0 time = 835
.meas tran vdout1_91ck166 FIND v(dout1_91) AT=835.025n

* CHECK dout1_92 Vdout1_92ck166 = 0 time = 835
.meas tran vdout1_92ck166 FIND v(dout1_92) AT=835.025n

* CHECK dout1_93 Vdout1_93ck166 = 0.9 time = 835
.meas tran vdout1_93ck166 FIND v(dout1_93) AT=835.025n

* CHECK dout1_94 Vdout1_94ck166 = 0 time = 835
.meas tran vdout1_94ck166 FIND v(dout1_94) AT=835.025n

* CHECK dout1_95 Vdout1_95ck166 = 0 time = 835
.meas tran vdout1_95ck166 FIND v(dout1_95) AT=835.025n

* CHECK dout1_96 Vdout1_96ck166 = 0 time = 835
.meas tran vdout1_96ck166 FIND v(dout1_96) AT=835.025n

* CHECK dout1_97 Vdout1_97ck166 = 0.9 time = 835
.meas tran vdout1_97ck166 FIND v(dout1_97) AT=835.025n

* CHECK dout1_98 Vdout1_98ck166 = 0.9 time = 835
.meas tran vdout1_98ck166 FIND v(dout1_98) AT=835.025n

* CHECK dout1_99 Vdout1_99ck166 = 0.9 time = 835
.meas tran vdout1_99ck166 FIND v(dout1_99) AT=835.025n

* CHECK dout1_100 Vdout1_100ck166 = 0 time = 835
.meas tran vdout1_100ck166 FIND v(dout1_100) AT=835.025n

* CHECK dout1_101 Vdout1_101ck166 = 0 time = 835
.meas tran vdout1_101ck166 FIND v(dout1_101) AT=835.025n

* CHECK dout1_102 Vdout1_102ck166 = 0.9 time = 835
.meas tran vdout1_102ck166 FIND v(dout1_102) AT=835.025n

* CHECK dout1_103 Vdout1_103ck166 = 0 time = 835
.meas tran vdout1_103ck166 FIND v(dout1_103) AT=835.025n

* CHECK dout1_104 Vdout1_104ck166 = 0 time = 835
.meas tran vdout1_104ck166 FIND v(dout1_104) AT=835.025n

* CHECK dout1_105 Vdout1_105ck166 = 0.9 time = 835
.meas tran vdout1_105ck166 FIND v(dout1_105) AT=835.025n

* CHECK dout1_106 Vdout1_106ck166 = 0 time = 835
.meas tran vdout1_106ck166 FIND v(dout1_106) AT=835.025n

* CHECK dout1_107 Vdout1_107ck166 = 0.9 time = 835
.meas tran vdout1_107ck166 FIND v(dout1_107) AT=835.025n

* CHECK dout1_108 Vdout1_108ck166 = 0.9 time = 835
.meas tran vdout1_108ck166 FIND v(dout1_108) AT=835.025n

* CHECK dout1_109 Vdout1_109ck166 = 0 time = 835
.meas tran vdout1_109ck166 FIND v(dout1_109) AT=835.025n

* CHECK dout1_110 Vdout1_110ck166 = 0.9 time = 835
.meas tran vdout1_110ck166 FIND v(dout1_110) AT=835.025n

* CHECK dout1_111 Vdout1_111ck166 = 0 time = 835
.meas tran vdout1_111ck166 FIND v(dout1_111) AT=835.025n

* CHECK dout1_112 Vdout1_112ck166 = 0 time = 835
.meas tran vdout1_112ck166 FIND v(dout1_112) AT=835.025n

* CHECK dout1_113 Vdout1_113ck166 = 0.9 time = 835
.meas tran vdout1_113ck166 FIND v(dout1_113) AT=835.025n

* CHECK dout1_114 Vdout1_114ck166 = 0.9 time = 835
.meas tran vdout1_114ck166 FIND v(dout1_114) AT=835.025n

* CHECK dout1_115 Vdout1_115ck166 = 0 time = 835
.meas tran vdout1_115ck166 FIND v(dout1_115) AT=835.025n

* CHECK dout1_116 Vdout1_116ck166 = 0.9 time = 835
.meas tran vdout1_116ck166 FIND v(dout1_116) AT=835.025n

* CHECK dout1_117 Vdout1_117ck166 = 0.9 time = 835
.meas tran vdout1_117ck166 FIND v(dout1_117) AT=835.025n

* CHECK dout1_118 Vdout1_118ck166 = 0 time = 835
.meas tran vdout1_118ck166 FIND v(dout1_118) AT=835.025n

* CHECK dout1_119 Vdout1_119ck166 = 0 time = 835
.meas tran vdout1_119ck166 FIND v(dout1_119) AT=835.025n

* CHECK dout1_0 Vdout1_0ck167 = 0 time = 840
.meas tran vdout1_0ck167 FIND v(dout1_0) AT=840.025n

* CHECK dout1_1 Vdout1_1ck167 = 0.9 time = 840
.meas tran vdout1_1ck167 FIND v(dout1_1) AT=840.025n

* CHECK dout1_2 Vdout1_2ck167 = 0 time = 840
.meas tran vdout1_2ck167 FIND v(dout1_2) AT=840.025n

* CHECK dout1_3 Vdout1_3ck167 = 0 time = 840
.meas tran vdout1_3ck167 FIND v(dout1_3) AT=840.025n

* CHECK dout1_4 Vdout1_4ck167 = 0.9 time = 840
.meas tran vdout1_4ck167 FIND v(dout1_4) AT=840.025n

* CHECK dout1_5 Vdout1_5ck167 = 0 time = 840
.meas tran vdout1_5ck167 FIND v(dout1_5) AT=840.025n

* CHECK dout1_6 Vdout1_6ck167 = 0 time = 840
.meas tran vdout1_6ck167 FIND v(dout1_6) AT=840.025n

* CHECK dout1_7 Vdout1_7ck167 = 0 time = 840
.meas tran vdout1_7ck167 FIND v(dout1_7) AT=840.025n

* CHECK dout1_8 Vdout1_8ck167 = 0.9 time = 840
.meas tran vdout1_8ck167 FIND v(dout1_8) AT=840.025n

* CHECK dout1_9 Vdout1_9ck167 = 0 time = 840
.meas tran vdout1_9ck167 FIND v(dout1_9) AT=840.025n

* CHECK dout1_10 Vdout1_10ck167 = 0.9 time = 840
.meas tran vdout1_10ck167 FIND v(dout1_10) AT=840.025n

* CHECK dout1_11 Vdout1_11ck167 = 0 time = 840
.meas tran vdout1_11ck167 FIND v(dout1_11) AT=840.025n

* CHECK dout1_12 Vdout1_12ck167 = 0.9 time = 840
.meas tran vdout1_12ck167 FIND v(dout1_12) AT=840.025n

* CHECK dout1_13 Vdout1_13ck167 = 0 time = 840
.meas tran vdout1_13ck167 FIND v(dout1_13) AT=840.025n

* CHECK dout1_14 Vdout1_14ck167 = 0 time = 840
.meas tran vdout1_14ck167 FIND v(dout1_14) AT=840.025n

* CHECK dout1_15 Vdout1_15ck167 = 0 time = 840
.meas tran vdout1_15ck167 FIND v(dout1_15) AT=840.025n

* CHECK dout1_16 Vdout1_16ck167 = 0 time = 840
.meas tran vdout1_16ck167 FIND v(dout1_16) AT=840.025n

* CHECK dout1_17 Vdout1_17ck167 = 0.9 time = 840
.meas tran vdout1_17ck167 FIND v(dout1_17) AT=840.025n

* CHECK dout1_18 Vdout1_18ck167 = 0.9 time = 840
.meas tran vdout1_18ck167 FIND v(dout1_18) AT=840.025n

* CHECK dout1_19 Vdout1_19ck167 = 0 time = 840
.meas tran vdout1_19ck167 FIND v(dout1_19) AT=840.025n

* CHECK dout1_20 Vdout1_20ck167 = 0 time = 840
.meas tran vdout1_20ck167 FIND v(dout1_20) AT=840.025n

* CHECK dout1_21 Vdout1_21ck167 = 0 time = 840
.meas tran vdout1_21ck167 FIND v(dout1_21) AT=840.025n

* CHECK dout1_22 Vdout1_22ck167 = 0 time = 840
.meas tran vdout1_22ck167 FIND v(dout1_22) AT=840.025n

* CHECK dout1_23 Vdout1_23ck167 = 0.9 time = 840
.meas tran vdout1_23ck167 FIND v(dout1_23) AT=840.025n

* CHECK dout1_24 Vdout1_24ck167 = 0.9 time = 840
.meas tran vdout1_24ck167 FIND v(dout1_24) AT=840.025n

* CHECK dout1_25 Vdout1_25ck167 = 0 time = 840
.meas tran vdout1_25ck167 FIND v(dout1_25) AT=840.025n

* CHECK dout1_26 Vdout1_26ck167 = 0.9 time = 840
.meas tran vdout1_26ck167 FIND v(dout1_26) AT=840.025n

* CHECK dout1_27 Vdout1_27ck167 = 0.9 time = 840
.meas tran vdout1_27ck167 FIND v(dout1_27) AT=840.025n

* CHECK dout1_28 Vdout1_28ck167 = 0.9 time = 840
.meas tran vdout1_28ck167 FIND v(dout1_28) AT=840.025n

* CHECK dout1_29 Vdout1_29ck167 = 0.9 time = 840
.meas tran vdout1_29ck167 FIND v(dout1_29) AT=840.025n

* CHECK dout1_30 Vdout1_30ck167 = 0.9 time = 840
.meas tran vdout1_30ck167 FIND v(dout1_30) AT=840.025n

* CHECK dout1_31 Vdout1_31ck167 = 0.9 time = 840
.meas tran vdout1_31ck167 FIND v(dout1_31) AT=840.025n

* CHECK dout1_32 Vdout1_32ck167 = 0 time = 840
.meas tran vdout1_32ck167 FIND v(dout1_32) AT=840.025n

* CHECK dout1_33 Vdout1_33ck167 = 0.9 time = 840
.meas tran vdout1_33ck167 FIND v(dout1_33) AT=840.025n

* CHECK dout1_34 Vdout1_34ck167 = 0.9 time = 840
.meas tran vdout1_34ck167 FIND v(dout1_34) AT=840.025n

* CHECK dout1_35 Vdout1_35ck167 = 0.9 time = 840
.meas tran vdout1_35ck167 FIND v(dout1_35) AT=840.025n

* CHECK dout1_36 Vdout1_36ck167 = 0.9 time = 840
.meas tran vdout1_36ck167 FIND v(dout1_36) AT=840.025n

* CHECK dout1_37 Vdout1_37ck167 = 0.9 time = 840
.meas tran vdout1_37ck167 FIND v(dout1_37) AT=840.025n

* CHECK dout1_38 Vdout1_38ck167 = 0 time = 840
.meas tran vdout1_38ck167 FIND v(dout1_38) AT=840.025n

* CHECK dout1_39 Vdout1_39ck167 = 0.9 time = 840
.meas tran vdout1_39ck167 FIND v(dout1_39) AT=840.025n

* CHECK dout1_40 Vdout1_40ck167 = 0 time = 840
.meas tran vdout1_40ck167 FIND v(dout1_40) AT=840.025n

* CHECK dout1_41 Vdout1_41ck167 = 0 time = 840
.meas tran vdout1_41ck167 FIND v(dout1_41) AT=840.025n

* CHECK dout1_42 Vdout1_42ck167 = 0 time = 840
.meas tran vdout1_42ck167 FIND v(dout1_42) AT=840.025n

* CHECK dout1_43 Vdout1_43ck167 = 0.9 time = 840
.meas tran vdout1_43ck167 FIND v(dout1_43) AT=840.025n

* CHECK dout1_44 Vdout1_44ck167 = 0.9 time = 840
.meas tran vdout1_44ck167 FIND v(dout1_44) AT=840.025n

* CHECK dout1_45 Vdout1_45ck167 = 0 time = 840
.meas tran vdout1_45ck167 FIND v(dout1_45) AT=840.025n

* CHECK dout1_46 Vdout1_46ck167 = 0 time = 840
.meas tran vdout1_46ck167 FIND v(dout1_46) AT=840.025n

* CHECK dout1_47 Vdout1_47ck167 = 0.9 time = 840
.meas tran vdout1_47ck167 FIND v(dout1_47) AT=840.025n

* CHECK dout1_48 Vdout1_48ck167 = 0.9 time = 840
.meas tran vdout1_48ck167 FIND v(dout1_48) AT=840.025n

* CHECK dout1_49 Vdout1_49ck167 = 0 time = 840
.meas tran vdout1_49ck167 FIND v(dout1_49) AT=840.025n

* CHECK dout1_50 Vdout1_50ck167 = 0 time = 840
.meas tran vdout1_50ck167 FIND v(dout1_50) AT=840.025n

* CHECK dout1_51 Vdout1_51ck167 = 0.9 time = 840
.meas tran vdout1_51ck167 FIND v(dout1_51) AT=840.025n

* CHECK dout1_52 Vdout1_52ck167 = 0 time = 840
.meas tran vdout1_52ck167 FIND v(dout1_52) AT=840.025n

* CHECK dout1_53 Vdout1_53ck167 = 0 time = 840
.meas tran vdout1_53ck167 FIND v(dout1_53) AT=840.025n

* CHECK dout1_54 Vdout1_54ck167 = 0.9 time = 840
.meas tran vdout1_54ck167 FIND v(dout1_54) AT=840.025n

* CHECK dout1_55 Vdout1_55ck167 = 0 time = 840
.meas tran vdout1_55ck167 FIND v(dout1_55) AT=840.025n

* CHECK dout1_56 Vdout1_56ck167 = 0 time = 840
.meas tran vdout1_56ck167 FIND v(dout1_56) AT=840.025n

* CHECK dout1_57 Vdout1_57ck167 = 0 time = 840
.meas tran vdout1_57ck167 FIND v(dout1_57) AT=840.025n

* CHECK dout1_58 Vdout1_58ck167 = 0 time = 840
.meas tran vdout1_58ck167 FIND v(dout1_58) AT=840.025n

* CHECK dout1_59 Vdout1_59ck167 = 0 time = 840
.meas tran vdout1_59ck167 FIND v(dout1_59) AT=840.025n

* CHECK dout1_60 Vdout1_60ck167 = 0.9 time = 840
.meas tran vdout1_60ck167 FIND v(dout1_60) AT=840.025n

* CHECK dout1_61 Vdout1_61ck167 = 0.9 time = 840
.meas tran vdout1_61ck167 FIND v(dout1_61) AT=840.025n

* CHECK dout1_62 Vdout1_62ck167 = 0 time = 840
.meas tran vdout1_62ck167 FIND v(dout1_62) AT=840.025n

* CHECK dout1_63 Vdout1_63ck167 = 0.9 time = 840
.meas tran vdout1_63ck167 FIND v(dout1_63) AT=840.025n

* CHECK dout1_64 Vdout1_64ck167 = 0 time = 840
.meas tran vdout1_64ck167 FIND v(dout1_64) AT=840.025n

* CHECK dout1_65 Vdout1_65ck167 = 0.9 time = 840
.meas tran vdout1_65ck167 FIND v(dout1_65) AT=840.025n

* CHECK dout1_66 Vdout1_66ck167 = 0.9 time = 840
.meas tran vdout1_66ck167 FIND v(dout1_66) AT=840.025n

* CHECK dout1_67 Vdout1_67ck167 = 0.9 time = 840
.meas tran vdout1_67ck167 FIND v(dout1_67) AT=840.025n

* CHECK dout1_68 Vdout1_68ck167 = 0 time = 840
.meas tran vdout1_68ck167 FIND v(dout1_68) AT=840.025n

* CHECK dout1_69 Vdout1_69ck167 = 0 time = 840
.meas tran vdout1_69ck167 FIND v(dout1_69) AT=840.025n

* CHECK dout1_70 Vdout1_70ck167 = 0.9 time = 840
.meas tran vdout1_70ck167 FIND v(dout1_70) AT=840.025n

* CHECK dout1_71 Vdout1_71ck167 = 0.9 time = 840
.meas tran vdout1_71ck167 FIND v(dout1_71) AT=840.025n

* CHECK dout1_72 Vdout1_72ck167 = 0 time = 840
.meas tran vdout1_72ck167 FIND v(dout1_72) AT=840.025n

* CHECK dout1_73 Vdout1_73ck167 = 0 time = 840
.meas tran vdout1_73ck167 FIND v(dout1_73) AT=840.025n

* CHECK dout1_74 Vdout1_74ck167 = 0.9 time = 840
.meas tran vdout1_74ck167 FIND v(dout1_74) AT=840.025n

* CHECK dout1_75 Vdout1_75ck167 = 0.9 time = 840
.meas tran vdout1_75ck167 FIND v(dout1_75) AT=840.025n

* CHECK dout1_76 Vdout1_76ck167 = 0.9 time = 840
.meas tran vdout1_76ck167 FIND v(dout1_76) AT=840.025n

* CHECK dout1_77 Vdout1_77ck167 = 0.9 time = 840
.meas tran vdout1_77ck167 FIND v(dout1_77) AT=840.025n

* CHECK dout1_78 Vdout1_78ck167 = 0 time = 840
.meas tran vdout1_78ck167 FIND v(dout1_78) AT=840.025n

* CHECK dout1_79 Vdout1_79ck167 = 0.9 time = 840
.meas tran vdout1_79ck167 FIND v(dout1_79) AT=840.025n

* CHECK dout1_80 Vdout1_80ck167 = 0 time = 840
.meas tran vdout1_80ck167 FIND v(dout1_80) AT=840.025n

* CHECK dout1_81 Vdout1_81ck167 = 0.9 time = 840
.meas tran vdout1_81ck167 FIND v(dout1_81) AT=840.025n

* CHECK dout1_82 Vdout1_82ck167 = 0.9 time = 840
.meas tran vdout1_82ck167 FIND v(dout1_82) AT=840.025n

* CHECK dout1_83 Vdout1_83ck167 = 0.9 time = 840
.meas tran vdout1_83ck167 FIND v(dout1_83) AT=840.025n

* CHECK dout1_84 Vdout1_84ck167 = 0.9 time = 840
.meas tran vdout1_84ck167 FIND v(dout1_84) AT=840.025n

* CHECK dout1_85 Vdout1_85ck167 = 0.9 time = 840
.meas tran vdout1_85ck167 FIND v(dout1_85) AT=840.025n

* CHECK dout1_86 Vdout1_86ck167 = 0.9 time = 840
.meas tran vdout1_86ck167 FIND v(dout1_86) AT=840.025n

* CHECK dout1_87 Vdout1_87ck167 = 0 time = 840
.meas tran vdout1_87ck167 FIND v(dout1_87) AT=840.025n

* CHECK dout1_88 Vdout1_88ck167 = 0.9 time = 840
.meas tran vdout1_88ck167 FIND v(dout1_88) AT=840.025n

* CHECK dout1_89 Vdout1_89ck167 = 0.9 time = 840
.meas tran vdout1_89ck167 FIND v(dout1_89) AT=840.025n

* CHECK dout1_90 Vdout1_90ck167 = 0 time = 840
.meas tran vdout1_90ck167 FIND v(dout1_90) AT=840.025n

* CHECK dout1_91 Vdout1_91ck167 = 0.9 time = 840
.meas tran vdout1_91ck167 FIND v(dout1_91) AT=840.025n

* CHECK dout1_92 Vdout1_92ck167 = 0.9 time = 840
.meas tran vdout1_92ck167 FIND v(dout1_92) AT=840.025n

* CHECK dout1_93 Vdout1_93ck167 = 0.9 time = 840
.meas tran vdout1_93ck167 FIND v(dout1_93) AT=840.025n

* CHECK dout1_94 Vdout1_94ck167 = 0 time = 840
.meas tran vdout1_94ck167 FIND v(dout1_94) AT=840.025n

* CHECK dout1_95 Vdout1_95ck167 = 0.9 time = 840
.meas tran vdout1_95ck167 FIND v(dout1_95) AT=840.025n

* CHECK dout1_96 Vdout1_96ck167 = 0.9 time = 840
.meas tran vdout1_96ck167 FIND v(dout1_96) AT=840.025n

* CHECK dout1_97 Vdout1_97ck167 = 0 time = 840
.meas tran vdout1_97ck167 FIND v(dout1_97) AT=840.025n

* CHECK dout1_98 Vdout1_98ck167 = 0 time = 840
.meas tran vdout1_98ck167 FIND v(dout1_98) AT=840.025n

* CHECK dout1_99 Vdout1_99ck167 = 0.9 time = 840
.meas tran vdout1_99ck167 FIND v(dout1_99) AT=840.025n

* CHECK dout1_100 Vdout1_100ck167 = 0 time = 840
.meas tran vdout1_100ck167 FIND v(dout1_100) AT=840.025n

* CHECK dout1_101 Vdout1_101ck167 = 0 time = 840
.meas tran vdout1_101ck167 FIND v(dout1_101) AT=840.025n

* CHECK dout1_102 Vdout1_102ck167 = 0 time = 840
.meas tran vdout1_102ck167 FIND v(dout1_102) AT=840.025n

* CHECK dout1_103 Vdout1_103ck167 = 0.9 time = 840
.meas tran vdout1_103ck167 FIND v(dout1_103) AT=840.025n

* CHECK dout1_104 Vdout1_104ck167 = 0.9 time = 840
.meas tran vdout1_104ck167 FIND v(dout1_104) AT=840.025n

* CHECK dout1_105 Vdout1_105ck167 = 0 time = 840
.meas tran vdout1_105ck167 FIND v(dout1_105) AT=840.025n

* CHECK dout1_106 Vdout1_106ck167 = 0.9 time = 840
.meas tran vdout1_106ck167 FIND v(dout1_106) AT=840.025n

* CHECK dout1_107 Vdout1_107ck167 = 0.9 time = 840
.meas tran vdout1_107ck167 FIND v(dout1_107) AT=840.025n

* CHECK dout1_108 Vdout1_108ck167 = 0.9 time = 840
.meas tran vdout1_108ck167 FIND v(dout1_108) AT=840.025n

* CHECK dout1_109 Vdout1_109ck167 = 0.9 time = 840
.meas tran vdout1_109ck167 FIND v(dout1_109) AT=840.025n

* CHECK dout1_110 Vdout1_110ck167 = 0 time = 840
.meas tran vdout1_110ck167 FIND v(dout1_110) AT=840.025n

* CHECK dout1_111 Vdout1_111ck167 = 0 time = 840
.meas tran vdout1_111ck167 FIND v(dout1_111) AT=840.025n

* CHECK dout1_112 Vdout1_112ck167 = 0.9 time = 840
.meas tran vdout1_112ck167 FIND v(dout1_112) AT=840.025n

* CHECK dout1_113 Vdout1_113ck167 = 0.9 time = 840
.meas tran vdout1_113ck167 FIND v(dout1_113) AT=840.025n

* CHECK dout1_114 Vdout1_114ck167 = 0.9 time = 840
.meas tran vdout1_114ck167 FIND v(dout1_114) AT=840.025n

* CHECK dout1_115 Vdout1_115ck167 = 0.9 time = 840
.meas tran vdout1_115ck167 FIND v(dout1_115) AT=840.025n

* CHECK dout1_116 Vdout1_116ck167 = 0 time = 840
.meas tran vdout1_116ck167 FIND v(dout1_116) AT=840.025n

* CHECK dout1_117 Vdout1_117ck167 = 0 time = 840
.meas tran vdout1_117ck167 FIND v(dout1_117) AT=840.025n

* CHECK dout1_118 Vdout1_118ck167 = 0.9 time = 840
.meas tran vdout1_118ck167 FIND v(dout1_118) AT=840.025n

* CHECK dout1_119 Vdout1_119ck167 = 0 time = 840
.meas tran vdout1_119ck167 FIND v(dout1_119) AT=840.025n

* CHECK dout1_0 Vdout1_0ck168 = 0 time = 845
.meas tran vdout1_0ck168 FIND v(dout1_0) AT=845.025n

* CHECK dout1_1 Vdout1_1ck168 = 0.9 time = 845
.meas tran vdout1_1ck168 FIND v(dout1_1) AT=845.025n

* CHECK dout1_2 Vdout1_2ck168 = 0 time = 845
.meas tran vdout1_2ck168 FIND v(dout1_2) AT=845.025n

* CHECK dout1_3 Vdout1_3ck168 = 0 time = 845
.meas tran vdout1_3ck168 FIND v(dout1_3) AT=845.025n

* CHECK dout1_4 Vdout1_4ck168 = 0.9 time = 845
.meas tran vdout1_4ck168 FIND v(dout1_4) AT=845.025n

* CHECK dout1_5 Vdout1_5ck168 = 0 time = 845
.meas tran vdout1_5ck168 FIND v(dout1_5) AT=845.025n

* CHECK dout1_6 Vdout1_6ck168 = 0 time = 845
.meas tran vdout1_6ck168 FIND v(dout1_6) AT=845.025n

* CHECK dout1_7 Vdout1_7ck168 = 0 time = 845
.meas tran vdout1_7ck168 FIND v(dout1_7) AT=845.025n

* CHECK dout1_8 Vdout1_8ck168 = 0.9 time = 845
.meas tran vdout1_8ck168 FIND v(dout1_8) AT=845.025n

* CHECK dout1_9 Vdout1_9ck168 = 0 time = 845
.meas tran vdout1_9ck168 FIND v(dout1_9) AT=845.025n

* CHECK dout1_10 Vdout1_10ck168 = 0.9 time = 845
.meas tran vdout1_10ck168 FIND v(dout1_10) AT=845.025n

* CHECK dout1_11 Vdout1_11ck168 = 0 time = 845
.meas tran vdout1_11ck168 FIND v(dout1_11) AT=845.025n

* CHECK dout1_12 Vdout1_12ck168 = 0.9 time = 845
.meas tran vdout1_12ck168 FIND v(dout1_12) AT=845.025n

* CHECK dout1_13 Vdout1_13ck168 = 0 time = 845
.meas tran vdout1_13ck168 FIND v(dout1_13) AT=845.025n

* CHECK dout1_14 Vdout1_14ck168 = 0 time = 845
.meas tran vdout1_14ck168 FIND v(dout1_14) AT=845.025n

* CHECK dout1_15 Vdout1_15ck168 = 0 time = 845
.meas tran vdout1_15ck168 FIND v(dout1_15) AT=845.025n

* CHECK dout1_16 Vdout1_16ck168 = 0 time = 845
.meas tran vdout1_16ck168 FIND v(dout1_16) AT=845.025n

* CHECK dout1_17 Vdout1_17ck168 = 0.9 time = 845
.meas tran vdout1_17ck168 FIND v(dout1_17) AT=845.025n

* CHECK dout1_18 Vdout1_18ck168 = 0.9 time = 845
.meas tran vdout1_18ck168 FIND v(dout1_18) AT=845.025n

* CHECK dout1_19 Vdout1_19ck168 = 0 time = 845
.meas tran vdout1_19ck168 FIND v(dout1_19) AT=845.025n

* CHECK dout1_20 Vdout1_20ck168 = 0 time = 845
.meas tran vdout1_20ck168 FIND v(dout1_20) AT=845.025n

* CHECK dout1_21 Vdout1_21ck168 = 0 time = 845
.meas tran vdout1_21ck168 FIND v(dout1_21) AT=845.025n

* CHECK dout1_22 Vdout1_22ck168 = 0 time = 845
.meas tran vdout1_22ck168 FIND v(dout1_22) AT=845.025n

* CHECK dout1_23 Vdout1_23ck168 = 0.9 time = 845
.meas tran vdout1_23ck168 FIND v(dout1_23) AT=845.025n

* CHECK dout1_24 Vdout1_24ck168 = 0.9 time = 845
.meas tran vdout1_24ck168 FIND v(dout1_24) AT=845.025n

* CHECK dout1_25 Vdout1_25ck168 = 0 time = 845
.meas tran vdout1_25ck168 FIND v(dout1_25) AT=845.025n

* CHECK dout1_26 Vdout1_26ck168 = 0.9 time = 845
.meas tran vdout1_26ck168 FIND v(dout1_26) AT=845.025n

* CHECK dout1_27 Vdout1_27ck168 = 0.9 time = 845
.meas tran vdout1_27ck168 FIND v(dout1_27) AT=845.025n

* CHECK dout1_28 Vdout1_28ck168 = 0.9 time = 845
.meas tran vdout1_28ck168 FIND v(dout1_28) AT=845.025n

* CHECK dout1_29 Vdout1_29ck168 = 0.9 time = 845
.meas tran vdout1_29ck168 FIND v(dout1_29) AT=845.025n

* CHECK dout1_30 Vdout1_30ck168 = 0.9 time = 845
.meas tran vdout1_30ck168 FIND v(dout1_30) AT=845.025n

* CHECK dout1_31 Vdout1_31ck168 = 0.9 time = 845
.meas tran vdout1_31ck168 FIND v(dout1_31) AT=845.025n

* CHECK dout1_32 Vdout1_32ck168 = 0 time = 845
.meas tran vdout1_32ck168 FIND v(dout1_32) AT=845.025n

* CHECK dout1_33 Vdout1_33ck168 = 0.9 time = 845
.meas tran vdout1_33ck168 FIND v(dout1_33) AT=845.025n

* CHECK dout1_34 Vdout1_34ck168 = 0.9 time = 845
.meas tran vdout1_34ck168 FIND v(dout1_34) AT=845.025n

* CHECK dout1_35 Vdout1_35ck168 = 0.9 time = 845
.meas tran vdout1_35ck168 FIND v(dout1_35) AT=845.025n

* CHECK dout1_36 Vdout1_36ck168 = 0.9 time = 845
.meas tran vdout1_36ck168 FIND v(dout1_36) AT=845.025n

* CHECK dout1_37 Vdout1_37ck168 = 0.9 time = 845
.meas tran vdout1_37ck168 FIND v(dout1_37) AT=845.025n

* CHECK dout1_38 Vdout1_38ck168 = 0 time = 845
.meas tran vdout1_38ck168 FIND v(dout1_38) AT=845.025n

* CHECK dout1_39 Vdout1_39ck168 = 0.9 time = 845
.meas tran vdout1_39ck168 FIND v(dout1_39) AT=845.025n

* CHECK dout1_40 Vdout1_40ck168 = 0 time = 845
.meas tran vdout1_40ck168 FIND v(dout1_40) AT=845.025n

* CHECK dout1_41 Vdout1_41ck168 = 0 time = 845
.meas tran vdout1_41ck168 FIND v(dout1_41) AT=845.025n

* CHECK dout1_42 Vdout1_42ck168 = 0 time = 845
.meas tran vdout1_42ck168 FIND v(dout1_42) AT=845.025n

* CHECK dout1_43 Vdout1_43ck168 = 0.9 time = 845
.meas tran vdout1_43ck168 FIND v(dout1_43) AT=845.025n

* CHECK dout1_44 Vdout1_44ck168 = 0.9 time = 845
.meas tran vdout1_44ck168 FIND v(dout1_44) AT=845.025n

* CHECK dout1_45 Vdout1_45ck168 = 0 time = 845
.meas tran vdout1_45ck168 FIND v(dout1_45) AT=845.025n

* CHECK dout1_46 Vdout1_46ck168 = 0 time = 845
.meas tran vdout1_46ck168 FIND v(dout1_46) AT=845.025n

* CHECK dout1_47 Vdout1_47ck168 = 0.9 time = 845
.meas tran vdout1_47ck168 FIND v(dout1_47) AT=845.025n

* CHECK dout1_48 Vdout1_48ck168 = 0.9 time = 845
.meas tran vdout1_48ck168 FIND v(dout1_48) AT=845.025n

* CHECK dout1_49 Vdout1_49ck168 = 0 time = 845
.meas tran vdout1_49ck168 FIND v(dout1_49) AT=845.025n

* CHECK dout1_50 Vdout1_50ck168 = 0 time = 845
.meas tran vdout1_50ck168 FIND v(dout1_50) AT=845.025n

* CHECK dout1_51 Vdout1_51ck168 = 0.9 time = 845
.meas tran vdout1_51ck168 FIND v(dout1_51) AT=845.025n

* CHECK dout1_52 Vdout1_52ck168 = 0 time = 845
.meas tran vdout1_52ck168 FIND v(dout1_52) AT=845.025n

* CHECK dout1_53 Vdout1_53ck168 = 0 time = 845
.meas tran vdout1_53ck168 FIND v(dout1_53) AT=845.025n

* CHECK dout1_54 Vdout1_54ck168 = 0.9 time = 845
.meas tran vdout1_54ck168 FIND v(dout1_54) AT=845.025n

* CHECK dout1_55 Vdout1_55ck168 = 0 time = 845
.meas tran vdout1_55ck168 FIND v(dout1_55) AT=845.025n

* CHECK dout1_56 Vdout1_56ck168 = 0 time = 845
.meas tran vdout1_56ck168 FIND v(dout1_56) AT=845.025n

* CHECK dout1_57 Vdout1_57ck168 = 0 time = 845
.meas tran vdout1_57ck168 FIND v(dout1_57) AT=845.025n

* CHECK dout1_58 Vdout1_58ck168 = 0 time = 845
.meas tran vdout1_58ck168 FIND v(dout1_58) AT=845.025n

* CHECK dout1_59 Vdout1_59ck168 = 0 time = 845
.meas tran vdout1_59ck168 FIND v(dout1_59) AT=845.025n

* CHECK dout1_60 Vdout1_60ck168 = 0.9 time = 845
.meas tran vdout1_60ck168 FIND v(dout1_60) AT=845.025n

* CHECK dout1_61 Vdout1_61ck168 = 0.9 time = 845
.meas tran vdout1_61ck168 FIND v(dout1_61) AT=845.025n

* CHECK dout1_62 Vdout1_62ck168 = 0 time = 845
.meas tran vdout1_62ck168 FIND v(dout1_62) AT=845.025n

* CHECK dout1_63 Vdout1_63ck168 = 0.9 time = 845
.meas tran vdout1_63ck168 FIND v(dout1_63) AT=845.025n

* CHECK dout1_64 Vdout1_64ck168 = 0 time = 845
.meas tran vdout1_64ck168 FIND v(dout1_64) AT=845.025n

* CHECK dout1_65 Vdout1_65ck168 = 0.9 time = 845
.meas tran vdout1_65ck168 FIND v(dout1_65) AT=845.025n

* CHECK dout1_66 Vdout1_66ck168 = 0.9 time = 845
.meas tran vdout1_66ck168 FIND v(dout1_66) AT=845.025n

* CHECK dout1_67 Vdout1_67ck168 = 0.9 time = 845
.meas tran vdout1_67ck168 FIND v(dout1_67) AT=845.025n

* CHECK dout1_68 Vdout1_68ck168 = 0 time = 845
.meas tran vdout1_68ck168 FIND v(dout1_68) AT=845.025n

* CHECK dout1_69 Vdout1_69ck168 = 0 time = 845
.meas tran vdout1_69ck168 FIND v(dout1_69) AT=845.025n

* CHECK dout1_70 Vdout1_70ck168 = 0.9 time = 845
.meas tran vdout1_70ck168 FIND v(dout1_70) AT=845.025n

* CHECK dout1_71 Vdout1_71ck168 = 0.9 time = 845
.meas tran vdout1_71ck168 FIND v(dout1_71) AT=845.025n

* CHECK dout1_72 Vdout1_72ck168 = 0 time = 845
.meas tran vdout1_72ck168 FIND v(dout1_72) AT=845.025n

* CHECK dout1_73 Vdout1_73ck168 = 0 time = 845
.meas tran vdout1_73ck168 FIND v(dout1_73) AT=845.025n

* CHECK dout1_74 Vdout1_74ck168 = 0.9 time = 845
.meas tran vdout1_74ck168 FIND v(dout1_74) AT=845.025n

* CHECK dout1_75 Vdout1_75ck168 = 0.9 time = 845
.meas tran vdout1_75ck168 FIND v(dout1_75) AT=845.025n

* CHECK dout1_76 Vdout1_76ck168 = 0.9 time = 845
.meas tran vdout1_76ck168 FIND v(dout1_76) AT=845.025n

* CHECK dout1_77 Vdout1_77ck168 = 0.9 time = 845
.meas tran vdout1_77ck168 FIND v(dout1_77) AT=845.025n

* CHECK dout1_78 Vdout1_78ck168 = 0 time = 845
.meas tran vdout1_78ck168 FIND v(dout1_78) AT=845.025n

* CHECK dout1_79 Vdout1_79ck168 = 0.9 time = 845
.meas tran vdout1_79ck168 FIND v(dout1_79) AT=845.025n

* CHECK dout1_80 Vdout1_80ck168 = 0 time = 845
.meas tran vdout1_80ck168 FIND v(dout1_80) AT=845.025n

* CHECK dout1_81 Vdout1_81ck168 = 0.9 time = 845
.meas tran vdout1_81ck168 FIND v(dout1_81) AT=845.025n

* CHECK dout1_82 Vdout1_82ck168 = 0.9 time = 845
.meas tran vdout1_82ck168 FIND v(dout1_82) AT=845.025n

* CHECK dout1_83 Vdout1_83ck168 = 0.9 time = 845
.meas tran vdout1_83ck168 FIND v(dout1_83) AT=845.025n

* CHECK dout1_84 Vdout1_84ck168 = 0.9 time = 845
.meas tran vdout1_84ck168 FIND v(dout1_84) AT=845.025n

* CHECK dout1_85 Vdout1_85ck168 = 0.9 time = 845
.meas tran vdout1_85ck168 FIND v(dout1_85) AT=845.025n

* CHECK dout1_86 Vdout1_86ck168 = 0.9 time = 845
.meas tran vdout1_86ck168 FIND v(dout1_86) AT=845.025n

* CHECK dout1_87 Vdout1_87ck168 = 0 time = 845
.meas tran vdout1_87ck168 FIND v(dout1_87) AT=845.025n

* CHECK dout1_88 Vdout1_88ck168 = 0.9 time = 845
.meas tran vdout1_88ck168 FIND v(dout1_88) AT=845.025n

* CHECK dout1_89 Vdout1_89ck168 = 0.9 time = 845
.meas tran vdout1_89ck168 FIND v(dout1_89) AT=845.025n

* CHECK dout1_90 Vdout1_90ck168 = 0 time = 845
.meas tran vdout1_90ck168 FIND v(dout1_90) AT=845.025n

* CHECK dout1_91 Vdout1_91ck168 = 0.9 time = 845
.meas tran vdout1_91ck168 FIND v(dout1_91) AT=845.025n

* CHECK dout1_92 Vdout1_92ck168 = 0.9 time = 845
.meas tran vdout1_92ck168 FIND v(dout1_92) AT=845.025n

* CHECK dout1_93 Vdout1_93ck168 = 0.9 time = 845
.meas tran vdout1_93ck168 FIND v(dout1_93) AT=845.025n

* CHECK dout1_94 Vdout1_94ck168 = 0 time = 845
.meas tran vdout1_94ck168 FIND v(dout1_94) AT=845.025n

* CHECK dout1_95 Vdout1_95ck168 = 0.9 time = 845
.meas tran vdout1_95ck168 FIND v(dout1_95) AT=845.025n

* CHECK dout1_96 Vdout1_96ck168 = 0.9 time = 845
.meas tran vdout1_96ck168 FIND v(dout1_96) AT=845.025n

* CHECK dout1_97 Vdout1_97ck168 = 0 time = 845
.meas tran vdout1_97ck168 FIND v(dout1_97) AT=845.025n

* CHECK dout1_98 Vdout1_98ck168 = 0 time = 845
.meas tran vdout1_98ck168 FIND v(dout1_98) AT=845.025n

* CHECK dout1_99 Vdout1_99ck168 = 0.9 time = 845
.meas tran vdout1_99ck168 FIND v(dout1_99) AT=845.025n

* CHECK dout1_100 Vdout1_100ck168 = 0 time = 845
.meas tran vdout1_100ck168 FIND v(dout1_100) AT=845.025n

* CHECK dout1_101 Vdout1_101ck168 = 0 time = 845
.meas tran vdout1_101ck168 FIND v(dout1_101) AT=845.025n

* CHECK dout1_102 Vdout1_102ck168 = 0 time = 845
.meas tran vdout1_102ck168 FIND v(dout1_102) AT=845.025n

* CHECK dout1_103 Vdout1_103ck168 = 0.9 time = 845
.meas tran vdout1_103ck168 FIND v(dout1_103) AT=845.025n

* CHECK dout1_104 Vdout1_104ck168 = 0.9 time = 845
.meas tran vdout1_104ck168 FIND v(dout1_104) AT=845.025n

* CHECK dout1_105 Vdout1_105ck168 = 0 time = 845
.meas tran vdout1_105ck168 FIND v(dout1_105) AT=845.025n

* CHECK dout1_106 Vdout1_106ck168 = 0.9 time = 845
.meas tran vdout1_106ck168 FIND v(dout1_106) AT=845.025n

* CHECK dout1_107 Vdout1_107ck168 = 0.9 time = 845
.meas tran vdout1_107ck168 FIND v(dout1_107) AT=845.025n

* CHECK dout1_108 Vdout1_108ck168 = 0.9 time = 845
.meas tran vdout1_108ck168 FIND v(dout1_108) AT=845.025n

* CHECK dout1_109 Vdout1_109ck168 = 0.9 time = 845
.meas tran vdout1_109ck168 FIND v(dout1_109) AT=845.025n

* CHECK dout1_110 Vdout1_110ck168 = 0 time = 845
.meas tran vdout1_110ck168 FIND v(dout1_110) AT=845.025n

* CHECK dout1_111 Vdout1_111ck168 = 0 time = 845
.meas tran vdout1_111ck168 FIND v(dout1_111) AT=845.025n

* CHECK dout1_112 Vdout1_112ck168 = 0.9 time = 845
.meas tran vdout1_112ck168 FIND v(dout1_112) AT=845.025n

* CHECK dout1_113 Vdout1_113ck168 = 0.9 time = 845
.meas tran vdout1_113ck168 FIND v(dout1_113) AT=845.025n

* CHECK dout1_114 Vdout1_114ck168 = 0.9 time = 845
.meas tran vdout1_114ck168 FIND v(dout1_114) AT=845.025n

* CHECK dout1_115 Vdout1_115ck168 = 0.9 time = 845
.meas tran vdout1_115ck168 FIND v(dout1_115) AT=845.025n

* CHECK dout1_116 Vdout1_116ck168 = 0 time = 845
.meas tran vdout1_116ck168 FIND v(dout1_116) AT=845.025n

* CHECK dout1_117 Vdout1_117ck168 = 0 time = 845
.meas tran vdout1_117ck168 FIND v(dout1_117) AT=845.025n

* CHECK dout1_118 Vdout1_118ck168 = 0.9 time = 845
.meas tran vdout1_118ck168 FIND v(dout1_118) AT=845.025n

* CHECK dout1_119 Vdout1_119ck168 = 0 time = 845
.meas tran vdout1_119ck168 FIND v(dout1_119) AT=845.025n

* CHECK dout1_0 Vdout1_0ck172 = 0 time = 865
.meas tran vdout1_0ck172 FIND v(dout1_0) AT=865.025n

* CHECK dout1_1 Vdout1_1ck172 = 0 time = 865
.meas tran vdout1_1ck172 FIND v(dout1_1) AT=865.025n

* CHECK dout1_2 Vdout1_2ck172 = 0 time = 865
.meas tran vdout1_2ck172 FIND v(dout1_2) AT=865.025n

* CHECK dout1_3 Vdout1_3ck172 = 0 time = 865
.meas tran vdout1_3ck172 FIND v(dout1_3) AT=865.025n

* CHECK dout1_4 Vdout1_4ck172 = 0 time = 865
.meas tran vdout1_4ck172 FIND v(dout1_4) AT=865.025n

* CHECK dout1_5 Vdout1_5ck172 = 0 time = 865
.meas tran vdout1_5ck172 FIND v(dout1_5) AT=865.025n

* CHECK dout1_6 Vdout1_6ck172 = 0.9 time = 865
.meas tran vdout1_6ck172 FIND v(dout1_6) AT=865.025n

* CHECK dout1_7 Vdout1_7ck172 = 0 time = 865
.meas tran vdout1_7ck172 FIND v(dout1_7) AT=865.025n

* CHECK dout1_8 Vdout1_8ck172 = 0 time = 865
.meas tran vdout1_8ck172 FIND v(dout1_8) AT=865.025n

* CHECK dout1_9 Vdout1_9ck172 = 0.9 time = 865
.meas tran vdout1_9ck172 FIND v(dout1_9) AT=865.025n

* CHECK dout1_10 Vdout1_10ck172 = 0 time = 865
.meas tran vdout1_10ck172 FIND v(dout1_10) AT=865.025n

* CHECK dout1_11 Vdout1_11ck172 = 0 time = 865
.meas tran vdout1_11ck172 FIND v(dout1_11) AT=865.025n

* CHECK dout1_12 Vdout1_12ck172 = 0.9 time = 865
.meas tran vdout1_12ck172 FIND v(dout1_12) AT=865.025n

* CHECK dout1_13 Vdout1_13ck172 = 0 time = 865
.meas tran vdout1_13ck172 FIND v(dout1_13) AT=865.025n

* CHECK dout1_14 Vdout1_14ck172 = 0 time = 865
.meas tran vdout1_14ck172 FIND v(dout1_14) AT=865.025n

* CHECK dout1_15 Vdout1_15ck172 = 0.9 time = 865
.meas tran vdout1_15ck172 FIND v(dout1_15) AT=865.025n

* CHECK dout1_16 Vdout1_16ck172 = 0.9 time = 865
.meas tran vdout1_16ck172 FIND v(dout1_16) AT=865.025n

* CHECK dout1_17 Vdout1_17ck172 = 0.9 time = 865
.meas tran vdout1_17ck172 FIND v(dout1_17) AT=865.025n

* CHECK dout1_18 Vdout1_18ck172 = 0 time = 865
.meas tran vdout1_18ck172 FIND v(dout1_18) AT=865.025n

* CHECK dout1_19 Vdout1_19ck172 = 0 time = 865
.meas tran vdout1_19ck172 FIND v(dout1_19) AT=865.025n

* CHECK dout1_20 Vdout1_20ck172 = 0 time = 865
.meas tran vdout1_20ck172 FIND v(dout1_20) AT=865.025n

* CHECK dout1_21 Vdout1_21ck172 = 0.9 time = 865
.meas tran vdout1_21ck172 FIND v(dout1_21) AT=865.025n

* CHECK dout1_22 Vdout1_22ck172 = 0.9 time = 865
.meas tran vdout1_22ck172 FIND v(dout1_22) AT=865.025n

* CHECK dout1_23 Vdout1_23ck172 = 0 time = 865
.meas tran vdout1_23ck172 FIND v(dout1_23) AT=865.025n

* CHECK dout1_24 Vdout1_24ck172 = 0.9 time = 865
.meas tran vdout1_24ck172 FIND v(dout1_24) AT=865.025n

* CHECK dout1_25 Vdout1_25ck172 = 0.9 time = 865
.meas tran vdout1_25ck172 FIND v(dout1_25) AT=865.025n

* CHECK dout1_26 Vdout1_26ck172 = 0 time = 865
.meas tran vdout1_26ck172 FIND v(dout1_26) AT=865.025n

* CHECK dout1_27 Vdout1_27ck172 = 0 time = 865
.meas tran vdout1_27ck172 FIND v(dout1_27) AT=865.025n

* CHECK dout1_28 Vdout1_28ck172 = 0.9 time = 865
.meas tran vdout1_28ck172 FIND v(dout1_28) AT=865.025n

* CHECK dout1_29 Vdout1_29ck172 = 0 time = 865
.meas tran vdout1_29ck172 FIND v(dout1_29) AT=865.025n

* CHECK dout1_30 Vdout1_30ck172 = 0.9 time = 865
.meas tran vdout1_30ck172 FIND v(dout1_30) AT=865.025n

* CHECK dout1_31 Vdout1_31ck172 = 0 time = 865
.meas tran vdout1_31ck172 FIND v(dout1_31) AT=865.025n

* CHECK dout1_32 Vdout1_32ck172 = 0.9 time = 865
.meas tran vdout1_32ck172 FIND v(dout1_32) AT=865.025n

* CHECK dout1_33 Vdout1_33ck172 = 0.9 time = 865
.meas tran vdout1_33ck172 FIND v(dout1_33) AT=865.025n

* CHECK dout1_34 Vdout1_34ck172 = 0 time = 865
.meas tran vdout1_34ck172 FIND v(dout1_34) AT=865.025n

* CHECK dout1_35 Vdout1_35ck172 = 0.9 time = 865
.meas tran vdout1_35ck172 FIND v(dout1_35) AT=865.025n

* CHECK dout1_36 Vdout1_36ck172 = 0.9 time = 865
.meas tran vdout1_36ck172 FIND v(dout1_36) AT=865.025n

* CHECK dout1_37 Vdout1_37ck172 = 0 time = 865
.meas tran vdout1_37ck172 FIND v(dout1_37) AT=865.025n

* CHECK dout1_38 Vdout1_38ck172 = 0.9 time = 865
.meas tran vdout1_38ck172 FIND v(dout1_38) AT=865.025n

* CHECK dout1_39 Vdout1_39ck172 = 0.9 time = 865
.meas tran vdout1_39ck172 FIND v(dout1_39) AT=865.025n

* CHECK dout1_40 Vdout1_40ck172 = 0.9 time = 865
.meas tran vdout1_40ck172 FIND v(dout1_40) AT=865.025n

* CHECK dout1_41 Vdout1_41ck172 = 0 time = 865
.meas tran vdout1_41ck172 FIND v(dout1_41) AT=865.025n

* CHECK dout1_42 Vdout1_42ck172 = 0.9 time = 865
.meas tran vdout1_42ck172 FIND v(dout1_42) AT=865.025n

* CHECK dout1_43 Vdout1_43ck172 = 0 time = 865
.meas tran vdout1_43ck172 FIND v(dout1_43) AT=865.025n

* CHECK dout1_44 Vdout1_44ck172 = 0 time = 865
.meas tran vdout1_44ck172 FIND v(dout1_44) AT=865.025n

* CHECK dout1_45 Vdout1_45ck172 = 0 time = 865
.meas tran vdout1_45ck172 FIND v(dout1_45) AT=865.025n

* CHECK dout1_46 Vdout1_46ck172 = 0 time = 865
.meas tran vdout1_46ck172 FIND v(dout1_46) AT=865.025n

* CHECK dout1_47 Vdout1_47ck172 = 0.9 time = 865
.meas tran vdout1_47ck172 FIND v(dout1_47) AT=865.025n

* CHECK dout1_48 Vdout1_48ck172 = 0 time = 865
.meas tran vdout1_48ck172 FIND v(dout1_48) AT=865.025n

* CHECK dout1_49 Vdout1_49ck172 = 0 time = 865
.meas tran vdout1_49ck172 FIND v(dout1_49) AT=865.025n

* CHECK dout1_50 Vdout1_50ck172 = 0 time = 865
.meas tran vdout1_50ck172 FIND v(dout1_50) AT=865.025n

* CHECK dout1_51 Vdout1_51ck172 = 0.9 time = 865
.meas tran vdout1_51ck172 FIND v(dout1_51) AT=865.025n

* CHECK dout1_52 Vdout1_52ck172 = 0 time = 865
.meas tran vdout1_52ck172 FIND v(dout1_52) AT=865.025n

* CHECK dout1_53 Vdout1_53ck172 = 0.9 time = 865
.meas tran vdout1_53ck172 FIND v(dout1_53) AT=865.025n

* CHECK dout1_54 Vdout1_54ck172 = 0.9 time = 865
.meas tran vdout1_54ck172 FIND v(dout1_54) AT=865.025n

* CHECK dout1_55 Vdout1_55ck172 = 0.9 time = 865
.meas tran vdout1_55ck172 FIND v(dout1_55) AT=865.025n

* CHECK dout1_56 Vdout1_56ck172 = 0.9 time = 865
.meas tran vdout1_56ck172 FIND v(dout1_56) AT=865.025n

* CHECK dout1_57 Vdout1_57ck172 = 0.9 time = 865
.meas tran vdout1_57ck172 FIND v(dout1_57) AT=865.025n

* CHECK dout1_58 Vdout1_58ck172 = 0 time = 865
.meas tran vdout1_58ck172 FIND v(dout1_58) AT=865.025n

* CHECK dout1_59 Vdout1_59ck172 = 0.9 time = 865
.meas tran vdout1_59ck172 FIND v(dout1_59) AT=865.025n

* CHECK dout1_60 Vdout1_60ck172 = 0 time = 865
.meas tran vdout1_60ck172 FIND v(dout1_60) AT=865.025n

* CHECK dout1_61 Vdout1_61ck172 = 0.9 time = 865
.meas tran vdout1_61ck172 FIND v(dout1_61) AT=865.025n

* CHECK dout1_62 Vdout1_62ck172 = 0 time = 865
.meas tran vdout1_62ck172 FIND v(dout1_62) AT=865.025n

* CHECK dout1_63 Vdout1_63ck172 = 0.9 time = 865
.meas tran vdout1_63ck172 FIND v(dout1_63) AT=865.025n

* CHECK dout1_64 Vdout1_64ck172 = 0 time = 865
.meas tran vdout1_64ck172 FIND v(dout1_64) AT=865.025n

* CHECK dout1_65 Vdout1_65ck172 = 0 time = 865
.meas tran vdout1_65ck172 FIND v(dout1_65) AT=865.025n

* CHECK dout1_66 Vdout1_66ck172 = 0.9 time = 865
.meas tran vdout1_66ck172 FIND v(dout1_66) AT=865.025n

* CHECK dout1_67 Vdout1_67ck172 = 0.9 time = 865
.meas tran vdout1_67ck172 FIND v(dout1_67) AT=865.025n

* CHECK dout1_68 Vdout1_68ck172 = 0 time = 865
.meas tran vdout1_68ck172 FIND v(dout1_68) AT=865.025n

* CHECK dout1_69 Vdout1_69ck172 = 0.9 time = 865
.meas tran vdout1_69ck172 FIND v(dout1_69) AT=865.025n

* CHECK dout1_70 Vdout1_70ck172 = 0.9 time = 865
.meas tran vdout1_70ck172 FIND v(dout1_70) AT=865.025n

* CHECK dout1_71 Vdout1_71ck172 = 0 time = 865
.meas tran vdout1_71ck172 FIND v(dout1_71) AT=865.025n

* CHECK dout1_72 Vdout1_72ck172 = 0 time = 865
.meas tran vdout1_72ck172 FIND v(dout1_72) AT=865.025n

* CHECK dout1_73 Vdout1_73ck172 = 0 time = 865
.meas tran vdout1_73ck172 FIND v(dout1_73) AT=865.025n

* CHECK dout1_74 Vdout1_74ck172 = 0.9 time = 865
.meas tran vdout1_74ck172 FIND v(dout1_74) AT=865.025n

* CHECK dout1_75 Vdout1_75ck172 = 0.9 time = 865
.meas tran vdout1_75ck172 FIND v(dout1_75) AT=865.025n

* CHECK dout1_76 Vdout1_76ck172 = 0 time = 865
.meas tran vdout1_76ck172 FIND v(dout1_76) AT=865.025n

* CHECK dout1_77 Vdout1_77ck172 = 0.9 time = 865
.meas tran vdout1_77ck172 FIND v(dout1_77) AT=865.025n

* CHECK dout1_78 Vdout1_78ck172 = 0 time = 865
.meas tran vdout1_78ck172 FIND v(dout1_78) AT=865.025n

* CHECK dout1_79 Vdout1_79ck172 = 0.9 time = 865
.meas tran vdout1_79ck172 FIND v(dout1_79) AT=865.025n

* CHECK dout1_80 Vdout1_80ck172 = 0 time = 865
.meas tran vdout1_80ck172 FIND v(dout1_80) AT=865.025n

* CHECK dout1_81 Vdout1_81ck172 = 0.9 time = 865
.meas tran vdout1_81ck172 FIND v(dout1_81) AT=865.025n

* CHECK dout1_82 Vdout1_82ck172 = 0 time = 865
.meas tran vdout1_82ck172 FIND v(dout1_82) AT=865.025n

* CHECK dout1_83 Vdout1_83ck172 = 0.9 time = 865
.meas tran vdout1_83ck172 FIND v(dout1_83) AT=865.025n

* CHECK dout1_84 Vdout1_84ck172 = 0 time = 865
.meas tran vdout1_84ck172 FIND v(dout1_84) AT=865.025n

* CHECK dout1_85 Vdout1_85ck172 = 0.9 time = 865
.meas tran vdout1_85ck172 FIND v(dout1_85) AT=865.025n

* CHECK dout1_86 Vdout1_86ck172 = 0.9 time = 865
.meas tran vdout1_86ck172 FIND v(dout1_86) AT=865.025n

* CHECK dout1_87 Vdout1_87ck172 = 0.9 time = 865
.meas tran vdout1_87ck172 FIND v(dout1_87) AT=865.025n

* CHECK dout1_88 Vdout1_88ck172 = 0.9 time = 865
.meas tran vdout1_88ck172 FIND v(dout1_88) AT=865.025n

* CHECK dout1_89 Vdout1_89ck172 = 0.9 time = 865
.meas tran vdout1_89ck172 FIND v(dout1_89) AT=865.025n

* CHECK dout1_90 Vdout1_90ck172 = 0 time = 865
.meas tran vdout1_90ck172 FIND v(dout1_90) AT=865.025n

* CHECK dout1_91 Vdout1_91ck172 = 0.9 time = 865
.meas tran vdout1_91ck172 FIND v(dout1_91) AT=865.025n

* CHECK dout1_92 Vdout1_92ck172 = 0 time = 865
.meas tran vdout1_92ck172 FIND v(dout1_92) AT=865.025n

* CHECK dout1_93 Vdout1_93ck172 = 0 time = 865
.meas tran vdout1_93ck172 FIND v(dout1_93) AT=865.025n

* CHECK dout1_94 Vdout1_94ck172 = 0 time = 865
.meas tran vdout1_94ck172 FIND v(dout1_94) AT=865.025n

* CHECK dout1_95 Vdout1_95ck172 = 0 time = 865
.meas tran vdout1_95ck172 FIND v(dout1_95) AT=865.025n

* CHECK dout1_96 Vdout1_96ck172 = 0.9 time = 865
.meas tran vdout1_96ck172 FIND v(dout1_96) AT=865.025n

* CHECK dout1_97 Vdout1_97ck172 = 0.9 time = 865
.meas tran vdout1_97ck172 FIND v(dout1_97) AT=865.025n

* CHECK dout1_98 Vdout1_98ck172 = 0.9 time = 865
.meas tran vdout1_98ck172 FIND v(dout1_98) AT=865.025n

* CHECK dout1_99 Vdout1_99ck172 = 0.9 time = 865
.meas tran vdout1_99ck172 FIND v(dout1_99) AT=865.025n

* CHECK dout1_100 Vdout1_100ck172 = 0 time = 865
.meas tran vdout1_100ck172 FIND v(dout1_100) AT=865.025n

* CHECK dout1_101 Vdout1_101ck172 = 0.9 time = 865
.meas tran vdout1_101ck172 FIND v(dout1_101) AT=865.025n

* CHECK dout1_102 Vdout1_102ck172 = 0 time = 865
.meas tran vdout1_102ck172 FIND v(dout1_102) AT=865.025n

* CHECK dout1_103 Vdout1_103ck172 = 0.9 time = 865
.meas tran vdout1_103ck172 FIND v(dout1_103) AT=865.025n

* CHECK dout1_104 Vdout1_104ck172 = 0 time = 865
.meas tran vdout1_104ck172 FIND v(dout1_104) AT=865.025n

* CHECK dout1_105 Vdout1_105ck172 = 0 time = 865
.meas tran vdout1_105ck172 FIND v(dout1_105) AT=865.025n

* CHECK dout1_106 Vdout1_106ck172 = 0.9 time = 865
.meas tran vdout1_106ck172 FIND v(dout1_106) AT=865.025n

* CHECK dout1_107 Vdout1_107ck172 = 0 time = 865
.meas tran vdout1_107ck172 FIND v(dout1_107) AT=865.025n

* CHECK dout1_108 Vdout1_108ck172 = 0.9 time = 865
.meas tran vdout1_108ck172 FIND v(dout1_108) AT=865.025n

* CHECK dout1_109 Vdout1_109ck172 = 0.9 time = 865
.meas tran vdout1_109ck172 FIND v(dout1_109) AT=865.025n

* CHECK dout1_110 Vdout1_110ck172 = 0.9 time = 865
.meas tran vdout1_110ck172 FIND v(dout1_110) AT=865.025n

* CHECK dout1_111 Vdout1_111ck172 = 0.9 time = 865
.meas tran vdout1_111ck172 FIND v(dout1_111) AT=865.025n

* CHECK dout1_112 Vdout1_112ck172 = 0 time = 865
.meas tran vdout1_112ck172 FIND v(dout1_112) AT=865.025n

* CHECK dout1_113 Vdout1_113ck172 = 0.9 time = 865
.meas tran vdout1_113ck172 FIND v(dout1_113) AT=865.025n

* CHECK dout1_114 Vdout1_114ck172 = 0.9 time = 865
.meas tran vdout1_114ck172 FIND v(dout1_114) AT=865.025n

* CHECK dout1_115 Vdout1_115ck172 = 0 time = 865
.meas tran vdout1_115ck172 FIND v(dout1_115) AT=865.025n

* CHECK dout1_116 Vdout1_116ck172 = 0 time = 865
.meas tran vdout1_116ck172 FIND v(dout1_116) AT=865.025n

* CHECK dout1_117 Vdout1_117ck172 = 0 time = 865
.meas tran vdout1_117ck172 FIND v(dout1_117) AT=865.025n

* CHECK dout1_118 Vdout1_118ck172 = 0 time = 865
.meas tran vdout1_118ck172 FIND v(dout1_118) AT=865.025n

* CHECK dout1_119 Vdout1_119ck172 = 0.9 time = 865
.meas tran vdout1_119ck172 FIND v(dout1_119) AT=865.025n

* CHECK dout1_0 Vdout1_0ck173 = 0 time = 870
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=870.025n

* CHECK dout1_1 Vdout1_1ck173 = 0 time = 870
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=870.025n

* CHECK dout1_2 Vdout1_2ck173 = 0 time = 870
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=870.025n

* CHECK dout1_3 Vdout1_3ck173 = 0 time = 870
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=870.025n

* CHECK dout1_4 Vdout1_4ck173 = 0 time = 870
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=870.025n

* CHECK dout1_5 Vdout1_5ck173 = 0 time = 870
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=870.025n

* CHECK dout1_6 Vdout1_6ck173 = 0.9 time = 870
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=870.025n

* CHECK dout1_7 Vdout1_7ck173 = 0 time = 870
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=870.025n

* CHECK dout1_8 Vdout1_8ck173 = 0 time = 870
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=870.025n

* CHECK dout1_9 Vdout1_9ck173 = 0.9 time = 870
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=870.025n

* CHECK dout1_10 Vdout1_10ck173 = 0 time = 870
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=870.025n

* CHECK dout1_11 Vdout1_11ck173 = 0 time = 870
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=870.025n

* CHECK dout1_12 Vdout1_12ck173 = 0.9 time = 870
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=870.025n

* CHECK dout1_13 Vdout1_13ck173 = 0 time = 870
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=870.025n

* CHECK dout1_14 Vdout1_14ck173 = 0 time = 870
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=870.025n

* CHECK dout1_15 Vdout1_15ck173 = 0.9 time = 870
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=870.025n

* CHECK dout1_16 Vdout1_16ck173 = 0.9 time = 870
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=870.025n

* CHECK dout1_17 Vdout1_17ck173 = 0.9 time = 870
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=870.025n

* CHECK dout1_18 Vdout1_18ck173 = 0 time = 870
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=870.025n

* CHECK dout1_19 Vdout1_19ck173 = 0 time = 870
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=870.025n

* CHECK dout1_20 Vdout1_20ck173 = 0 time = 870
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=870.025n

* CHECK dout1_21 Vdout1_21ck173 = 0.9 time = 870
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=870.025n

* CHECK dout1_22 Vdout1_22ck173 = 0.9 time = 870
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=870.025n

* CHECK dout1_23 Vdout1_23ck173 = 0 time = 870
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=870.025n

* CHECK dout1_24 Vdout1_24ck173 = 0.9 time = 870
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=870.025n

* CHECK dout1_25 Vdout1_25ck173 = 0.9 time = 870
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=870.025n

* CHECK dout1_26 Vdout1_26ck173 = 0 time = 870
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=870.025n

* CHECK dout1_27 Vdout1_27ck173 = 0 time = 870
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=870.025n

* CHECK dout1_28 Vdout1_28ck173 = 0.9 time = 870
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=870.025n

* CHECK dout1_29 Vdout1_29ck173 = 0 time = 870
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=870.025n

* CHECK dout1_30 Vdout1_30ck173 = 0.9 time = 870
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=870.025n

* CHECK dout1_31 Vdout1_31ck173 = 0 time = 870
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=870.025n

* CHECK dout1_32 Vdout1_32ck173 = 0.9 time = 870
.meas tran vdout1_32ck173 FIND v(dout1_32) AT=870.025n

* CHECK dout1_33 Vdout1_33ck173 = 0.9 time = 870
.meas tran vdout1_33ck173 FIND v(dout1_33) AT=870.025n

* CHECK dout1_34 Vdout1_34ck173 = 0 time = 870
.meas tran vdout1_34ck173 FIND v(dout1_34) AT=870.025n

* CHECK dout1_35 Vdout1_35ck173 = 0.9 time = 870
.meas tran vdout1_35ck173 FIND v(dout1_35) AT=870.025n

* CHECK dout1_36 Vdout1_36ck173 = 0.9 time = 870
.meas tran vdout1_36ck173 FIND v(dout1_36) AT=870.025n

* CHECK dout1_37 Vdout1_37ck173 = 0 time = 870
.meas tran vdout1_37ck173 FIND v(dout1_37) AT=870.025n

* CHECK dout1_38 Vdout1_38ck173 = 0.9 time = 870
.meas tran vdout1_38ck173 FIND v(dout1_38) AT=870.025n

* CHECK dout1_39 Vdout1_39ck173 = 0.9 time = 870
.meas tran vdout1_39ck173 FIND v(dout1_39) AT=870.025n

* CHECK dout1_40 Vdout1_40ck173 = 0.9 time = 870
.meas tran vdout1_40ck173 FIND v(dout1_40) AT=870.025n

* CHECK dout1_41 Vdout1_41ck173 = 0 time = 870
.meas tran vdout1_41ck173 FIND v(dout1_41) AT=870.025n

* CHECK dout1_42 Vdout1_42ck173 = 0.9 time = 870
.meas tran vdout1_42ck173 FIND v(dout1_42) AT=870.025n

* CHECK dout1_43 Vdout1_43ck173 = 0 time = 870
.meas tran vdout1_43ck173 FIND v(dout1_43) AT=870.025n

* CHECK dout1_44 Vdout1_44ck173 = 0 time = 870
.meas tran vdout1_44ck173 FIND v(dout1_44) AT=870.025n

* CHECK dout1_45 Vdout1_45ck173 = 0 time = 870
.meas tran vdout1_45ck173 FIND v(dout1_45) AT=870.025n

* CHECK dout1_46 Vdout1_46ck173 = 0 time = 870
.meas tran vdout1_46ck173 FIND v(dout1_46) AT=870.025n

* CHECK dout1_47 Vdout1_47ck173 = 0.9 time = 870
.meas tran vdout1_47ck173 FIND v(dout1_47) AT=870.025n

* CHECK dout1_48 Vdout1_48ck173 = 0 time = 870
.meas tran vdout1_48ck173 FIND v(dout1_48) AT=870.025n

* CHECK dout1_49 Vdout1_49ck173 = 0 time = 870
.meas tran vdout1_49ck173 FIND v(dout1_49) AT=870.025n

* CHECK dout1_50 Vdout1_50ck173 = 0 time = 870
.meas tran vdout1_50ck173 FIND v(dout1_50) AT=870.025n

* CHECK dout1_51 Vdout1_51ck173 = 0.9 time = 870
.meas tran vdout1_51ck173 FIND v(dout1_51) AT=870.025n

* CHECK dout1_52 Vdout1_52ck173 = 0 time = 870
.meas tran vdout1_52ck173 FIND v(dout1_52) AT=870.025n

* CHECK dout1_53 Vdout1_53ck173 = 0.9 time = 870
.meas tran vdout1_53ck173 FIND v(dout1_53) AT=870.025n

* CHECK dout1_54 Vdout1_54ck173 = 0.9 time = 870
.meas tran vdout1_54ck173 FIND v(dout1_54) AT=870.025n

* CHECK dout1_55 Vdout1_55ck173 = 0.9 time = 870
.meas tran vdout1_55ck173 FIND v(dout1_55) AT=870.025n

* CHECK dout1_56 Vdout1_56ck173 = 0.9 time = 870
.meas tran vdout1_56ck173 FIND v(dout1_56) AT=870.025n

* CHECK dout1_57 Vdout1_57ck173 = 0.9 time = 870
.meas tran vdout1_57ck173 FIND v(dout1_57) AT=870.025n

* CHECK dout1_58 Vdout1_58ck173 = 0 time = 870
.meas tran vdout1_58ck173 FIND v(dout1_58) AT=870.025n

* CHECK dout1_59 Vdout1_59ck173 = 0.9 time = 870
.meas tran vdout1_59ck173 FIND v(dout1_59) AT=870.025n

* CHECK dout1_60 Vdout1_60ck173 = 0 time = 870
.meas tran vdout1_60ck173 FIND v(dout1_60) AT=870.025n

* CHECK dout1_61 Vdout1_61ck173 = 0.9 time = 870
.meas tran vdout1_61ck173 FIND v(dout1_61) AT=870.025n

* CHECK dout1_62 Vdout1_62ck173 = 0 time = 870
.meas tran vdout1_62ck173 FIND v(dout1_62) AT=870.025n

* CHECK dout1_63 Vdout1_63ck173 = 0.9 time = 870
.meas tran vdout1_63ck173 FIND v(dout1_63) AT=870.025n

* CHECK dout1_64 Vdout1_64ck173 = 0 time = 870
.meas tran vdout1_64ck173 FIND v(dout1_64) AT=870.025n

* CHECK dout1_65 Vdout1_65ck173 = 0 time = 870
.meas tran vdout1_65ck173 FIND v(dout1_65) AT=870.025n

* CHECK dout1_66 Vdout1_66ck173 = 0.9 time = 870
.meas tran vdout1_66ck173 FIND v(dout1_66) AT=870.025n

* CHECK dout1_67 Vdout1_67ck173 = 0.9 time = 870
.meas tran vdout1_67ck173 FIND v(dout1_67) AT=870.025n

* CHECK dout1_68 Vdout1_68ck173 = 0 time = 870
.meas tran vdout1_68ck173 FIND v(dout1_68) AT=870.025n

* CHECK dout1_69 Vdout1_69ck173 = 0.9 time = 870
.meas tran vdout1_69ck173 FIND v(dout1_69) AT=870.025n

* CHECK dout1_70 Vdout1_70ck173 = 0.9 time = 870
.meas tran vdout1_70ck173 FIND v(dout1_70) AT=870.025n

* CHECK dout1_71 Vdout1_71ck173 = 0 time = 870
.meas tran vdout1_71ck173 FIND v(dout1_71) AT=870.025n

* CHECK dout1_72 Vdout1_72ck173 = 0 time = 870
.meas tran vdout1_72ck173 FIND v(dout1_72) AT=870.025n

* CHECK dout1_73 Vdout1_73ck173 = 0 time = 870
.meas tran vdout1_73ck173 FIND v(dout1_73) AT=870.025n

* CHECK dout1_74 Vdout1_74ck173 = 0.9 time = 870
.meas tran vdout1_74ck173 FIND v(dout1_74) AT=870.025n

* CHECK dout1_75 Vdout1_75ck173 = 0.9 time = 870
.meas tran vdout1_75ck173 FIND v(dout1_75) AT=870.025n

* CHECK dout1_76 Vdout1_76ck173 = 0 time = 870
.meas tran vdout1_76ck173 FIND v(dout1_76) AT=870.025n

* CHECK dout1_77 Vdout1_77ck173 = 0.9 time = 870
.meas tran vdout1_77ck173 FIND v(dout1_77) AT=870.025n

* CHECK dout1_78 Vdout1_78ck173 = 0 time = 870
.meas tran vdout1_78ck173 FIND v(dout1_78) AT=870.025n

* CHECK dout1_79 Vdout1_79ck173 = 0.9 time = 870
.meas tran vdout1_79ck173 FIND v(dout1_79) AT=870.025n

* CHECK dout1_80 Vdout1_80ck173 = 0 time = 870
.meas tran vdout1_80ck173 FIND v(dout1_80) AT=870.025n

* CHECK dout1_81 Vdout1_81ck173 = 0.9 time = 870
.meas tran vdout1_81ck173 FIND v(dout1_81) AT=870.025n

* CHECK dout1_82 Vdout1_82ck173 = 0 time = 870
.meas tran vdout1_82ck173 FIND v(dout1_82) AT=870.025n

* CHECK dout1_83 Vdout1_83ck173 = 0.9 time = 870
.meas tran vdout1_83ck173 FIND v(dout1_83) AT=870.025n

* CHECK dout1_84 Vdout1_84ck173 = 0 time = 870
.meas tran vdout1_84ck173 FIND v(dout1_84) AT=870.025n

* CHECK dout1_85 Vdout1_85ck173 = 0.9 time = 870
.meas tran vdout1_85ck173 FIND v(dout1_85) AT=870.025n

* CHECK dout1_86 Vdout1_86ck173 = 0.9 time = 870
.meas tran vdout1_86ck173 FIND v(dout1_86) AT=870.025n

* CHECK dout1_87 Vdout1_87ck173 = 0.9 time = 870
.meas tran vdout1_87ck173 FIND v(dout1_87) AT=870.025n

* CHECK dout1_88 Vdout1_88ck173 = 0.9 time = 870
.meas tran vdout1_88ck173 FIND v(dout1_88) AT=870.025n

* CHECK dout1_89 Vdout1_89ck173 = 0.9 time = 870
.meas tran vdout1_89ck173 FIND v(dout1_89) AT=870.025n

* CHECK dout1_90 Vdout1_90ck173 = 0 time = 870
.meas tran vdout1_90ck173 FIND v(dout1_90) AT=870.025n

* CHECK dout1_91 Vdout1_91ck173 = 0.9 time = 870
.meas tran vdout1_91ck173 FIND v(dout1_91) AT=870.025n

* CHECK dout1_92 Vdout1_92ck173 = 0 time = 870
.meas tran vdout1_92ck173 FIND v(dout1_92) AT=870.025n

* CHECK dout1_93 Vdout1_93ck173 = 0 time = 870
.meas tran vdout1_93ck173 FIND v(dout1_93) AT=870.025n

* CHECK dout1_94 Vdout1_94ck173 = 0 time = 870
.meas tran vdout1_94ck173 FIND v(dout1_94) AT=870.025n

* CHECK dout1_95 Vdout1_95ck173 = 0 time = 870
.meas tran vdout1_95ck173 FIND v(dout1_95) AT=870.025n

* CHECK dout1_96 Vdout1_96ck173 = 0.9 time = 870
.meas tran vdout1_96ck173 FIND v(dout1_96) AT=870.025n

* CHECK dout1_97 Vdout1_97ck173 = 0.9 time = 870
.meas tran vdout1_97ck173 FIND v(dout1_97) AT=870.025n

* CHECK dout1_98 Vdout1_98ck173 = 0.9 time = 870
.meas tran vdout1_98ck173 FIND v(dout1_98) AT=870.025n

* CHECK dout1_99 Vdout1_99ck173 = 0.9 time = 870
.meas tran vdout1_99ck173 FIND v(dout1_99) AT=870.025n

* CHECK dout1_100 Vdout1_100ck173 = 0 time = 870
.meas tran vdout1_100ck173 FIND v(dout1_100) AT=870.025n

* CHECK dout1_101 Vdout1_101ck173 = 0.9 time = 870
.meas tran vdout1_101ck173 FIND v(dout1_101) AT=870.025n

* CHECK dout1_102 Vdout1_102ck173 = 0 time = 870
.meas tran vdout1_102ck173 FIND v(dout1_102) AT=870.025n

* CHECK dout1_103 Vdout1_103ck173 = 0.9 time = 870
.meas tran vdout1_103ck173 FIND v(dout1_103) AT=870.025n

* CHECK dout1_104 Vdout1_104ck173 = 0 time = 870
.meas tran vdout1_104ck173 FIND v(dout1_104) AT=870.025n

* CHECK dout1_105 Vdout1_105ck173 = 0 time = 870
.meas tran vdout1_105ck173 FIND v(dout1_105) AT=870.025n

* CHECK dout1_106 Vdout1_106ck173 = 0.9 time = 870
.meas tran vdout1_106ck173 FIND v(dout1_106) AT=870.025n

* CHECK dout1_107 Vdout1_107ck173 = 0 time = 870
.meas tran vdout1_107ck173 FIND v(dout1_107) AT=870.025n

* CHECK dout1_108 Vdout1_108ck173 = 0.9 time = 870
.meas tran vdout1_108ck173 FIND v(dout1_108) AT=870.025n

* CHECK dout1_109 Vdout1_109ck173 = 0.9 time = 870
.meas tran vdout1_109ck173 FIND v(dout1_109) AT=870.025n

* CHECK dout1_110 Vdout1_110ck173 = 0.9 time = 870
.meas tran vdout1_110ck173 FIND v(dout1_110) AT=870.025n

* CHECK dout1_111 Vdout1_111ck173 = 0.9 time = 870
.meas tran vdout1_111ck173 FIND v(dout1_111) AT=870.025n

* CHECK dout1_112 Vdout1_112ck173 = 0 time = 870
.meas tran vdout1_112ck173 FIND v(dout1_112) AT=870.025n

* CHECK dout1_113 Vdout1_113ck173 = 0.9 time = 870
.meas tran vdout1_113ck173 FIND v(dout1_113) AT=870.025n

* CHECK dout1_114 Vdout1_114ck173 = 0.9 time = 870
.meas tran vdout1_114ck173 FIND v(dout1_114) AT=870.025n

* CHECK dout1_115 Vdout1_115ck173 = 0 time = 870
.meas tran vdout1_115ck173 FIND v(dout1_115) AT=870.025n

* CHECK dout1_116 Vdout1_116ck173 = 0 time = 870
.meas tran vdout1_116ck173 FIND v(dout1_116) AT=870.025n

* CHECK dout1_117 Vdout1_117ck173 = 0 time = 870
.meas tran vdout1_117ck173 FIND v(dout1_117) AT=870.025n

* CHECK dout1_118 Vdout1_118ck173 = 0 time = 870
.meas tran vdout1_118ck173 FIND v(dout1_118) AT=870.025n

* CHECK dout1_119 Vdout1_119ck173 = 0.9 time = 870
.meas tran vdout1_119ck173 FIND v(dout1_119) AT=870.025n

* CHECK dout1_0 Vdout1_0ck176 = 0 time = 885
.meas tran vdout1_0ck176 FIND v(dout1_0) AT=885.025n

* CHECK dout1_1 Vdout1_1ck176 = 0 time = 885
.meas tran vdout1_1ck176 FIND v(dout1_1) AT=885.025n

* CHECK dout1_2 Vdout1_2ck176 = 0 time = 885
.meas tran vdout1_2ck176 FIND v(dout1_2) AT=885.025n

* CHECK dout1_3 Vdout1_3ck176 = 0 time = 885
.meas tran vdout1_3ck176 FIND v(dout1_3) AT=885.025n

* CHECK dout1_4 Vdout1_4ck176 = 0 time = 885
.meas tran vdout1_4ck176 FIND v(dout1_4) AT=885.025n

* CHECK dout1_5 Vdout1_5ck176 = 0 time = 885
.meas tran vdout1_5ck176 FIND v(dout1_5) AT=885.025n

* CHECK dout1_6 Vdout1_6ck176 = 0.9 time = 885
.meas tran vdout1_6ck176 FIND v(dout1_6) AT=885.025n

* CHECK dout1_7 Vdout1_7ck176 = 0 time = 885
.meas tran vdout1_7ck176 FIND v(dout1_7) AT=885.025n

* CHECK dout1_8 Vdout1_8ck176 = 0 time = 885
.meas tran vdout1_8ck176 FIND v(dout1_8) AT=885.025n

* CHECK dout1_9 Vdout1_9ck176 = 0.9 time = 885
.meas tran vdout1_9ck176 FIND v(dout1_9) AT=885.025n

* CHECK dout1_10 Vdout1_10ck176 = 0 time = 885
.meas tran vdout1_10ck176 FIND v(dout1_10) AT=885.025n

* CHECK dout1_11 Vdout1_11ck176 = 0 time = 885
.meas tran vdout1_11ck176 FIND v(dout1_11) AT=885.025n

* CHECK dout1_12 Vdout1_12ck176 = 0.9 time = 885
.meas tran vdout1_12ck176 FIND v(dout1_12) AT=885.025n

* CHECK dout1_13 Vdout1_13ck176 = 0 time = 885
.meas tran vdout1_13ck176 FIND v(dout1_13) AT=885.025n

* CHECK dout1_14 Vdout1_14ck176 = 0 time = 885
.meas tran vdout1_14ck176 FIND v(dout1_14) AT=885.025n

* CHECK dout1_15 Vdout1_15ck176 = 0.9 time = 885
.meas tran vdout1_15ck176 FIND v(dout1_15) AT=885.025n

* CHECK dout1_16 Vdout1_16ck176 = 0.9 time = 885
.meas tran vdout1_16ck176 FIND v(dout1_16) AT=885.025n

* CHECK dout1_17 Vdout1_17ck176 = 0.9 time = 885
.meas tran vdout1_17ck176 FIND v(dout1_17) AT=885.025n

* CHECK dout1_18 Vdout1_18ck176 = 0 time = 885
.meas tran vdout1_18ck176 FIND v(dout1_18) AT=885.025n

* CHECK dout1_19 Vdout1_19ck176 = 0 time = 885
.meas tran vdout1_19ck176 FIND v(dout1_19) AT=885.025n

* CHECK dout1_20 Vdout1_20ck176 = 0 time = 885
.meas tran vdout1_20ck176 FIND v(dout1_20) AT=885.025n

* CHECK dout1_21 Vdout1_21ck176 = 0.9 time = 885
.meas tran vdout1_21ck176 FIND v(dout1_21) AT=885.025n

* CHECK dout1_22 Vdout1_22ck176 = 0.9 time = 885
.meas tran vdout1_22ck176 FIND v(dout1_22) AT=885.025n

* CHECK dout1_23 Vdout1_23ck176 = 0 time = 885
.meas tran vdout1_23ck176 FIND v(dout1_23) AT=885.025n

* CHECK dout1_24 Vdout1_24ck176 = 0.9 time = 885
.meas tran vdout1_24ck176 FIND v(dout1_24) AT=885.025n

* CHECK dout1_25 Vdout1_25ck176 = 0.9 time = 885
.meas tran vdout1_25ck176 FIND v(dout1_25) AT=885.025n

* CHECK dout1_26 Vdout1_26ck176 = 0 time = 885
.meas tran vdout1_26ck176 FIND v(dout1_26) AT=885.025n

* CHECK dout1_27 Vdout1_27ck176 = 0 time = 885
.meas tran vdout1_27ck176 FIND v(dout1_27) AT=885.025n

* CHECK dout1_28 Vdout1_28ck176 = 0.9 time = 885
.meas tran vdout1_28ck176 FIND v(dout1_28) AT=885.025n

* CHECK dout1_29 Vdout1_29ck176 = 0 time = 885
.meas tran vdout1_29ck176 FIND v(dout1_29) AT=885.025n

* CHECK dout1_30 Vdout1_30ck176 = 0.9 time = 885
.meas tran vdout1_30ck176 FIND v(dout1_30) AT=885.025n

* CHECK dout1_31 Vdout1_31ck176 = 0 time = 885
.meas tran vdout1_31ck176 FIND v(dout1_31) AT=885.025n

* CHECK dout1_32 Vdout1_32ck176 = 0.9 time = 885
.meas tran vdout1_32ck176 FIND v(dout1_32) AT=885.025n

* CHECK dout1_33 Vdout1_33ck176 = 0.9 time = 885
.meas tran vdout1_33ck176 FIND v(dout1_33) AT=885.025n

* CHECK dout1_34 Vdout1_34ck176 = 0 time = 885
.meas tran vdout1_34ck176 FIND v(dout1_34) AT=885.025n

* CHECK dout1_35 Vdout1_35ck176 = 0.9 time = 885
.meas tran vdout1_35ck176 FIND v(dout1_35) AT=885.025n

* CHECK dout1_36 Vdout1_36ck176 = 0.9 time = 885
.meas tran vdout1_36ck176 FIND v(dout1_36) AT=885.025n

* CHECK dout1_37 Vdout1_37ck176 = 0 time = 885
.meas tran vdout1_37ck176 FIND v(dout1_37) AT=885.025n

* CHECK dout1_38 Vdout1_38ck176 = 0.9 time = 885
.meas tran vdout1_38ck176 FIND v(dout1_38) AT=885.025n

* CHECK dout1_39 Vdout1_39ck176 = 0.9 time = 885
.meas tran vdout1_39ck176 FIND v(dout1_39) AT=885.025n

* CHECK dout1_40 Vdout1_40ck176 = 0.9 time = 885
.meas tran vdout1_40ck176 FIND v(dout1_40) AT=885.025n

* CHECK dout1_41 Vdout1_41ck176 = 0 time = 885
.meas tran vdout1_41ck176 FIND v(dout1_41) AT=885.025n

* CHECK dout1_42 Vdout1_42ck176 = 0.9 time = 885
.meas tran vdout1_42ck176 FIND v(dout1_42) AT=885.025n

* CHECK dout1_43 Vdout1_43ck176 = 0 time = 885
.meas tran vdout1_43ck176 FIND v(dout1_43) AT=885.025n

* CHECK dout1_44 Vdout1_44ck176 = 0 time = 885
.meas tran vdout1_44ck176 FIND v(dout1_44) AT=885.025n

* CHECK dout1_45 Vdout1_45ck176 = 0 time = 885
.meas tran vdout1_45ck176 FIND v(dout1_45) AT=885.025n

* CHECK dout1_46 Vdout1_46ck176 = 0 time = 885
.meas tran vdout1_46ck176 FIND v(dout1_46) AT=885.025n

* CHECK dout1_47 Vdout1_47ck176 = 0.9 time = 885
.meas tran vdout1_47ck176 FIND v(dout1_47) AT=885.025n

* CHECK dout1_48 Vdout1_48ck176 = 0 time = 885
.meas tran vdout1_48ck176 FIND v(dout1_48) AT=885.025n

* CHECK dout1_49 Vdout1_49ck176 = 0 time = 885
.meas tran vdout1_49ck176 FIND v(dout1_49) AT=885.025n

* CHECK dout1_50 Vdout1_50ck176 = 0 time = 885
.meas tran vdout1_50ck176 FIND v(dout1_50) AT=885.025n

* CHECK dout1_51 Vdout1_51ck176 = 0.9 time = 885
.meas tran vdout1_51ck176 FIND v(dout1_51) AT=885.025n

* CHECK dout1_52 Vdout1_52ck176 = 0 time = 885
.meas tran vdout1_52ck176 FIND v(dout1_52) AT=885.025n

* CHECK dout1_53 Vdout1_53ck176 = 0.9 time = 885
.meas tran vdout1_53ck176 FIND v(dout1_53) AT=885.025n

* CHECK dout1_54 Vdout1_54ck176 = 0.9 time = 885
.meas tran vdout1_54ck176 FIND v(dout1_54) AT=885.025n

* CHECK dout1_55 Vdout1_55ck176 = 0.9 time = 885
.meas tran vdout1_55ck176 FIND v(dout1_55) AT=885.025n

* CHECK dout1_56 Vdout1_56ck176 = 0.9 time = 885
.meas tran vdout1_56ck176 FIND v(dout1_56) AT=885.025n

* CHECK dout1_57 Vdout1_57ck176 = 0.9 time = 885
.meas tran vdout1_57ck176 FIND v(dout1_57) AT=885.025n

* CHECK dout1_58 Vdout1_58ck176 = 0 time = 885
.meas tran vdout1_58ck176 FIND v(dout1_58) AT=885.025n

* CHECK dout1_59 Vdout1_59ck176 = 0.9 time = 885
.meas tran vdout1_59ck176 FIND v(dout1_59) AT=885.025n

* CHECK dout1_60 Vdout1_60ck176 = 0 time = 885
.meas tran vdout1_60ck176 FIND v(dout1_60) AT=885.025n

* CHECK dout1_61 Vdout1_61ck176 = 0.9 time = 885
.meas tran vdout1_61ck176 FIND v(dout1_61) AT=885.025n

* CHECK dout1_62 Vdout1_62ck176 = 0 time = 885
.meas tran vdout1_62ck176 FIND v(dout1_62) AT=885.025n

* CHECK dout1_63 Vdout1_63ck176 = 0.9 time = 885
.meas tran vdout1_63ck176 FIND v(dout1_63) AT=885.025n

* CHECK dout1_64 Vdout1_64ck176 = 0 time = 885
.meas tran vdout1_64ck176 FIND v(dout1_64) AT=885.025n

* CHECK dout1_65 Vdout1_65ck176 = 0 time = 885
.meas tran vdout1_65ck176 FIND v(dout1_65) AT=885.025n

* CHECK dout1_66 Vdout1_66ck176 = 0.9 time = 885
.meas tran vdout1_66ck176 FIND v(dout1_66) AT=885.025n

* CHECK dout1_67 Vdout1_67ck176 = 0.9 time = 885
.meas tran vdout1_67ck176 FIND v(dout1_67) AT=885.025n

* CHECK dout1_68 Vdout1_68ck176 = 0 time = 885
.meas tran vdout1_68ck176 FIND v(dout1_68) AT=885.025n

* CHECK dout1_69 Vdout1_69ck176 = 0.9 time = 885
.meas tran vdout1_69ck176 FIND v(dout1_69) AT=885.025n

* CHECK dout1_70 Vdout1_70ck176 = 0.9 time = 885
.meas tran vdout1_70ck176 FIND v(dout1_70) AT=885.025n

* CHECK dout1_71 Vdout1_71ck176 = 0 time = 885
.meas tran vdout1_71ck176 FIND v(dout1_71) AT=885.025n

* CHECK dout1_72 Vdout1_72ck176 = 0 time = 885
.meas tran vdout1_72ck176 FIND v(dout1_72) AT=885.025n

* CHECK dout1_73 Vdout1_73ck176 = 0 time = 885
.meas tran vdout1_73ck176 FIND v(dout1_73) AT=885.025n

* CHECK dout1_74 Vdout1_74ck176 = 0.9 time = 885
.meas tran vdout1_74ck176 FIND v(dout1_74) AT=885.025n

* CHECK dout1_75 Vdout1_75ck176 = 0.9 time = 885
.meas tran vdout1_75ck176 FIND v(dout1_75) AT=885.025n

* CHECK dout1_76 Vdout1_76ck176 = 0 time = 885
.meas tran vdout1_76ck176 FIND v(dout1_76) AT=885.025n

* CHECK dout1_77 Vdout1_77ck176 = 0.9 time = 885
.meas tran vdout1_77ck176 FIND v(dout1_77) AT=885.025n

* CHECK dout1_78 Vdout1_78ck176 = 0 time = 885
.meas tran vdout1_78ck176 FIND v(dout1_78) AT=885.025n

* CHECK dout1_79 Vdout1_79ck176 = 0.9 time = 885
.meas tran vdout1_79ck176 FIND v(dout1_79) AT=885.025n

* CHECK dout1_80 Vdout1_80ck176 = 0 time = 885
.meas tran vdout1_80ck176 FIND v(dout1_80) AT=885.025n

* CHECK dout1_81 Vdout1_81ck176 = 0.9 time = 885
.meas tran vdout1_81ck176 FIND v(dout1_81) AT=885.025n

* CHECK dout1_82 Vdout1_82ck176 = 0 time = 885
.meas tran vdout1_82ck176 FIND v(dout1_82) AT=885.025n

* CHECK dout1_83 Vdout1_83ck176 = 0.9 time = 885
.meas tran vdout1_83ck176 FIND v(dout1_83) AT=885.025n

* CHECK dout1_84 Vdout1_84ck176 = 0 time = 885
.meas tran vdout1_84ck176 FIND v(dout1_84) AT=885.025n

* CHECK dout1_85 Vdout1_85ck176 = 0.9 time = 885
.meas tran vdout1_85ck176 FIND v(dout1_85) AT=885.025n

* CHECK dout1_86 Vdout1_86ck176 = 0.9 time = 885
.meas tran vdout1_86ck176 FIND v(dout1_86) AT=885.025n

* CHECK dout1_87 Vdout1_87ck176 = 0.9 time = 885
.meas tran vdout1_87ck176 FIND v(dout1_87) AT=885.025n

* CHECK dout1_88 Vdout1_88ck176 = 0.9 time = 885
.meas tran vdout1_88ck176 FIND v(dout1_88) AT=885.025n

* CHECK dout1_89 Vdout1_89ck176 = 0.9 time = 885
.meas tran vdout1_89ck176 FIND v(dout1_89) AT=885.025n

* CHECK dout1_90 Vdout1_90ck176 = 0 time = 885
.meas tran vdout1_90ck176 FIND v(dout1_90) AT=885.025n

* CHECK dout1_91 Vdout1_91ck176 = 0.9 time = 885
.meas tran vdout1_91ck176 FIND v(dout1_91) AT=885.025n

* CHECK dout1_92 Vdout1_92ck176 = 0 time = 885
.meas tran vdout1_92ck176 FIND v(dout1_92) AT=885.025n

* CHECK dout1_93 Vdout1_93ck176 = 0 time = 885
.meas tran vdout1_93ck176 FIND v(dout1_93) AT=885.025n

* CHECK dout1_94 Vdout1_94ck176 = 0 time = 885
.meas tran vdout1_94ck176 FIND v(dout1_94) AT=885.025n

* CHECK dout1_95 Vdout1_95ck176 = 0 time = 885
.meas tran vdout1_95ck176 FIND v(dout1_95) AT=885.025n

* CHECK dout1_96 Vdout1_96ck176 = 0.9 time = 885
.meas tran vdout1_96ck176 FIND v(dout1_96) AT=885.025n

* CHECK dout1_97 Vdout1_97ck176 = 0.9 time = 885
.meas tran vdout1_97ck176 FIND v(dout1_97) AT=885.025n

* CHECK dout1_98 Vdout1_98ck176 = 0.9 time = 885
.meas tran vdout1_98ck176 FIND v(dout1_98) AT=885.025n

* CHECK dout1_99 Vdout1_99ck176 = 0.9 time = 885
.meas tran vdout1_99ck176 FIND v(dout1_99) AT=885.025n

* CHECK dout1_100 Vdout1_100ck176 = 0 time = 885
.meas tran vdout1_100ck176 FIND v(dout1_100) AT=885.025n

* CHECK dout1_101 Vdout1_101ck176 = 0.9 time = 885
.meas tran vdout1_101ck176 FIND v(dout1_101) AT=885.025n

* CHECK dout1_102 Vdout1_102ck176 = 0 time = 885
.meas tran vdout1_102ck176 FIND v(dout1_102) AT=885.025n

* CHECK dout1_103 Vdout1_103ck176 = 0.9 time = 885
.meas tran vdout1_103ck176 FIND v(dout1_103) AT=885.025n

* CHECK dout1_104 Vdout1_104ck176 = 0 time = 885
.meas tran vdout1_104ck176 FIND v(dout1_104) AT=885.025n

* CHECK dout1_105 Vdout1_105ck176 = 0 time = 885
.meas tran vdout1_105ck176 FIND v(dout1_105) AT=885.025n

* CHECK dout1_106 Vdout1_106ck176 = 0.9 time = 885
.meas tran vdout1_106ck176 FIND v(dout1_106) AT=885.025n

* CHECK dout1_107 Vdout1_107ck176 = 0 time = 885
.meas tran vdout1_107ck176 FIND v(dout1_107) AT=885.025n

* CHECK dout1_108 Vdout1_108ck176 = 0.9 time = 885
.meas tran vdout1_108ck176 FIND v(dout1_108) AT=885.025n

* CHECK dout1_109 Vdout1_109ck176 = 0.9 time = 885
.meas tran vdout1_109ck176 FIND v(dout1_109) AT=885.025n

* CHECK dout1_110 Vdout1_110ck176 = 0.9 time = 885
.meas tran vdout1_110ck176 FIND v(dout1_110) AT=885.025n

* CHECK dout1_111 Vdout1_111ck176 = 0.9 time = 885
.meas tran vdout1_111ck176 FIND v(dout1_111) AT=885.025n

* CHECK dout1_112 Vdout1_112ck176 = 0 time = 885
.meas tran vdout1_112ck176 FIND v(dout1_112) AT=885.025n

* CHECK dout1_113 Vdout1_113ck176 = 0.9 time = 885
.meas tran vdout1_113ck176 FIND v(dout1_113) AT=885.025n

* CHECK dout1_114 Vdout1_114ck176 = 0.9 time = 885
.meas tran vdout1_114ck176 FIND v(dout1_114) AT=885.025n

* CHECK dout1_115 Vdout1_115ck176 = 0 time = 885
.meas tran vdout1_115ck176 FIND v(dout1_115) AT=885.025n

* CHECK dout1_116 Vdout1_116ck176 = 0 time = 885
.meas tran vdout1_116ck176 FIND v(dout1_116) AT=885.025n

* CHECK dout1_117 Vdout1_117ck176 = 0 time = 885
.meas tran vdout1_117ck176 FIND v(dout1_117) AT=885.025n

* CHECK dout1_118 Vdout1_118ck176 = 0 time = 885
.meas tran vdout1_118ck176 FIND v(dout1_118) AT=885.025n

* CHECK dout1_119 Vdout1_119ck176 = 0.9 time = 885
.meas tran vdout1_119ck176 FIND v(dout1_119) AT=885.025n

* CHECK dout1_0 Vdout1_0ck177 = 0 time = 890
.meas tran vdout1_0ck177 FIND v(dout1_0) AT=890.025n

* CHECK dout1_1 Vdout1_1ck177 = 0 time = 890
.meas tran vdout1_1ck177 FIND v(dout1_1) AT=890.025n

* CHECK dout1_2 Vdout1_2ck177 = 0.9 time = 890
.meas tran vdout1_2ck177 FIND v(dout1_2) AT=890.025n

* CHECK dout1_3 Vdout1_3ck177 = 0.9 time = 890
.meas tran vdout1_3ck177 FIND v(dout1_3) AT=890.025n

* CHECK dout1_4 Vdout1_4ck177 = 0 time = 890
.meas tran vdout1_4ck177 FIND v(dout1_4) AT=890.025n

* CHECK dout1_5 Vdout1_5ck177 = 0 time = 890
.meas tran vdout1_5ck177 FIND v(dout1_5) AT=890.025n

* CHECK dout1_6 Vdout1_6ck177 = 0.9 time = 890
.meas tran vdout1_6ck177 FIND v(dout1_6) AT=890.025n

* CHECK dout1_7 Vdout1_7ck177 = 0 time = 890
.meas tran vdout1_7ck177 FIND v(dout1_7) AT=890.025n

* CHECK dout1_8 Vdout1_8ck177 = 0.9 time = 890
.meas tran vdout1_8ck177 FIND v(dout1_8) AT=890.025n

* CHECK dout1_9 Vdout1_9ck177 = 0 time = 890
.meas tran vdout1_9ck177 FIND v(dout1_9) AT=890.025n

* CHECK dout1_10 Vdout1_10ck177 = 0 time = 890
.meas tran vdout1_10ck177 FIND v(dout1_10) AT=890.025n

* CHECK dout1_11 Vdout1_11ck177 = 0.9 time = 890
.meas tran vdout1_11ck177 FIND v(dout1_11) AT=890.025n

* CHECK dout1_12 Vdout1_12ck177 = 0.9 time = 890
.meas tran vdout1_12ck177 FIND v(dout1_12) AT=890.025n

* CHECK dout1_13 Vdout1_13ck177 = 0 time = 890
.meas tran vdout1_13ck177 FIND v(dout1_13) AT=890.025n

* CHECK dout1_14 Vdout1_14ck177 = 0 time = 890
.meas tran vdout1_14ck177 FIND v(dout1_14) AT=890.025n

* CHECK dout1_15 Vdout1_15ck177 = 0 time = 890
.meas tran vdout1_15ck177 FIND v(dout1_15) AT=890.025n

* CHECK dout1_16 Vdout1_16ck177 = 0 time = 890
.meas tran vdout1_16ck177 FIND v(dout1_16) AT=890.025n

* CHECK dout1_17 Vdout1_17ck177 = 0.9 time = 890
.meas tran vdout1_17ck177 FIND v(dout1_17) AT=890.025n

* CHECK dout1_18 Vdout1_18ck177 = 0.9 time = 890
.meas tran vdout1_18ck177 FIND v(dout1_18) AT=890.025n

* CHECK dout1_19 Vdout1_19ck177 = 0.9 time = 890
.meas tran vdout1_19ck177 FIND v(dout1_19) AT=890.025n

* CHECK dout1_20 Vdout1_20ck177 = 0.9 time = 890
.meas tran vdout1_20ck177 FIND v(dout1_20) AT=890.025n

* CHECK dout1_21 Vdout1_21ck177 = 0.9 time = 890
.meas tran vdout1_21ck177 FIND v(dout1_21) AT=890.025n

* CHECK dout1_22 Vdout1_22ck177 = 0.9 time = 890
.meas tran vdout1_22ck177 FIND v(dout1_22) AT=890.025n

* CHECK dout1_23 Vdout1_23ck177 = 0.9 time = 890
.meas tran vdout1_23ck177 FIND v(dout1_23) AT=890.025n

* CHECK dout1_24 Vdout1_24ck177 = 0 time = 890
.meas tran vdout1_24ck177 FIND v(dout1_24) AT=890.025n

* CHECK dout1_25 Vdout1_25ck177 = 0.9 time = 890
.meas tran vdout1_25ck177 FIND v(dout1_25) AT=890.025n

* CHECK dout1_26 Vdout1_26ck177 = 0.9 time = 890
.meas tran vdout1_26ck177 FIND v(dout1_26) AT=890.025n

* CHECK dout1_27 Vdout1_27ck177 = 0 time = 890
.meas tran vdout1_27ck177 FIND v(dout1_27) AT=890.025n

* CHECK dout1_28 Vdout1_28ck177 = 0 time = 890
.meas tran vdout1_28ck177 FIND v(dout1_28) AT=890.025n

* CHECK dout1_29 Vdout1_29ck177 = 0 time = 890
.meas tran vdout1_29ck177 FIND v(dout1_29) AT=890.025n

* CHECK dout1_30 Vdout1_30ck177 = 0.9 time = 890
.meas tran vdout1_30ck177 FIND v(dout1_30) AT=890.025n

* CHECK dout1_31 Vdout1_31ck177 = 0 time = 890
.meas tran vdout1_31ck177 FIND v(dout1_31) AT=890.025n

* CHECK dout1_32 Vdout1_32ck177 = 0 time = 890
.meas tran vdout1_32ck177 FIND v(dout1_32) AT=890.025n

* CHECK dout1_33 Vdout1_33ck177 = 0 time = 890
.meas tran vdout1_33ck177 FIND v(dout1_33) AT=890.025n

* CHECK dout1_34 Vdout1_34ck177 = 0 time = 890
.meas tran vdout1_34ck177 FIND v(dout1_34) AT=890.025n

* CHECK dout1_35 Vdout1_35ck177 = 0.9 time = 890
.meas tran vdout1_35ck177 FIND v(dout1_35) AT=890.025n

* CHECK dout1_36 Vdout1_36ck177 = 0 time = 890
.meas tran vdout1_36ck177 FIND v(dout1_36) AT=890.025n

* CHECK dout1_37 Vdout1_37ck177 = 0 time = 890
.meas tran vdout1_37ck177 FIND v(dout1_37) AT=890.025n

* CHECK dout1_38 Vdout1_38ck177 = 0.9 time = 890
.meas tran vdout1_38ck177 FIND v(dout1_38) AT=890.025n

* CHECK dout1_39 Vdout1_39ck177 = 0.9 time = 890
.meas tran vdout1_39ck177 FIND v(dout1_39) AT=890.025n

* CHECK dout1_40 Vdout1_40ck177 = 0.9 time = 890
.meas tran vdout1_40ck177 FIND v(dout1_40) AT=890.025n

* CHECK dout1_41 Vdout1_41ck177 = 0 time = 890
.meas tran vdout1_41ck177 FIND v(dout1_41) AT=890.025n

* CHECK dout1_42 Vdout1_42ck177 = 0 time = 890
.meas tran vdout1_42ck177 FIND v(dout1_42) AT=890.025n

* CHECK dout1_43 Vdout1_43ck177 = 0 time = 890
.meas tran vdout1_43ck177 FIND v(dout1_43) AT=890.025n

* CHECK dout1_44 Vdout1_44ck177 = 0.9 time = 890
.meas tran vdout1_44ck177 FIND v(dout1_44) AT=890.025n

* CHECK dout1_45 Vdout1_45ck177 = 0 time = 890
.meas tran vdout1_45ck177 FIND v(dout1_45) AT=890.025n

* CHECK dout1_46 Vdout1_46ck177 = 0 time = 890
.meas tran vdout1_46ck177 FIND v(dout1_46) AT=890.025n

* CHECK dout1_47 Vdout1_47ck177 = 0.9 time = 890
.meas tran vdout1_47ck177 FIND v(dout1_47) AT=890.025n

* CHECK dout1_48 Vdout1_48ck177 = 0.9 time = 890
.meas tran vdout1_48ck177 FIND v(dout1_48) AT=890.025n

* CHECK dout1_49 Vdout1_49ck177 = 0.9 time = 890
.meas tran vdout1_49ck177 FIND v(dout1_49) AT=890.025n

* CHECK dout1_50 Vdout1_50ck177 = 0.9 time = 890
.meas tran vdout1_50ck177 FIND v(dout1_50) AT=890.025n

* CHECK dout1_51 Vdout1_51ck177 = 0.9 time = 890
.meas tran vdout1_51ck177 FIND v(dout1_51) AT=890.025n

* CHECK dout1_52 Vdout1_52ck177 = 0.9 time = 890
.meas tran vdout1_52ck177 FIND v(dout1_52) AT=890.025n

* CHECK dout1_53 Vdout1_53ck177 = 0.9 time = 890
.meas tran vdout1_53ck177 FIND v(dout1_53) AT=890.025n

* CHECK dout1_54 Vdout1_54ck177 = 0 time = 890
.meas tran vdout1_54ck177 FIND v(dout1_54) AT=890.025n

* CHECK dout1_55 Vdout1_55ck177 = 0 time = 890
.meas tran vdout1_55ck177 FIND v(dout1_55) AT=890.025n

* CHECK dout1_56 Vdout1_56ck177 = 0.9 time = 890
.meas tran vdout1_56ck177 FIND v(dout1_56) AT=890.025n

* CHECK dout1_57 Vdout1_57ck177 = 0 time = 890
.meas tran vdout1_57ck177 FIND v(dout1_57) AT=890.025n

* CHECK dout1_58 Vdout1_58ck177 = 0 time = 890
.meas tran vdout1_58ck177 FIND v(dout1_58) AT=890.025n

* CHECK dout1_59 Vdout1_59ck177 = 0 time = 890
.meas tran vdout1_59ck177 FIND v(dout1_59) AT=890.025n

* CHECK dout1_60 Vdout1_60ck177 = 0 time = 890
.meas tran vdout1_60ck177 FIND v(dout1_60) AT=890.025n

* CHECK dout1_61 Vdout1_61ck177 = 0.9 time = 890
.meas tran vdout1_61ck177 FIND v(dout1_61) AT=890.025n

* CHECK dout1_62 Vdout1_62ck177 = 0 time = 890
.meas tran vdout1_62ck177 FIND v(dout1_62) AT=890.025n

* CHECK dout1_63 Vdout1_63ck177 = 0 time = 890
.meas tran vdout1_63ck177 FIND v(dout1_63) AT=890.025n

* CHECK dout1_64 Vdout1_64ck177 = 0.9 time = 890
.meas tran vdout1_64ck177 FIND v(dout1_64) AT=890.025n

* CHECK dout1_65 Vdout1_65ck177 = 0.9 time = 890
.meas tran vdout1_65ck177 FIND v(dout1_65) AT=890.025n

* CHECK dout1_66 Vdout1_66ck177 = 0.9 time = 890
.meas tran vdout1_66ck177 FIND v(dout1_66) AT=890.025n

* CHECK dout1_67 Vdout1_67ck177 = 0 time = 890
.meas tran vdout1_67ck177 FIND v(dout1_67) AT=890.025n

* CHECK dout1_68 Vdout1_68ck177 = 0 time = 890
.meas tran vdout1_68ck177 FIND v(dout1_68) AT=890.025n

* CHECK dout1_69 Vdout1_69ck177 = 0.9 time = 890
.meas tran vdout1_69ck177 FIND v(dout1_69) AT=890.025n

* CHECK dout1_70 Vdout1_70ck177 = 0.9 time = 890
.meas tran vdout1_70ck177 FIND v(dout1_70) AT=890.025n

* CHECK dout1_71 Vdout1_71ck177 = 0.9 time = 890
.meas tran vdout1_71ck177 FIND v(dout1_71) AT=890.025n

* CHECK dout1_72 Vdout1_72ck177 = 0 time = 890
.meas tran vdout1_72ck177 FIND v(dout1_72) AT=890.025n

* CHECK dout1_73 Vdout1_73ck177 = 0.9 time = 890
.meas tran vdout1_73ck177 FIND v(dout1_73) AT=890.025n

* CHECK dout1_74 Vdout1_74ck177 = 0.9 time = 890
.meas tran vdout1_74ck177 FIND v(dout1_74) AT=890.025n

* CHECK dout1_75 Vdout1_75ck177 = 0.9 time = 890
.meas tran vdout1_75ck177 FIND v(dout1_75) AT=890.025n

* CHECK dout1_76 Vdout1_76ck177 = 0.9 time = 890
.meas tran vdout1_76ck177 FIND v(dout1_76) AT=890.025n

* CHECK dout1_77 Vdout1_77ck177 = 0 time = 890
.meas tran vdout1_77ck177 FIND v(dout1_77) AT=890.025n

* CHECK dout1_78 Vdout1_78ck177 = 0 time = 890
.meas tran vdout1_78ck177 FIND v(dout1_78) AT=890.025n

* CHECK dout1_79 Vdout1_79ck177 = 0 time = 890
.meas tran vdout1_79ck177 FIND v(dout1_79) AT=890.025n

* CHECK dout1_80 Vdout1_80ck177 = 0 time = 890
.meas tran vdout1_80ck177 FIND v(dout1_80) AT=890.025n

* CHECK dout1_81 Vdout1_81ck177 = 0 time = 890
.meas tran vdout1_81ck177 FIND v(dout1_81) AT=890.025n

* CHECK dout1_82 Vdout1_82ck177 = 0.9 time = 890
.meas tran vdout1_82ck177 FIND v(dout1_82) AT=890.025n

* CHECK dout1_83 Vdout1_83ck177 = 0.9 time = 890
.meas tran vdout1_83ck177 FIND v(dout1_83) AT=890.025n

* CHECK dout1_84 Vdout1_84ck177 = 0.9 time = 890
.meas tran vdout1_84ck177 FIND v(dout1_84) AT=890.025n

* CHECK dout1_85 Vdout1_85ck177 = 0.9 time = 890
.meas tran vdout1_85ck177 FIND v(dout1_85) AT=890.025n

* CHECK dout1_86 Vdout1_86ck177 = 0.9 time = 890
.meas tran vdout1_86ck177 FIND v(dout1_86) AT=890.025n

* CHECK dout1_87 Vdout1_87ck177 = 0.9 time = 890
.meas tran vdout1_87ck177 FIND v(dout1_87) AT=890.025n

* CHECK dout1_88 Vdout1_88ck177 = 0 time = 890
.meas tran vdout1_88ck177 FIND v(dout1_88) AT=890.025n

* CHECK dout1_89 Vdout1_89ck177 = 0.9 time = 890
.meas tran vdout1_89ck177 FIND v(dout1_89) AT=890.025n

* CHECK dout1_90 Vdout1_90ck177 = 0 time = 890
.meas tran vdout1_90ck177 FIND v(dout1_90) AT=890.025n

* CHECK dout1_91 Vdout1_91ck177 = 0.9 time = 890
.meas tran vdout1_91ck177 FIND v(dout1_91) AT=890.025n

* CHECK dout1_92 Vdout1_92ck177 = 0 time = 890
.meas tran vdout1_92ck177 FIND v(dout1_92) AT=890.025n

* CHECK dout1_93 Vdout1_93ck177 = 0.9 time = 890
.meas tran vdout1_93ck177 FIND v(dout1_93) AT=890.025n

* CHECK dout1_94 Vdout1_94ck177 = 0 time = 890
.meas tran vdout1_94ck177 FIND v(dout1_94) AT=890.025n

* CHECK dout1_95 Vdout1_95ck177 = 0 time = 890
.meas tran vdout1_95ck177 FIND v(dout1_95) AT=890.025n

* CHECK dout1_96 Vdout1_96ck177 = 0.9 time = 890
.meas tran vdout1_96ck177 FIND v(dout1_96) AT=890.025n

* CHECK dout1_97 Vdout1_97ck177 = 0.9 time = 890
.meas tran vdout1_97ck177 FIND v(dout1_97) AT=890.025n

* CHECK dout1_98 Vdout1_98ck177 = 0.9 time = 890
.meas tran vdout1_98ck177 FIND v(dout1_98) AT=890.025n

* CHECK dout1_99 Vdout1_99ck177 = 0 time = 890
.meas tran vdout1_99ck177 FIND v(dout1_99) AT=890.025n

* CHECK dout1_100 Vdout1_100ck177 = 0 time = 890
.meas tran vdout1_100ck177 FIND v(dout1_100) AT=890.025n

* CHECK dout1_101 Vdout1_101ck177 = 0.9 time = 890
.meas tran vdout1_101ck177 FIND v(dout1_101) AT=890.025n

* CHECK dout1_102 Vdout1_102ck177 = 0.9 time = 890
.meas tran vdout1_102ck177 FIND v(dout1_102) AT=890.025n

* CHECK dout1_103 Vdout1_103ck177 = 0 time = 890
.meas tran vdout1_103ck177 FIND v(dout1_103) AT=890.025n

* CHECK dout1_104 Vdout1_104ck177 = 0 time = 890
.meas tran vdout1_104ck177 FIND v(dout1_104) AT=890.025n

* CHECK dout1_105 Vdout1_105ck177 = 0.9 time = 890
.meas tran vdout1_105ck177 FIND v(dout1_105) AT=890.025n

* CHECK dout1_106 Vdout1_106ck177 = 0 time = 890
.meas tran vdout1_106ck177 FIND v(dout1_106) AT=890.025n

* CHECK dout1_107 Vdout1_107ck177 = 0.9 time = 890
.meas tran vdout1_107ck177 FIND v(dout1_107) AT=890.025n

* CHECK dout1_108 Vdout1_108ck177 = 0 time = 890
.meas tran vdout1_108ck177 FIND v(dout1_108) AT=890.025n

* CHECK dout1_109 Vdout1_109ck177 = 0.9 time = 890
.meas tran vdout1_109ck177 FIND v(dout1_109) AT=890.025n

* CHECK dout1_110 Vdout1_110ck177 = 0 time = 890
.meas tran vdout1_110ck177 FIND v(dout1_110) AT=890.025n

* CHECK dout1_111 Vdout1_111ck177 = 0.9 time = 890
.meas tran vdout1_111ck177 FIND v(dout1_111) AT=890.025n

* CHECK dout1_112 Vdout1_112ck177 = 0.9 time = 890
.meas tran vdout1_112ck177 FIND v(dout1_112) AT=890.025n

* CHECK dout1_113 Vdout1_113ck177 = 0.9 time = 890
.meas tran vdout1_113ck177 FIND v(dout1_113) AT=890.025n

* CHECK dout1_114 Vdout1_114ck177 = 0.9 time = 890
.meas tran vdout1_114ck177 FIND v(dout1_114) AT=890.025n

* CHECK dout1_115 Vdout1_115ck177 = 0 time = 890
.meas tran vdout1_115ck177 FIND v(dout1_115) AT=890.025n

* CHECK dout1_116 Vdout1_116ck177 = 0.9 time = 890
.meas tran vdout1_116ck177 FIND v(dout1_116) AT=890.025n

* CHECK dout1_117 Vdout1_117ck177 = 0 time = 890
.meas tran vdout1_117ck177 FIND v(dout1_117) AT=890.025n

* CHECK dout1_118 Vdout1_118ck177 = 0 time = 890
.meas tran vdout1_118ck177 FIND v(dout1_118) AT=890.025n

* CHECK dout1_119 Vdout1_119ck177 = 0.9 time = 890
.meas tran vdout1_119ck177 FIND v(dout1_119) AT=890.025n

* CHECK dout1_0 Vdout1_0ck180 = 0.9 time = 905
.meas tran vdout1_0ck180 FIND v(dout1_0) AT=905.025n

* CHECK dout1_1 Vdout1_1ck180 = 0 time = 905
.meas tran vdout1_1ck180 FIND v(dout1_1) AT=905.025n

* CHECK dout1_2 Vdout1_2ck180 = 0.9 time = 905
.meas tran vdout1_2ck180 FIND v(dout1_2) AT=905.025n

* CHECK dout1_3 Vdout1_3ck180 = 0.9 time = 905
.meas tran vdout1_3ck180 FIND v(dout1_3) AT=905.025n

* CHECK dout1_4 Vdout1_4ck180 = 0 time = 905
.meas tran vdout1_4ck180 FIND v(dout1_4) AT=905.025n

* CHECK dout1_5 Vdout1_5ck180 = 0.9 time = 905
.meas tran vdout1_5ck180 FIND v(dout1_5) AT=905.025n

* CHECK dout1_6 Vdout1_6ck180 = 0.9 time = 905
.meas tran vdout1_6ck180 FIND v(dout1_6) AT=905.025n

* CHECK dout1_7 Vdout1_7ck180 = 0 time = 905
.meas tran vdout1_7ck180 FIND v(dout1_7) AT=905.025n

* CHECK dout1_8 Vdout1_8ck180 = 0.9 time = 905
.meas tran vdout1_8ck180 FIND v(dout1_8) AT=905.025n

* CHECK dout1_9 Vdout1_9ck180 = 0 time = 905
.meas tran vdout1_9ck180 FIND v(dout1_9) AT=905.025n

* CHECK dout1_10 Vdout1_10ck180 = 0 time = 905
.meas tran vdout1_10ck180 FIND v(dout1_10) AT=905.025n

* CHECK dout1_11 Vdout1_11ck180 = 0.9 time = 905
.meas tran vdout1_11ck180 FIND v(dout1_11) AT=905.025n

* CHECK dout1_12 Vdout1_12ck180 = 0 time = 905
.meas tran vdout1_12ck180 FIND v(dout1_12) AT=905.025n

* CHECK dout1_13 Vdout1_13ck180 = 0.9 time = 905
.meas tran vdout1_13ck180 FIND v(dout1_13) AT=905.025n

* CHECK dout1_14 Vdout1_14ck180 = 0 time = 905
.meas tran vdout1_14ck180 FIND v(dout1_14) AT=905.025n

* CHECK dout1_15 Vdout1_15ck180 = 0 time = 905
.meas tran vdout1_15ck180 FIND v(dout1_15) AT=905.025n

* CHECK dout1_16 Vdout1_16ck180 = 0 time = 905
.meas tran vdout1_16ck180 FIND v(dout1_16) AT=905.025n

* CHECK dout1_17 Vdout1_17ck180 = 0.9 time = 905
.meas tran vdout1_17ck180 FIND v(dout1_17) AT=905.025n

* CHECK dout1_18 Vdout1_18ck180 = 0 time = 905
.meas tran vdout1_18ck180 FIND v(dout1_18) AT=905.025n

* CHECK dout1_19 Vdout1_19ck180 = 0 time = 905
.meas tran vdout1_19ck180 FIND v(dout1_19) AT=905.025n

* CHECK dout1_20 Vdout1_20ck180 = 0.9 time = 905
.meas tran vdout1_20ck180 FIND v(dout1_20) AT=905.025n

* CHECK dout1_21 Vdout1_21ck180 = 0 time = 905
.meas tran vdout1_21ck180 FIND v(dout1_21) AT=905.025n

* CHECK dout1_22 Vdout1_22ck180 = 0.9 time = 905
.meas tran vdout1_22ck180 FIND v(dout1_22) AT=905.025n

* CHECK dout1_23 Vdout1_23ck180 = 0.9 time = 905
.meas tran vdout1_23ck180 FIND v(dout1_23) AT=905.025n

* CHECK dout1_24 Vdout1_24ck180 = 0.9 time = 905
.meas tran vdout1_24ck180 FIND v(dout1_24) AT=905.025n

* CHECK dout1_25 Vdout1_25ck180 = 0 time = 905
.meas tran vdout1_25ck180 FIND v(dout1_25) AT=905.025n

* CHECK dout1_26 Vdout1_26ck180 = 0.9 time = 905
.meas tran vdout1_26ck180 FIND v(dout1_26) AT=905.025n

* CHECK dout1_27 Vdout1_27ck180 = 0 time = 905
.meas tran vdout1_27ck180 FIND v(dout1_27) AT=905.025n

* CHECK dout1_28 Vdout1_28ck180 = 0.9 time = 905
.meas tran vdout1_28ck180 FIND v(dout1_28) AT=905.025n

* CHECK dout1_29 Vdout1_29ck180 = 0 time = 905
.meas tran vdout1_29ck180 FIND v(dout1_29) AT=905.025n

* CHECK dout1_30 Vdout1_30ck180 = 0 time = 905
.meas tran vdout1_30ck180 FIND v(dout1_30) AT=905.025n

* CHECK dout1_31 Vdout1_31ck180 = 0 time = 905
.meas tran vdout1_31ck180 FIND v(dout1_31) AT=905.025n

* CHECK dout1_32 Vdout1_32ck180 = 0 time = 905
.meas tran vdout1_32ck180 FIND v(dout1_32) AT=905.025n

* CHECK dout1_33 Vdout1_33ck180 = 0.9 time = 905
.meas tran vdout1_33ck180 FIND v(dout1_33) AT=905.025n

* CHECK dout1_34 Vdout1_34ck180 = 0.9 time = 905
.meas tran vdout1_34ck180 FIND v(dout1_34) AT=905.025n

* CHECK dout1_35 Vdout1_35ck180 = 0 time = 905
.meas tran vdout1_35ck180 FIND v(dout1_35) AT=905.025n

* CHECK dout1_36 Vdout1_36ck180 = 0 time = 905
.meas tran vdout1_36ck180 FIND v(dout1_36) AT=905.025n

* CHECK dout1_37 Vdout1_37ck180 = 0 time = 905
.meas tran vdout1_37ck180 FIND v(dout1_37) AT=905.025n

* CHECK dout1_38 Vdout1_38ck180 = 0.9 time = 905
.meas tran vdout1_38ck180 FIND v(dout1_38) AT=905.025n

* CHECK dout1_39 Vdout1_39ck180 = 0.9 time = 905
.meas tran vdout1_39ck180 FIND v(dout1_39) AT=905.025n

* CHECK dout1_40 Vdout1_40ck180 = 0 time = 905
.meas tran vdout1_40ck180 FIND v(dout1_40) AT=905.025n

* CHECK dout1_41 Vdout1_41ck180 = 0 time = 905
.meas tran vdout1_41ck180 FIND v(dout1_41) AT=905.025n

* CHECK dout1_42 Vdout1_42ck180 = 0.9 time = 905
.meas tran vdout1_42ck180 FIND v(dout1_42) AT=905.025n

* CHECK dout1_43 Vdout1_43ck180 = 0.9 time = 905
.meas tran vdout1_43ck180 FIND v(dout1_43) AT=905.025n

* CHECK dout1_44 Vdout1_44ck180 = 0.9 time = 905
.meas tran vdout1_44ck180 FIND v(dout1_44) AT=905.025n

* CHECK dout1_45 Vdout1_45ck180 = 0.9 time = 905
.meas tran vdout1_45ck180 FIND v(dout1_45) AT=905.025n

* CHECK dout1_46 Vdout1_46ck180 = 0 time = 905
.meas tran vdout1_46ck180 FIND v(dout1_46) AT=905.025n

* CHECK dout1_47 Vdout1_47ck180 = 0 time = 905
.meas tran vdout1_47ck180 FIND v(dout1_47) AT=905.025n

* CHECK dout1_48 Vdout1_48ck180 = 0.9 time = 905
.meas tran vdout1_48ck180 FIND v(dout1_48) AT=905.025n

* CHECK dout1_49 Vdout1_49ck180 = 0 time = 905
.meas tran vdout1_49ck180 FIND v(dout1_49) AT=905.025n

* CHECK dout1_50 Vdout1_50ck180 = 0 time = 905
.meas tran vdout1_50ck180 FIND v(dout1_50) AT=905.025n

* CHECK dout1_51 Vdout1_51ck180 = 0 time = 905
.meas tran vdout1_51ck180 FIND v(dout1_51) AT=905.025n

* CHECK dout1_52 Vdout1_52ck180 = 0 time = 905
.meas tran vdout1_52ck180 FIND v(dout1_52) AT=905.025n

* CHECK dout1_53 Vdout1_53ck180 = 0.9 time = 905
.meas tran vdout1_53ck180 FIND v(dout1_53) AT=905.025n

* CHECK dout1_54 Vdout1_54ck180 = 0.9 time = 905
.meas tran vdout1_54ck180 FIND v(dout1_54) AT=905.025n

* CHECK dout1_55 Vdout1_55ck180 = 0 time = 905
.meas tran vdout1_55ck180 FIND v(dout1_55) AT=905.025n

* CHECK dout1_56 Vdout1_56ck180 = 0.9 time = 905
.meas tran vdout1_56ck180 FIND v(dout1_56) AT=905.025n

* CHECK dout1_57 Vdout1_57ck180 = 0 time = 905
.meas tran vdout1_57ck180 FIND v(dout1_57) AT=905.025n

* CHECK dout1_58 Vdout1_58ck180 = 0 time = 905
.meas tran vdout1_58ck180 FIND v(dout1_58) AT=905.025n

* CHECK dout1_59 Vdout1_59ck180 = 0.9 time = 905
.meas tran vdout1_59ck180 FIND v(dout1_59) AT=905.025n

* CHECK dout1_60 Vdout1_60ck180 = 0 time = 905
.meas tran vdout1_60ck180 FIND v(dout1_60) AT=905.025n

* CHECK dout1_61 Vdout1_61ck180 = 0 time = 905
.meas tran vdout1_61ck180 FIND v(dout1_61) AT=905.025n

* CHECK dout1_62 Vdout1_62ck180 = 0 time = 905
.meas tran vdout1_62ck180 FIND v(dout1_62) AT=905.025n

* CHECK dout1_63 Vdout1_63ck180 = 0.9 time = 905
.meas tran vdout1_63ck180 FIND v(dout1_63) AT=905.025n

* CHECK dout1_64 Vdout1_64ck180 = 0 time = 905
.meas tran vdout1_64ck180 FIND v(dout1_64) AT=905.025n

* CHECK dout1_65 Vdout1_65ck180 = 0.9 time = 905
.meas tran vdout1_65ck180 FIND v(dout1_65) AT=905.025n

* CHECK dout1_66 Vdout1_66ck180 = 0 time = 905
.meas tran vdout1_66ck180 FIND v(dout1_66) AT=905.025n

* CHECK dout1_67 Vdout1_67ck180 = 0 time = 905
.meas tran vdout1_67ck180 FIND v(dout1_67) AT=905.025n

* CHECK dout1_68 Vdout1_68ck180 = 0.9 time = 905
.meas tran vdout1_68ck180 FIND v(dout1_68) AT=905.025n

* CHECK dout1_69 Vdout1_69ck180 = 0.9 time = 905
.meas tran vdout1_69ck180 FIND v(dout1_69) AT=905.025n

* CHECK dout1_70 Vdout1_70ck180 = 0.9 time = 905
.meas tran vdout1_70ck180 FIND v(dout1_70) AT=905.025n

* CHECK dout1_71 Vdout1_71ck180 = 0.9 time = 905
.meas tran vdout1_71ck180 FIND v(dout1_71) AT=905.025n

* CHECK dout1_72 Vdout1_72ck180 = 0.9 time = 905
.meas tran vdout1_72ck180 FIND v(dout1_72) AT=905.025n

* CHECK dout1_73 Vdout1_73ck180 = 0.9 time = 905
.meas tran vdout1_73ck180 FIND v(dout1_73) AT=905.025n

* CHECK dout1_74 Vdout1_74ck180 = 0 time = 905
.meas tran vdout1_74ck180 FIND v(dout1_74) AT=905.025n

* CHECK dout1_75 Vdout1_75ck180 = 0.9 time = 905
.meas tran vdout1_75ck180 FIND v(dout1_75) AT=905.025n

* CHECK dout1_76 Vdout1_76ck180 = 0.9 time = 905
.meas tran vdout1_76ck180 FIND v(dout1_76) AT=905.025n

* CHECK dout1_77 Vdout1_77ck180 = 0 time = 905
.meas tran vdout1_77ck180 FIND v(dout1_77) AT=905.025n

* CHECK dout1_78 Vdout1_78ck180 = 0.9 time = 905
.meas tran vdout1_78ck180 FIND v(dout1_78) AT=905.025n

* CHECK dout1_79 Vdout1_79ck180 = 0 time = 905
.meas tran vdout1_79ck180 FIND v(dout1_79) AT=905.025n

* CHECK dout1_80 Vdout1_80ck180 = 0.9 time = 905
.meas tran vdout1_80ck180 FIND v(dout1_80) AT=905.025n

* CHECK dout1_81 Vdout1_81ck180 = 0.9 time = 905
.meas tran vdout1_81ck180 FIND v(dout1_81) AT=905.025n

* CHECK dout1_82 Vdout1_82ck180 = 0.9 time = 905
.meas tran vdout1_82ck180 FIND v(dout1_82) AT=905.025n

* CHECK dout1_83 Vdout1_83ck180 = 0.9 time = 905
.meas tran vdout1_83ck180 FIND v(dout1_83) AT=905.025n

* CHECK dout1_84 Vdout1_84ck180 = 0.9 time = 905
.meas tran vdout1_84ck180 FIND v(dout1_84) AT=905.025n

* CHECK dout1_85 Vdout1_85ck180 = 0.9 time = 905
.meas tran vdout1_85ck180 FIND v(dout1_85) AT=905.025n

* CHECK dout1_86 Vdout1_86ck180 = 0 time = 905
.meas tran vdout1_86ck180 FIND v(dout1_86) AT=905.025n

* CHECK dout1_87 Vdout1_87ck180 = 0.9 time = 905
.meas tran vdout1_87ck180 FIND v(dout1_87) AT=905.025n

* CHECK dout1_88 Vdout1_88ck180 = 0 time = 905
.meas tran vdout1_88ck180 FIND v(dout1_88) AT=905.025n

* CHECK dout1_89 Vdout1_89ck180 = 0 time = 905
.meas tran vdout1_89ck180 FIND v(dout1_89) AT=905.025n

* CHECK dout1_90 Vdout1_90ck180 = 0.9 time = 905
.meas tran vdout1_90ck180 FIND v(dout1_90) AT=905.025n

* CHECK dout1_91 Vdout1_91ck180 = 0 time = 905
.meas tran vdout1_91ck180 FIND v(dout1_91) AT=905.025n

* CHECK dout1_92 Vdout1_92ck180 = 0.9 time = 905
.meas tran vdout1_92ck180 FIND v(dout1_92) AT=905.025n

* CHECK dout1_93 Vdout1_93ck180 = 0.9 time = 905
.meas tran vdout1_93ck180 FIND v(dout1_93) AT=905.025n

* CHECK dout1_94 Vdout1_94ck180 = 0 time = 905
.meas tran vdout1_94ck180 FIND v(dout1_94) AT=905.025n

* CHECK dout1_95 Vdout1_95ck180 = 0 time = 905
.meas tran vdout1_95ck180 FIND v(dout1_95) AT=905.025n

* CHECK dout1_96 Vdout1_96ck180 = 0 time = 905
.meas tran vdout1_96ck180 FIND v(dout1_96) AT=905.025n

* CHECK dout1_97 Vdout1_97ck180 = 0 time = 905
.meas tran vdout1_97ck180 FIND v(dout1_97) AT=905.025n

* CHECK dout1_98 Vdout1_98ck180 = 0 time = 905
.meas tran vdout1_98ck180 FIND v(dout1_98) AT=905.025n

* CHECK dout1_99 Vdout1_99ck180 = 0 time = 905
.meas tran vdout1_99ck180 FIND v(dout1_99) AT=905.025n

* CHECK dout1_100 Vdout1_100ck180 = 0.9 time = 905
.meas tran vdout1_100ck180 FIND v(dout1_100) AT=905.025n

* CHECK dout1_101 Vdout1_101ck180 = 0 time = 905
.meas tran vdout1_101ck180 FIND v(dout1_101) AT=905.025n

* CHECK dout1_102 Vdout1_102ck180 = 0.9 time = 905
.meas tran vdout1_102ck180 FIND v(dout1_102) AT=905.025n

* CHECK dout1_103 Vdout1_103ck180 = 0.9 time = 905
.meas tran vdout1_103ck180 FIND v(dout1_103) AT=905.025n

* CHECK dout1_104 Vdout1_104ck180 = 0.9 time = 905
.meas tran vdout1_104ck180 FIND v(dout1_104) AT=905.025n

* CHECK dout1_105 Vdout1_105ck180 = 0 time = 905
.meas tran vdout1_105ck180 FIND v(dout1_105) AT=905.025n

* CHECK dout1_106 Vdout1_106ck180 = 0 time = 905
.meas tran vdout1_106ck180 FIND v(dout1_106) AT=905.025n

* CHECK dout1_107 Vdout1_107ck180 = 0 time = 905
.meas tran vdout1_107ck180 FIND v(dout1_107) AT=905.025n

* CHECK dout1_108 Vdout1_108ck180 = 0.9 time = 905
.meas tran vdout1_108ck180 FIND v(dout1_108) AT=905.025n

* CHECK dout1_109 Vdout1_109ck180 = 0 time = 905
.meas tran vdout1_109ck180 FIND v(dout1_109) AT=905.025n

* CHECK dout1_110 Vdout1_110ck180 = 0 time = 905
.meas tran vdout1_110ck180 FIND v(dout1_110) AT=905.025n

* CHECK dout1_111 Vdout1_111ck180 = 0.9 time = 905
.meas tran vdout1_111ck180 FIND v(dout1_111) AT=905.025n

* CHECK dout1_112 Vdout1_112ck180 = 0.9 time = 905
.meas tran vdout1_112ck180 FIND v(dout1_112) AT=905.025n

* CHECK dout1_113 Vdout1_113ck180 = 0.9 time = 905
.meas tran vdout1_113ck180 FIND v(dout1_113) AT=905.025n

* CHECK dout1_114 Vdout1_114ck180 = 0 time = 905
.meas tran vdout1_114ck180 FIND v(dout1_114) AT=905.025n

* CHECK dout1_115 Vdout1_115ck180 = 0.9 time = 905
.meas tran vdout1_115ck180 FIND v(dout1_115) AT=905.025n

* CHECK dout1_116 Vdout1_116ck180 = 0.9 time = 905
.meas tran vdout1_116ck180 FIND v(dout1_116) AT=905.025n

* CHECK dout1_117 Vdout1_117ck180 = 0 time = 905
.meas tran vdout1_117ck180 FIND v(dout1_117) AT=905.025n

* CHECK dout1_118 Vdout1_118ck180 = 0.9 time = 905
.meas tran vdout1_118ck180 FIND v(dout1_118) AT=905.025n

* CHECK dout1_119 Vdout1_119ck180 = 0.9 time = 905
.meas tran vdout1_119ck180 FIND v(dout1_119) AT=905.025n

* CHECK dout1_0 Vdout1_0ck183 = 0.9 time = 920
.meas tran vdout1_0ck183 FIND v(dout1_0) AT=920.025n

* CHECK dout1_1 Vdout1_1ck183 = 0 time = 920
.meas tran vdout1_1ck183 FIND v(dout1_1) AT=920.025n

* CHECK dout1_2 Vdout1_2ck183 = 0.9 time = 920
.meas tran vdout1_2ck183 FIND v(dout1_2) AT=920.025n

* CHECK dout1_3 Vdout1_3ck183 = 0 time = 920
.meas tran vdout1_3ck183 FIND v(dout1_3) AT=920.025n

* CHECK dout1_4 Vdout1_4ck183 = 0 time = 920
.meas tran vdout1_4ck183 FIND v(dout1_4) AT=920.025n

* CHECK dout1_5 Vdout1_5ck183 = 0.9 time = 920
.meas tran vdout1_5ck183 FIND v(dout1_5) AT=920.025n

* CHECK dout1_6 Vdout1_6ck183 = 0.9 time = 920
.meas tran vdout1_6ck183 FIND v(dout1_6) AT=920.025n

* CHECK dout1_7 Vdout1_7ck183 = 0 time = 920
.meas tran vdout1_7ck183 FIND v(dout1_7) AT=920.025n

* CHECK dout1_8 Vdout1_8ck183 = 0.9 time = 920
.meas tran vdout1_8ck183 FIND v(dout1_8) AT=920.025n

* CHECK dout1_9 Vdout1_9ck183 = 0.9 time = 920
.meas tran vdout1_9ck183 FIND v(dout1_9) AT=920.025n

* CHECK dout1_10 Vdout1_10ck183 = 0.9 time = 920
.meas tran vdout1_10ck183 FIND v(dout1_10) AT=920.025n

* CHECK dout1_11 Vdout1_11ck183 = 0.9 time = 920
.meas tran vdout1_11ck183 FIND v(dout1_11) AT=920.025n

* CHECK dout1_12 Vdout1_12ck183 = 0.9 time = 920
.meas tran vdout1_12ck183 FIND v(dout1_12) AT=920.025n

* CHECK dout1_13 Vdout1_13ck183 = 0 time = 920
.meas tran vdout1_13ck183 FIND v(dout1_13) AT=920.025n

* CHECK dout1_14 Vdout1_14ck183 = 0 time = 920
.meas tran vdout1_14ck183 FIND v(dout1_14) AT=920.025n

* CHECK dout1_15 Vdout1_15ck183 = 0.9 time = 920
.meas tran vdout1_15ck183 FIND v(dout1_15) AT=920.025n

* CHECK dout1_16 Vdout1_16ck183 = 0.9 time = 920
.meas tran vdout1_16ck183 FIND v(dout1_16) AT=920.025n

* CHECK dout1_17 Vdout1_17ck183 = 0 time = 920
.meas tran vdout1_17ck183 FIND v(dout1_17) AT=920.025n

* CHECK dout1_18 Vdout1_18ck183 = 0.9 time = 920
.meas tran vdout1_18ck183 FIND v(dout1_18) AT=920.025n

* CHECK dout1_19 Vdout1_19ck183 = 0 time = 920
.meas tran vdout1_19ck183 FIND v(dout1_19) AT=920.025n

* CHECK dout1_20 Vdout1_20ck183 = 0 time = 920
.meas tran vdout1_20ck183 FIND v(dout1_20) AT=920.025n

* CHECK dout1_21 Vdout1_21ck183 = 0.9 time = 920
.meas tran vdout1_21ck183 FIND v(dout1_21) AT=920.025n

* CHECK dout1_22 Vdout1_22ck183 = 0 time = 920
.meas tran vdout1_22ck183 FIND v(dout1_22) AT=920.025n

* CHECK dout1_23 Vdout1_23ck183 = 0.9 time = 920
.meas tran vdout1_23ck183 FIND v(dout1_23) AT=920.025n

* CHECK dout1_24 Vdout1_24ck183 = 0.9 time = 920
.meas tran vdout1_24ck183 FIND v(dout1_24) AT=920.025n

* CHECK dout1_25 Vdout1_25ck183 = 0 time = 920
.meas tran vdout1_25ck183 FIND v(dout1_25) AT=920.025n

* CHECK dout1_26 Vdout1_26ck183 = 0 time = 920
.meas tran vdout1_26ck183 FIND v(dout1_26) AT=920.025n

* CHECK dout1_27 Vdout1_27ck183 = 0 time = 920
.meas tran vdout1_27ck183 FIND v(dout1_27) AT=920.025n

* CHECK dout1_28 Vdout1_28ck183 = 0.9 time = 920
.meas tran vdout1_28ck183 FIND v(dout1_28) AT=920.025n

* CHECK dout1_29 Vdout1_29ck183 = 0.9 time = 920
.meas tran vdout1_29ck183 FIND v(dout1_29) AT=920.025n

* CHECK dout1_30 Vdout1_30ck183 = 0.9 time = 920
.meas tran vdout1_30ck183 FIND v(dout1_30) AT=920.025n

* CHECK dout1_31 Vdout1_31ck183 = 0 time = 920
.meas tran vdout1_31ck183 FIND v(dout1_31) AT=920.025n

* CHECK dout1_32 Vdout1_32ck183 = 0.9 time = 920
.meas tran vdout1_32ck183 FIND v(dout1_32) AT=920.025n

* CHECK dout1_33 Vdout1_33ck183 = 0 time = 920
.meas tran vdout1_33ck183 FIND v(dout1_33) AT=920.025n

* CHECK dout1_34 Vdout1_34ck183 = 0 time = 920
.meas tran vdout1_34ck183 FIND v(dout1_34) AT=920.025n

* CHECK dout1_35 Vdout1_35ck183 = 0.9 time = 920
.meas tran vdout1_35ck183 FIND v(dout1_35) AT=920.025n

* CHECK dout1_36 Vdout1_36ck183 = 0 time = 920
.meas tran vdout1_36ck183 FIND v(dout1_36) AT=920.025n

* CHECK dout1_37 Vdout1_37ck183 = 0.9 time = 920
.meas tran vdout1_37ck183 FIND v(dout1_37) AT=920.025n

* CHECK dout1_38 Vdout1_38ck183 = 0 time = 920
.meas tran vdout1_38ck183 FIND v(dout1_38) AT=920.025n

* CHECK dout1_39 Vdout1_39ck183 = 0.9 time = 920
.meas tran vdout1_39ck183 FIND v(dout1_39) AT=920.025n

* CHECK dout1_40 Vdout1_40ck183 = 0.9 time = 920
.meas tran vdout1_40ck183 FIND v(dout1_40) AT=920.025n

* CHECK dout1_41 Vdout1_41ck183 = 0 time = 920
.meas tran vdout1_41ck183 FIND v(dout1_41) AT=920.025n

* CHECK dout1_42 Vdout1_42ck183 = 0.9 time = 920
.meas tran vdout1_42ck183 FIND v(dout1_42) AT=920.025n

* CHECK dout1_43 Vdout1_43ck183 = 0.9 time = 920
.meas tran vdout1_43ck183 FIND v(dout1_43) AT=920.025n

* CHECK dout1_44 Vdout1_44ck183 = 0.9 time = 920
.meas tran vdout1_44ck183 FIND v(dout1_44) AT=920.025n

* CHECK dout1_45 Vdout1_45ck183 = 0.9 time = 920
.meas tran vdout1_45ck183 FIND v(dout1_45) AT=920.025n

* CHECK dout1_46 Vdout1_46ck183 = 0 time = 920
.meas tran vdout1_46ck183 FIND v(dout1_46) AT=920.025n

* CHECK dout1_47 Vdout1_47ck183 = 0 time = 920
.meas tran vdout1_47ck183 FIND v(dout1_47) AT=920.025n

* CHECK dout1_48 Vdout1_48ck183 = 0 time = 920
.meas tran vdout1_48ck183 FIND v(dout1_48) AT=920.025n

* CHECK dout1_49 Vdout1_49ck183 = 0 time = 920
.meas tran vdout1_49ck183 FIND v(dout1_49) AT=920.025n

* CHECK dout1_50 Vdout1_50ck183 = 0 time = 920
.meas tran vdout1_50ck183 FIND v(dout1_50) AT=920.025n

* CHECK dout1_51 Vdout1_51ck183 = 0 time = 920
.meas tran vdout1_51ck183 FIND v(dout1_51) AT=920.025n

* CHECK dout1_52 Vdout1_52ck183 = 0.9 time = 920
.meas tran vdout1_52ck183 FIND v(dout1_52) AT=920.025n

* CHECK dout1_53 Vdout1_53ck183 = 0.9 time = 920
.meas tran vdout1_53ck183 FIND v(dout1_53) AT=920.025n

* CHECK dout1_54 Vdout1_54ck183 = 0.9 time = 920
.meas tran vdout1_54ck183 FIND v(dout1_54) AT=920.025n

* CHECK dout1_55 Vdout1_55ck183 = 0.9 time = 920
.meas tran vdout1_55ck183 FIND v(dout1_55) AT=920.025n

* CHECK dout1_56 Vdout1_56ck183 = 0 time = 920
.meas tran vdout1_56ck183 FIND v(dout1_56) AT=920.025n

* CHECK dout1_57 Vdout1_57ck183 = 0.9 time = 920
.meas tran vdout1_57ck183 FIND v(dout1_57) AT=920.025n

* CHECK dout1_58 Vdout1_58ck183 = 0 time = 920
.meas tran vdout1_58ck183 FIND v(dout1_58) AT=920.025n

* CHECK dout1_59 Vdout1_59ck183 = 0.9 time = 920
.meas tran vdout1_59ck183 FIND v(dout1_59) AT=920.025n

* CHECK dout1_60 Vdout1_60ck183 = 0.9 time = 920
.meas tran vdout1_60ck183 FIND v(dout1_60) AT=920.025n

* CHECK dout1_61 Vdout1_61ck183 = 0 time = 920
.meas tran vdout1_61ck183 FIND v(dout1_61) AT=920.025n

* CHECK dout1_62 Vdout1_62ck183 = 0 time = 920
.meas tran vdout1_62ck183 FIND v(dout1_62) AT=920.025n

* CHECK dout1_63 Vdout1_63ck183 = 0.9 time = 920
.meas tran vdout1_63ck183 FIND v(dout1_63) AT=920.025n

* CHECK dout1_64 Vdout1_64ck183 = 0 time = 920
.meas tran vdout1_64ck183 FIND v(dout1_64) AT=920.025n

* CHECK dout1_65 Vdout1_65ck183 = 0 time = 920
.meas tran vdout1_65ck183 FIND v(dout1_65) AT=920.025n

* CHECK dout1_66 Vdout1_66ck183 = 0.9 time = 920
.meas tran vdout1_66ck183 FIND v(dout1_66) AT=920.025n

* CHECK dout1_67 Vdout1_67ck183 = 0.9 time = 920
.meas tran vdout1_67ck183 FIND v(dout1_67) AT=920.025n

* CHECK dout1_68 Vdout1_68ck183 = 0.9 time = 920
.meas tran vdout1_68ck183 FIND v(dout1_68) AT=920.025n

* CHECK dout1_69 Vdout1_69ck183 = 0 time = 920
.meas tran vdout1_69ck183 FIND v(dout1_69) AT=920.025n

* CHECK dout1_70 Vdout1_70ck183 = 0 time = 920
.meas tran vdout1_70ck183 FIND v(dout1_70) AT=920.025n

* CHECK dout1_71 Vdout1_71ck183 = 0 time = 920
.meas tran vdout1_71ck183 FIND v(dout1_71) AT=920.025n

* CHECK dout1_72 Vdout1_72ck183 = 0.9 time = 920
.meas tran vdout1_72ck183 FIND v(dout1_72) AT=920.025n

* CHECK dout1_73 Vdout1_73ck183 = 0.9 time = 920
.meas tran vdout1_73ck183 FIND v(dout1_73) AT=920.025n

* CHECK dout1_74 Vdout1_74ck183 = 0 time = 920
.meas tran vdout1_74ck183 FIND v(dout1_74) AT=920.025n

* CHECK dout1_75 Vdout1_75ck183 = 0.9 time = 920
.meas tran vdout1_75ck183 FIND v(dout1_75) AT=920.025n

* CHECK dout1_76 Vdout1_76ck183 = 0.9 time = 920
.meas tran vdout1_76ck183 FIND v(dout1_76) AT=920.025n

* CHECK dout1_77 Vdout1_77ck183 = 0.9 time = 920
.meas tran vdout1_77ck183 FIND v(dout1_77) AT=920.025n

* CHECK dout1_78 Vdout1_78ck183 = 0 time = 920
.meas tran vdout1_78ck183 FIND v(dout1_78) AT=920.025n

* CHECK dout1_79 Vdout1_79ck183 = 0 time = 920
.meas tran vdout1_79ck183 FIND v(dout1_79) AT=920.025n

* CHECK dout1_80 Vdout1_80ck183 = 0 time = 920
.meas tran vdout1_80ck183 FIND v(dout1_80) AT=920.025n

* CHECK dout1_81 Vdout1_81ck183 = 0.9 time = 920
.meas tran vdout1_81ck183 FIND v(dout1_81) AT=920.025n

* CHECK dout1_82 Vdout1_82ck183 = 0.9 time = 920
.meas tran vdout1_82ck183 FIND v(dout1_82) AT=920.025n

* CHECK dout1_83 Vdout1_83ck183 = 0 time = 920
.meas tran vdout1_83ck183 FIND v(dout1_83) AT=920.025n

* CHECK dout1_84 Vdout1_84ck183 = 0.9 time = 920
.meas tran vdout1_84ck183 FIND v(dout1_84) AT=920.025n

* CHECK dout1_85 Vdout1_85ck183 = 0.9 time = 920
.meas tran vdout1_85ck183 FIND v(dout1_85) AT=920.025n

* CHECK dout1_86 Vdout1_86ck183 = 0.9 time = 920
.meas tran vdout1_86ck183 FIND v(dout1_86) AT=920.025n

* CHECK dout1_87 Vdout1_87ck183 = 0 time = 920
.meas tran vdout1_87ck183 FIND v(dout1_87) AT=920.025n

* CHECK dout1_88 Vdout1_88ck183 = 0 time = 920
.meas tran vdout1_88ck183 FIND v(dout1_88) AT=920.025n

* CHECK dout1_89 Vdout1_89ck183 = 0.9 time = 920
.meas tran vdout1_89ck183 FIND v(dout1_89) AT=920.025n

* CHECK dout1_90 Vdout1_90ck183 = 0 time = 920
.meas tran vdout1_90ck183 FIND v(dout1_90) AT=920.025n

* CHECK dout1_91 Vdout1_91ck183 = 0 time = 920
.meas tran vdout1_91ck183 FIND v(dout1_91) AT=920.025n

* CHECK dout1_92 Vdout1_92ck183 = 0 time = 920
.meas tran vdout1_92ck183 FIND v(dout1_92) AT=920.025n

* CHECK dout1_93 Vdout1_93ck183 = 0 time = 920
.meas tran vdout1_93ck183 FIND v(dout1_93) AT=920.025n

* CHECK dout1_94 Vdout1_94ck183 = 0 time = 920
.meas tran vdout1_94ck183 FIND v(dout1_94) AT=920.025n

* CHECK dout1_95 Vdout1_95ck183 = 0 time = 920
.meas tran vdout1_95ck183 FIND v(dout1_95) AT=920.025n

* CHECK dout1_96 Vdout1_96ck183 = 0 time = 920
.meas tran vdout1_96ck183 FIND v(dout1_96) AT=920.025n

* CHECK dout1_97 Vdout1_97ck183 = 0.9 time = 920
.meas tran vdout1_97ck183 FIND v(dout1_97) AT=920.025n

* CHECK dout1_98 Vdout1_98ck183 = 0 time = 920
.meas tran vdout1_98ck183 FIND v(dout1_98) AT=920.025n

* CHECK dout1_99 Vdout1_99ck183 = 0 time = 920
.meas tran vdout1_99ck183 FIND v(dout1_99) AT=920.025n

* CHECK dout1_100 Vdout1_100ck183 = 0.9 time = 920
.meas tran vdout1_100ck183 FIND v(dout1_100) AT=920.025n

* CHECK dout1_101 Vdout1_101ck183 = 0 time = 920
.meas tran vdout1_101ck183 FIND v(dout1_101) AT=920.025n

* CHECK dout1_102 Vdout1_102ck183 = 0 time = 920
.meas tran vdout1_102ck183 FIND v(dout1_102) AT=920.025n

* CHECK dout1_103 Vdout1_103ck183 = 0.9 time = 920
.meas tran vdout1_103ck183 FIND v(dout1_103) AT=920.025n

* CHECK dout1_104 Vdout1_104ck183 = 0.9 time = 920
.meas tran vdout1_104ck183 FIND v(dout1_104) AT=920.025n

* CHECK dout1_105 Vdout1_105ck183 = 0 time = 920
.meas tran vdout1_105ck183 FIND v(dout1_105) AT=920.025n

* CHECK dout1_106 Vdout1_106ck183 = 0 time = 920
.meas tran vdout1_106ck183 FIND v(dout1_106) AT=920.025n

* CHECK dout1_107 Vdout1_107ck183 = 0.9 time = 920
.meas tran vdout1_107ck183 FIND v(dout1_107) AT=920.025n

* CHECK dout1_108 Vdout1_108ck183 = 0 time = 920
.meas tran vdout1_108ck183 FIND v(dout1_108) AT=920.025n

* CHECK dout1_109 Vdout1_109ck183 = 0 time = 920
.meas tran vdout1_109ck183 FIND v(dout1_109) AT=920.025n

* CHECK dout1_110 Vdout1_110ck183 = 0 time = 920
.meas tran vdout1_110ck183 FIND v(dout1_110) AT=920.025n

* CHECK dout1_111 Vdout1_111ck183 = 0 time = 920
.meas tran vdout1_111ck183 FIND v(dout1_111) AT=920.025n

* CHECK dout1_112 Vdout1_112ck183 = 0.9 time = 920
.meas tran vdout1_112ck183 FIND v(dout1_112) AT=920.025n

* CHECK dout1_113 Vdout1_113ck183 = 0.9 time = 920
.meas tran vdout1_113ck183 FIND v(dout1_113) AT=920.025n

* CHECK dout1_114 Vdout1_114ck183 = 0.9 time = 920
.meas tran vdout1_114ck183 FIND v(dout1_114) AT=920.025n

* CHECK dout1_115 Vdout1_115ck183 = 0 time = 920
.meas tran vdout1_115ck183 FIND v(dout1_115) AT=920.025n

* CHECK dout1_116 Vdout1_116ck183 = 0.9 time = 920
.meas tran vdout1_116ck183 FIND v(dout1_116) AT=920.025n

* CHECK dout1_117 Vdout1_117ck183 = 0.9 time = 920
.meas tran vdout1_117ck183 FIND v(dout1_117) AT=920.025n

* CHECK dout1_118 Vdout1_118ck183 = 0 time = 920
.meas tran vdout1_118ck183 FIND v(dout1_118) AT=920.025n

* CHECK dout1_119 Vdout1_119ck183 = 0.9 time = 920
.meas tran vdout1_119ck183 FIND v(dout1_119) AT=920.025n

* CHECK dout1_0 Vdout1_0ck185 = 0 time = 930
.meas tran vdout1_0ck185 FIND v(dout1_0) AT=930.025n

* CHECK dout1_1 Vdout1_1ck185 = 0 time = 930
.meas tran vdout1_1ck185 FIND v(dout1_1) AT=930.025n

* CHECK dout1_2 Vdout1_2ck185 = 0.9 time = 930
.meas tran vdout1_2ck185 FIND v(dout1_2) AT=930.025n

* CHECK dout1_3 Vdout1_3ck185 = 0.9 time = 930
.meas tran vdout1_3ck185 FIND v(dout1_3) AT=930.025n

* CHECK dout1_4 Vdout1_4ck185 = 0 time = 930
.meas tran vdout1_4ck185 FIND v(dout1_4) AT=930.025n

* CHECK dout1_5 Vdout1_5ck185 = 0 time = 930
.meas tran vdout1_5ck185 FIND v(dout1_5) AT=930.025n

* CHECK dout1_6 Vdout1_6ck185 = 0.9 time = 930
.meas tran vdout1_6ck185 FIND v(dout1_6) AT=930.025n

* CHECK dout1_7 Vdout1_7ck185 = 0 time = 930
.meas tran vdout1_7ck185 FIND v(dout1_7) AT=930.025n

* CHECK dout1_8 Vdout1_8ck185 = 0.9 time = 930
.meas tran vdout1_8ck185 FIND v(dout1_8) AT=930.025n

* CHECK dout1_9 Vdout1_9ck185 = 0 time = 930
.meas tran vdout1_9ck185 FIND v(dout1_9) AT=930.025n

* CHECK dout1_10 Vdout1_10ck185 = 0 time = 930
.meas tran vdout1_10ck185 FIND v(dout1_10) AT=930.025n

* CHECK dout1_11 Vdout1_11ck185 = 0.9 time = 930
.meas tran vdout1_11ck185 FIND v(dout1_11) AT=930.025n

* CHECK dout1_12 Vdout1_12ck185 = 0.9 time = 930
.meas tran vdout1_12ck185 FIND v(dout1_12) AT=930.025n

* CHECK dout1_13 Vdout1_13ck185 = 0 time = 930
.meas tran vdout1_13ck185 FIND v(dout1_13) AT=930.025n

* CHECK dout1_14 Vdout1_14ck185 = 0 time = 930
.meas tran vdout1_14ck185 FIND v(dout1_14) AT=930.025n

* CHECK dout1_15 Vdout1_15ck185 = 0 time = 930
.meas tran vdout1_15ck185 FIND v(dout1_15) AT=930.025n

* CHECK dout1_16 Vdout1_16ck185 = 0 time = 930
.meas tran vdout1_16ck185 FIND v(dout1_16) AT=930.025n

* CHECK dout1_17 Vdout1_17ck185 = 0.9 time = 930
.meas tran vdout1_17ck185 FIND v(dout1_17) AT=930.025n

* CHECK dout1_18 Vdout1_18ck185 = 0.9 time = 930
.meas tran vdout1_18ck185 FIND v(dout1_18) AT=930.025n

* CHECK dout1_19 Vdout1_19ck185 = 0.9 time = 930
.meas tran vdout1_19ck185 FIND v(dout1_19) AT=930.025n

* CHECK dout1_20 Vdout1_20ck185 = 0.9 time = 930
.meas tran vdout1_20ck185 FIND v(dout1_20) AT=930.025n

* CHECK dout1_21 Vdout1_21ck185 = 0.9 time = 930
.meas tran vdout1_21ck185 FIND v(dout1_21) AT=930.025n

* CHECK dout1_22 Vdout1_22ck185 = 0.9 time = 930
.meas tran vdout1_22ck185 FIND v(dout1_22) AT=930.025n

* CHECK dout1_23 Vdout1_23ck185 = 0.9 time = 930
.meas tran vdout1_23ck185 FIND v(dout1_23) AT=930.025n

* CHECK dout1_24 Vdout1_24ck185 = 0 time = 930
.meas tran vdout1_24ck185 FIND v(dout1_24) AT=930.025n

* CHECK dout1_25 Vdout1_25ck185 = 0.9 time = 930
.meas tran vdout1_25ck185 FIND v(dout1_25) AT=930.025n

* CHECK dout1_26 Vdout1_26ck185 = 0.9 time = 930
.meas tran vdout1_26ck185 FIND v(dout1_26) AT=930.025n

* CHECK dout1_27 Vdout1_27ck185 = 0 time = 930
.meas tran vdout1_27ck185 FIND v(dout1_27) AT=930.025n

* CHECK dout1_28 Vdout1_28ck185 = 0 time = 930
.meas tran vdout1_28ck185 FIND v(dout1_28) AT=930.025n

* CHECK dout1_29 Vdout1_29ck185 = 0 time = 930
.meas tran vdout1_29ck185 FIND v(dout1_29) AT=930.025n

* CHECK dout1_30 Vdout1_30ck185 = 0.9 time = 930
.meas tran vdout1_30ck185 FIND v(dout1_30) AT=930.025n

* CHECK dout1_31 Vdout1_31ck185 = 0 time = 930
.meas tran vdout1_31ck185 FIND v(dout1_31) AT=930.025n

* CHECK dout1_32 Vdout1_32ck185 = 0 time = 930
.meas tran vdout1_32ck185 FIND v(dout1_32) AT=930.025n

* CHECK dout1_33 Vdout1_33ck185 = 0 time = 930
.meas tran vdout1_33ck185 FIND v(dout1_33) AT=930.025n

* CHECK dout1_34 Vdout1_34ck185 = 0 time = 930
.meas tran vdout1_34ck185 FIND v(dout1_34) AT=930.025n

* CHECK dout1_35 Vdout1_35ck185 = 0.9 time = 930
.meas tran vdout1_35ck185 FIND v(dout1_35) AT=930.025n

* CHECK dout1_36 Vdout1_36ck185 = 0 time = 930
.meas tran vdout1_36ck185 FIND v(dout1_36) AT=930.025n

* CHECK dout1_37 Vdout1_37ck185 = 0 time = 930
.meas tran vdout1_37ck185 FIND v(dout1_37) AT=930.025n

* CHECK dout1_38 Vdout1_38ck185 = 0.9 time = 930
.meas tran vdout1_38ck185 FIND v(dout1_38) AT=930.025n

* CHECK dout1_39 Vdout1_39ck185 = 0.9 time = 930
.meas tran vdout1_39ck185 FIND v(dout1_39) AT=930.025n

* CHECK dout1_40 Vdout1_40ck185 = 0.9 time = 930
.meas tran vdout1_40ck185 FIND v(dout1_40) AT=930.025n

* CHECK dout1_41 Vdout1_41ck185 = 0 time = 930
.meas tran vdout1_41ck185 FIND v(dout1_41) AT=930.025n

* CHECK dout1_42 Vdout1_42ck185 = 0 time = 930
.meas tran vdout1_42ck185 FIND v(dout1_42) AT=930.025n

* CHECK dout1_43 Vdout1_43ck185 = 0 time = 930
.meas tran vdout1_43ck185 FIND v(dout1_43) AT=930.025n

* CHECK dout1_44 Vdout1_44ck185 = 0.9 time = 930
.meas tran vdout1_44ck185 FIND v(dout1_44) AT=930.025n

* CHECK dout1_45 Vdout1_45ck185 = 0 time = 930
.meas tran vdout1_45ck185 FIND v(dout1_45) AT=930.025n

* CHECK dout1_46 Vdout1_46ck185 = 0 time = 930
.meas tran vdout1_46ck185 FIND v(dout1_46) AT=930.025n

* CHECK dout1_47 Vdout1_47ck185 = 0.9 time = 930
.meas tran vdout1_47ck185 FIND v(dout1_47) AT=930.025n

* CHECK dout1_48 Vdout1_48ck185 = 0.9 time = 930
.meas tran vdout1_48ck185 FIND v(dout1_48) AT=930.025n

* CHECK dout1_49 Vdout1_49ck185 = 0.9 time = 930
.meas tran vdout1_49ck185 FIND v(dout1_49) AT=930.025n

* CHECK dout1_50 Vdout1_50ck185 = 0.9 time = 930
.meas tran vdout1_50ck185 FIND v(dout1_50) AT=930.025n

* CHECK dout1_51 Vdout1_51ck185 = 0.9 time = 930
.meas tran vdout1_51ck185 FIND v(dout1_51) AT=930.025n

* CHECK dout1_52 Vdout1_52ck185 = 0.9 time = 930
.meas tran vdout1_52ck185 FIND v(dout1_52) AT=930.025n

* CHECK dout1_53 Vdout1_53ck185 = 0.9 time = 930
.meas tran vdout1_53ck185 FIND v(dout1_53) AT=930.025n

* CHECK dout1_54 Vdout1_54ck185 = 0 time = 930
.meas tran vdout1_54ck185 FIND v(dout1_54) AT=930.025n

* CHECK dout1_55 Vdout1_55ck185 = 0 time = 930
.meas tran vdout1_55ck185 FIND v(dout1_55) AT=930.025n

* CHECK dout1_56 Vdout1_56ck185 = 0.9 time = 930
.meas tran vdout1_56ck185 FIND v(dout1_56) AT=930.025n

* CHECK dout1_57 Vdout1_57ck185 = 0 time = 930
.meas tran vdout1_57ck185 FIND v(dout1_57) AT=930.025n

* CHECK dout1_58 Vdout1_58ck185 = 0 time = 930
.meas tran vdout1_58ck185 FIND v(dout1_58) AT=930.025n

* CHECK dout1_59 Vdout1_59ck185 = 0 time = 930
.meas tran vdout1_59ck185 FIND v(dout1_59) AT=930.025n

* CHECK dout1_60 Vdout1_60ck185 = 0 time = 930
.meas tran vdout1_60ck185 FIND v(dout1_60) AT=930.025n

* CHECK dout1_61 Vdout1_61ck185 = 0.9 time = 930
.meas tran vdout1_61ck185 FIND v(dout1_61) AT=930.025n

* CHECK dout1_62 Vdout1_62ck185 = 0 time = 930
.meas tran vdout1_62ck185 FIND v(dout1_62) AT=930.025n

* CHECK dout1_63 Vdout1_63ck185 = 0 time = 930
.meas tran vdout1_63ck185 FIND v(dout1_63) AT=930.025n

* CHECK dout1_64 Vdout1_64ck185 = 0.9 time = 930
.meas tran vdout1_64ck185 FIND v(dout1_64) AT=930.025n

* CHECK dout1_65 Vdout1_65ck185 = 0.9 time = 930
.meas tran vdout1_65ck185 FIND v(dout1_65) AT=930.025n

* CHECK dout1_66 Vdout1_66ck185 = 0.9 time = 930
.meas tran vdout1_66ck185 FIND v(dout1_66) AT=930.025n

* CHECK dout1_67 Vdout1_67ck185 = 0 time = 930
.meas tran vdout1_67ck185 FIND v(dout1_67) AT=930.025n

* CHECK dout1_68 Vdout1_68ck185 = 0 time = 930
.meas tran vdout1_68ck185 FIND v(dout1_68) AT=930.025n

* CHECK dout1_69 Vdout1_69ck185 = 0.9 time = 930
.meas tran vdout1_69ck185 FIND v(dout1_69) AT=930.025n

* CHECK dout1_70 Vdout1_70ck185 = 0.9 time = 930
.meas tran vdout1_70ck185 FIND v(dout1_70) AT=930.025n

* CHECK dout1_71 Vdout1_71ck185 = 0.9 time = 930
.meas tran vdout1_71ck185 FIND v(dout1_71) AT=930.025n

* CHECK dout1_72 Vdout1_72ck185 = 0 time = 930
.meas tran vdout1_72ck185 FIND v(dout1_72) AT=930.025n

* CHECK dout1_73 Vdout1_73ck185 = 0.9 time = 930
.meas tran vdout1_73ck185 FIND v(dout1_73) AT=930.025n

* CHECK dout1_74 Vdout1_74ck185 = 0.9 time = 930
.meas tran vdout1_74ck185 FIND v(dout1_74) AT=930.025n

* CHECK dout1_75 Vdout1_75ck185 = 0.9 time = 930
.meas tran vdout1_75ck185 FIND v(dout1_75) AT=930.025n

* CHECK dout1_76 Vdout1_76ck185 = 0.9 time = 930
.meas tran vdout1_76ck185 FIND v(dout1_76) AT=930.025n

* CHECK dout1_77 Vdout1_77ck185 = 0 time = 930
.meas tran vdout1_77ck185 FIND v(dout1_77) AT=930.025n

* CHECK dout1_78 Vdout1_78ck185 = 0 time = 930
.meas tran vdout1_78ck185 FIND v(dout1_78) AT=930.025n

* CHECK dout1_79 Vdout1_79ck185 = 0 time = 930
.meas tran vdout1_79ck185 FIND v(dout1_79) AT=930.025n

* CHECK dout1_80 Vdout1_80ck185 = 0 time = 930
.meas tran vdout1_80ck185 FIND v(dout1_80) AT=930.025n

* CHECK dout1_81 Vdout1_81ck185 = 0 time = 930
.meas tran vdout1_81ck185 FIND v(dout1_81) AT=930.025n

* CHECK dout1_82 Vdout1_82ck185 = 0.9 time = 930
.meas tran vdout1_82ck185 FIND v(dout1_82) AT=930.025n

* CHECK dout1_83 Vdout1_83ck185 = 0.9 time = 930
.meas tran vdout1_83ck185 FIND v(dout1_83) AT=930.025n

* CHECK dout1_84 Vdout1_84ck185 = 0.9 time = 930
.meas tran vdout1_84ck185 FIND v(dout1_84) AT=930.025n

* CHECK dout1_85 Vdout1_85ck185 = 0.9 time = 930
.meas tran vdout1_85ck185 FIND v(dout1_85) AT=930.025n

* CHECK dout1_86 Vdout1_86ck185 = 0.9 time = 930
.meas tran vdout1_86ck185 FIND v(dout1_86) AT=930.025n

* CHECK dout1_87 Vdout1_87ck185 = 0.9 time = 930
.meas tran vdout1_87ck185 FIND v(dout1_87) AT=930.025n

* CHECK dout1_88 Vdout1_88ck185 = 0 time = 930
.meas tran vdout1_88ck185 FIND v(dout1_88) AT=930.025n

* CHECK dout1_89 Vdout1_89ck185 = 0.9 time = 930
.meas tran vdout1_89ck185 FIND v(dout1_89) AT=930.025n

* CHECK dout1_90 Vdout1_90ck185 = 0 time = 930
.meas tran vdout1_90ck185 FIND v(dout1_90) AT=930.025n

* CHECK dout1_91 Vdout1_91ck185 = 0.9 time = 930
.meas tran vdout1_91ck185 FIND v(dout1_91) AT=930.025n

* CHECK dout1_92 Vdout1_92ck185 = 0 time = 930
.meas tran vdout1_92ck185 FIND v(dout1_92) AT=930.025n

* CHECK dout1_93 Vdout1_93ck185 = 0.9 time = 930
.meas tran vdout1_93ck185 FIND v(dout1_93) AT=930.025n

* CHECK dout1_94 Vdout1_94ck185 = 0 time = 930
.meas tran vdout1_94ck185 FIND v(dout1_94) AT=930.025n

* CHECK dout1_95 Vdout1_95ck185 = 0 time = 930
.meas tran vdout1_95ck185 FIND v(dout1_95) AT=930.025n

* CHECK dout1_96 Vdout1_96ck185 = 0.9 time = 930
.meas tran vdout1_96ck185 FIND v(dout1_96) AT=930.025n

* CHECK dout1_97 Vdout1_97ck185 = 0.9 time = 930
.meas tran vdout1_97ck185 FIND v(dout1_97) AT=930.025n

* CHECK dout1_98 Vdout1_98ck185 = 0.9 time = 930
.meas tran vdout1_98ck185 FIND v(dout1_98) AT=930.025n

* CHECK dout1_99 Vdout1_99ck185 = 0 time = 930
.meas tran vdout1_99ck185 FIND v(dout1_99) AT=930.025n

* CHECK dout1_100 Vdout1_100ck185 = 0 time = 930
.meas tran vdout1_100ck185 FIND v(dout1_100) AT=930.025n

* CHECK dout1_101 Vdout1_101ck185 = 0.9 time = 930
.meas tran vdout1_101ck185 FIND v(dout1_101) AT=930.025n

* CHECK dout1_102 Vdout1_102ck185 = 0.9 time = 930
.meas tran vdout1_102ck185 FIND v(dout1_102) AT=930.025n

* CHECK dout1_103 Vdout1_103ck185 = 0 time = 930
.meas tran vdout1_103ck185 FIND v(dout1_103) AT=930.025n

* CHECK dout1_104 Vdout1_104ck185 = 0 time = 930
.meas tran vdout1_104ck185 FIND v(dout1_104) AT=930.025n

* CHECK dout1_105 Vdout1_105ck185 = 0.9 time = 930
.meas tran vdout1_105ck185 FIND v(dout1_105) AT=930.025n

* CHECK dout1_106 Vdout1_106ck185 = 0 time = 930
.meas tran vdout1_106ck185 FIND v(dout1_106) AT=930.025n

* CHECK dout1_107 Vdout1_107ck185 = 0.9 time = 930
.meas tran vdout1_107ck185 FIND v(dout1_107) AT=930.025n

* CHECK dout1_108 Vdout1_108ck185 = 0 time = 930
.meas tran vdout1_108ck185 FIND v(dout1_108) AT=930.025n

* CHECK dout1_109 Vdout1_109ck185 = 0.9 time = 930
.meas tran vdout1_109ck185 FIND v(dout1_109) AT=930.025n

* CHECK dout1_110 Vdout1_110ck185 = 0 time = 930
.meas tran vdout1_110ck185 FIND v(dout1_110) AT=930.025n

* CHECK dout1_111 Vdout1_111ck185 = 0.9 time = 930
.meas tran vdout1_111ck185 FIND v(dout1_111) AT=930.025n

* CHECK dout1_112 Vdout1_112ck185 = 0.9 time = 930
.meas tran vdout1_112ck185 FIND v(dout1_112) AT=930.025n

* CHECK dout1_113 Vdout1_113ck185 = 0.9 time = 930
.meas tran vdout1_113ck185 FIND v(dout1_113) AT=930.025n

* CHECK dout1_114 Vdout1_114ck185 = 0.9 time = 930
.meas tran vdout1_114ck185 FIND v(dout1_114) AT=930.025n

* CHECK dout1_115 Vdout1_115ck185 = 0 time = 930
.meas tran vdout1_115ck185 FIND v(dout1_115) AT=930.025n

* CHECK dout1_116 Vdout1_116ck185 = 0.9 time = 930
.meas tran vdout1_116ck185 FIND v(dout1_116) AT=930.025n

* CHECK dout1_117 Vdout1_117ck185 = 0 time = 930
.meas tran vdout1_117ck185 FIND v(dout1_117) AT=930.025n

* CHECK dout1_118 Vdout1_118ck185 = 0 time = 930
.meas tran vdout1_118ck185 FIND v(dout1_118) AT=930.025n

* CHECK dout1_119 Vdout1_119ck185 = 0.9 time = 930
.meas tran vdout1_119ck185 FIND v(dout1_119) AT=930.025n

* CHECK dout1_0 Vdout1_0ck187 = 0 time = 940
.meas tran vdout1_0ck187 FIND v(dout1_0) AT=940.025n

* CHECK dout1_1 Vdout1_1ck187 = 0 time = 940
.meas tran vdout1_1ck187 FIND v(dout1_1) AT=940.025n

* CHECK dout1_2 Vdout1_2ck187 = 0.9 time = 940
.meas tran vdout1_2ck187 FIND v(dout1_2) AT=940.025n

* CHECK dout1_3 Vdout1_3ck187 = 0.9 time = 940
.meas tran vdout1_3ck187 FIND v(dout1_3) AT=940.025n

* CHECK dout1_4 Vdout1_4ck187 = 0 time = 940
.meas tran vdout1_4ck187 FIND v(dout1_4) AT=940.025n

* CHECK dout1_5 Vdout1_5ck187 = 0 time = 940
.meas tran vdout1_5ck187 FIND v(dout1_5) AT=940.025n

* CHECK dout1_6 Vdout1_6ck187 = 0.9 time = 940
.meas tran vdout1_6ck187 FIND v(dout1_6) AT=940.025n

* CHECK dout1_7 Vdout1_7ck187 = 0 time = 940
.meas tran vdout1_7ck187 FIND v(dout1_7) AT=940.025n

* CHECK dout1_8 Vdout1_8ck187 = 0.9 time = 940
.meas tran vdout1_8ck187 FIND v(dout1_8) AT=940.025n

* CHECK dout1_9 Vdout1_9ck187 = 0 time = 940
.meas tran vdout1_9ck187 FIND v(dout1_9) AT=940.025n

* CHECK dout1_10 Vdout1_10ck187 = 0 time = 940
.meas tran vdout1_10ck187 FIND v(dout1_10) AT=940.025n

* CHECK dout1_11 Vdout1_11ck187 = 0.9 time = 940
.meas tran vdout1_11ck187 FIND v(dout1_11) AT=940.025n

* CHECK dout1_12 Vdout1_12ck187 = 0.9 time = 940
.meas tran vdout1_12ck187 FIND v(dout1_12) AT=940.025n

* CHECK dout1_13 Vdout1_13ck187 = 0 time = 940
.meas tran vdout1_13ck187 FIND v(dout1_13) AT=940.025n

* CHECK dout1_14 Vdout1_14ck187 = 0 time = 940
.meas tran vdout1_14ck187 FIND v(dout1_14) AT=940.025n

* CHECK dout1_15 Vdout1_15ck187 = 0 time = 940
.meas tran vdout1_15ck187 FIND v(dout1_15) AT=940.025n

* CHECK dout1_16 Vdout1_16ck187 = 0 time = 940
.meas tran vdout1_16ck187 FIND v(dout1_16) AT=940.025n

* CHECK dout1_17 Vdout1_17ck187 = 0.9 time = 940
.meas tran vdout1_17ck187 FIND v(dout1_17) AT=940.025n

* CHECK dout1_18 Vdout1_18ck187 = 0.9 time = 940
.meas tran vdout1_18ck187 FIND v(dout1_18) AT=940.025n

* CHECK dout1_19 Vdout1_19ck187 = 0.9 time = 940
.meas tran vdout1_19ck187 FIND v(dout1_19) AT=940.025n

* CHECK dout1_20 Vdout1_20ck187 = 0.9 time = 940
.meas tran vdout1_20ck187 FIND v(dout1_20) AT=940.025n

* CHECK dout1_21 Vdout1_21ck187 = 0.9 time = 940
.meas tran vdout1_21ck187 FIND v(dout1_21) AT=940.025n

* CHECK dout1_22 Vdout1_22ck187 = 0.9 time = 940
.meas tran vdout1_22ck187 FIND v(dout1_22) AT=940.025n

* CHECK dout1_23 Vdout1_23ck187 = 0.9 time = 940
.meas tran vdout1_23ck187 FIND v(dout1_23) AT=940.025n

* CHECK dout1_24 Vdout1_24ck187 = 0 time = 940
.meas tran vdout1_24ck187 FIND v(dout1_24) AT=940.025n

* CHECK dout1_25 Vdout1_25ck187 = 0.9 time = 940
.meas tran vdout1_25ck187 FIND v(dout1_25) AT=940.025n

* CHECK dout1_26 Vdout1_26ck187 = 0.9 time = 940
.meas tran vdout1_26ck187 FIND v(dout1_26) AT=940.025n

* CHECK dout1_27 Vdout1_27ck187 = 0 time = 940
.meas tran vdout1_27ck187 FIND v(dout1_27) AT=940.025n

* CHECK dout1_28 Vdout1_28ck187 = 0 time = 940
.meas tran vdout1_28ck187 FIND v(dout1_28) AT=940.025n

* CHECK dout1_29 Vdout1_29ck187 = 0 time = 940
.meas tran vdout1_29ck187 FIND v(dout1_29) AT=940.025n

* CHECK dout1_30 Vdout1_30ck187 = 0.9 time = 940
.meas tran vdout1_30ck187 FIND v(dout1_30) AT=940.025n

* CHECK dout1_31 Vdout1_31ck187 = 0 time = 940
.meas tran vdout1_31ck187 FIND v(dout1_31) AT=940.025n

* CHECK dout1_32 Vdout1_32ck187 = 0 time = 940
.meas tran vdout1_32ck187 FIND v(dout1_32) AT=940.025n

* CHECK dout1_33 Vdout1_33ck187 = 0 time = 940
.meas tran vdout1_33ck187 FIND v(dout1_33) AT=940.025n

* CHECK dout1_34 Vdout1_34ck187 = 0 time = 940
.meas tran vdout1_34ck187 FIND v(dout1_34) AT=940.025n

* CHECK dout1_35 Vdout1_35ck187 = 0.9 time = 940
.meas tran vdout1_35ck187 FIND v(dout1_35) AT=940.025n

* CHECK dout1_36 Vdout1_36ck187 = 0 time = 940
.meas tran vdout1_36ck187 FIND v(dout1_36) AT=940.025n

* CHECK dout1_37 Vdout1_37ck187 = 0 time = 940
.meas tran vdout1_37ck187 FIND v(dout1_37) AT=940.025n

* CHECK dout1_38 Vdout1_38ck187 = 0.9 time = 940
.meas tran vdout1_38ck187 FIND v(dout1_38) AT=940.025n

* CHECK dout1_39 Vdout1_39ck187 = 0.9 time = 940
.meas tran vdout1_39ck187 FIND v(dout1_39) AT=940.025n

* CHECK dout1_40 Vdout1_40ck187 = 0.9 time = 940
.meas tran vdout1_40ck187 FIND v(dout1_40) AT=940.025n

* CHECK dout1_41 Vdout1_41ck187 = 0 time = 940
.meas tran vdout1_41ck187 FIND v(dout1_41) AT=940.025n

* CHECK dout1_42 Vdout1_42ck187 = 0 time = 940
.meas tran vdout1_42ck187 FIND v(dout1_42) AT=940.025n

* CHECK dout1_43 Vdout1_43ck187 = 0 time = 940
.meas tran vdout1_43ck187 FIND v(dout1_43) AT=940.025n

* CHECK dout1_44 Vdout1_44ck187 = 0.9 time = 940
.meas tran vdout1_44ck187 FIND v(dout1_44) AT=940.025n

* CHECK dout1_45 Vdout1_45ck187 = 0 time = 940
.meas tran vdout1_45ck187 FIND v(dout1_45) AT=940.025n

* CHECK dout1_46 Vdout1_46ck187 = 0 time = 940
.meas tran vdout1_46ck187 FIND v(dout1_46) AT=940.025n

* CHECK dout1_47 Vdout1_47ck187 = 0.9 time = 940
.meas tran vdout1_47ck187 FIND v(dout1_47) AT=940.025n

* CHECK dout1_48 Vdout1_48ck187 = 0.9 time = 940
.meas tran vdout1_48ck187 FIND v(dout1_48) AT=940.025n

* CHECK dout1_49 Vdout1_49ck187 = 0.9 time = 940
.meas tran vdout1_49ck187 FIND v(dout1_49) AT=940.025n

* CHECK dout1_50 Vdout1_50ck187 = 0.9 time = 940
.meas tran vdout1_50ck187 FIND v(dout1_50) AT=940.025n

* CHECK dout1_51 Vdout1_51ck187 = 0.9 time = 940
.meas tran vdout1_51ck187 FIND v(dout1_51) AT=940.025n

* CHECK dout1_52 Vdout1_52ck187 = 0.9 time = 940
.meas tran vdout1_52ck187 FIND v(dout1_52) AT=940.025n

* CHECK dout1_53 Vdout1_53ck187 = 0.9 time = 940
.meas tran vdout1_53ck187 FIND v(dout1_53) AT=940.025n

* CHECK dout1_54 Vdout1_54ck187 = 0 time = 940
.meas tran vdout1_54ck187 FIND v(dout1_54) AT=940.025n

* CHECK dout1_55 Vdout1_55ck187 = 0 time = 940
.meas tran vdout1_55ck187 FIND v(dout1_55) AT=940.025n

* CHECK dout1_56 Vdout1_56ck187 = 0.9 time = 940
.meas tran vdout1_56ck187 FIND v(dout1_56) AT=940.025n

* CHECK dout1_57 Vdout1_57ck187 = 0 time = 940
.meas tran vdout1_57ck187 FIND v(dout1_57) AT=940.025n

* CHECK dout1_58 Vdout1_58ck187 = 0 time = 940
.meas tran vdout1_58ck187 FIND v(dout1_58) AT=940.025n

* CHECK dout1_59 Vdout1_59ck187 = 0 time = 940
.meas tran vdout1_59ck187 FIND v(dout1_59) AT=940.025n

* CHECK dout1_60 Vdout1_60ck187 = 0 time = 940
.meas tran vdout1_60ck187 FIND v(dout1_60) AT=940.025n

* CHECK dout1_61 Vdout1_61ck187 = 0.9 time = 940
.meas tran vdout1_61ck187 FIND v(dout1_61) AT=940.025n

* CHECK dout1_62 Vdout1_62ck187 = 0 time = 940
.meas tran vdout1_62ck187 FIND v(dout1_62) AT=940.025n

* CHECK dout1_63 Vdout1_63ck187 = 0 time = 940
.meas tran vdout1_63ck187 FIND v(dout1_63) AT=940.025n

* CHECK dout1_64 Vdout1_64ck187 = 0.9 time = 940
.meas tran vdout1_64ck187 FIND v(dout1_64) AT=940.025n

* CHECK dout1_65 Vdout1_65ck187 = 0.9 time = 940
.meas tran vdout1_65ck187 FIND v(dout1_65) AT=940.025n

* CHECK dout1_66 Vdout1_66ck187 = 0.9 time = 940
.meas tran vdout1_66ck187 FIND v(dout1_66) AT=940.025n

* CHECK dout1_67 Vdout1_67ck187 = 0 time = 940
.meas tran vdout1_67ck187 FIND v(dout1_67) AT=940.025n

* CHECK dout1_68 Vdout1_68ck187 = 0 time = 940
.meas tran vdout1_68ck187 FIND v(dout1_68) AT=940.025n

* CHECK dout1_69 Vdout1_69ck187 = 0.9 time = 940
.meas tran vdout1_69ck187 FIND v(dout1_69) AT=940.025n

* CHECK dout1_70 Vdout1_70ck187 = 0.9 time = 940
.meas tran vdout1_70ck187 FIND v(dout1_70) AT=940.025n

* CHECK dout1_71 Vdout1_71ck187 = 0.9 time = 940
.meas tran vdout1_71ck187 FIND v(dout1_71) AT=940.025n

* CHECK dout1_72 Vdout1_72ck187 = 0 time = 940
.meas tran vdout1_72ck187 FIND v(dout1_72) AT=940.025n

* CHECK dout1_73 Vdout1_73ck187 = 0.9 time = 940
.meas tran vdout1_73ck187 FIND v(dout1_73) AT=940.025n

* CHECK dout1_74 Vdout1_74ck187 = 0.9 time = 940
.meas tran vdout1_74ck187 FIND v(dout1_74) AT=940.025n

* CHECK dout1_75 Vdout1_75ck187 = 0.9 time = 940
.meas tran vdout1_75ck187 FIND v(dout1_75) AT=940.025n

* CHECK dout1_76 Vdout1_76ck187 = 0.9 time = 940
.meas tran vdout1_76ck187 FIND v(dout1_76) AT=940.025n

* CHECK dout1_77 Vdout1_77ck187 = 0 time = 940
.meas tran vdout1_77ck187 FIND v(dout1_77) AT=940.025n

* CHECK dout1_78 Vdout1_78ck187 = 0 time = 940
.meas tran vdout1_78ck187 FIND v(dout1_78) AT=940.025n

* CHECK dout1_79 Vdout1_79ck187 = 0 time = 940
.meas tran vdout1_79ck187 FIND v(dout1_79) AT=940.025n

* CHECK dout1_80 Vdout1_80ck187 = 0 time = 940
.meas tran vdout1_80ck187 FIND v(dout1_80) AT=940.025n

* CHECK dout1_81 Vdout1_81ck187 = 0 time = 940
.meas tran vdout1_81ck187 FIND v(dout1_81) AT=940.025n

* CHECK dout1_82 Vdout1_82ck187 = 0.9 time = 940
.meas tran vdout1_82ck187 FIND v(dout1_82) AT=940.025n

* CHECK dout1_83 Vdout1_83ck187 = 0.9 time = 940
.meas tran vdout1_83ck187 FIND v(dout1_83) AT=940.025n

* CHECK dout1_84 Vdout1_84ck187 = 0.9 time = 940
.meas tran vdout1_84ck187 FIND v(dout1_84) AT=940.025n

* CHECK dout1_85 Vdout1_85ck187 = 0.9 time = 940
.meas tran vdout1_85ck187 FIND v(dout1_85) AT=940.025n

* CHECK dout1_86 Vdout1_86ck187 = 0.9 time = 940
.meas tran vdout1_86ck187 FIND v(dout1_86) AT=940.025n

* CHECK dout1_87 Vdout1_87ck187 = 0.9 time = 940
.meas tran vdout1_87ck187 FIND v(dout1_87) AT=940.025n

* CHECK dout1_88 Vdout1_88ck187 = 0 time = 940
.meas tran vdout1_88ck187 FIND v(dout1_88) AT=940.025n

* CHECK dout1_89 Vdout1_89ck187 = 0.9 time = 940
.meas tran vdout1_89ck187 FIND v(dout1_89) AT=940.025n

* CHECK dout1_90 Vdout1_90ck187 = 0 time = 940
.meas tran vdout1_90ck187 FIND v(dout1_90) AT=940.025n

* CHECK dout1_91 Vdout1_91ck187 = 0.9 time = 940
.meas tran vdout1_91ck187 FIND v(dout1_91) AT=940.025n

* CHECK dout1_92 Vdout1_92ck187 = 0 time = 940
.meas tran vdout1_92ck187 FIND v(dout1_92) AT=940.025n

* CHECK dout1_93 Vdout1_93ck187 = 0.9 time = 940
.meas tran vdout1_93ck187 FIND v(dout1_93) AT=940.025n

* CHECK dout1_94 Vdout1_94ck187 = 0 time = 940
.meas tran vdout1_94ck187 FIND v(dout1_94) AT=940.025n

* CHECK dout1_95 Vdout1_95ck187 = 0 time = 940
.meas tran vdout1_95ck187 FIND v(dout1_95) AT=940.025n

* CHECK dout1_96 Vdout1_96ck187 = 0.9 time = 940
.meas tran vdout1_96ck187 FIND v(dout1_96) AT=940.025n

* CHECK dout1_97 Vdout1_97ck187 = 0.9 time = 940
.meas tran vdout1_97ck187 FIND v(dout1_97) AT=940.025n

* CHECK dout1_98 Vdout1_98ck187 = 0.9 time = 940
.meas tran vdout1_98ck187 FIND v(dout1_98) AT=940.025n

* CHECK dout1_99 Vdout1_99ck187 = 0 time = 940
.meas tran vdout1_99ck187 FIND v(dout1_99) AT=940.025n

* CHECK dout1_100 Vdout1_100ck187 = 0 time = 940
.meas tran vdout1_100ck187 FIND v(dout1_100) AT=940.025n

* CHECK dout1_101 Vdout1_101ck187 = 0.9 time = 940
.meas tran vdout1_101ck187 FIND v(dout1_101) AT=940.025n

* CHECK dout1_102 Vdout1_102ck187 = 0.9 time = 940
.meas tran vdout1_102ck187 FIND v(dout1_102) AT=940.025n

* CHECK dout1_103 Vdout1_103ck187 = 0 time = 940
.meas tran vdout1_103ck187 FIND v(dout1_103) AT=940.025n

* CHECK dout1_104 Vdout1_104ck187 = 0 time = 940
.meas tran vdout1_104ck187 FIND v(dout1_104) AT=940.025n

* CHECK dout1_105 Vdout1_105ck187 = 0.9 time = 940
.meas tran vdout1_105ck187 FIND v(dout1_105) AT=940.025n

* CHECK dout1_106 Vdout1_106ck187 = 0 time = 940
.meas tran vdout1_106ck187 FIND v(dout1_106) AT=940.025n

* CHECK dout1_107 Vdout1_107ck187 = 0.9 time = 940
.meas tran vdout1_107ck187 FIND v(dout1_107) AT=940.025n

* CHECK dout1_108 Vdout1_108ck187 = 0 time = 940
.meas tran vdout1_108ck187 FIND v(dout1_108) AT=940.025n

* CHECK dout1_109 Vdout1_109ck187 = 0.9 time = 940
.meas tran vdout1_109ck187 FIND v(dout1_109) AT=940.025n

* CHECK dout1_110 Vdout1_110ck187 = 0 time = 940
.meas tran vdout1_110ck187 FIND v(dout1_110) AT=940.025n

* CHECK dout1_111 Vdout1_111ck187 = 0.9 time = 940
.meas tran vdout1_111ck187 FIND v(dout1_111) AT=940.025n

* CHECK dout1_112 Vdout1_112ck187 = 0.9 time = 940
.meas tran vdout1_112ck187 FIND v(dout1_112) AT=940.025n

* CHECK dout1_113 Vdout1_113ck187 = 0.9 time = 940
.meas tran vdout1_113ck187 FIND v(dout1_113) AT=940.025n

* CHECK dout1_114 Vdout1_114ck187 = 0.9 time = 940
.meas tran vdout1_114ck187 FIND v(dout1_114) AT=940.025n

* CHECK dout1_115 Vdout1_115ck187 = 0 time = 940
.meas tran vdout1_115ck187 FIND v(dout1_115) AT=940.025n

* CHECK dout1_116 Vdout1_116ck187 = 0.9 time = 940
.meas tran vdout1_116ck187 FIND v(dout1_116) AT=940.025n

* CHECK dout1_117 Vdout1_117ck187 = 0 time = 940
.meas tran vdout1_117ck187 FIND v(dout1_117) AT=940.025n

* CHECK dout1_118 Vdout1_118ck187 = 0 time = 940
.meas tran vdout1_118ck187 FIND v(dout1_118) AT=940.025n

* CHECK dout1_119 Vdout1_119ck187 = 0.9 time = 940
.meas tran vdout1_119ck187 FIND v(dout1_119) AT=940.025n

* CHECK dout1_0 Vdout1_0ck189 = 0 time = 950
.meas tran vdout1_0ck189 FIND v(dout1_0) AT=950.025n

* CHECK dout1_1 Vdout1_1ck189 = 0 time = 950
.meas tran vdout1_1ck189 FIND v(dout1_1) AT=950.025n

* CHECK dout1_2 Vdout1_2ck189 = 0.9 time = 950
.meas tran vdout1_2ck189 FIND v(dout1_2) AT=950.025n

* CHECK dout1_3 Vdout1_3ck189 = 0.9 time = 950
.meas tran vdout1_3ck189 FIND v(dout1_3) AT=950.025n

* CHECK dout1_4 Vdout1_4ck189 = 0 time = 950
.meas tran vdout1_4ck189 FIND v(dout1_4) AT=950.025n

* CHECK dout1_5 Vdout1_5ck189 = 0 time = 950
.meas tran vdout1_5ck189 FIND v(dout1_5) AT=950.025n

* CHECK dout1_6 Vdout1_6ck189 = 0.9 time = 950
.meas tran vdout1_6ck189 FIND v(dout1_6) AT=950.025n

* CHECK dout1_7 Vdout1_7ck189 = 0 time = 950
.meas tran vdout1_7ck189 FIND v(dout1_7) AT=950.025n

* CHECK dout1_8 Vdout1_8ck189 = 0.9 time = 950
.meas tran vdout1_8ck189 FIND v(dout1_8) AT=950.025n

* CHECK dout1_9 Vdout1_9ck189 = 0 time = 950
.meas tran vdout1_9ck189 FIND v(dout1_9) AT=950.025n

* CHECK dout1_10 Vdout1_10ck189 = 0 time = 950
.meas tran vdout1_10ck189 FIND v(dout1_10) AT=950.025n

* CHECK dout1_11 Vdout1_11ck189 = 0.9 time = 950
.meas tran vdout1_11ck189 FIND v(dout1_11) AT=950.025n

* CHECK dout1_12 Vdout1_12ck189 = 0.9 time = 950
.meas tran vdout1_12ck189 FIND v(dout1_12) AT=950.025n

* CHECK dout1_13 Vdout1_13ck189 = 0 time = 950
.meas tran vdout1_13ck189 FIND v(dout1_13) AT=950.025n

* CHECK dout1_14 Vdout1_14ck189 = 0 time = 950
.meas tran vdout1_14ck189 FIND v(dout1_14) AT=950.025n

* CHECK dout1_15 Vdout1_15ck189 = 0 time = 950
.meas tran vdout1_15ck189 FIND v(dout1_15) AT=950.025n

* CHECK dout1_16 Vdout1_16ck189 = 0 time = 950
.meas tran vdout1_16ck189 FIND v(dout1_16) AT=950.025n

* CHECK dout1_17 Vdout1_17ck189 = 0.9 time = 950
.meas tran vdout1_17ck189 FIND v(dout1_17) AT=950.025n

* CHECK dout1_18 Vdout1_18ck189 = 0.9 time = 950
.meas tran vdout1_18ck189 FIND v(dout1_18) AT=950.025n

* CHECK dout1_19 Vdout1_19ck189 = 0.9 time = 950
.meas tran vdout1_19ck189 FIND v(dout1_19) AT=950.025n

* CHECK dout1_20 Vdout1_20ck189 = 0.9 time = 950
.meas tran vdout1_20ck189 FIND v(dout1_20) AT=950.025n

* CHECK dout1_21 Vdout1_21ck189 = 0.9 time = 950
.meas tran vdout1_21ck189 FIND v(dout1_21) AT=950.025n

* CHECK dout1_22 Vdout1_22ck189 = 0.9 time = 950
.meas tran vdout1_22ck189 FIND v(dout1_22) AT=950.025n

* CHECK dout1_23 Vdout1_23ck189 = 0.9 time = 950
.meas tran vdout1_23ck189 FIND v(dout1_23) AT=950.025n

* CHECK dout1_24 Vdout1_24ck189 = 0 time = 950
.meas tran vdout1_24ck189 FIND v(dout1_24) AT=950.025n

* CHECK dout1_25 Vdout1_25ck189 = 0.9 time = 950
.meas tran vdout1_25ck189 FIND v(dout1_25) AT=950.025n

* CHECK dout1_26 Vdout1_26ck189 = 0.9 time = 950
.meas tran vdout1_26ck189 FIND v(dout1_26) AT=950.025n

* CHECK dout1_27 Vdout1_27ck189 = 0 time = 950
.meas tran vdout1_27ck189 FIND v(dout1_27) AT=950.025n

* CHECK dout1_28 Vdout1_28ck189 = 0 time = 950
.meas tran vdout1_28ck189 FIND v(dout1_28) AT=950.025n

* CHECK dout1_29 Vdout1_29ck189 = 0 time = 950
.meas tran vdout1_29ck189 FIND v(dout1_29) AT=950.025n

* CHECK dout1_30 Vdout1_30ck189 = 0.9 time = 950
.meas tran vdout1_30ck189 FIND v(dout1_30) AT=950.025n

* CHECK dout1_31 Vdout1_31ck189 = 0 time = 950
.meas tran vdout1_31ck189 FIND v(dout1_31) AT=950.025n

* CHECK dout1_32 Vdout1_32ck189 = 0 time = 950
.meas tran vdout1_32ck189 FIND v(dout1_32) AT=950.025n

* CHECK dout1_33 Vdout1_33ck189 = 0 time = 950
.meas tran vdout1_33ck189 FIND v(dout1_33) AT=950.025n

* CHECK dout1_34 Vdout1_34ck189 = 0 time = 950
.meas tran vdout1_34ck189 FIND v(dout1_34) AT=950.025n

* CHECK dout1_35 Vdout1_35ck189 = 0.9 time = 950
.meas tran vdout1_35ck189 FIND v(dout1_35) AT=950.025n

* CHECK dout1_36 Vdout1_36ck189 = 0 time = 950
.meas tran vdout1_36ck189 FIND v(dout1_36) AT=950.025n

* CHECK dout1_37 Vdout1_37ck189 = 0 time = 950
.meas tran vdout1_37ck189 FIND v(dout1_37) AT=950.025n

* CHECK dout1_38 Vdout1_38ck189 = 0.9 time = 950
.meas tran vdout1_38ck189 FIND v(dout1_38) AT=950.025n

* CHECK dout1_39 Vdout1_39ck189 = 0.9 time = 950
.meas tran vdout1_39ck189 FIND v(dout1_39) AT=950.025n

* CHECK dout1_40 Vdout1_40ck189 = 0.9 time = 950
.meas tran vdout1_40ck189 FIND v(dout1_40) AT=950.025n

* CHECK dout1_41 Vdout1_41ck189 = 0 time = 950
.meas tran vdout1_41ck189 FIND v(dout1_41) AT=950.025n

* CHECK dout1_42 Vdout1_42ck189 = 0 time = 950
.meas tran vdout1_42ck189 FIND v(dout1_42) AT=950.025n

* CHECK dout1_43 Vdout1_43ck189 = 0 time = 950
.meas tran vdout1_43ck189 FIND v(dout1_43) AT=950.025n

* CHECK dout1_44 Vdout1_44ck189 = 0.9 time = 950
.meas tran vdout1_44ck189 FIND v(dout1_44) AT=950.025n

* CHECK dout1_45 Vdout1_45ck189 = 0 time = 950
.meas tran vdout1_45ck189 FIND v(dout1_45) AT=950.025n

* CHECK dout1_46 Vdout1_46ck189 = 0 time = 950
.meas tran vdout1_46ck189 FIND v(dout1_46) AT=950.025n

* CHECK dout1_47 Vdout1_47ck189 = 0.9 time = 950
.meas tran vdout1_47ck189 FIND v(dout1_47) AT=950.025n

* CHECK dout1_48 Vdout1_48ck189 = 0.9 time = 950
.meas tran vdout1_48ck189 FIND v(dout1_48) AT=950.025n

* CHECK dout1_49 Vdout1_49ck189 = 0.9 time = 950
.meas tran vdout1_49ck189 FIND v(dout1_49) AT=950.025n

* CHECK dout1_50 Vdout1_50ck189 = 0.9 time = 950
.meas tran vdout1_50ck189 FIND v(dout1_50) AT=950.025n

* CHECK dout1_51 Vdout1_51ck189 = 0.9 time = 950
.meas tran vdout1_51ck189 FIND v(dout1_51) AT=950.025n

* CHECK dout1_52 Vdout1_52ck189 = 0.9 time = 950
.meas tran vdout1_52ck189 FIND v(dout1_52) AT=950.025n

* CHECK dout1_53 Vdout1_53ck189 = 0.9 time = 950
.meas tran vdout1_53ck189 FIND v(dout1_53) AT=950.025n

* CHECK dout1_54 Vdout1_54ck189 = 0 time = 950
.meas tran vdout1_54ck189 FIND v(dout1_54) AT=950.025n

* CHECK dout1_55 Vdout1_55ck189 = 0 time = 950
.meas tran vdout1_55ck189 FIND v(dout1_55) AT=950.025n

* CHECK dout1_56 Vdout1_56ck189 = 0.9 time = 950
.meas tran vdout1_56ck189 FIND v(dout1_56) AT=950.025n

* CHECK dout1_57 Vdout1_57ck189 = 0 time = 950
.meas tran vdout1_57ck189 FIND v(dout1_57) AT=950.025n

* CHECK dout1_58 Vdout1_58ck189 = 0 time = 950
.meas tran vdout1_58ck189 FIND v(dout1_58) AT=950.025n

* CHECK dout1_59 Vdout1_59ck189 = 0 time = 950
.meas tran vdout1_59ck189 FIND v(dout1_59) AT=950.025n

* CHECK dout1_60 Vdout1_60ck189 = 0 time = 950
.meas tran vdout1_60ck189 FIND v(dout1_60) AT=950.025n

* CHECK dout1_61 Vdout1_61ck189 = 0.9 time = 950
.meas tran vdout1_61ck189 FIND v(dout1_61) AT=950.025n

* CHECK dout1_62 Vdout1_62ck189 = 0 time = 950
.meas tran vdout1_62ck189 FIND v(dout1_62) AT=950.025n

* CHECK dout1_63 Vdout1_63ck189 = 0 time = 950
.meas tran vdout1_63ck189 FIND v(dout1_63) AT=950.025n

* CHECK dout1_64 Vdout1_64ck189 = 0.9 time = 950
.meas tran vdout1_64ck189 FIND v(dout1_64) AT=950.025n

* CHECK dout1_65 Vdout1_65ck189 = 0.9 time = 950
.meas tran vdout1_65ck189 FIND v(dout1_65) AT=950.025n

* CHECK dout1_66 Vdout1_66ck189 = 0.9 time = 950
.meas tran vdout1_66ck189 FIND v(dout1_66) AT=950.025n

* CHECK dout1_67 Vdout1_67ck189 = 0 time = 950
.meas tran vdout1_67ck189 FIND v(dout1_67) AT=950.025n

* CHECK dout1_68 Vdout1_68ck189 = 0 time = 950
.meas tran vdout1_68ck189 FIND v(dout1_68) AT=950.025n

* CHECK dout1_69 Vdout1_69ck189 = 0.9 time = 950
.meas tran vdout1_69ck189 FIND v(dout1_69) AT=950.025n

* CHECK dout1_70 Vdout1_70ck189 = 0.9 time = 950
.meas tran vdout1_70ck189 FIND v(dout1_70) AT=950.025n

* CHECK dout1_71 Vdout1_71ck189 = 0.9 time = 950
.meas tran vdout1_71ck189 FIND v(dout1_71) AT=950.025n

* CHECK dout1_72 Vdout1_72ck189 = 0 time = 950
.meas tran vdout1_72ck189 FIND v(dout1_72) AT=950.025n

* CHECK dout1_73 Vdout1_73ck189 = 0.9 time = 950
.meas tran vdout1_73ck189 FIND v(dout1_73) AT=950.025n

* CHECK dout1_74 Vdout1_74ck189 = 0.9 time = 950
.meas tran vdout1_74ck189 FIND v(dout1_74) AT=950.025n

* CHECK dout1_75 Vdout1_75ck189 = 0.9 time = 950
.meas tran vdout1_75ck189 FIND v(dout1_75) AT=950.025n

* CHECK dout1_76 Vdout1_76ck189 = 0.9 time = 950
.meas tran vdout1_76ck189 FIND v(dout1_76) AT=950.025n

* CHECK dout1_77 Vdout1_77ck189 = 0 time = 950
.meas tran vdout1_77ck189 FIND v(dout1_77) AT=950.025n

* CHECK dout1_78 Vdout1_78ck189 = 0 time = 950
.meas tran vdout1_78ck189 FIND v(dout1_78) AT=950.025n

* CHECK dout1_79 Vdout1_79ck189 = 0 time = 950
.meas tran vdout1_79ck189 FIND v(dout1_79) AT=950.025n

* CHECK dout1_80 Vdout1_80ck189 = 0 time = 950
.meas tran vdout1_80ck189 FIND v(dout1_80) AT=950.025n

* CHECK dout1_81 Vdout1_81ck189 = 0 time = 950
.meas tran vdout1_81ck189 FIND v(dout1_81) AT=950.025n

* CHECK dout1_82 Vdout1_82ck189 = 0.9 time = 950
.meas tran vdout1_82ck189 FIND v(dout1_82) AT=950.025n

* CHECK dout1_83 Vdout1_83ck189 = 0.9 time = 950
.meas tran vdout1_83ck189 FIND v(dout1_83) AT=950.025n

* CHECK dout1_84 Vdout1_84ck189 = 0.9 time = 950
.meas tran vdout1_84ck189 FIND v(dout1_84) AT=950.025n

* CHECK dout1_85 Vdout1_85ck189 = 0.9 time = 950
.meas tran vdout1_85ck189 FIND v(dout1_85) AT=950.025n

* CHECK dout1_86 Vdout1_86ck189 = 0.9 time = 950
.meas tran vdout1_86ck189 FIND v(dout1_86) AT=950.025n

* CHECK dout1_87 Vdout1_87ck189 = 0.9 time = 950
.meas tran vdout1_87ck189 FIND v(dout1_87) AT=950.025n

* CHECK dout1_88 Vdout1_88ck189 = 0 time = 950
.meas tran vdout1_88ck189 FIND v(dout1_88) AT=950.025n

* CHECK dout1_89 Vdout1_89ck189 = 0.9 time = 950
.meas tran vdout1_89ck189 FIND v(dout1_89) AT=950.025n

* CHECK dout1_90 Vdout1_90ck189 = 0 time = 950
.meas tran vdout1_90ck189 FIND v(dout1_90) AT=950.025n

* CHECK dout1_91 Vdout1_91ck189 = 0.9 time = 950
.meas tran vdout1_91ck189 FIND v(dout1_91) AT=950.025n

* CHECK dout1_92 Vdout1_92ck189 = 0 time = 950
.meas tran vdout1_92ck189 FIND v(dout1_92) AT=950.025n

* CHECK dout1_93 Vdout1_93ck189 = 0.9 time = 950
.meas tran vdout1_93ck189 FIND v(dout1_93) AT=950.025n

* CHECK dout1_94 Vdout1_94ck189 = 0 time = 950
.meas tran vdout1_94ck189 FIND v(dout1_94) AT=950.025n

* CHECK dout1_95 Vdout1_95ck189 = 0 time = 950
.meas tran vdout1_95ck189 FIND v(dout1_95) AT=950.025n

* CHECK dout1_96 Vdout1_96ck189 = 0.9 time = 950
.meas tran vdout1_96ck189 FIND v(dout1_96) AT=950.025n

* CHECK dout1_97 Vdout1_97ck189 = 0.9 time = 950
.meas tran vdout1_97ck189 FIND v(dout1_97) AT=950.025n

* CHECK dout1_98 Vdout1_98ck189 = 0.9 time = 950
.meas tran vdout1_98ck189 FIND v(dout1_98) AT=950.025n

* CHECK dout1_99 Vdout1_99ck189 = 0 time = 950
.meas tran vdout1_99ck189 FIND v(dout1_99) AT=950.025n

* CHECK dout1_100 Vdout1_100ck189 = 0 time = 950
.meas tran vdout1_100ck189 FIND v(dout1_100) AT=950.025n

* CHECK dout1_101 Vdout1_101ck189 = 0.9 time = 950
.meas tran vdout1_101ck189 FIND v(dout1_101) AT=950.025n

* CHECK dout1_102 Vdout1_102ck189 = 0.9 time = 950
.meas tran vdout1_102ck189 FIND v(dout1_102) AT=950.025n

* CHECK dout1_103 Vdout1_103ck189 = 0 time = 950
.meas tran vdout1_103ck189 FIND v(dout1_103) AT=950.025n

* CHECK dout1_104 Vdout1_104ck189 = 0 time = 950
.meas tran vdout1_104ck189 FIND v(dout1_104) AT=950.025n

* CHECK dout1_105 Vdout1_105ck189 = 0.9 time = 950
.meas tran vdout1_105ck189 FIND v(dout1_105) AT=950.025n

* CHECK dout1_106 Vdout1_106ck189 = 0 time = 950
.meas tran vdout1_106ck189 FIND v(dout1_106) AT=950.025n

* CHECK dout1_107 Vdout1_107ck189 = 0.9 time = 950
.meas tran vdout1_107ck189 FIND v(dout1_107) AT=950.025n

* CHECK dout1_108 Vdout1_108ck189 = 0 time = 950
.meas tran vdout1_108ck189 FIND v(dout1_108) AT=950.025n

* CHECK dout1_109 Vdout1_109ck189 = 0.9 time = 950
.meas tran vdout1_109ck189 FIND v(dout1_109) AT=950.025n

* CHECK dout1_110 Vdout1_110ck189 = 0 time = 950
.meas tran vdout1_110ck189 FIND v(dout1_110) AT=950.025n

* CHECK dout1_111 Vdout1_111ck189 = 0.9 time = 950
.meas tran vdout1_111ck189 FIND v(dout1_111) AT=950.025n

* CHECK dout1_112 Vdout1_112ck189 = 0.9 time = 950
.meas tran vdout1_112ck189 FIND v(dout1_112) AT=950.025n

* CHECK dout1_113 Vdout1_113ck189 = 0.9 time = 950
.meas tran vdout1_113ck189 FIND v(dout1_113) AT=950.025n

* CHECK dout1_114 Vdout1_114ck189 = 0.9 time = 950
.meas tran vdout1_114ck189 FIND v(dout1_114) AT=950.025n

* CHECK dout1_115 Vdout1_115ck189 = 0 time = 950
.meas tran vdout1_115ck189 FIND v(dout1_115) AT=950.025n

* CHECK dout1_116 Vdout1_116ck189 = 0.9 time = 950
.meas tran vdout1_116ck189 FIND v(dout1_116) AT=950.025n

* CHECK dout1_117 Vdout1_117ck189 = 0 time = 950
.meas tran vdout1_117ck189 FIND v(dout1_117) AT=950.025n

* CHECK dout1_118 Vdout1_118ck189 = 0 time = 950
.meas tran vdout1_118ck189 FIND v(dout1_118) AT=950.025n

* CHECK dout1_119 Vdout1_119ck189 = 0.9 time = 950
.meas tran vdout1_119ck189 FIND v(dout1_119) AT=950.025n

* CHECK dout1_0 Vdout1_0ck190 = 0 time = 955
.meas tran vdout1_0ck190 FIND v(dout1_0) AT=955.025n

* CHECK dout1_1 Vdout1_1ck190 = 0 time = 955
.meas tran vdout1_1ck190 FIND v(dout1_1) AT=955.025n

* CHECK dout1_2 Vdout1_2ck190 = 0.9 time = 955
.meas tran vdout1_2ck190 FIND v(dout1_2) AT=955.025n

* CHECK dout1_3 Vdout1_3ck190 = 0.9 time = 955
.meas tran vdout1_3ck190 FIND v(dout1_3) AT=955.025n

* CHECK dout1_4 Vdout1_4ck190 = 0 time = 955
.meas tran vdout1_4ck190 FIND v(dout1_4) AT=955.025n

* CHECK dout1_5 Vdout1_5ck190 = 0 time = 955
.meas tran vdout1_5ck190 FIND v(dout1_5) AT=955.025n

* CHECK dout1_6 Vdout1_6ck190 = 0.9 time = 955
.meas tran vdout1_6ck190 FIND v(dout1_6) AT=955.025n

* CHECK dout1_7 Vdout1_7ck190 = 0 time = 955
.meas tran vdout1_7ck190 FIND v(dout1_7) AT=955.025n

* CHECK dout1_8 Vdout1_8ck190 = 0.9 time = 955
.meas tran vdout1_8ck190 FIND v(dout1_8) AT=955.025n

* CHECK dout1_9 Vdout1_9ck190 = 0 time = 955
.meas tran vdout1_9ck190 FIND v(dout1_9) AT=955.025n

* CHECK dout1_10 Vdout1_10ck190 = 0 time = 955
.meas tran vdout1_10ck190 FIND v(dout1_10) AT=955.025n

* CHECK dout1_11 Vdout1_11ck190 = 0.9 time = 955
.meas tran vdout1_11ck190 FIND v(dout1_11) AT=955.025n

* CHECK dout1_12 Vdout1_12ck190 = 0.9 time = 955
.meas tran vdout1_12ck190 FIND v(dout1_12) AT=955.025n

* CHECK dout1_13 Vdout1_13ck190 = 0 time = 955
.meas tran vdout1_13ck190 FIND v(dout1_13) AT=955.025n

* CHECK dout1_14 Vdout1_14ck190 = 0 time = 955
.meas tran vdout1_14ck190 FIND v(dout1_14) AT=955.025n

* CHECK dout1_15 Vdout1_15ck190 = 0 time = 955
.meas tran vdout1_15ck190 FIND v(dout1_15) AT=955.025n

* CHECK dout1_16 Vdout1_16ck190 = 0 time = 955
.meas tran vdout1_16ck190 FIND v(dout1_16) AT=955.025n

* CHECK dout1_17 Vdout1_17ck190 = 0.9 time = 955
.meas tran vdout1_17ck190 FIND v(dout1_17) AT=955.025n

* CHECK dout1_18 Vdout1_18ck190 = 0.9 time = 955
.meas tran vdout1_18ck190 FIND v(dout1_18) AT=955.025n

* CHECK dout1_19 Vdout1_19ck190 = 0.9 time = 955
.meas tran vdout1_19ck190 FIND v(dout1_19) AT=955.025n

* CHECK dout1_20 Vdout1_20ck190 = 0.9 time = 955
.meas tran vdout1_20ck190 FIND v(dout1_20) AT=955.025n

* CHECK dout1_21 Vdout1_21ck190 = 0.9 time = 955
.meas tran vdout1_21ck190 FIND v(dout1_21) AT=955.025n

* CHECK dout1_22 Vdout1_22ck190 = 0.9 time = 955
.meas tran vdout1_22ck190 FIND v(dout1_22) AT=955.025n

* CHECK dout1_23 Vdout1_23ck190 = 0.9 time = 955
.meas tran vdout1_23ck190 FIND v(dout1_23) AT=955.025n

* CHECK dout1_24 Vdout1_24ck190 = 0 time = 955
.meas tran vdout1_24ck190 FIND v(dout1_24) AT=955.025n

* CHECK dout1_25 Vdout1_25ck190 = 0.9 time = 955
.meas tran vdout1_25ck190 FIND v(dout1_25) AT=955.025n

* CHECK dout1_26 Vdout1_26ck190 = 0.9 time = 955
.meas tran vdout1_26ck190 FIND v(dout1_26) AT=955.025n

* CHECK dout1_27 Vdout1_27ck190 = 0 time = 955
.meas tran vdout1_27ck190 FIND v(dout1_27) AT=955.025n

* CHECK dout1_28 Vdout1_28ck190 = 0 time = 955
.meas tran vdout1_28ck190 FIND v(dout1_28) AT=955.025n

* CHECK dout1_29 Vdout1_29ck190 = 0 time = 955
.meas tran vdout1_29ck190 FIND v(dout1_29) AT=955.025n

* CHECK dout1_30 Vdout1_30ck190 = 0.9 time = 955
.meas tran vdout1_30ck190 FIND v(dout1_30) AT=955.025n

* CHECK dout1_31 Vdout1_31ck190 = 0 time = 955
.meas tran vdout1_31ck190 FIND v(dout1_31) AT=955.025n

* CHECK dout1_32 Vdout1_32ck190 = 0 time = 955
.meas tran vdout1_32ck190 FIND v(dout1_32) AT=955.025n

* CHECK dout1_33 Vdout1_33ck190 = 0 time = 955
.meas tran vdout1_33ck190 FIND v(dout1_33) AT=955.025n

* CHECK dout1_34 Vdout1_34ck190 = 0 time = 955
.meas tran vdout1_34ck190 FIND v(dout1_34) AT=955.025n

* CHECK dout1_35 Vdout1_35ck190 = 0.9 time = 955
.meas tran vdout1_35ck190 FIND v(dout1_35) AT=955.025n

* CHECK dout1_36 Vdout1_36ck190 = 0 time = 955
.meas tran vdout1_36ck190 FIND v(dout1_36) AT=955.025n

* CHECK dout1_37 Vdout1_37ck190 = 0 time = 955
.meas tran vdout1_37ck190 FIND v(dout1_37) AT=955.025n

* CHECK dout1_38 Vdout1_38ck190 = 0.9 time = 955
.meas tran vdout1_38ck190 FIND v(dout1_38) AT=955.025n

* CHECK dout1_39 Vdout1_39ck190 = 0.9 time = 955
.meas tran vdout1_39ck190 FIND v(dout1_39) AT=955.025n

* CHECK dout1_40 Vdout1_40ck190 = 0.9 time = 955
.meas tran vdout1_40ck190 FIND v(dout1_40) AT=955.025n

* CHECK dout1_41 Vdout1_41ck190 = 0 time = 955
.meas tran vdout1_41ck190 FIND v(dout1_41) AT=955.025n

* CHECK dout1_42 Vdout1_42ck190 = 0 time = 955
.meas tran vdout1_42ck190 FIND v(dout1_42) AT=955.025n

* CHECK dout1_43 Vdout1_43ck190 = 0 time = 955
.meas tran vdout1_43ck190 FIND v(dout1_43) AT=955.025n

* CHECK dout1_44 Vdout1_44ck190 = 0.9 time = 955
.meas tran vdout1_44ck190 FIND v(dout1_44) AT=955.025n

* CHECK dout1_45 Vdout1_45ck190 = 0 time = 955
.meas tran vdout1_45ck190 FIND v(dout1_45) AT=955.025n

* CHECK dout1_46 Vdout1_46ck190 = 0 time = 955
.meas tran vdout1_46ck190 FIND v(dout1_46) AT=955.025n

* CHECK dout1_47 Vdout1_47ck190 = 0.9 time = 955
.meas tran vdout1_47ck190 FIND v(dout1_47) AT=955.025n

* CHECK dout1_48 Vdout1_48ck190 = 0.9 time = 955
.meas tran vdout1_48ck190 FIND v(dout1_48) AT=955.025n

* CHECK dout1_49 Vdout1_49ck190 = 0.9 time = 955
.meas tran vdout1_49ck190 FIND v(dout1_49) AT=955.025n

* CHECK dout1_50 Vdout1_50ck190 = 0.9 time = 955
.meas tran vdout1_50ck190 FIND v(dout1_50) AT=955.025n

* CHECK dout1_51 Vdout1_51ck190 = 0.9 time = 955
.meas tran vdout1_51ck190 FIND v(dout1_51) AT=955.025n

* CHECK dout1_52 Vdout1_52ck190 = 0.9 time = 955
.meas tran vdout1_52ck190 FIND v(dout1_52) AT=955.025n

* CHECK dout1_53 Vdout1_53ck190 = 0.9 time = 955
.meas tran vdout1_53ck190 FIND v(dout1_53) AT=955.025n

* CHECK dout1_54 Vdout1_54ck190 = 0 time = 955
.meas tran vdout1_54ck190 FIND v(dout1_54) AT=955.025n

* CHECK dout1_55 Vdout1_55ck190 = 0 time = 955
.meas tran vdout1_55ck190 FIND v(dout1_55) AT=955.025n

* CHECK dout1_56 Vdout1_56ck190 = 0.9 time = 955
.meas tran vdout1_56ck190 FIND v(dout1_56) AT=955.025n

* CHECK dout1_57 Vdout1_57ck190 = 0 time = 955
.meas tran vdout1_57ck190 FIND v(dout1_57) AT=955.025n

* CHECK dout1_58 Vdout1_58ck190 = 0 time = 955
.meas tran vdout1_58ck190 FIND v(dout1_58) AT=955.025n

* CHECK dout1_59 Vdout1_59ck190 = 0 time = 955
.meas tran vdout1_59ck190 FIND v(dout1_59) AT=955.025n

* CHECK dout1_60 Vdout1_60ck190 = 0 time = 955
.meas tran vdout1_60ck190 FIND v(dout1_60) AT=955.025n

* CHECK dout1_61 Vdout1_61ck190 = 0.9 time = 955
.meas tran vdout1_61ck190 FIND v(dout1_61) AT=955.025n

* CHECK dout1_62 Vdout1_62ck190 = 0 time = 955
.meas tran vdout1_62ck190 FIND v(dout1_62) AT=955.025n

* CHECK dout1_63 Vdout1_63ck190 = 0 time = 955
.meas tran vdout1_63ck190 FIND v(dout1_63) AT=955.025n

* CHECK dout1_64 Vdout1_64ck190 = 0.9 time = 955
.meas tran vdout1_64ck190 FIND v(dout1_64) AT=955.025n

* CHECK dout1_65 Vdout1_65ck190 = 0.9 time = 955
.meas tran vdout1_65ck190 FIND v(dout1_65) AT=955.025n

* CHECK dout1_66 Vdout1_66ck190 = 0.9 time = 955
.meas tran vdout1_66ck190 FIND v(dout1_66) AT=955.025n

* CHECK dout1_67 Vdout1_67ck190 = 0 time = 955
.meas tran vdout1_67ck190 FIND v(dout1_67) AT=955.025n

* CHECK dout1_68 Vdout1_68ck190 = 0 time = 955
.meas tran vdout1_68ck190 FIND v(dout1_68) AT=955.025n

* CHECK dout1_69 Vdout1_69ck190 = 0.9 time = 955
.meas tran vdout1_69ck190 FIND v(dout1_69) AT=955.025n

* CHECK dout1_70 Vdout1_70ck190 = 0.9 time = 955
.meas tran vdout1_70ck190 FIND v(dout1_70) AT=955.025n

* CHECK dout1_71 Vdout1_71ck190 = 0.9 time = 955
.meas tran vdout1_71ck190 FIND v(dout1_71) AT=955.025n

* CHECK dout1_72 Vdout1_72ck190 = 0 time = 955
.meas tran vdout1_72ck190 FIND v(dout1_72) AT=955.025n

* CHECK dout1_73 Vdout1_73ck190 = 0.9 time = 955
.meas tran vdout1_73ck190 FIND v(dout1_73) AT=955.025n

* CHECK dout1_74 Vdout1_74ck190 = 0.9 time = 955
.meas tran vdout1_74ck190 FIND v(dout1_74) AT=955.025n

* CHECK dout1_75 Vdout1_75ck190 = 0.9 time = 955
.meas tran vdout1_75ck190 FIND v(dout1_75) AT=955.025n

* CHECK dout1_76 Vdout1_76ck190 = 0.9 time = 955
.meas tran vdout1_76ck190 FIND v(dout1_76) AT=955.025n

* CHECK dout1_77 Vdout1_77ck190 = 0 time = 955
.meas tran vdout1_77ck190 FIND v(dout1_77) AT=955.025n

* CHECK dout1_78 Vdout1_78ck190 = 0 time = 955
.meas tran vdout1_78ck190 FIND v(dout1_78) AT=955.025n

* CHECK dout1_79 Vdout1_79ck190 = 0 time = 955
.meas tran vdout1_79ck190 FIND v(dout1_79) AT=955.025n

* CHECK dout1_80 Vdout1_80ck190 = 0 time = 955
.meas tran vdout1_80ck190 FIND v(dout1_80) AT=955.025n

* CHECK dout1_81 Vdout1_81ck190 = 0 time = 955
.meas tran vdout1_81ck190 FIND v(dout1_81) AT=955.025n

* CHECK dout1_82 Vdout1_82ck190 = 0.9 time = 955
.meas tran vdout1_82ck190 FIND v(dout1_82) AT=955.025n

* CHECK dout1_83 Vdout1_83ck190 = 0.9 time = 955
.meas tran vdout1_83ck190 FIND v(dout1_83) AT=955.025n

* CHECK dout1_84 Vdout1_84ck190 = 0.9 time = 955
.meas tran vdout1_84ck190 FIND v(dout1_84) AT=955.025n

* CHECK dout1_85 Vdout1_85ck190 = 0.9 time = 955
.meas tran vdout1_85ck190 FIND v(dout1_85) AT=955.025n

* CHECK dout1_86 Vdout1_86ck190 = 0.9 time = 955
.meas tran vdout1_86ck190 FIND v(dout1_86) AT=955.025n

* CHECK dout1_87 Vdout1_87ck190 = 0.9 time = 955
.meas tran vdout1_87ck190 FIND v(dout1_87) AT=955.025n

* CHECK dout1_88 Vdout1_88ck190 = 0 time = 955
.meas tran vdout1_88ck190 FIND v(dout1_88) AT=955.025n

* CHECK dout1_89 Vdout1_89ck190 = 0.9 time = 955
.meas tran vdout1_89ck190 FIND v(dout1_89) AT=955.025n

* CHECK dout1_90 Vdout1_90ck190 = 0 time = 955
.meas tran vdout1_90ck190 FIND v(dout1_90) AT=955.025n

* CHECK dout1_91 Vdout1_91ck190 = 0.9 time = 955
.meas tran vdout1_91ck190 FIND v(dout1_91) AT=955.025n

* CHECK dout1_92 Vdout1_92ck190 = 0 time = 955
.meas tran vdout1_92ck190 FIND v(dout1_92) AT=955.025n

* CHECK dout1_93 Vdout1_93ck190 = 0.9 time = 955
.meas tran vdout1_93ck190 FIND v(dout1_93) AT=955.025n

* CHECK dout1_94 Vdout1_94ck190 = 0 time = 955
.meas tran vdout1_94ck190 FIND v(dout1_94) AT=955.025n

* CHECK dout1_95 Vdout1_95ck190 = 0 time = 955
.meas tran vdout1_95ck190 FIND v(dout1_95) AT=955.025n

* CHECK dout1_96 Vdout1_96ck190 = 0.9 time = 955
.meas tran vdout1_96ck190 FIND v(dout1_96) AT=955.025n

* CHECK dout1_97 Vdout1_97ck190 = 0.9 time = 955
.meas tran vdout1_97ck190 FIND v(dout1_97) AT=955.025n

* CHECK dout1_98 Vdout1_98ck190 = 0.9 time = 955
.meas tran vdout1_98ck190 FIND v(dout1_98) AT=955.025n

* CHECK dout1_99 Vdout1_99ck190 = 0 time = 955
.meas tran vdout1_99ck190 FIND v(dout1_99) AT=955.025n

* CHECK dout1_100 Vdout1_100ck190 = 0 time = 955
.meas tran vdout1_100ck190 FIND v(dout1_100) AT=955.025n

* CHECK dout1_101 Vdout1_101ck190 = 0.9 time = 955
.meas tran vdout1_101ck190 FIND v(dout1_101) AT=955.025n

* CHECK dout1_102 Vdout1_102ck190 = 0.9 time = 955
.meas tran vdout1_102ck190 FIND v(dout1_102) AT=955.025n

* CHECK dout1_103 Vdout1_103ck190 = 0 time = 955
.meas tran vdout1_103ck190 FIND v(dout1_103) AT=955.025n

* CHECK dout1_104 Vdout1_104ck190 = 0 time = 955
.meas tran vdout1_104ck190 FIND v(dout1_104) AT=955.025n

* CHECK dout1_105 Vdout1_105ck190 = 0.9 time = 955
.meas tran vdout1_105ck190 FIND v(dout1_105) AT=955.025n

* CHECK dout1_106 Vdout1_106ck190 = 0 time = 955
.meas tran vdout1_106ck190 FIND v(dout1_106) AT=955.025n

* CHECK dout1_107 Vdout1_107ck190 = 0.9 time = 955
.meas tran vdout1_107ck190 FIND v(dout1_107) AT=955.025n

* CHECK dout1_108 Vdout1_108ck190 = 0 time = 955
.meas tran vdout1_108ck190 FIND v(dout1_108) AT=955.025n

* CHECK dout1_109 Vdout1_109ck190 = 0.9 time = 955
.meas tran vdout1_109ck190 FIND v(dout1_109) AT=955.025n

* CHECK dout1_110 Vdout1_110ck190 = 0 time = 955
.meas tran vdout1_110ck190 FIND v(dout1_110) AT=955.025n

* CHECK dout1_111 Vdout1_111ck190 = 0.9 time = 955
.meas tran vdout1_111ck190 FIND v(dout1_111) AT=955.025n

* CHECK dout1_112 Vdout1_112ck190 = 0.9 time = 955
.meas tran vdout1_112ck190 FIND v(dout1_112) AT=955.025n

* CHECK dout1_113 Vdout1_113ck190 = 0.9 time = 955
.meas tran vdout1_113ck190 FIND v(dout1_113) AT=955.025n

* CHECK dout1_114 Vdout1_114ck190 = 0.9 time = 955
.meas tran vdout1_114ck190 FIND v(dout1_114) AT=955.025n

* CHECK dout1_115 Vdout1_115ck190 = 0 time = 955
.meas tran vdout1_115ck190 FIND v(dout1_115) AT=955.025n

* CHECK dout1_116 Vdout1_116ck190 = 0.9 time = 955
.meas tran vdout1_116ck190 FIND v(dout1_116) AT=955.025n

* CHECK dout1_117 Vdout1_117ck190 = 0 time = 955
.meas tran vdout1_117ck190 FIND v(dout1_117) AT=955.025n

* CHECK dout1_118 Vdout1_118ck190 = 0 time = 955
.meas tran vdout1_118ck190 FIND v(dout1_118) AT=955.025n

* CHECK dout1_119 Vdout1_119ck190 = 0.9 time = 955
.meas tran vdout1_119ck190 FIND v(dout1_119) AT=955.025n

* CHECK dout1_0 Vdout1_0ck192 = 0 time = 965
.meas tran vdout1_0ck192 FIND v(dout1_0) AT=965.025n

* CHECK dout1_1 Vdout1_1ck192 = 0 time = 965
.meas tran vdout1_1ck192 FIND v(dout1_1) AT=965.025n

* CHECK dout1_2 Vdout1_2ck192 = 0.9 time = 965
.meas tran vdout1_2ck192 FIND v(dout1_2) AT=965.025n

* CHECK dout1_3 Vdout1_3ck192 = 0.9 time = 965
.meas tran vdout1_3ck192 FIND v(dout1_3) AT=965.025n

* CHECK dout1_4 Vdout1_4ck192 = 0 time = 965
.meas tran vdout1_4ck192 FIND v(dout1_4) AT=965.025n

* CHECK dout1_5 Vdout1_5ck192 = 0 time = 965
.meas tran vdout1_5ck192 FIND v(dout1_5) AT=965.025n

* CHECK dout1_6 Vdout1_6ck192 = 0.9 time = 965
.meas tran vdout1_6ck192 FIND v(dout1_6) AT=965.025n

* CHECK dout1_7 Vdout1_7ck192 = 0 time = 965
.meas tran vdout1_7ck192 FIND v(dout1_7) AT=965.025n

* CHECK dout1_8 Vdout1_8ck192 = 0.9 time = 965
.meas tran vdout1_8ck192 FIND v(dout1_8) AT=965.025n

* CHECK dout1_9 Vdout1_9ck192 = 0 time = 965
.meas tran vdout1_9ck192 FIND v(dout1_9) AT=965.025n

* CHECK dout1_10 Vdout1_10ck192 = 0 time = 965
.meas tran vdout1_10ck192 FIND v(dout1_10) AT=965.025n

* CHECK dout1_11 Vdout1_11ck192 = 0.9 time = 965
.meas tran vdout1_11ck192 FIND v(dout1_11) AT=965.025n

* CHECK dout1_12 Vdout1_12ck192 = 0.9 time = 965
.meas tran vdout1_12ck192 FIND v(dout1_12) AT=965.025n

* CHECK dout1_13 Vdout1_13ck192 = 0 time = 965
.meas tran vdout1_13ck192 FIND v(dout1_13) AT=965.025n

* CHECK dout1_14 Vdout1_14ck192 = 0 time = 965
.meas tran vdout1_14ck192 FIND v(dout1_14) AT=965.025n

* CHECK dout1_15 Vdout1_15ck192 = 0 time = 965
.meas tran vdout1_15ck192 FIND v(dout1_15) AT=965.025n

* CHECK dout1_16 Vdout1_16ck192 = 0 time = 965
.meas tran vdout1_16ck192 FIND v(dout1_16) AT=965.025n

* CHECK dout1_17 Vdout1_17ck192 = 0.9 time = 965
.meas tran vdout1_17ck192 FIND v(dout1_17) AT=965.025n

* CHECK dout1_18 Vdout1_18ck192 = 0.9 time = 965
.meas tran vdout1_18ck192 FIND v(dout1_18) AT=965.025n

* CHECK dout1_19 Vdout1_19ck192 = 0.9 time = 965
.meas tran vdout1_19ck192 FIND v(dout1_19) AT=965.025n

* CHECK dout1_20 Vdout1_20ck192 = 0.9 time = 965
.meas tran vdout1_20ck192 FIND v(dout1_20) AT=965.025n

* CHECK dout1_21 Vdout1_21ck192 = 0.9 time = 965
.meas tran vdout1_21ck192 FIND v(dout1_21) AT=965.025n

* CHECK dout1_22 Vdout1_22ck192 = 0.9 time = 965
.meas tran vdout1_22ck192 FIND v(dout1_22) AT=965.025n

* CHECK dout1_23 Vdout1_23ck192 = 0.9 time = 965
.meas tran vdout1_23ck192 FIND v(dout1_23) AT=965.025n

* CHECK dout1_24 Vdout1_24ck192 = 0 time = 965
.meas tran vdout1_24ck192 FIND v(dout1_24) AT=965.025n

* CHECK dout1_25 Vdout1_25ck192 = 0.9 time = 965
.meas tran vdout1_25ck192 FIND v(dout1_25) AT=965.025n

* CHECK dout1_26 Vdout1_26ck192 = 0.9 time = 965
.meas tran vdout1_26ck192 FIND v(dout1_26) AT=965.025n

* CHECK dout1_27 Vdout1_27ck192 = 0 time = 965
.meas tran vdout1_27ck192 FIND v(dout1_27) AT=965.025n

* CHECK dout1_28 Vdout1_28ck192 = 0 time = 965
.meas tran vdout1_28ck192 FIND v(dout1_28) AT=965.025n

* CHECK dout1_29 Vdout1_29ck192 = 0 time = 965
.meas tran vdout1_29ck192 FIND v(dout1_29) AT=965.025n

* CHECK dout1_30 Vdout1_30ck192 = 0.9 time = 965
.meas tran vdout1_30ck192 FIND v(dout1_30) AT=965.025n

* CHECK dout1_31 Vdout1_31ck192 = 0 time = 965
.meas tran vdout1_31ck192 FIND v(dout1_31) AT=965.025n

* CHECK dout1_32 Vdout1_32ck192 = 0 time = 965
.meas tran vdout1_32ck192 FIND v(dout1_32) AT=965.025n

* CHECK dout1_33 Vdout1_33ck192 = 0 time = 965
.meas tran vdout1_33ck192 FIND v(dout1_33) AT=965.025n

* CHECK dout1_34 Vdout1_34ck192 = 0 time = 965
.meas tran vdout1_34ck192 FIND v(dout1_34) AT=965.025n

* CHECK dout1_35 Vdout1_35ck192 = 0.9 time = 965
.meas tran vdout1_35ck192 FIND v(dout1_35) AT=965.025n

* CHECK dout1_36 Vdout1_36ck192 = 0 time = 965
.meas tran vdout1_36ck192 FIND v(dout1_36) AT=965.025n

* CHECK dout1_37 Vdout1_37ck192 = 0 time = 965
.meas tran vdout1_37ck192 FIND v(dout1_37) AT=965.025n

* CHECK dout1_38 Vdout1_38ck192 = 0.9 time = 965
.meas tran vdout1_38ck192 FIND v(dout1_38) AT=965.025n

* CHECK dout1_39 Vdout1_39ck192 = 0.9 time = 965
.meas tran vdout1_39ck192 FIND v(dout1_39) AT=965.025n

* CHECK dout1_40 Vdout1_40ck192 = 0.9 time = 965
.meas tran vdout1_40ck192 FIND v(dout1_40) AT=965.025n

* CHECK dout1_41 Vdout1_41ck192 = 0 time = 965
.meas tran vdout1_41ck192 FIND v(dout1_41) AT=965.025n

* CHECK dout1_42 Vdout1_42ck192 = 0 time = 965
.meas tran vdout1_42ck192 FIND v(dout1_42) AT=965.025n

* CHECK dout1_43 Vdout1_43ck192 = 0 time = 965
.meas tran vdout1_43ck192 FIND v(dout1_43) AT=965.025n

* CHECK dout1_44 Vdout1_44ck192 = 0.9 time = 965
.meas tran vdout1_44ck192 FIND v(dout1_44) AT=965.025n

* CHECK dout1_45 Vdout1_45ck192 = 0 time = 965
.meas tran vdout1_45ck192 FIND v(dout1_45) AT=965.025n

* CHECK dout1_46 Vdout1_46ck192 = 0 time = 965
.meas tran vdout1_46ck192 FIND v(dout1_46) AT=965.025n

* CHECK dout1_47 Vdout1_47ck192 = 0.9 time = 965
.meas tran vdout1_47ck192 FIND v(dout1_47) AT=965.025n

* CHECK dout1_48 Vdout1_48ck192 = 0.9 time = 965
.meas tran vdout1_48ck192 FIND v(dout1_48) AT=965.025n

* CHECK dout1_49 Vdout1_49ck192 = 0.9 time = 965
.meas tran vdout1_49ck192 FIND v(dout1_49) AT=965.025n

* CHECK dout1_50 Vdout1_50ck192 = 0.9 time = 965
.meas tran vdout1_50ck192 FIND v(dout1_50) AT=965.025n

* CHECK dout1_51 Vdout1_51ck192 = 0.9 time = 965
.meas tran vdout1_51ck192 FIND v(dout1_51) AT=965.025n

* CHECK dout1_52 Vdout1_52ck192 = 0.9 time = 965
.meas tran vdout1_52ck192 FIND v(dout1_52) AT=965.025n

* CHECK dout1_53 Vdout1_53ck192 = 0.9 time = 965
.meas tran vdout1_53ck192 FIND v(dout1_53) AT=965.025n

* CHECK dout1_54 Vdout1_54ck192 = 0 time = 965
.meas tran vdout1_54ck192 FIND v(dout1_54) AT=965.025n

* CHECK dout1_55 Vdout1_55ck192 = 0 time = 965
.meas tran vdout1_55ck192 FIND v(dout1_55) AT=965.025n

* CHECK dout1_56 Vdout1_56ck192 = 0.9 time = 965
.meas tran vdout1_56ck192 FIND v(dout1_56) AT=965.025n

* CHECK dout1_57 Vdout1_57ck192 = 0 time = 965
.meas tran vdout1_57ck192 FIND v(dout1_57) AT=965.025n

* CHECK dout1_58 Vdout1_58ck192 = 0 time = 965
.meas tran vdout1_58ck192 FIND v(dout1_58) AT=965.025n

* CHECK dout1_59 Vdout1_59ck192 = 0 time = 965
.meas tran vdout1_59ck192 FIND v(dout1_59) AT=965.025n

* CHECK dout1_60 Vdout1_60ck192 = 0 time = 965
.meas tran vdout1_60ck192 FIND v(dout1_60) AT=965.025n

* CHECK dout1_61 Vdout1_61ck192 = 0.9 time = 965
.meas tran vdout1_61ck192 FIND v(dout1_61) AT=965.025n

* CHECK dout1_62 Vdout1_62ck192 = 0 time = 965
.meas tran vdout1_62ck192 FIND v(dout1_62) AT=965.025n

* CHECK dout1_63 Vdout1_63ck192 = 0 time = 965
.meas tran vdout1_63ck192 FIND v(dout1_63) AT=965.025n

* CHECK dout1_64 Vdout1_64ck192 = 0.9 time = 965
.meas tran vdout1_64ck192 FIND v(dout1_64) AT=965.025n

* CHECK dout1_65 Vdout1_65ck192 = 0.9 time = 965
.meas tran vdout1_65ck192 FIND v(dout1_65) AT=965.025n

* CHECK dout1_66 Vdout1_66ck192 = 0.9 time = 965
.meas tran vdout1_66ck192 FIND v(dout1_66) AT=965.025n

* CHECK dout1_67 Vdout1_67ck192 = 0 time = 965
.meas tran vdout1_67ck192 FIND v(dout1_67) AT=965.025n

* CHECK dout1_68 Vdout1_68ck192 = 0 time = 965
.meas tran vdout1_68ck192 FIND v(dout1_68) AT=965.025n

* CHECK dout1_69 Vdout1_69ck192 = 0.9 time = 965
.meas tran vdout1_69ck192 FIND v(dout1_69) AT=965.025n

* CHECK dout1_70 Vdout1_70ck192 = 0.9 time = 965
.meas tran vdout1_70ck192 FIND v(dout1_70) AT=965.025n

* CHECK dout1_71 Vdout1_71ck192 = 0.9 time = 965
.meas tran vdout1_71ck192 FIND v(dout1_71) AT=965.025n

* CHECK dout1_72 Vdout1_72ck192 = 0 time = 965
.meas tran vdout1_72ck192 FIND v(dout1_72) AT=965.025n

* CHECK dout1_73 Vdout1_73ck192 = 0.9 time = 965
.meas tran vdout1_73ck192 FIND v(dout1_73) AT=965.025n

* CHECK dout1_74 Vdout1_74ck192 = 0.9 time = 965
.meas tran vdout1_74ck192 FIND v(dout1_74) AT=965.025n

* CHECK dout1_75 Vdout1_75ck192 = 0.9 time = 965
.meas tran vdout1_75ck192 FIND v(dout1_75) AT=965.025n

* CHECK dout1_76 Vdout1_76ck192 = 0.9 time = 965
.meas tran vdout1_76ck192 FIND v(dout1_76) AT=965.025n

* CHECK dout1_77 Vdout1_77ck192 = 0 time = 965
.meas tran vdout1_77ck192 FIND v(dout1_77) AT=965.025n

* CHECK dout1_78 Vdout1_78ck192 = 0 time = 965
.meas tran vdout1_78ck192 FIND v(dout1_78) AT=965.025n

* CHECK dout1_79 Vdout1_79ck192 = 0 time = 965
.meas tran vdout1_79ck192 FIND v(dout1_79) AT=965.025n

* CHECK dout1_80 Vdout1_80ck192 = 0 time = 965
.meas tran vdout1_80ck192 FIND v(dout1_80) AT=965.025n

* CHECK dout1_81 Vdout1_81ck192 = 0 time = 965
.meas tran vdout1_81ck192 FIND v(dout1_81) AT=965.025n

* CHECK dout1_82 Vdout1_82ck192 = 0.9 time = 965
.meas tran vdout1_82ck192 FIND v(dout1_82) AT=965.025n

* CHECK dout1_83 Vdout1_83ck192 = 0.9 time = 965
.meas tran vdout1_83ck192 FIND v(dout1_83) AT=965.025n

* CHECK dout1_84 Vdout1_84ck192 = 0.9 time = 965
.meas tran vdout1_84ck192 FIND v(dout1_84) AT=965.025n

* CHECK dout1_85 Vdout1_85ck192 = 0.9 time = 965
.meas tran vdout1_85ck192 FIND v(dout1_85) AT=965.025n

* CHECK dout1_86 Vdout1_86ck192 = 0.9 time = 965
.meas tran vdout1_86ck192 FIND v(dout1_86) AT=965.025n

* CHECK dout1_87 Vdout1_87ck192 = 0.9 time = 965
.meas tran vdout1_87ck192 FIND v(dout1_87) AT=965.025n

* CHECK dout1_88 Vdout1_88ck192 = 0 time = 965
.meas tran vdout1_88ck192 FIND v(dout1_88) AT=965.025n

* CHECK dout1_89 Vdout1_89ck192 = 0.9 time = 965
.meas tran vdout1_89ck192 FIND v(dout1_89) AT=965.025n

* CHECK dout1_90 Vdout1_90ck192 = 0 time = 965
.meas tran vdout1_90ck192 FIND v(dout1_90) AT=965.025n

* CHECK dout1_91 Vdout1_91ck192 = 0.9 time = 965
.meas tran vdout1_91ck192 FIND v(dout1_91) AT=965.025n

* CHECK dout1_92 Vdout1_92ck192 = 0 time = 965
.meas tran vdout1_92ck192 FIND v(dout1_92) AT=965.025n

* CHECK dout1_93 Vdout1_93ck192 = 0.9 time = 965
.meas tran vdout1_93ck192 FIND v(dout1_93) AT=965.025n

* CHECK dout1_94 Vdout1_94ck192 = 0 time = 965
.meas tran vdout1_94ck192 FIND v(dout1_94) AT=965.025n

* CHECK dout1_95 Vdout1_95ck192 = 0 time = 965
.meas tran vdout1_95ck192 FIND v(dout1_95) AT=965.025n

* CHECK dout1_96 Vdout1_96ck192 = 0.9 time = 965
.meas tran vdout1_96ck192 FIND v(dout1_96) AT=965.025n

* CHECK dout1_97 Vdout1_97ck192 = 0.9 time = 965
.meas tran vdout1_97ck192 FIND v(dout1_97) AT=965.025n

* CHECK dout1_98 Vdout1_98ck192 = 0.9 time = 965
.meas tran vdout1_98ck192 FIND v(dout1_98) AT=965.025n

* CHECK dout1_99 Vdout1_99ck192 = 0 time = 965
.meas tran vdout1_99ck192 FIND v(dout1_99) AT=965.025n

* CHECK dout1_100 Vdout1_100ck192 = 0 time = 965
.meas tran vdout1_100ck192 FIND v(dout1_100) AT=965.025n

* CHECK dout1_101 Vdout1_101ck192 = 0.9 time = 965
.meas tran vdout1_101ck192 FIND v(dout1_101) AT=965.025n

* CHECK dout1_102 Vdout1_102ck192 = 0.9 time = 965
.meas tran vdout1_102ck192 FIND v(dout1_102) AT=965.025n

* CHECK dout1_103 Vdout1_103ck192 = 0 time = 965
.meas tran vdout1_103ck192 FIND v(dout1_103) AT=965.025n

* CHECK dout1_104 Vdout1_104ck192 = 0 time = 965
.meas tran vdout1_104ck192 FIND v(dout1_104) AT=965.025n

* CHECK dout1_105 Vdout1_105ck192 = 0.9 time = 965
.meas tran vdout1_105ck192 FIND v(dout1_105) AT=965.025n

* CHECK dout1_106 Vdout1_106ck192 = 0 time = 965
.meas tran vdout1_106ck192 FIND v(dout1_106) AT=965.025n

* CHECK dout1_107 Vdout1_107ck192 = 0.9 time = 965
.meas tran vdout1_107ck192 FIND v(dout1_107) AT=965.025n

* CHECK dout1_108 Vdout1_108ck192 = 0 time = 965
.meas tran vdout1_108ck192 FIND v(dout1_108) AT=965.025n

* CHECK dout1_109 Vdout1_109ck192 = 0.9 time = 965
.meas tran vdout1_109ck192 FIND v(dout1_109) AT=965.025n

* CHECK dout1_110 Vdout1_110ck192 = 0 time = 965
.meas tran vdout1_110ck192 FIND v(dout1_110) AT=965.025n

* CHECK dout1_111 Vdout1_111ck192 = 0.9 time = 965
.meas tran vdout1_111ck192 FIND v(dout1_111) AT=965.025n

* CHECK dout1_112 Vdout1_112ck192 = 0.9 time = 965
.meas tran vdout1_112ck192 FIND v(dout1_112) AT=965.025n

* CHECK dout1_113 Vdout1_113ck192 = 0.9 time = 965
.meas tran vdout1_113ck192 FIND v(dout1_113) AT=965.025n

* CHECK dout1_114 Vdout1_114ck192 = 0.9 time = 965
.meas tran vdout1_114ck192 FIND v(dout1_114) AT=965.025n

* CHECK dout1_115 Vdout1_115ck192 = 0 time = 965
.meas tran vdout1_115ck192 FIND v(dout1_115) AT=965.025n

* CHECK dout1_116 Vdout1_116ck192 = 0.9 time = 965
.meas tran vdout1_116ck192 FIND v(dout1_116) AT=965.025n

* CHECK dout1_117 Vdout1_117ck192 = 0 time = 965
.meas tran vdout1_117ck192 FIND v(dout1_117) AT=965.025n

* CHECK dout1_118 Vdout1_118ck192 = 0 time = 965
.meas tran vdout1_118ck192 FIND v(dout1_118) AT=965.025n

* CHECK dout1_119 Vdout1_119ck192 = 0.9 time = 965
.meas tran vdout1_119ck192 FIND v(dout1_119) AT=965.025n

* CHECK dout1_0 Vdout1_0ck194 = 0 time = 975
.meas tran vdout1_0ck194 FIND v(dout1_0) AT=975.025n

* CHECK dout1_1 Vdout1_1ck194 = 0 time = 975
.meas tran vdout1_1ck194 FIND v(dout1_1) AT=975.025n

* CHECK dout1_2 Vdout1_2ck194 = 0 time = 975
.meas tran vdout1_2ck194 FIND v(dout1_2) AT=975.025n

* CHECK dout1_3 Vdout1_3ck194 = 0 time = 975
.meas tran vdout1_3ck194 FIND v(dout1_3) AT=975.025n

* CHECK dout1_4 Vdout1_4ck194 = 0.9 time = 975
.meas tran vdout1_4ck194 FIND v(dout1_4) AT=975.025n

* CHECK dout1_5 Vdout1_5ck194 = 0.9 time = 975
.meas tran vdout1_5ck194 FIND v(dout1_5) AT=975.025n

* CHECK dout1_6 Vdout1_6ck194 = 0.9 time = 975
.meas tran vdout1_6ck194 FIND v(dout1_6) AT=975.025n

* CHECK dout1_7 Vdout1_7ck194 = 0 time = 975
.meas tran vdout1_7ck194 FIND v(dout1_7) AT=975.025n

* CHECK dout1_8 Vdout1_8ck194 = 0 time = 975
.meas tran vdout1_8ck194 FIND v(dout1_8) AT=975.025n

* CHECK dout1_9 Vdout1_9ck194 = 0.9 time = 975
.meas tran vdout1_9ck194 FIND v(dout1_9) AT=975.025n

* CHECK dout1_10 Vdout1_10ck194 = 0.9 time = 975
.meas tran vdout1_10ck194 FIND v(dout1_10) AT=975.025n

* CHECK dout1_11 Vdout1_11ck194 = 0.9 time = 975
.meas tran vdout1_11ck194 FIND v(dout1_11) AT=975.025n

* CHECK dout1_12 Vdout1_12ck194 = 0 time = 975
.meas tran vdout1_12ck194 FIND v(dout1_12) AT=975.025n

* CHECK dout1_13 Vdout1_13ck194 = 0.9 time = 975
.meas tran vdout1_13ck194 FIND v(dout1_13) AT=975.025n

* CHECK dout1_14 Vdout1_14ck194 = 0 time = 975
.meas tran vdout1_14ck194 FIND v(dout1_14) AT=975.025n

* CHECK dout1_15 Vdout1_15ck194 = 0.9 time = 975
.meas tran vdout1_15ck194 FIND v(dout1_15) AT=975.025n

* CHECK dout1_16 Vdout1_16ck194 = 0.9 time = 975
.meas tran vdout1_16ck194 FIND v(dout1_16) AT=975.025n

* CHECK dout1_17 Vdout1_17ck194 = 0.9 time = 975
.meas tran vdout1_17ck194 FIND v(dout1_17) AT=975.025n

* CHECK dout1_18 Vdout1_18ck194 = 0 time = 975
.meas tran vdout1_18ck194 FIND v(dout1_18) AT=975.025n

* CHECK dout1_19 Vdout1_19ck194 = 0.9 time = 975
.meas tran vdout1_19ck194 FIND v(dout1_19) AT=975.025n

* CHECK dout1_20 Vdout1_20ck194 = 0 time = 975
.meas tran vdout1_20ck194 FIND v(dout1_20) AT=975.025n

* CHECK dout1_21 Vdout1_21ck194 = 0 time = 975
.meas tran vdout1_21ck194 FIND v(dout1_21) AT=975.025n

* CHECK dout1_22 Vdout1_22ck194 = 0 time = 975
.meas tran vdout1_22ck194 FIND v(dout1_22) AT=975.025n

* CHECK dout1_23 Vdout1_23ck194 = 0 time = 975
.meas tran vdout1_23ck194 FIND v(dout1_23) AT=975.025n

* CHECK dout1_24 Vdout1_24ck194 = 0.9 time = 975
.meas tran vdout1_24ck194 FIND v(dout1_24) AT=975.025n

* CHECK dout1_25 Vdout1_25ck194 = 0.9 time = 975
.meas tran vdout1_25ck194 FIND v(dout1_25) AT=975.025n

* CHECK dout1_26 Vdout1_26ck194 = 0.9 time = 975
.meas tran vdout1_26ck194 FIND v(dout1_26) AT=975.025n

* CHECK dout1_27 Vdout1_27ck194 = 0.9 time = 975
.meas tran vdout1_27ck194 FIND v(dout1_27) AT=975.025n

* CHECK dout1_28 Vdout1_28ck194 = 0.9 time = 975
.meas tran vdout1_28ck194 FIND v(dout1_28) AT=975.025n

* CHECK dout1_29 Vdout1_29ck194 = 0 time = 975
.meas tran vdout1_29ck194 FIND v(dout1_29) AT=975.025n

* CHECK dout1_30 Vdout1_30ck194 = 0.9 time = 975
.meas tran vdout1_30ck194 FIND v(dout1_30) AT=975.025n

* CHECK dout1_31 Vdout1_31ck194 = 0.9 time = 975
.meas tran vdout1_31ck194 FIND v(dout1_31) AT=975.025n

* CHECK dout1_32 Vdout1_32ck194 = 0.9 time = 975
.meas tran vdout1_32ck194 FIND v(dout1_32) AT=975.025n

* CHECK dout1_33 Vdout1_33ck194 = 0.9 time = 975
.meas tran vdout1_33ck194 FIND v(dout1_33) AT=975.025n

* CHECK dout1_34 Vdout1_34ck194 = 0 time = 975
.meas tran vdout1_34ck194 FIND v(dout1_34) AT=975.025n

* CHECK dout1_35 Vdout1_35ck194 = 0 time = 975
.meas tran vdout1_35ck194 FIND v(dout1_35) AT=975.025n

* CHECK dout1_36 Vdout1_36ck194 = 0 time = 975
.meas tran vdout1_36ck194 FIND v(dout1_36) AT=975.025n

* CHECK dout1_37 Vdout1_37ck194 = 0 time = 975
.meas tran vdout1_37ck194 FIND v(dout1_37) AT=975.025n

* CHECK dout1_38 Vdout1_38ck194 = 0.9 time = 975
.meas tran vdout1_38ck194 FIND v(dout1_38) AT=975.025n

* CHECK dout1_39 Vdout1_39ck194 = 0.9 time = 975
.meas tran vdout1_39ck194 FIND v(dout1_39) AT=975.025n

* CHECK dout1_40 Vdout1_40ck194 = 0.9 time = 975
.meas tran vdout1_40ck194 FIND v(dout1_40) AT=975.025n

* CHECK dout1_41 Vdout1_41ck194 = 0.9 time = 975
.meas tran vdout1_41ck194 FIND v(dout1_41) AT=975.025n

* CHECK dout1_42 Vdout1_42ck194 = 0 time = 975
.meas tran vdout1_42ck194 FIND v(dout1_42) AT=975.025n

* CHECK dout1_43 Vdout1_43ck194 = 0.9 time = 975
.meas tran vdout1_43ck194 FIND v(dout1_43) AT=975.025n

* CHECK dout1_44 Vdout1_44ck194 = 0.9 time = 975
.meas tran vdout1_44ck194 FIND v(dout1_44) AT=975.025n

* CHECK dout1_45 Vdout1_45ck194 = 0 time = 975
.meas tran vdout1_45ck194 FIND v(dout1_45) AT=975.025n

* CHECK dout1_46 Vdout1_46ck194 = 0.9 time = 975
.meas tran vdout1_46ck194 FIND v(dout1_46) AT=975.025n

* CHECK dout1_47 Vdout1_47ck194 = 0.9 time = 975
.meas tran vdout1_47ck194 FIND v(dout1_47) AT=975.025n

* CHECK dout1_48 Vdout1_48ck194 = 0.9 time = 975
.meas tran vdout1_48ck194 FIND v(dout1_48) AT=975.025n

* CHECK dout1_49 Vdout1_49ck194 = 0 time = 975
.meas tran vdout1_49ck194 FIND v(dout1_49) AT=975.025n

* CHECK dout1_50 Vdout1_50ck194 = 0.9 time = 975
.meas tran vdout1_50ck194 FIND v(dout1_50) AT=975.025n

* CHECK dout1_51 Vdout1_51ck194 = 0.9 time = 975
.meas tran vdout1_51ck194 FIND v(dout1_51) AT=975.025n

* CHECK dout1_52 Vdout1_52ck194 = 0 time = 975
.meas tran vdout1_52ck194 FIND v(dout1_52) AT=975.025n

* CHECK dout1_53 Vdout1_53ck194 = 0 time = 975
.meas tran vdout1_53ck194 FIND v(dout1_53) AT=975.025n

* CHECK dout1_54 Vdout1_54ck194 = 0 time = 975
.meas tran vdout1_54ck194 FIND v(dout1_54) AT=975.025n

* CHECK dout1_55 Vdout1_55ck194 = 0.9 time = 975
.meas tran vdout1_55ck194 FIND v(dout1_55) AT=975.025n

* CHECK dout1_56 Vdout1_56ck194 = 0 time = 975
.meas tran vdout1_56ck194 FIND v(dout1_56) AT=975.025n

* CHECK dout1_57 Vdout1_57ck194 = 0 time = 975
.meas tran vdout1_57ck194 FIND v(dout1_57) AT=975.025n

* CHECK dout1_58 Vdout1_58ck194 = 0 time = 975
.meas tran vdout1_58ck194 FIND v(dout1_58) AT=975.025n

* CHECK dout1_59 Vdout1_59ck194 = 0 time = 975
.meas tran vdout1_59ck194 FIND v(dout1_59) AT=975.025n

* CHECK dout1_60 Vdout1_60ck194 = 0.9 time = 975
.meas tran vdout1_60ck194 FIND v(dout1_60) AT=975.025n

* CHECK dout1_61 Vdout1_61ck194 = 0.9 time = 975
.meas tran vdout1_61ck194 FIND v(dout1_61) AT=975.025n

* CHECK dout1_62 Vdout1_62ck194 = 0.9 time = 975
.meas tran vdout1_62ck194 FIND v(dout1_62) AT=975.025n

* CHECK dout1_63 Vdout1_63ck194 = 0 time = 975
.meas tran vdout1_63ck194 FIND v(dout1_63) AT=975.025n

* CHECK dout1_64 Vdout1_64ck194 = 0 time = 975
.meas tran vdout1_64ck194 FIND v(dout1_64) AT=975.025n

* CHECK dout1_65 Vdout1_65ck194 = 0.9 time = 975
.meas tran vdout1_65ck194 FIND v(dout1_65) AT=975.025n

* CHECK dout1_66 Vdout1_66ck194 = 0 time = 975
.meas tran vdout1_66ck194 FIND v(dout1_66) AT=975.025n

* CHECK dout1_67 Vdout1_67ck194 = 0 time = 975
.meas tran vdout1_67ck194 FIND v(dout1_67) AT=975.025n

* CHECK dout1_68 Vdout1_68ck194 = 0.9 time = 975
.meas tran vdout1_68ck194 FIND v(dout1_68) AT=975.025n

* CHECK dout1_69 Vdout1_69ck194 = 0.9 time = 975
.meas tran vdout1_69ck194 FIND v(dout1_69) AT=975.025n

* CHECK dout1_70 Vdout1_70ck194 = 0.9 time = 975
.meas tran vdout1_70ck194 FIND v(dout1_70) AT=975.025n

* CHECK dout1_71 Vdout1_71ck194 = 0.9 time = 975
.meas tran vdout1_71ck194 FIND v(dout1_71) AT=975.025n

* CHECK dout1_72 Vdout1_72ck194 = 0.9 time = 975
.meas tran vdout1_72ck194 FIND v(dout1_72) AT=975.025n

* CHECK dout1_73 Vdout1_73ck194 = 0 time = 975
.meas tran vdout1_73ck194 FIND v(dout1_73) AT=975.025n

* CHECK dout1_74 Vdout1_74ck194 = 0 time = 975
.meas tran vdout1_74ck194 FIND v(dout1_74) AT=975.025n

* CHECK dout1_75 Vdout1_75ck194 = 0 time = 975
.meas tran vdout1_75ck194 FIND v(dout1_75) AT=975.025n

* CHECK dout1_76 Vdout1_76ck194 = 0.9 time = 975
.meas tran vdout1_76ck194 FIND v(dout1_76) AT=975.025n

* CHECK dout1_77 Vdout1_77ck194 = 0.9 time = 975
.meas tran vdout1_77ck194 FIND v(dout1_77) AT=975.025n

* CHECK dout1_78 Vdout1_78ck194 = 0 time = 975
.meas tran vdout1_78ck194 FIND v(dout1_78) AT=975.025n

* CHECK dout1_79 Vdout1_79ck194 = 0.9 time = 975
.meas tran vdout1_79ck194 FIND v(dout1_79) AT=975.025n

* CHECK dout1_80 Vdout1_80ck194 = 0.9 time = 975
.meas tran vdout1_80ck194 FIND v(dout1_80) AT=975.025n

* CHECK dout1_81 Vdout1_81ck194 = 0.9 time = 975
.meas tran vdout1_81ck194 FIND v(dout1_81) AT=975.025n

* CHECK dout1_82 Vdout1_82ck194 = 0 time = 975
.meas tran vdout1_82ck194 FIND v(dout1_82) AT=975.025n

* CHECK dout1_83 Vdout1_83ck194 = 0 time = 975
.meas tran vdout1_83ck194 FIND v(dout1_83) AT=975.025n

* CHECK dout1_84 Vdout1_84ck194 = 0 time = 975
.meas tran vdout1_84ck194 FIND v(dout1_84) AT=975.025n

* CHECK dout1_85 Vdout1_85ck194 = 0.9 time = 975
.meas tran vdout1_85ck194 FIND v(dout1_85) AT=975.025n

* CHECK dout1_86 Vdout1_86ck194 = 0 time = 975
.meas tran vdout1_86ck194 FIND v(dout1_86) AT=975.025n

* CHECK dout1_87 Vdout1_87ck194 = 0 time = 975
.meas tran vdout1_87ck194 FIND v(dout1_87) AT=975.025n

* CHECK dout1_88 Vdout1_88ck194 = 0 time = 975
.meas tran vdout1_88ck194 FIND v(dout1_88) AT=975.025n

* CHECK dout1_89 Vdout1_89ck194 = 0.9 time = 975
.meas tran vdout1_89ck194 FIND v(dout1_89) AT=975.025n

* CHECK dout1_90 Vdout1_90ck194 = 0.9 time = 975
.meas tran vdout1_90ck194 FIND v(dout1_90) AT=975.025n

* CHECK dout1_91 Vdout1_91ck194 = 0 time = 975
.meas tran vdout1_91ck194 FIND v(dout1_91) AT=975.025n

* CHECK dout1_92 Vdout1_92ck194 = 0 time = 975
.meas tran vdout1_92ck194 FIND v(dout1_92) AT=975.025n

* CHECK dout1_93 Vdout1_93ck194 = 0.9 time = 975
.meas tran vdout1_93ck194 FIND v(dout1_93) AT=975.025n

* CHECK dout1_94 Vdout1_94ck194 = 0.9 time = 975
.meas tran vdout1_94ck194 FIND v(dout1_94) AT=975.025n

* CHECK dout1_95 Vdout1_95ck194 = 0.9 time = 975
.meas tran vdout1_95ck194 FIND v(dout1_95) AT=975.025n

* CHECK dout1_96 Vdout1_96ck194 = 0 time = 975
.meas tran vdout1_96ck194 FIND v(dout1_96) AT=975.025n

* CHECK dout1_97 Vdout1_97ck194 = 0 time = 975
.meas tran vdout1_97ck194 FIND v(dout1_97) AT=975.025n

* CHECK dout1_98 Vdout1_98ck194 = 0 time = 975
.meas tran vdout1_98ck194 FIND v(dout1_98) AT=975.025n

* CHECK dout1_99 Vdout1_99ck194 = 0.9 time = 975
.meas tran vdout1_99ck194 FIND v(dout1_99) AT=975.025n

* CHECK dout1_100 Vdout1_100ck194 = 0.9 time = 975
.meas tran vdout1_100ck194 FIND v(dout1_100) AT=975.025n

* CHECK dout1_101 Vdout1_101ck194 = 0.9 time = 975
.meas tran vdout1_101ck194 FIND v(dout1_101) AT=975.025n

* CHECK dout1_102 Vdout1_102ck194 = 0 time = 975
.meas tran vdout1_102ck194 FIND v(dout1_102) AT=975.025n

* CHECK dout1_103 Vdout1_103ck194 = 0.9 time = 975
.meas tran vdout1_103ck194 FIND v(dout1_103) AT=975.025n

* CHECK dout1_104 Vdout1_104ck194 = 0 time = 975
.meas tran vdout1_104ck194 FIND v(dout1_104) AT=975.025n

* CHECK dout1_105 Vdout1_105ck194 = 0.9 time = 975
.meas tran vdout1_105ck194 FIND v(dout1_105) AT=975.025n

* CHECK dout1_106 Vdout1_106ck194 = 0 time = 975
.meas tran vdout1_106ck194 FIND v(dout1_106) AT=975.025n

* CHECK dout1_107 Vdout1_107ck194 = 0.9 time = 975
.meas tran vdout1_107ck194 FIND v(dout1_107) AT=975.025n

* CHECK dout1_108 Vdout1_108ck194 = 0.9 time = 975
.meas tran vdout1_108ck194 FIND v(dout1_108) AT=975.025n

* CHECK dout1_109 Vdout1_109ck194 = 0.9 time = 975
.meas tran vdout1_109ck194 FIND v(dout1_109) AT=975.025n

* CHECK dout1_110 Vdout1_110ck194 = 0.9 time = 975
.meas tran vdout1_110ck194 FIND v(dout1_110) AT=975.025n

* CHECK dout1_111 Vdout1_111ck194 = 0.9 time = 975
.meas tran vdout1_111ck194 FIND v(dout1_111) AT=975.025n

* CHECK dout1_112 Vdout1_112ck194 = 0 time = 975
.meas tran vdout1_112ck194 FIND v(dout1_112) AT=975.025n

* CHECK dout1_113 Vdout1_113ck194 = 0 time = 975
.meas tran vdout1_113ck194 FIND v(dout1_113) AT=975.025n

* CHECK dout1_114 Vdout1_114ck194 = 0.9 time = 975
.meas tran vdout1_114ck194 FIND v(dout1_114) AT=975.025n

* CHECK dout1_115 Vdout1_115ck194 = 0.9 time = 975
.meas tran vdout1_115ck194 FIND v(dout1_115) AT=975.025n

* CHECK dout1_116 Vdout1_116ck194 = 0 time = 975
.meas tran vdout1_116ck194 FIND v(dout1_116) AT=975.025n

* CHECK dout1_117 Vdout1_117ck194 = 0.9 time = 975
.meas tran vdout1_117ck194 FIND v(dout1_117) AT=975.025n

* CHECK dout1_118 Vdout1_118ck194 = 0.9 time = 975
.meas tran vdout1_118ck194 FIND v(dout1_118) AT=975.025n

* CHECK dout1_119 Vdout1_119ck194 = 0 time = 975
.meas tran vdout1_119ck194 FIND v(dout1_119) AT=975.025n

* CHECK dout1_0 Vdout1_0ck195 = 0 time = 980
.meas tran vdout1_0ck195 FIND v(dout1_0) AT=980.025n

* CHECK dout1_1 Vdout1_1ck195 = 0 time = 980
.meas tran vdout1_1ck195 FIND v(dout1_1) AT=980.025n

* CHECK dout1_2 Vdout1_2ck195 = 0.9 time = 980
.meas tran vdout1_2ck195 FIND v(dout1_2) AT=980.025n

* CHECK dout1_3 Vdout1_3ck195 = 0.9 time = 980
.meas tran vdout1_3ck195 FIND v(dout1_3) AT=980.025n

* CHECK dout1_4 Vdout1_4ck195 = 0 time = 980
.meas tran vdout1_4ck195 FIND v(dout1_4) AT=980.025n

* CHECK dout1_5 Vdout1_5ck195 = 0 time = 980
.meas tran vdout1_5ck195 FIND v(dout1_5) AT=980.025n

* CHECK dout1_6 Vdout1_6ck195 = 0.9 time = 980
.meas tran vdout1_6ck195 FIND v(dout1_6) AT=980.025n

* CHECK dout1_7 Vdout1_7ck195 = 0 time = 980
.meas tran vdout1_7ck195 FIND v(dout1_7) AT=980.025n

* CHECK dout1_8 Vdout1_8ck195 = 0.9 time = 980
.meas tran vdout1_8ck195 FIND v(dout1_8) AT=980.025n

* CHECK dout1_9 Vdout1_9ck195 = 0 time = 980
.meas tran vdout1_9ck195 FIND v(dout1_9) AT=980.025n

* CHECK dout1_10 Vdout1_10ck195 = 0 time = 980
.meas tran vdout1_10ck195 FIND v(dout1_10) AT=980.025n

* CHECK dout1_11 Vdout1_11ck195 = 0.9 time = 980
.meas tran vdout1_11ck195 FIND v(dout1_11) AT=980.025n

* CHECK dout1_12 Vdout1_12ck195 = 0.9 time = 980
.meas tran vdout1_12ck195 FIND v(dout1_12) AT=980.025n

* CHECK dout1_13 Vdout1_13ck195 = 0 time = 980
.meas tran vdout1_13ck195 FIND v(dout1_13) AT=980.025n

* CHECK dout1_14 Vdout1_14ck195 = 0 time = 980
.meas tran vdout1_14ck195 FIND v(dout1_14) AT=980.025n

* CHECK dout1_15 Vdout1_15ck195 = 0 time = 980
.meas tran vdout1_15ck195 FIND v(dout1_15) AT=980.025n

* CHECK dout1_16 Vdout1_16ck195 = 0 time = 980
.meas tran vdout1_16ck195 FIND v(dout1_16) AT=980.025n

* CHECK dout1_17 Vdout1_17ck195 = 0.9 time = 980
.meas tran vdout1_17ck195 FIND v(dout1_17) AT=980.025n

* CHECK dout1_18 Vdout1_18ck195 = 0.9 time = 980
.meas tran vdout1_18ck195 FIND v(dout1_18) AT=980.025n

* CHECK dout1_19 Vdout1_19ck195 = 0.9 time = 980
.meas tran vdout1_19ck195 FIND v(dout1_19) AT=980.025n

* CHECK dout1_20 Vdout1_20ck195 = 0.9 time = 980
.meas tran vdout1_20ck195 FIND v(dout1_20) AT=980.025n

* CHECK dout1_21 Vdout1_21ck195 = 0.9 time = 980
.meas tran vdout1_21ck195 FIND v(dout1_21) AT=980.025n

* CHECK dout1_22 Vdout1_22ck195 = 0.9 time = 980
.meas tran vdout1_22ck195 FIND v(dout1_22) AT=980.025n

* CHECK dout1_23 Vdout1_23ck195 = 0.9 time = 980
.meas tran vdout1_23ck195 FIND v(dout1_23) AT=980.025n

* CHECK dout1_24 Vdout1_24ck195 = 0 time = 980
.meas tran vdout1_24ck195 FIND v(dout1_24) AT=980.025n

* CHECK dout1_25 Vdout1_25ck195 = 0.9 time = 980
.meas tran vdout1_25ck195 FIND v(dout1_25) AT=980.025n

* CHECK dout1_26 Vdout1_26ck195 = 0.9 time = 980
.meas tran vdout1_26ck195 FIND v(dout1_26) AT=980.025n

* CHECK dout1_27 Vdout1_27ck195 = 0 time = 980
.meas tran vdout1_27ck195 FIND v(dout1_27) AT=980.025n

* CHECK dout1_28 Vdout1_28ck195 = 0 time = 980
.meas tran vdout1_28ck195 FIND v(dout1_28) AT=980.025n

* CHECK dout1_29 Vdout1_29ck195 = 0 time = 980
.meas tran vdout1_29ck195 FIND v(dout1_29) AT=980.025n

* CHECK dout1_30 Vdout1_30ck195 = 0.9 time = 980
.meas tran vdout1_30ck195 FIND v(dout1_30) AT=980.025n

* CHECK dout1_31 Vdout1_31ck195 = 0 time = 980
.meas tran vdout1_31ck195 FIND v(dout1_31) AT=980.025n

* CHECK dout1_32 Vdout1_32ck195 = 0 time = 980
.meas tran vdout1_32ck195 FIND v(dout1_32) AT=980.025n

* CHECK dout1_33 Vdout1_33ck195 = 0 time = 980
.meas tran vdout1_33ck195 FIND v(dout1_33) AT=980.025n

* CHECK dout1_34 Vdout1_34ck195 = 0 time = 980
.meas tran vdout1_34ck195 FIND v(dout1_34) AT=980.025n

* CHECK dout1_35 Vdout1_35ck195 = 0.9 time = 980
.meas tran vdout1_35ck195 FIND v(dout1_35) AT=980.025n

* CHECK dout1_36 Vdout1_36ck195 = 0 time = 980
.meas tran vdout1_36ck195 FIND v(dout1_36) AT=980.025n

* CHECK dout1_37 Vdout1_37ck195 = 0 time = 980
.meas tran vdout1_37ck195 FIND v(dout1_37) AT=980.025n

* CHECK dout1_38 Vdout1_38ck195 = 0.9 time = 980
.meas tran vdout1_38ck195 FIND v(dout1_38) AT=980.025n

* CHECK dout1_39 Vdout1_39ck195 = 0.9 time = 980
.meas tran vdout1_39ck195 FIND v(dout1_39) AT=980.025n

* CHECK dout1_40 Vdout1_40ck195 = 0.9 time = 980
.meas tran vdout1_40ck195 FIND v(dout1_40) AT=980.025n

* CHECK dout1_41 Vdout1_41ck195 = 0 time = 980
.meas tran vdout1_41ck195 FIND v(dout1_41) AT=980.025n

* CHECK dout1_42 Vdout1_42ck195 = 0 time = 980
.meas tran vdout1_42ck195 FIND v(dout1_42) AT=980.025n

* CHECK dout1_43 Vdout1_43ck195 = 0 time = 980
.meas tran vdout1_43ck195 FIND v(dout1_43) AT=980.025n

* CHECK dout1_44 Vdout1_44ck195 = 0.9 time = 980
.meas tran vdout1_44ck195 FIND v(dout1_44) AT=980.025n

* CHECK dout1_45 Vdout1_45ck195 = 0 time = 980
.meas tran vdout1_45ck195 FIND v(dout1_45) AT=980.025n

* CHECK dout1_46 Vdout1_46ck195 = 0 time = 980
.meas tran vdout1_46ck195 FIND v(dout1_46) AT=980.025n

* CHECK dout1_47 Vdout1_47ck195 = 0.9 time = 980
.meas tran vdout1_47ck195 FIND v(dout1_47) AT=980.025n

* CHECK dout1_48 Vdout1_48ck195 = 0.9 time = 980
.meas tran vdout1_48ck195 FIND v(dout1_48) AT=980.025n

* CHECK dout1_49 Vdout1_49ck195 = 0.9 time = 980
.meas tran vdout1_49ck195 FIND v(dout1_49) AT=980.025n

* CHECK dout1_50 Vdout1_50ck195 = 0.9 time = 980
.meas tran vdout1_50ck195 FIND v(dout1_50) AT=980.025n

* CHECK dout1_51 Vdout1_51ck195 = 0.9 time = 980
.meas tran vdout1_51ck195 FIND v(dout1_51) AT=980.025n

* CHECK dout1_52 Vdout1_52ck195 = 0.9 time = 980
.meas tran vdout1_52ck195 FIND v(dout1_52) AT=980.025n

* CHECK dout1_53 Vdout1_53ck195 = 0.9 time = 980
.meas tran vdout1_53ck195 FIND v(dout1_53) AT=980.025n

* CHECK dout1_54 Vdout1_54ck195 = 0 time = 980
.meas tran vdout1_54ck195 FIND v(dout1_54) AT=980.025n

* CHECK dout1_55 Vdout1_55ck195 = 0 time = 980
.meas tran vdout1_55ck195 FIND v(dout1_55) AT=980.025n

* CHECK dout1_56 Vdout1_56ck195 = 0.9 time = 980
.meas tran vdout1_56ck195 FIND v(dout1_56) AT=980.025n

* CHECK dout1_57 Vdout1_57ck195 = 0 time = 980
.meas tran vdout1_57ck195 FIND v(dout1_57) AT=980.025n

* CHECK dout1_58 Vdout1_58ck195 = 0 time = 980
.meas tran vdout1_58ck195 FIND v(dout1_58) AT=980.025n

* CHECK dout1_59 Vdout1_59ck195 = 0 time = 980
.meas tran vdout1_59ck195 FIND v(dout1_59) AT=980.025n

* CHECK dout1_60 Vdout1_60ck195 = 0 time = 980
.meas tran vdout1_60ck195 FIND v(dout1_60) AT=980.025n

* CHECK dout1_61 Vdout1_61ck195 = 0.9 time = 980
.meas tran vdout1_61ck195 FIND v(dout1_61) AT=980.025n

* CHECK dout1_62 Vdout1_62ck195 = 0 time = 980
.meas tran vdout1_62ck195 FIND v(dout1_62) AT=980.025n

* CHECK dout1_63 Vdout1_63ck195 = 0 time = 980
.meas tran vdout1_63ck195 FIND v(dout1_63) AT=980.025n

* CHECK dout1_64 Vdout1_64ck195 = 0.9 time = 980
.meas tran vdout1_64ck195 FIND v(dout1_64) AT=980.025n

* CHECK dout1_65 Vdout1_65ck195 = 0.9 time = 980
.meas tran vdout1_65ck195 FIND v(dout1_65) AT=980.025n

* CHECK dout1_66 Vdout1_66ck195 = 0.9 time = 980
.meas tran vdout1_66ck195 FIND v(dout1_66) AT=980.025n

* CHECK dout1_67 Vdout1_67ck195 = 0 time = 980
.meas tran vdout1_67ck195 FIND v(dout1_67) AT=980.025n

* CHECK dout1_68 Vdout1_68ck195 = 0 time = 980
.meas tran vdout1_68ck195 FIND v(dout1_68) AT=980.025n

* CHECK dout1_69 Vdout1_69ck195 = 0.9 time = 980
.meas tran vdout1_69ck195 FIND v(dout1_69) AT=980.025n

* CHECK dout1_70 Vdout1_70ck195 = 0.9 time = 980
.meas tran vdout1_70ck195 FIND v(dout1_70) AT=980.025n

* CHECK dout1_71 Vdout1_71ck195 = 0.9 time = 980
.meas tran vdout1_71ck195 FIND v(dout1_71) AT=980.025n

* CHECK dout1_72 Vdout1_72ck195 = 0 time = 980
.meas tran vdout1_72ck195 FIND v(dout1_72) AT=980.025n

* CHECK dout1_73 Vdout1_73ck195 = 0.9 time = 980
.meas tran vdout1_73ck195 FIND v(dout1_73) AT=980.025n

* CHECK dout1_74 Vdout1_74ck195 = 0.9 time = 980
.meas tran vdout1_74ck195 FIND v(dout1_74) AT=980.025n

* CHECK dout1_75 Vdout1_75ck195 = 0.9 time = 980
.meas tran vdout1_75ck195 FIND v(dout1_75) AT=980.025n

* CHECK dout1_76 Vdout1_76ck195 = 0.9 time = 980
.meas tran vdout1_76ck195 FIND v(dout1_76) AT=980.025n

* CHECK dout1_77 Vdout1_77ck195 = 0 time = 980
.meas tran vdout1_77ck195 FIND v(dout1_77) AT=980.025n

* CHECK dout1_78 Vdout1_78ck195 = 0 time = 980
.meas tran vdout1_78ck195 FIND v(dout1_78) AT=980.025n

* CHECK dout1_79 Vdout1_79ck195 = 0 time = 980
.meas tran vdout1_79ck195 FIND v(dout1_79) AT=980.025n

* CHECK dout1_80 Vdout1_80ck195 = 0 time = 980
.meas tran vdout1_80ck195 FIND v(dout1_80) AT=980.025n

* CHECK dout1_81 Vdout1_81ck195 = 0 time = 980
.meas tran vdout1_81ck195 FIND v(dout1_81) AT=980.025n

* CHECK dout1_82 Vdout1_82ck195 = 0.9 time = 980
.meas tran vdout1_82ck195 FIND v(dout1_82) AT=980.025n

* CHECK dout1_83 Vdout1_83ck195 = 0.9 time = 980
.meas tran vdout1_83ck195 FIND v(dout1_83) AT=980.025n

* CHECK dout1_84 Vdout1_84ck195 = 0.9 time = 980
.meas tran vdout1_84ck195 FIND v(dout1_84) AT=980.025n

* CHECK dout1_85 Vdout1_85ck195 = 0.9 time = 980
.meas tran vdout1_85ck195 FIND v(dout1_85) AT=980.025n

* CHECK dout1_86 Vdout1_86ck195 = 0.9 time = 980
.meas tran vdout1_86ck195 FIND v(dout1_86) AT=980.025n

* CHECK dout1_87 Vdout1_87ck195 = 0.9 time = 980
.meas tran vdout1_87ck195 FIND v(dout1_87) AT=980.025n

* CHECK dout1_88 Vdout1_88ck195 = 0 time = 980
.meas tran vdout1_88ck195 FIND v(dout1_88) AT=980.025n

* CHECK dout1_89 Vdout1_89ck195 = 0.9 time = 980
.meas tran vdout1_89ck195 FIND v(dout1_89) AT=980.025n

* CHECK dout1_90 Vdout1_90ck195 = 0 time = 980
.meas tran vdout1_90ck195 FIND v(dout1_90) AT=980.025n

* CHECK dout1_91 Vdout1_91ck195 = 0.9 time = 980
.meas tran vdout1_91ck195 FIND v(dout1_91) AT=980.025n

* CHECK dout1_92 Vdout1_92ck195 = 0 time = 980
.meas tran vdout1_92ck195 FIND v(dout1_92) AT=980.025n

* CHECK dout1_93 Vdout1_93ck195 = 0.9 time = 980
.meas tran vdout1_93ck195 FIND v(dout1_93) AT=980.025n

* CHECK dout1_94 Vdout1_94ck195 = 0 time = 980
.meas tran vdout1_94ck195 FIND v(dout1_94) AT=980.025n

* CHECK dout1_95 Vdout1_95ck195 = 0 time = 980
.meas tran vdout1_95ck195 FIND v(dout1_95) AT=980.025n

* CHECK dout1_96 Vdout1_96ck195 = 0.9 time = 980
.meas tran vdout1_96ck195 FIND v(dout1_96) AT=980.025n

* CHECK dout1_97 Vdout1_97ck195 = 0.9 time = 980
.meas tran vdout1_97ck195 FIND v(dout1_97) AT=980.025n

* CHECK dout1_98 Vdout1_98ck195 = 0.9 time = 980
.meas tran vdout1_98ck195 FIND v(dout1_98) AT=980.025n

* CHECK dout1_99 Vdout1_99ck195 = 0 time = 980
.meas tran vdout1_99ck195 FIND v(dout1_99) AT=980.025n

* CHECK dout1_100 Vdout1_100ck195 = 0 time = 980
.meas tran vdout1_100ck195 FIND v(dout1_100) AT=980.025n

* CHECK dout1_101 Vdout1_101ck195 = 0.9 time = 980
.meas tran vdout1_101ck195 FIND v(dout1_101) AT=980.025n

* CHECK dout1_102 Vdout1_102ck195 = 0.9 time = 980
.meas tran vdout1_102ck195 FIND v(dout1_102) AT=980.025n

* CHECK dout1_103 Vdout1_103ck195 = 0 time = 980
.meas tran vdout1_103ck195 FIND v(dout1_103) AT=980.025n

* CHECK dout1_104 Vdout1_104ck195 = 0 time = 980
.meas tran vdout1_104ck195 FIND v(dout1_104) AT=980.025n

* CHECK dout1_105 Vdout1_105ck195 = 0.9 time = 980
.meas tran vdout1_105ck195 FIND v(dout1_105) AT=980.025n

* CHECK dout1_106 Vdout1_106ck195 = 0 time = 980
.meas tran vdout1_106ck195 FIND v(dout1_106) AT=980.025n

* CHECK dout1_107 Vdout1_107ck195 = 0.9 time = 980
.meas tran vdout1_107ck195 FIND v(dout1_107) AT=980.025n

* CHECK dout1_108 Vdout1_108ck195 = 0 time = 980
.meas tran vdout1_108ck195 FIND v(dout1_108) AT=980.025n

* CHECK dout1_109 Vdout1_109ck195 = 0.9 time = 980
.meas tran vdout1_109ck195 FIND v(dout1_109) AT=980.025n

* CHECK dout1_110 Vdout1_110ck195 = 0 time = 980
.meas tran vdout1_110ck195 FIND v(dout1_110) AT=980.025n

* CHECK dout1_111 Vdout1_111ck195 = 0.9 time = 980
.meas tran vdout1_111ck195 FIND v(dout1_111) AT=980.025n

* CHECK dout1_112 Vdout1_112ck195 = 0.9 time = 980
.meas tran vdout1_112ck195 FIND v(dout1_112) AT=980.025n

* CHECK dout1_113 Vdout1_113ck195 = 0.9 time = 980
.meas tran vdout1_113ck195 FIND v(dout1_113) AT=980.025n

* CHECK dout1_114 Vdout1_114ck195 = 0.9 time = 980
.meas tran vdout1_114ck195 FIND v(dout1_114) AT=980.025n

* CHECK dout1_115 Vdout1_115ck195 = 0 time = 980
.meas tran vdout1_115ck195 FIND v(dout1_115) AT=980.025n

* CHECK dout1_116 Vdout1_116ck195 = 0.9 time = 980
.meas tran vdout1_116ck195 FIND v(dout1_116) AT=980.025n

* CHECK dout1_117 Vdout1_117ck195 = 0 time = 980
.meas tran vdout1_117ck195 FIND v(dout1_117) AT=980.025n

* CHECK dout1_118 Vdout1_118ck195 = 0 time = 980
.meas tran vdout1_118ck195 FIND v(dout1_118) AT=980.025n

* CHECK dout1_119 Vdout1_119ck195 = 0.9 time = 980
.meas tran vdout1_119ck195 FIND v(dout1_119) AT=980.025n

* CHECK dout1_0 Vdout1_0ck200 = 0.9 time = 1005
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=1005.025n

* CHECK dout1_1 Vdout1_1ck200 = 0.9 time = 1005
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=1005.025n

* CHECK dout1_2 Vdout1_2ck200 = 0.9 time = 1005
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=1005.025n

* CHECK dout1_3 Vdout1_3ck200 = 0.9 time = 1005
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=1005.025n

* CHECK dout1_4 Vdout1_4ck200 = 0.9 time = 1005
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=1005.025n

* CHECK dout1_5 Vdout1_5ck200 = 0.9 time = 1005
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=1005.025n

* CHECK dout1_6 Vdout1_6ck200 = 0.9 time = 1005
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=1005.025n

* CHECK dout1_7 Vdout1_7ck200 = 0.9 time = 1005
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=1005.025n

* CHECK dout1_8 Vdout1_8ck200 = 0 time = 1005
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=1005.025n

* CHECK dout1_9 Vdout1_9ck200 = 0.9 time = 1005
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=1005.025n

* CHECK dout1_10 Vdout1_10ck200 = 0 time = 1005
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=1005.025n

* CHECK dout1_11 Vdout1_11ck200 = 0.9 time = 1005
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=1005.025n

* CHECK dout1_12 Vdout1_12ck200 = 0.9 time = 1005
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=1005.025n

* CHECK dout1_13 Vdout1_13ck200 = 0 time = 1005
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=1005.025n

* CHECK dout1_14 Vdout1_14ck200 = 0 time = 1005
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=1005.025n

* CHECK dout1_15 Vdout1_15ck200 = 0 time = 1005
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=1005.025n

* CHECK dout1_16 Vdout1_16ck200 = 0.9 time = 1005
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=1005.025n

* CHECK dout1_17 Vdout1_17ck200 = 0.9 time = 1005
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=1005.025n

* CHECK dout1_18 Vdout1_18ck200 = 0 time = 1005
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=1005.025n

* CHECK dout1_19 Vdout1_19ck200 = 0.9 time = 1005
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=1005.025n

* CHECK dout1_20 Vdout1_20ck200 = 0 time = 1005
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=1005.025n

* CHECK dout1_21 Vdout1_21ck200 = 0 time = 1005
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=1005.025n

* CHECK dout1_22 Vdout1_22ck200 = 0 time = 1005
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=1005.025n

* CHECK dout1_23 Vdout1_23ck200 = 0 time = 1005
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=1005.025n

* CHECK dout1_24 Vdout1_24ck200 = 0.9 time = 1005
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=1005.025n

* CHECK dout1_25 Vdout1_25ck200 = 0 time = 1005
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=1005.025n

* CHECK dout1_26 Vdout1_26ck200 = 0.9 time = 1005
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=1005.025n

* CHECK dout1_27 Vdout1_27ck200 = 0 time = 1005
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=1005.025n

* CHECK dout1_28 Vdout1_28ck200 = 0.9 time = 1005
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=1005.025n

* CHECK dout1_29 Vdout1_29ck200 = 0.9 time = 1005
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=1005.025n

* CHECK dout1_30 Vdout1_30ck200 = 0.9 time = 1005
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=1005.025n

* CHECK dout1_31 Vdout1_31ck200 = 0.9 time = 1005
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=1005.025n

* CHECK dout1_32 Vdout1_32ck200 = 0 time = 1005
.meas tran vdout1_32ck200 FIND v(dout1_32) AT=1005.025n

* CHECK dout1_33 Vdout1_33ck200 = 0.9 time = 1005
.meas tran vdout1_33ck200 FIND v(dout1_33) AT=1005.025n

* CHECK dout1_34 Vdout1_34ck200 = 0.9 time = 1005
.meas tran vdout1_34ck200 FIND v(dout1_34) AT=1005.025n

* CHECK dout1_35 Vdout1_35ck200 = 0 time = 1005
.meas tran vdout1_35ck200 FIND v(dout1_35) AT=1005.025n

* CHECK dout1_36 Vdout1_36ck200 = 0 time = 1005
.meas tran vdout1_36ck200 FIND v(dout1_36) AT=1005.025n

* CHECK dout1_37 Vdout1_37ck200 = 0 time = 1005
.meas tran vdout1_37ck200 FIND v(dout1_37) AT=1005.025n

* CHECK dout1_38 Vdout1_38ck200 = 0.9 time = 1005
.meas tran vdout1_38ck200 FIND v(dout1_38) AT=1005.025n

* CHECK dout1_39 Vdout1_39ck200 = 0.9 time = 1005
.meas tran vdout1_39ck200 FIND v(dout1_39) AT=1005.025n

* CHECK dout1_40 Vdout1_40ck200 = 0.9 time = 1005
.meas tran vdout1_40ck200 FIND v(dout1_40) AT=1005.025n

* CHECK dout1_41 Vdout1_41ck200 = 0 time = 1005
.meas tran vdout1_41ck200 FIND v(dout1_41) AT=1005.025n

* CHECK dout1_42 Vdout1_42ck200 = 0.9 time = 1005
.meas tran vdout1_42ck200 FIND v(dout1_42) AT=1005.025n

* CHECK dout1_43 Vdout1_43ck200 = 0 time = 1005
.meas tran vdout1_43ck200 FIND v(dout1_43) AT=1005.025n

* CHECK dout1_44 Vdout1_44ck200 = 0.9 time = 1005
.meas tran vdout1_44ck200 FIND v(dout1_44) AT=1005.025n

* CHECK dout1_45 Vdout1_45ck200 = 0.9 time = 1005
.meas tran vdout1_45ck200 FIND v(dout1_45) AT=1005.025n

* CHECK dout1_46 Vdout1_46ck200 = 0.9 time = 1005
.meas tran vdout1_46ck200 FIND v(dout1_46) AT=1005.025n

* CHECK dout1_47 Vdout1_47ck200 = 0 time = 1005
.meas tran vdout1_47ck200 FIND v(dout1_47) AT=1005.025n

* CHECK dout1_48 Vdout1_48ck200 = 0 time = 1005
.meas tran vdout1_48ck200 FIND v(dout1_48) AT=1005.025n

* CHECK dout1_49 Vdout1_49ck200 = 0.9 time = 1005
.meas tran vdout1_49ck200 FIND v(dout1_49) AT=1005.025n

* CHECK dout1_50 Vdout1_50ck200 = 0.9 time = 1005
.meas tran vdout1_50ck200 FIND v(dout1_50) AT=1005.025n

* CHECK dout1_51 Vdout1_51ck200 = 0.9 time = 1005
.meas tran vdout1_51ck200 FIND v(dout1_51) AT=1005.025n

* CHECK dout1_52 Vdout1_52ck200 = 0.9 time = 1005
.meas tran vdout1_52ck200 FIND v(dout1_52) AT=1005.025n

* CHECK dout1_53 Vdout1_53ck200 = 0 time = 1005
.meas tran vdout1_53ck200 FIND v(dout1_53) AT=1005.025n

* CHECK dout1_54 Vdout1_54ck200 = 0.9 time = 1005
.meas tran vdout1_54ck200 FIND v(dout1_54) AT=1005.025n

* CHECK dout1_55 Vdout1_55ck200 = 0.9 time = 1005
.meas tran vdout1_55ck200 FIND v(dout1_55) AT=1005.025n

* CHECK dout1_56 Vdout1_56ck200 = 0.9 time = 1005
.meas tran vdout1_56ck200 FIND v(dout1_56) AT=1005.025n

* CHECK dout1_57 Vdout1_57ck200 = 0 time = 1005
.meas tran vdout1_57ck200 FIND v(dout1_57) AT=1005.025n

* CHECK dout1_58 Vdout1_58ck200 = 0 time = 1005
.meas tran vdout1_58ck200 FIND v(dout1_58) AT=1005.025n

* CHECK dout1_59 Vdout1_59ck200 = 0 time = 1005
.meas tran vdout1_59ck200 FIND v(dout1_59) AT=1005.025n

* CHECK dout1_60 Vdout1_60ck200 = 0.9 time = 1005
.meas tran vdout1_60ck200 FIND v(dout1_60) AT=1005.025n

* CHECK dout1_61 Vdout1_61ck200 = 0.9 time = 1005
.meas tran vdout1_61ck200 FIND v(dout1_61) AT=1005.025n

* CHECK dout1_62 Vdout1_62ck200 = 0 time = 1005
.meas tran vdout1_62ck200 FIND v(dout1_62) AT=1005.025n

* CHECK dout1_63 Vdout1_63ck200 = 0.9 time = 1005
.meas tran vdout1_63ck200 FIND v(dout1_63) AT=1005.025n

* CHECK dout1_64 Vdout1_64ck200 = 0.9 time = 1005
.meas tran vdout1_64ck200 FIND v(dout1_64) AT=1005.025n

* CHECK dout1_65 Vdout1_65ck200 = 0 time = 1005
.meas tran vdout1_65ck200 FIND v(dout1_65) AT=1005.025n

* CHECK dout1_66 Vdout1_66ck200 = 0.9 time = 1005
.meas tran vdout1_66ck200 FIND v(dout1_66) AT=1005.025n

* CHECK dout1_67 Vdout1_67ck200 = 0 time = 1005
.meas tran vdout1_67ck200 FIND v(dout1_67) AT=1005.025n

* CHECK dout1_68 Vdout1_68ck200 = 0 time = 1005
.meas tran vdout1_68ck200 FIND v(dout1_68) AT=1005.025n

* CHECK dout1_69 Vdout1_69ck200 = 0 time = 1005
.meas tran vdout1_69ck200 FIND v(dout1_69) AT=1005.025n

* CHECK dout1_70 Vdout1_70ck200 = 0.9 time = 1005
.meas tran vdout1_70ck200 FIND v(dout1_70) AT=1005.025n

* CHECK dout1_71 Vdout1_71ck200 = 0 time = 1005
.meas tran vdout1_71ck200 FIND v(dout1_71) AT=1005.025n

* CHECK dout1_72 Vdout1_72ck200 = 0 time = 1005
.meas tran vdout1_72ck200 FIND v(dout1_72) AT=1005.025n

* CHECK dout1_73 Vdout1_73ck200 = 0 time = 1005
.meas tran vdout1_73ck200 FIND v(dout1_73) AT=1005.025n

* CHECK dout1_74 Vdout1_74ck200 = 0.9 time = 1005
.meas tran vdout1_74ck200 FIND v(dout1_74) AT=1005.025n

* CHECK dout1_75 Vdout1_75ck200 = 0.9 time = 1005
.meas tran vdout1_75ck200 FIND v(dout1_75) AT=1005.025n

* CHECK dout1_76 Vdout1_76ck200 = 0 time = 1005
.meas tran vdout1_76ck200 FIND v(dout1_76) AT=1005.025n

* CHECK dout1_77 Vdout1_77ck200 = 0 time = 1005
.meas tran vdout1_77ck200 FIND v(dout1_77) AT=1005.025n

* CHECK dout1_78 Vdout1_78ck200 = 0.9 time = 1005
.meas tran vdout1_78ck200 FIND v(dout1_78) AT=1005.025n

* CHECK dout1_79 Vdout1_79ck200 = 0 time = 1005
.meas tran vdout1_79ck200 FIND v(dout1_79) AT=1005.025n

* CHECK dout1_80 Vdout1_80ck200 = 0 time = 1005
.meas tran vdout1_80ck200 FIND v(dout1_80) AT=1005.025n

* CHECK dout1_81 Vdout1_81ck200 = 0.9 time = 1005
.meas tran vdout1_81ck200 FIND v(dout1_81) AT=1005.025n

* CHECK dout1_82 Vdout1_82ck200 = 0.9 time = 1005
.meas tran vdout1_82ck200 FIND v(dout1_82) AT=1005.025n

* CHECK dout1_83 Vdout1_83ck200 = 0 time = 1005
.meas tran vdout1_83ck200 FIND v(dout1_83) AT=1005.025n

* CHECK dout1_84 Vdout1_84ck200 = 0 time = 1005
.meas tran vdout1_84ck200 FIND v(dout1_84) AT=1005.025n

* CHECK dout1_85 Vdout1_85ck200 = 0 time = 1005
.meas tran vdout1_85ck200 FIND v(dout1_85) AT=1005.025n

* CHECK dout1_86 Vdout1_86ck200 = 0.9 time = 1005
.meas tran vdout1_86ck200 FIND v(dout1_86) AT=1005.025n

* CHECK dout1_87 Vdout1_87ck200 = 0.9 time = 1005
.meas tran vdout1_87ck200 FIND v(dout1_87) AT=1005.025n

* CHECK dout1_88 Vdout1_88ck200 = 0.9 time = 1005
.meas tran vdout1_88ck200 FIND v(dout1_88) AT=1005.025n

* CHECK dout1_89 Vdout1_89ck200 = 0 time = 1005
.meas tran vdout1_89ck200 FIND v(dout1_89) AT=1005.025n

* CHECK dout1_90 Vdout1_90ck200 = 0 time = 1005
.meas tran vdout1_90ck200 FIND v(dout1_90) AT=1005.025n

* CHECK dout1_91 Vdout1_91ck200 = 0 time = 1005
.meas tran vdout1_91ck200 FIND v(dout1_91) AT=1005.025n

* CHECK dout1_92 Vdout1_92ck200 = 0.9 time = 1005
.meas tran vdout1_92ck200 FIND v(dout1_92) AT=1005.025n

* CHECK dout1_93 Vdout1_93ck200 = 0.9 time = 1005
.meas tran vdout1_93ck200 FIND v(dout1_93) AT=1005.025n

* CHECK dout1_94 Vdout1_94ck200 = 0.9 time = 1005
.meas tran vdout1_94ck200 FIND v(dout1_94) AT=1005.025n

* CHECK dout1_95 Vdout1_95ck200 = 0.9 time = 1005
.meas tran vdout1_95ck200 FIND v(dout1_95) AT=1005.025n

* CHECK dout1_96 Vdout1_96ck200 = 0 time = 1005
.meas tran vdout1_96ck200 FIND v(dout1_96) AT=1005.025n

* CHECK dout1_97 Vdout1_97ck200 = 0 time = 1005
.meas tran vdout1_97ck200 FIND v(dout1_97) AT=1005.025n

* CHECK dout1_98 Vdout1_98ck200 = 0 time = 1005
.meas tran vdout1_98ck200 FIND v(dout1_98) AT=1005.025n

* CHECK dout1_99 Vdout1_99ck200 = 0 time = 1005
.meas tran vdout1_99ck200 FIND v(dout1_99) AT=1005.025n

* CHECK dout1_100 Vdout1_100ck200 = 0 time = 1005
.meas tran vdout1_100ck200 FIND v(dout1_100) AT=1005.025n

* CHECK dout1_101 Vdout1_101ck200 = 0 time = 1005
.meas tran vdout1_101ck200 FIND v(dout1_101) AT=1005.025n

* CHECK dout1_102 Vdout1_102ck200 = 0.9 time = 1005
.meas tran vdout1_102ck200 FIND v(dout1_102) AT=1005.025n

* CHECK dout1_103 Vdout1_103ck200 = 0.9 time = 1005
.meas tran vdout1_103ck200 FIND v(dout1_103) AT=1005.025n

* CHECK dout1_104 Vdout1_104ck200 = 0 time = 1005
.meas tran vdout1_104ck200 FIND v(dout1_104) AT=1005.025n

* CHECK dout1_105 Vdout1_105ck200 = 0 time = 1005
.meas tran vdout1_105ck200 FIND v(dout1_105) AT=1005.025n

* CHECK dout1_106 Vdout1_106ck200 = 0 time = 1005
.meas tran vdout1_106ck200 FIND v(dout1_106) AT=1005.025n

* CHECK dout1_107 Vdout1_107ck200 = 0.9 time = 1005
.meas tran vdout1_107ck200 FIND v(dout1_107) AT=1005.025n

* CHECK dout1_108 Vdout1_108ck200 = 0 time = 1005
.meas tran vdout1_108ck200 FIND v(dout1_108) AT=1005.025n

* CHECK dout1_109 Vdout1_109ck200 = 0 time = 1005
.meas tran vdout1_109ck200 FIND v(dout1_109) AT=1005.025n

* CHECK dout1_110 Vdout1_110ck200 = 0 time = 1005
.meas tran vdout1_110ck200 FIND v(dout1_110) AT=1005.025n

* CHECK dout1_111 Vdout1_111ck200 = 0.9 time = 1005
.meas tran vdout1_111ck200 FIND v(dout1_111) AT=1005.025n

* CHECK dout1_112 Vdout1_112ck200 = 0.9 time = 1005
.meas tran vdout1_112ck200 FIND v(dout1_112) AT=1005.025n

* CHECK dout1_113 Vdout1_113ck200 = 0 time = 1005
.meas tran vdout1_113ck200 FIND v(dout1_113) AT=1005.025n

* CHECK dout1_114 Vdout1_114ck200 = 0.9 time = 1005
.meas tran vdout1_114ck200 FIND v(dout1_114) AT=1005.025n

* CHECK dout1_115 Vdout1_115ck200 = 0.9 time = 1005
.meas tran vdout1_115ck200 FIND v(dout1_115) AT=1005.025n

* CHECK dout1_116 Vdout1_116ck200 = 0 time = 1005
.meas tran vdout1_116ck200 FIND v(dout1_116) AT=1005.025n

* CHECK dout1_117 Vdout1_117ck200 = 0.9 time = 1005
.meas tran vdout1_117ck200 FIND v(dout1_117) AT=1005.025n

* CHECK dout1_118 Vdout1_118ck200 = 0 time = 1005
.meas tran vdout1_118ck200 FIND v(dout1_118) AT=1005.025n

* CHECK dout1_119 Vdout1_119ck200 = 0 time = 1005
.meas tran vdout1_119ck200 FIND v(dout1_119) AT=1005.025n

* CHECK dout1_0 Vdout1_0ck202 = 0.9 time = 1015
.meas tran vdout1_0ck202 FIND v(dout1_0) AT=1015.025n

* CHECK dout1_1 Vdout1_1ck202 = 0.9 time = 1015
.meas tran vdout1_1ck202 FIND v(dout1_1) AT=1015.025n

* CHECK dout1_2 Vdout1_2ck202 = 0.9 time = 1015
.meas tran vdout1_2ck202 FIND v(dout1_2) AT=1015.025n

* CHECK dout1_3 Vdout1_3ck202 = 0 time = 1015
.meas tran vdout1_3ck202 FIND v(dout1_3) AT=1015.025n

* CHECK dout1_4 Vdout1_4ck202 = 0.9 time = 1015
.meas tran vdout1_4ck202 FIND v(dout1_4) AT=1015.025n

* CHECK dout1_5 Vdout1_5ck202 = 0.9 time = 1015
.meas tran vdout1_5ck202 FIND v(dout1_5) AT=1015.025n

* CHECK dout1_6 Vdout1_6ck202 = 0 time = 1015
.meas tran vdout1_6ck202 FIND v(dout1_6) AT=1015.025n

* CHECK dout1_7 Vdout1_7ck202 = 0 time = 1015
.meas tran vdout1_7ck202 FIND v(dout1_7) AT=1015.025n

* CHECK dout1_8 Vdout1_8ck202 = 0 time = 1015
.meas tran vdout1_8ck202 FIND v(dout1_8) AT=1015.025n

* CHECK dout1_9 Vdout1_9ck202 = 0.9 time = 1015
.meas tran vdout1_9ck202 FIND v(dout1_9) AT=1015.025n

* CHECK dout1_10 Vdout1_10ck202 = 0.9 time = 1015
.meas tran vdout1_10ck202 FIND v(dout1_10) AT=1015.025n

* CHECK dout1_11 Vdout1_11ck202 = 0 time = 1015
.meas tran vdout1_11ck202 FIND v(dout1_11) AT=1015.025n

* CHECK dout1_12 Vdout1_12ck202 = 0 time = 1015
.meas tran vdout1_12ck202 FIND v(dout1_12) AT=1015.025n

* CHECK dout1_13 Vdout1_13ck202 = 0.9 time = 1015
.meas tran vdout1_13ck202 FIND v(dout1_13) AT=1015.025n

* CHECK dout1_14 Vdout1_14ck202 = 0.9 time = 1015
.meas tran vdout1_14ck202 FIND v(dout1_14) AT=1015.025n

* CHECK dout1_15 Vdout1_15ck202 = 0.9 time = 1015
.meas tran vdout1_15ck202 FIND v(dout1_15) AT=1015.025n

* CHECK dout1_16 Vdout1_16ck202 = 0 time = 1015
.meas tran vdout1_16ck202 FIND v(dout1_16) AT=1015.025n

* CHECK dout1_17 Vdout1_17ck202 = 0 time = 1015
.meas tran vdout1_17ck202 FIND v(dout1_17) AT=1015.025n

* CHECK dout1_18 Vdout1_18ck202 = 0.9 time = 1015
.meas tran vdout1_18ck202 FIND v(dout1_18) AT=1015.025n

* CHECK dout1_19 Vdout1_19ck202 = 0 time = 1015
.meas tran vdout1_19ck202 FIND v(dout1_19) AT=1015.025n

* CHECK dout1_20 Vdout1_20ck202 = 0 time = 1015
.meas tran vdout1_20ck202 FIND v(dout1_20) AT=1015.025n

* CHECK dout1_21 Vdout1_21ck202 = 0.9 time = 1015
.meas tran vdout1_21ck202 FIND v(dout1_21) AT=1015.025n

* CHECK dout1_22 Vdout1_22ck202 = 0 time = 1015
.meas tran vdout1_22ck202 FIND v(dout1_22) AT=1015.025n

* CHECK dout1_23 Vdout1_23ck202 = 0.9 time = 1015
.meas tran vdout1_23ck202 FIND v(dout1_23) AT=1015.025n

* CHECK dout1_24 Vdout1_24ck202 = 0.9 time = 1015
.meas tran vdout1_24ck202 FIND v(dout1_24) AT=1015.025n

* CHECK dout1_25 Vdout1_25ck202 = 0.9 time = 1015
.meas tran vdout1_25ck202 FIND v(dout1_25) AT=1015.025n

* CHECK dout1_26 Vdout1_26ck202 = 0.9 time = 1015
.meas tran vdout1_26ck202 FIND v(dout1_26) AT=1015.025n

* CHECK dout1_27 Vdout1_27ck202 = 0.9 time = 1015
.meas tran vdout1_27ck202 FIND v(dout1_27) AT=1015.025n

* CHECK dout1_28 Vdout1_28ck202 = 0.9 time = 1015
.meas tran vdout1_28ck202 FIND v(dout1_28) AT=1015.025n

* CHECK dout1_29 Vdout1_29ck202 = 0 time = 1015
.meas tran vdout1_29ck202 FIND v(dout1_29) AT=1015.025n

* CHECK dout1_30 Vdout1_30ck202 = 0.9 time = 1015
.meas tran vdout1_30ck202 FIND v(dout1_30) AT=1015.025n

* CHECK dout1_31 Vdout1_31ck202 = 0 time = 1015
.meas tran vdout1_31ck202 FIND v(dout1_31) AT=1015.025n

* CHECK dout1_32 Vdout1_32ck202 = 0 time = 1015
.meas tran vdout1_32ck202 FIND v(dout1_32) AT=1015.025n

* CHECK dout1_33 Vdout1_33ck202 = 0 time = 1015
.meas tran vdout1_33ck202 FIND v(dout1_33) AT=1015.025n

* CHECK dout1_34 Vdout1_34ck202 = 0.9 time = 1015
.meas tran vdout1_34ck202 FIND v(dout1_34) AT=1015.025n

* CHECK dout1_35 Vdout1_35ck202 = 0.9 time = 1015
.meas tran vdout1_35ck202 FIND v(dout1_35) AT=1015.025n

* CHECK dout1_36 Vdout1_36ck202 = 0.9 time = 1015
.meas tran vdout1_36ck202 FIND v(dout1_36) AT=1015.025n

* CHECK dout1_37 Vdout1_37ck202 = 0 time = 1015
.meas tran vdout1_37ck202 FIND v(dout1_37) AT=1015.025n

* CHECK dout1_38 Vdout1_38ck202 = 0 time = 1015
.meas tran vdout1_38ck202 FIND v(dout1_38) AT=1015.025n

* CHECK dout1_39 Vdout1_39ck202 = 0.9 time = 1015
.meas tran vdout1_39ck202 FIND v(dout1_39) AT=1015.025n

* CHECK dout1_40 Vdout1_40ck202 = 0 time = 1015
.meas tran vdout1_40ck202 FIND v(dout1_40) AT=1015.025n

* CHECK dout1_41 Vdout1_41ck202 = 0 time = 1015
.meas tran vdout1_41ck202 FIND v(dout1_41) AT=1015.025n

* CHECK dout1_42 Vdout1_42ck202 = 0 time = 1015
.meas tran vdout1_42ck202 FIND v(dout1_42) AT=1015.025n

* CHECK dout1_43 Vdout1_43ck202 = 0.9 time = 1015
.meas tran vdout1_43ck202 FIND v(dout1_43) AT=1015.025n

* CHECK dout1_44 Vdout1_44ck202 = 0.9 time = 1015
.meas tran vdout1_44ck202 FIND v(dout1_44) AT=1015.025n

* CHECK dout1_45 Vdout1_45ck202 = 0.9 time = 1015
.meas tran vdout1_45ck202 FIND v(dout1_45) AT=1015.025n

* CHECK dout1_46 Vdout1_46ck202 = 0 time = 1015
.meas tran vdout1_46ck202 FIND v(dout1_46) AT=1015.025n

* CHECK dout1_47 Vdout1_47ck202 = 0.9 time = 1015
.meas tran vdout1_47ck202 FIND v(dout1_47) AT=1015.025n

* CHECK dout1_48 Vdout1_48ck202 = 0 time = 1015
.meas tran vdout1_48ck202 FIND v(dout1_48) AT=1015.025n

* CHECK dout1_49 Vdout1_49ck202 = 0 time = 1015
.meas tran vdout1_49ck202 FIND v(dout1_49) AT=1015.025n

* CHECK dout1_50 Vdout1_50ck202 = 0 time = 1015
.meas tran vdout1_50ck202 FIND v(dout1_50) AT=1015.025n

* CHECK dout1_51 Vdout1_51ck202 = 0.9 time = 1015
.meas tran vdout1_51ck202 FIND v(dout1_51) AT=1015.025n

* CHECK dout1_52 Vdout1_52ck202 = 0.9 time = 1015
.meas tran vdout1_52ck202 FIND v(dout1_52) AT=1015.025n

* CHECK dout1_53 Vdout1_53ck202 = 0 time = 1015
.meas tran vdout1_53ck202 FIND v(dout1_53) AT=1015.025n

* CHECK dout1_54 Vdout1_54ck202 = 0 time = 1015
.meas tran vdout1_54ck202 FIND v(dout1_54) AT=1015.025n

* CHECK dout1_55 Vdout1_55ck202 = 0.9 time = 1015
.meas tran vdout1_55ck202 FIND v(dout1_55) AT=1015.025n

* CHECK dout1_56 Vdout1_56ck202 = 0.9 time = 1015
.meas tran vdout1_56ck202 FIND v(dout1_56) AT=1015.025n

* CHECK dout1_57 Vdout1_57ck202 = 0 time = 1015
.meas tran vdout1_57ck202 FIND v(dout1_57) AT=1015.025n

* CHECK dout1_58 Vdout1_58ck202 = 0.9 time = 1015
.meas tran vdout1_58ck202 FIND v(dout1_58) AT=1015.025n

* CHECK dout1_59 Vdout1_59ck202 = 0 time = 1015
.meas tran vdout1_59ck202 FIND v(dout1_59) AT=1015.025n

* CHECK dout1_60 Vdout1_60ck202 = 0 time = 1015
.meas tran vdout1_60ck202 FIND v(dout1_60) AT=1015.025n

* CHECK dout1_61 Vdout1_61ck202 = 0 time = 1015
.meas tran vdout1_61ck202 FIND v(dout1_61) AT=1015.025n

* CHECK dout1_62 Vdout1_62ck202 = 0 time = 1015
.meas tran vdout1_62ck202 FIND v(dout1_62) AT=1015.025n

* CHECK dout1_63 Vdout1_63ck202 = 0 time = 1015
.meas tran vdout1_63ck202 FIND v(dout1_63) AT=1015.025n

* CHECK dout1_64 Vdout1_64ck202 = 0.9 time = 1015
.meas tran vdout1_64ck202 FIND v(dout1_64) AT=1015.025n

* CHECK dout1_65 Vdout1_65ck202 = 0.9 time = 1015
.meas tran vdout1_65ck202 FIND v(dout1_65) AT=1015.025n

* CHECK dout1_66 Vdout1_66ck202 = 0.9 time = 1015
.meas tran vdout1_66ck202 FIND v(dout1_66) AT=1015.025n

* CHECK dout1_67 Vdout1_67ck202 = 0 time = 1015
.meas tran vdout1_67ck202 FIND v(dout1_67) AT=1015.025n

* CHECK dout1_68 Vdout1_68ck202 = 0 time = 1015
.meas tran vdout1_68ck202 FIND v(dout1_68) AT=1015.025n

* CHECK dout1_69 Vdout1_69ck202 = 0 time = 1015
.meas tran vdout1_69ck202 FIND v(dout1_69) AT=1015.025n

* CHECK dout1_70 Vdout1_70ck202 = 0.9 time = 1015
.meas tran vdout1_70ck202 FIND v(dout1_70) AT=1015.025n

* CHECK dout1_71 Vdout1_71ck202 = 0 time = 1015
.meas tran vdout1_71ck202 FIND v(dout1_71) AT=1015.025n

* CHECK dout1_72 Vdout1_72ck202 = 0 time = 1015
.meas tran vdout1_72ck202 FIND v(dout1_72) AT=1015.025n

* CHECK dout1_73 Vdout1_73ck202 = 0 time = 1015
.meas tran vdout1_73ck202 FIND v(dout1_73) AT=1015.025n

* CHECK dout1_74 Vdout1_74ck202 = 0.9 time = 1015
.meas tran vdout1_74ck202 FIND v(dout1_74) AT=1015.025n

* CHECK dout1_75 Vdout1_75ck202 = 0 time = 1015
.meas tran vdout1_75ck202 FIND v(dout1_75) AT=1015.025n

* CHECK dout1_76 Vdout1_76ck202 = 0 time = 1015
.meas tran vdout1_76ck202 FIND v(dout1_76) AT=1015.025n

* CHECK dout1_77 Vdout1_77ck202 = 0.9 time = 1015
.meas tran vdout1_77ck202 FIND v(dout1_77) AT=1015.025n

* CHECK dout1_78 Vdout1_78ck202 = 0 time = 1015
.meas tran vdout1_78ck202 FIND v(dout1_78) AT=1015.025n

* CHECK dout1_79 Vdout1_79ck202 = 0.9 time = 1015
.meas tran vdout1_79ck202 FIND v(dout1_79) AT=1015.025n

* CHECK dout1_80 Vdout1_80ck202 = 0.9 time = 1015
.meas tran vdout1_80ck202 FIND v(dout1_80) AT=1015.025n

* CHECK dout1_81 Vdout1_81ck202 = 0 time = 1015
.meas tran vdout1_81ck202 FIND v(dout1_81) AT=1015.025n

* CHECK dout1_82 Vdout1_82ck202 = 0 time = 1015
.meas tran vdout1_82ck202 FIND v(dout1_82) AT=1015.025n

* CHECK dout1_83 Vdout1_83ck202 = 0.9 time = 1015
.meas tran vdout1_83ck202 FIND v(dout1_83) AT=1015.025n

* CHECK dout1_84 Vdout1_84ck202 = 0 time = 1015
.meas tran vdout1_84ck202 FIND v(dout1_84) AT=1015.025n

* CHECK dout1_85 Vdout1_85ck202 = 0.9 time = 1015
.meas tran vdout1_85ck202 FIND v(dout1_85) AT=1015.025n

* CHECK dout1_86 Vdout1_86ck202 = 0 time = 1015
.meas tran vdout1_86ck202 FIND v(dout1_86) AT=1015.025n

* CHECK dout1_87 Vdout1_87ck202 = 0 time = 1015
.meas tran vdout1_87ck202 FIND v(dout1_87) AT=1015.025n

* CHECK dout1_88 Vdout1_88ck202 = 0 time = 1015
.meas tran vdout1_88ck202 FIND v(dout1_88) AT=1015.025n

* CHECK dout1_89 Vdout1_89ck202 = 0.9 time = 1015
.meas tran vdout1_89ck202 FIND v(dout1_89) AT=1015.025n

* CHECK dout1_90 Vdout1_90ck202 = 0.9 time = 1015
.meas tran vdout1_90ck202 FIND v(dout1_90) AT=1015.025n

* CHECK dout1_91 Vdout1_91ck202 = 0 time = 1015
.meas tran vdout1_91ck202 FIND v(dout1_91) AT=1015.025n

* CHECK dout1_92 Vdout1_92ck202 = 0.9 time = 1015
.meas tran vdout1_92ck202 FIND v(dout1_92) AT=1015.025n

* CHECK dout1_93 Vdout1_93ck202 = 0 time = 1015
.meas tran vdout1_93ck202 FIND v(dout1_93) AT=1015.025n

* CHECK dout1_94 Vdout1_94ck202 = 0.9 time = 1015
.meas tran vdout1_94ck202 FIND v(dout1_94) AT=1015.025n

* CHECK dout1_95 Vdout1_95ck202 = 0 time = 1015
.meas tran vdout1_95ck202 FIND v(dout1_95) AT=1015.025n

* CHECK dout1_96 Vdout1_96ck202 = 0 time = 1015
.meas tran vdout1_96ck202 FIND v(dout1_96) AT=1015.025n

* CHECK dout1_97 Vdout1_97ck202 = 0 time = 1015
.meas tran vdout1_97ck202 FIND v(dout1_97) AT=1015.025n

* CHECK dout1_98 Vdout1_98ck202 = 0 time = 1015
.meas tran vdout1_98ck202 FIND v(dout1_98) AT=1015.025n

* CHECK dout1_99 Vdout1_99ck202 = 0 time = 1015
.meas tran vdout1_99ck202 FIND v(dout1_99) AT=1015.025n

* CHECK dout1_100 Vdout1_100ck202 = 0 time = 1015
.meas tran vdout1_100ck202 FIND v(dout1_100) AT=1015.025n

* CHECK dout1_101 Vdout1_101ck202 = 0.9 time = 1015
.meas tran vdout1_101ck202 FIND v(dout1_101) AT=1015.025n

* CHECK dout1_102 Vdout1_102ck202 = 0 time = 1015
.meas tran vdout1_102ck202 FIND v(dout1_102) AT=1015.025n

* CHECK dout1_103 Vdout1_103ck202 = 0.9 time = 1015
.meas tran vdout1_103ck202 FIND v(dout1_103) AT=1015.025n

* CHECK dout1_104 Vdout1_104ck202 = 0.9 time = 1015
.meas tran vdout1_104ck202 FIND v(dout1_104) AT=1015.025n

* CHECK dout1_105 Vdout1_105ck202 = 0 time = 1015
.meas tran vdout1_105ck202 FIND v(dout1_105) AT=1015.025n

* CHECK dout1_106 Vdout1_106ck202 = 0.9 time = 1015
.meas tran vdout1_106ck202 FIND v(dout1_106) AT=1015.025n

* CHECK dout1_107 Vdout1_107ck202 = 0.9 time = 1015
.meas tran vdout1_107ck202 FIND v(dout1_107) AT=1015.025n

* CHECK dout1_108 Vdout1_108ck202 = 0.9 time = 1015
.meas tran vdout1_108ck202 FIND v(dout1_108) AT=1015.025n

* CHECK dout1_109 Vdout1_109ck202 = 0 time = 1015
.meas tran vdout1_109ck202 FIND v(dout1_109) AT=1015.025n

* CHECK dout1_110 Vdout1_110ck202 = 0 time = 1015
.meas tran vdout1_110ck202 FIND v(dout1_110) AT=1015.025n

* CHECK dout1_111 Vdout1_111ck202 = 0 time = 1015
.meas tran vdout1_111ck202 FIND v(dout1_111) AT=1015.025n

* CHECK dout1_112 Vdout1_112ck202 = 0.9 time = 1015
.meas tran vdout1_112ck202 FIND v(dout1_112) AT=1015.025n

* CHECK dout1_113 Vdout1_113ck202 = 0.9 time = 1015
.meas tran vdout1_113ck202 FIND v(dout1_113) AT=1015.025n

* CHECK dout1_114 Vdout1_114ck202 = 0 time = 1015
.meas tran vdout1_114ck202 FIND v(dout1_114) AT=1015.025n

* CHECK dout1_115 Vdout1_115ck202 = 0 time = 1015
.meas tran vdout1_115ck202 FIND v(dout1_115) AT=1015.025n

* CHECK dout1_116 Vdout1_116ck202 = 0 time = 1015
.meas tran vdout1_116ck202 FIND v(dout1_116) AT=1015.025n

* CHECK dout1_117 Vdout1_117ck202 = 0 time = 1015
.meas tran vdout1_117ck202 FIND v(dout1_117) AT=1015.025n

* CHECK dout1_118 Vdout1_118ck202 = 0 time = 1015
.meas tran vdout1_118ck202 FIND v(dout1_118) AT=1015.025n

* CHECK dout1_119 Vdout1_119ck202 = 0 time = 1015
.meas tran vdout1_119ck202 FIND v(dout1_119) AT=1015.025n

* CHECK dout1_0 Vdout1_0ck204 = 0.9 time = 1025
.meas tran vdout1_0ck204 FIND v(dout1_0) AT=1025.025n

* CHECK dout1_1 Vdout1_1ck204 = 0.9 time = 1025
.meas tran vdout1_1ck204 FIND v(dout1_1) AT=1025.025n

* CHECK dout1_2 Vdout1_2ck204 = 0.9 time = 1025
.meas tran vdout1_2ck204 FIND v(dout1_2) AT=1025.025n

* CHECK dout1_3 Vdout1_3ck204 = 0.9 time = 1025
.meas tran vdout1_3ck204 FIND v(dout1_3) AT=1025.025n

* CHECK dout1_4 Vdout1_4ck204 = 0 time = 1025
.meas tran vdout1_4ck204 FIND v(dout1_4) AT=1025.025n

* CHECK dout1_5 Vdout1_5ck204 = 0.9 time = 1025
.meas tran vdout1_5ck204 FIND v(dout1_5) AT=1025.025n

* CHECK dout1_6 Vdout1_6ck204 = 0.9 time = 1025
.meas tran vdout1_6ck204 FIND v(dout1_6) AT=1025.025n

* CHECK dout1_7 Vdout1_7ck204 = 0.9 time = 1025
.meas tran vdout1_7ck204 FIND v(dout1_7) AT=1025.025n

* CHECK dout1_8 Vdout1_8ck204 = 0.9 time = 1025
.meas tran vdout1_8ck204 FIND v(dout1_8) AT=1025.025n

* CHECK dout1_9 Vdout1_9ck204 = 0.9 time = 1025
.meas tran vdout1_9ck204 FIND v(dout1_9) AT=1025.025n

* CHECK dout1_10 Vdout1_10ck204 = 0 time = 1025
.meas tran vdout1_10ck204 FIND v(dout1_10) AT=1025.025n

* CHECK dout1_11 Vdout1_11ck204 = 0.9 time = 1025
.meas tran vdout1_11ck204 FIND v(dout1_11) AT=1025.025n

* CHECK dout1_12 Vdout1_12ck204 = 0 time = 1025
.meas tran vdout1_12ck204 FIND v(dout1_12) AT=1025.025n

* CHECK dout1_13 Vdout1_13ck204 = 0.9 time = 1025
.meas tran vdout1_13ck204 FIND v(dout1_13) AT=1025.025n

* CHECK dout1_14 Vdout1_14ck204 = 0 time = 1025
.meas tran vdout1_14ck204 FIND v(dout1_14) AT=1025.025n

* CHECK dout1_15 Vdout1_15ck204 = 0 time = 1025
.meas tran vdout1_15ck204 FIND v(dout1_15) AT=1025.025n

* CHECK dout1_16 Vdout1_16ck204 = 0 time = 1025
.meas tran vdout1_16ck204 FIND v(dout1_16) AT=1025.025n

* CHECK dout1_17 Vdout1_17ck204 = 0.9 time = 1025
.meas tran vdout1_17ck204 FIND v(dout1_17) AT=1025.025n

* CHECK dout1_18 Vdout1_18ck204 = 0 time = 1025
.meas tran vdout1_18ck204 FIND v(dout1_18) AT=1025.025n

* CHECK dout1_19 Vdout1_19ck204 = 0 time = 1025
.meas tran vdout1_19ck204 FIND v(dout1_19) AT=1025.025n

* CHECK dout1_20 Vdout1_20ck204 = 0.9 time = 1025
.meas tran vdout1_20ck204 FIND v(dout1_20) AT=1025.025n

* CHECK dout1_21 Vdout1_21ck204 = 0 time = 1025
.meas tran vdout1_21ck204 FIND v(dout1_21) AT=1025.025n

* CHECK dout1_22 Vdout1_22ck204 = 0 time = 1025
.meas tran vdout1_22ck204 FIND v(dout1_22) AT=1025.025n

* CHECK dout1_23 Vdout1_23ck204 = 0 time = 1025
.meas tran vdout1_23ck204 FIND v(dout1_23) AT=1025.025n

* CHECK dout1_24 Vdout1_24ck204 = 0.9 time = 1025
.meas tran vdout1_24ck204 FIND v(dout1_24) AT=1025.025n

* CHECK dout1_25 Vdout1_25ck204 = 0.9 time = 1025
.meas tran vdout1_25ck204 FIND v(dout1_25) AT=1025.025n

* CHECK dout1_26 Vdout1_26ck204 = 0.9 time = 1025
.meas tran vdout1_26ck204 FIND v(dout1_26) AT=1025.025n

* CHECK dout1_27 Vdout1_27ck204 = 0.9 time = 1025
.meas tran vdout1_27ck204 FIND v(dout1_27) AT=1025.025n

* CHECK dout1_28 Vdout1_28ck204 = 0.9 time = 1025
.meas tran vdout1_28ck204 FIND v(dout1_28) AT=1025.025n

* CHECK dout1_29 Vdout1_29ck204 = 0.9 time = 1025
.meas tran vdout1_29ck204 FIND v(dout1_29) AT=1025.025n

* CHECK dout1_30 Vdout1_30ck204 = 0 time = 1025
.meas tran vdout1_30ck204 FIND v(dout1_30) AT=1025.025n

* CHECK dout1_31 Vdout1_31ck204 = 0.9 time = 1025
.meas tran vdout1_31ck204 FIND v(dout1_31) AT=1025.025n

* CHECK dout1_32 Vdout1_32ck204 = 0.9 time = 1025
.meas tran vdout1_32ck204 FIND v(dout1_32) AT=1025.025n

* CHECK dout1_33 Vdout1_33ck204 = 0.9 time = 1025
.meas tran vdout1_33ck204 FIND v(dout1_33) AT=1025.025n

* CHECK dout1_34 Vdout1_34ck204 = 0.9 time = 1025
.meas tran vdout1_34ck204 FIND v(dout1_34) AT=1025.025n

* CHECK dout1_35 Vdout1_35ck204 = 0.9 time = 1025
.meas tran vdout1_35ck204 FIND v(dout1_35) AT=1025.025n

* CHECK dout1_36 Vdout1_36ck204 = 0.9 time = 1025
.meas tran vdout1_36ck204 FIND v(dout1_36) AT=1025.025n

* CHECK dout1_37 Vdout1_37ck204 = 0 time = 1025
.meas tran vdout1_37ck204 FIND v(dout1_37) AT=1025.025n

* CHECK dout1_38 Vdout1_38ck204 = 0.9 time = 1025
.meas tran vdout1_38ck204 FIND v(dout1_38) AT=1025.025n

* CHECK dout1_39 Vdout1_39ck204 = 0 time = 1025
.meas tran vdout1_39ck204 FIND v(dout1_39) AT=1025.025n

* CHECK dout1_40 Vdout1_40ck204 = 0.9 time = 1025
.meas tran vdout1_40ck204 FIND v(dout1_40) AT=1025.025n

* CHECK dout1_41 Vdout1_41ck204 = 0.9 time = 1025
.meas tran vdout1_41ck204 FIND v(dout1_41) AT=1025.025n

* CHECK dout1_42 Vdout1_42ck204 = 0 time = 1025
.meas tran vdout1_42ck204 FIND v(dout1_42) AT=1025.025n

* CHECK dout1_43 Vdout1_43ck204 = 0.9 time = 1025
.meas tran vdout1_43ck204 FIND v(dout1_43) AT=1025.025n

* CHECK dout1_44 Vdout1_44ck204 = 0 time = 1025
.meas tran vdout1_44ck204 FIND v(dout1_44) AT=1025.025n

* CHECK dout1_45 Vdout1_45ck204 = 0 time = 1025
.meas tran vdout1_45ck204 FIND v(dout1_45) AT=1025.025n

* CHECK dout1_46 Vdout1_46ck204 = 0.9 time = 1025
.meas tran vdout1_46ck204 FIND v(dout1_46) AT=1025.025n

* CHECK dout1_47 Vdout1_47ck204 = 0 time = 1025
.meas tran vdout1_47ck204 FIND v(dout1_47) AT=1025.025n

* CHECK dout1_48 Vdout1_48ck204 = 0.9 time = 1025
.meas tran vdout1_48ck204 FIND v(dout1_48) AT=1025.025n

* CHECK dout1_49 Vdout1_49ck204 = 0 time = 1025
.meas tran vdout1_49ck204 FIND v(dout1_49) AT=1025.025n

* CHECK dout1_50 Vdout1_50ck204 = 0 time = 1025
.meas tran vdout1_50ck204 FIND v(dout1_50) AT=1025.025n

* CHECK dout1_51 Vdout1_51ck204 = 0.9 time = 1025
.meas tran vdout1_51ck204 FIND v(dout1_51) AT=1025.025n

* CHECK dout1_52 Vdout1_52ck204 = 0 time = 1025
.meas tran vdout1_52ck204 FIND v(dout1_52) AT=1025.025n

* CHECK dout1_53 Vdout1_53ck204 = 0.9 time = 1025
.meas tran vdout1_53ck204 FIND v(dout1_53) AT=1025.025n

* CHECK dout1_54 Vdout1_54ck204 = 0 time = 1025
.meas tran vdout1_54ck204 FIND v(dout1_54) AT=1025.025n

* CHECK dout1_55 Vdout1_55ck204 = 0.9 time = 1025
.meas tran vdout1_55ck204 FIND v(dout1_55) AT=1025.025n

* CHECK dout1_56 Vdout1_56ck204 = 0 time = 1025
.meas tran vdout1_56ck204 FIND v(dout1_56) AT=1025.025n

* CHECK dout1_57 Vdout1_57ck204 = 0.9 time = 1025
.meas tran vdout1_57ck204 FIND v(dout1_57) AT=1025.025n

* CHECK dout1_58 Vdout1_58ck204 = 0.9 time = 1025
.meas tran vdout1_58ck204 FIND v(dout1_58) AT=1025.025n

* CHECK dout1_59 Vdout1_59ck204 = 0.9 time = 1025
.meas tran vdout1_59ck204 FIND v(dout1_59) AT=1025.025n

* CHECK dout1_60 Vdout1_60ck204 = 0 time = 1025
.meas tran vdout1_60ck204 FIND v(dout1_60) AT=1025.025n

* CHECK dout1_61 Vdout1_61ck204 = 0.9 time = 1025
.meas tran vdout1_61ck204 FIND v(dout1_61) AT=1025.025n

* CHECK dout1_62 Vdout1_62ck204 = 0 time = 1025
.meas tran vdout1_62ck204 FIND v(dout1_62) AT=1025.025n

* CHECK dout1_63 Vdout1_63ck204 = 0 time = 1025
.meas tran vdout1_63ck204 FIND v(dout1_63) AT=1025.025n

* CHECK dout1_64 Vdout1_64ck204 = 0 time = 1025
.meas tran vdout1_64ck204 FIND v(dout1_64) AT=1025.025n

* CHECK dout1_65 Vdout1_65ck204 = 0.9 time = 1025
.meas tran vdout1_65ck204 FIND v(dout1_65) AT=1025.025n

* CHECK dout1_66 Vdout1_66ck204 = 0 time = 1025
.meas tran vdout1_66ck204 FIND v(dout1_66) AT=1025.025n

* CHECK dout1_67 Vdout1_67ck204 = 0.9 time = 1025
.meas tran vdout1_67ck204 FIND v(dout1_67) AT=1025.025n

* CHECK dout1_68 Vdout1_68ck204 = 0.9 time = 1025
.meas tran vdout1_68ck204 FIND v(dout1_68) AT=1025.025n

* CHECK dout1_69 Vdout1_69ck204 = 0 time = 1025
.meas tran vdout1_69ck204 FIND v(dout1_69) AT=1025.025n

* CHECK dout1_70 Vdout1_70ck204 = 0 time = 1025
.meas tran vdout1_70ck204 FIND v(dout1_70) AT=1025.025n

* CHECK dout1_71 Vdout1_71ck204 = 0 time = 1025
.meas tran vdout1_71ck204 FIND v(dout1_71) AT=1025.025n

* CHECK dout1_72 Vdout1_72ck204 = 0 time = 1025
.meas tran vdout1_72ck204 FIND v(dout1_72) AT=1025.025n

* CHECK dout1_73 Vdout1_73ck204 = 0.9 time = 1025
.meas tran vdout1_73ck204 FIND v(dout1_73) AT=1025.025n

* CHECK dout1_74 Vdout1_74ck204 = 0 time = 1025
.meas tran vdout1_74ck204 FIND v(dout1_74) AT=1025.025n

* CHECK dout1_75 Vdout1_75ck204 = 0 time = 1025
.meas tran vdout1_75ck204 FIND v(dout1_75) AT=1025.025n

* CHECK dout1_76 Vdout1_76ck204 = 0.9 time = 1025
.meas tran vdout1_76ck204 FIND v(dout1_76) AT=1025.025n

* CHECK dout1_77 Vdout1_77ck204 = 0.9 time = 1025
.meas tran vdout1_77ck204 FIND v(dout1_77) AT=1025.025n

* CHECK dout1_78 Vdout1_78ck204 = 0.9 time = 1025
.meas tran vdout1_78ck204 FIND v(dout1_78) AT=1025.025n

* CHECK dout1_79 Vdout1_79ck204 = 0 time = 1025
.meas tran vdout1_79ck204 FIND v(dout1_79) AT=1025.025n

* CHECK dout1_80 Vdout1_80ck204 = 0.9 time = 1025
.meas tran vdout1_80ck204 FIND v(dout1_80) AT=1025.025n

* CHECK dout1_81 Vdout1_81ck204 = 0.9 time = 1025
.meas tran vdout1_81ck204 FIND v(dout1_81) AT=1025.025n

* CHECK dout1_82 Vdout1_82ck204 = 0 time = 1025
.meas tran vdout1_82ck204 FIND v(dout1_82) AT=1025.025n

* CHECK dout1_83 Vdout1_83ck204 = 0 time = 1025
.meas tran vdout1_83ck204 FIND v(dout1_83) AT=1025.025n

* CHECK dout1_84 Vdout1_84ck204 = 0.9 time = 1025
.meas tran vdout1_84ck204 FIND v(dout1_84) AT=1025.025n

* CHECK dout1_85 Vdout1_85ck204 = 0.9 time = 1025
.meas tran vdout1_85ck204 FIND v(dout1_85) AT=1025.025n

* CHECK dout1_86 Vdout1_86ck204 = 0 time = 1025
.meas tran vdout1_86ck204 FIND v(dout1_86) AT=1025.025n

* CHECK dout1_87 Vdout1_87ck204 = 0 time = 1025
.meas tran vdout1_87ck204 FIND v(dout1_87) AT=1025.025n

* CHECK dout1_88 Vdout1_88ck204 = 0 time = 1025
.meas tran vdout1_88ck204 FIND v(dout1_88) AT=1025.025n

* CHECK dout1_89 Vdout1_89ck204 = 0.9 time = 1025
.meas tran vdout1_89ck204 FIND v(dout1_89) AT=1025.025n

* CHECK dout1_90 Vdout1_90ck204 = 0.9 time = 1025
.meas tran vdout1_90ck204 FIND v(dout1_90) AT=1025.025n

* CHECK dout1_91 Vdout1_91ck204 = 0 time = 1025
.meas tran vdout1_91ck204 FIND v(dout1_91) AT=1025.025n

* CHECK dout1_92 Vdout1_92ck204 = 0 time = 1025
.meas tran vdout1_92ck204 FIND v(dout1_92) AT=1025.025n

* CHECK dout1_93 Vdout1_93ck204 = 0 time = 1025
.meas tran vdout1_93ck204 FIND v(dout1_93) AT=1025.025n

* CHECK dout1_94 Vdout1_94ck204 = 0.9 time = 1025
.meas tran vdout1_94ck204 FIND v(dout1_94) AT=1025.025n

* CHECK dout1_95 Vdout1_95ck204 = 0 time = 1025
.meas tran vdout1_95ck204 FIND v(dout1_95) AT=1025.025n

* CHECK dout1_96 Vdout1_96ck204 = 0.9 time = 1025
.meas tran vdout1_96ck204 FIND v(dout1_96) AT=1025.025n

* CHECK dout1_97 Vdout1_97ck204 = 0 time = 1025
.meas tran vdout1_97ck204 FIND v(dout1_97) AT=1025.025n

* CHECK dout1_98 Vdout1_98ck204 = 0 time = 1025
.meas tran vdout1_98ck204 FIND v(dout1_98) AT=1025.025n

* CHECK dout1_99 Vdout1_99ck204 = 0 time = 1025
.meas tran vdout1_99ck204 FIND v(dout1_99) AT=1025.025n

* CHECK dout1_100 Vdout1_100ck204 = 0 time = 1025
.meas tran vdout1_100ck204 FIND v(dout1_100) AT=1025.025n

* CHECK dout1_101 Vdout1_101ck204 = 0.9 time = 1025
.meas tran vdout1_101ck204 FIND v(dout1_101) AT=1025.025n

* CHECK dout1_102 Vdout1_102ck204 = 0 time = 1025
.meas tran vdout1_102ck204 FIND v(dout1_102) AT=1025.025n

* CHECK dout1_103 Vdout1_103ck204 = 0.9 time = 1025
.meas tran vdout1_103ck204 FIND v(dout1_103) AT=1025.025n

* CHECK dout1_104 Vdout1_104ck204 = 0.9 time = 1025
.meas tran vdout1_104ck204 FIND v(dout1_104) AT=1025.025n

* CHECK dout1_105 Vdout1_105ck204 = 0.9 time = 1025
.meas tran vdout1_105ck204 FIND v(dout1_105) AT=1025.025n

* CHECK dout1_106 Vdout1_106ck204 = 0.9 time = 1025
.meas tran vdout1_106ck204 FIND v(dout1_106) AT=1025.025n

* CHECK dout1_107 Vdout1_107ck204 = 0 time = 1025
.meas tran vdout1_107ck204 FIND v(dout1_107) AT=1025.025n

* CHECK dout1_108 Vdout1_108ck204 = 0 time = 1025
.meas tran vdout1_108ck204 FIND v(dout1_108) AT=1025.025n

* CHECK dout1_109 Vdout1_109ck204 = 0.9 time = 1025
.meas tran vdout1_109ck204 FIND v(dout1_109) AT=1025.025n

* CHECK dout1_110 Vdout1_110ck204 = 0 time = 1025
.meas tran vdout1_110ck204 FIND v(dout1_110) AT=1025.025n

* CHECK dout1_111 Vdout1_111ck204 = 0.9 time = 1025
.meas tran vdout1_111ck204 FIND v(dout1_111) AT=1025.025n

* CHECK dout1_112 Vdout1_112ck204 = 0 time = 1025
.meas tran vdout1_112ck204 FIND v(dout1_112) AT=1025.025n

* CHECK dout1_113 Vdout1_113ck204 = 0 time = 1025
.meas tran vdout1_113ck204 FIND v(dout1_113) AT=1025.025n

* CHECK dout1_114 Vdout1_114ck204 = 0.9 time = 1025
.meas tran vdout1_114ck204 FIND v(dout1_114) AT=1025.025n

* CHECK dout1_115 Vdout1_115ck204 = 0.9 time = 1025
.meas tran vdout1_115ck204 FIND v(dout1_115) AT=1025.025n

* CHECK dout1_116 Vdout1_116ck204 = 0.9 time = 1025
.meas tran vdout1_116ck204 FIND v(dout1_116) AT=1025.025n

* CHECK dout1_117 Vdout1_117ck204 = 0.9 time = 1025
.meas tran vdout1_117ck204 FIND v(dout1_117) AT=1025.025n

* CHECK dout1_118 Vdout1_118ck204 = 0 time = 1025
.meas tran vdout1_118ck204 FIND v(dout1_118) AT=1025.025n

* CHECK dout1_119 Vdout1_119ck204 = 0.9 time = 1025
.meas tran vdout1_119ck204 FIND v(dout1_119) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
