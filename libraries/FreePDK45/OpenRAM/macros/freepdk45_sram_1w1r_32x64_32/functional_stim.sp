* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_32x64_32.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_32x64_32 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 a0_0 a0_1 a0_2 a0_3 a0_4 a1_0 a1_1 a1_2 a1_3 a1_4 CSB0 CSB1 clk0 clk1 WMASK0_0 WMASK0_1 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 vdd gnd freepdk45_sram_1w1r_32x64_32

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_32x64_32.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_32x64_32.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_32x64_32.s_en
* q:	xfreepdk45_sram_1w1r_32x64_32.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_32x64_32.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 1000010000011000001101001111010000110111110011010000100101111101  to  address 00000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 0110111001000001001011010010010010110000111110000101110100100100  to  address 00000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 1100010001110101101110001011011011111000111111100010101010000001  to  address 00000 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 1100010001110101101110001011011011111000111111100010101010000001 from address 00000 (from port 1) during cycle 4 (20ns - 25ns)
*	Writing (partial) 0101000001111100101010110100110111100001001110111101100100100001  to  address 00000 with mask bit 01 (from port 0) during cycle 5 (25ns - 30ns)
*	Writing (partial) 0000001100001100110100111011010001111110100001100111010110000110  to  address 00000 with mask bit 01 (from port 0) during cycle 6 (30ns - 35ns)
*	Reading 1100010001110101101110001011011001111110100001100111010110000110 from address 00000 (from port 1) during cycle 7 (35ns - 40ns)
*	Writing 1011100010110101111100101000001011010110010000110000010110101100  to  address 11110 (from port 0) during cycle 8 (40ns - 45ns)
*	Reading 1100010001110101101110001011011001111110100001100111010110000110 from address 00000 (from port 1) during cycle 9 (45ns - 50ns)
*	Writing 1111101011110001101001111010010111011110101110011110111001011010  to  address 00000 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 1011100010110101111100101000001011010110010000110000010110101100 from address 11110 (from port 1) during cycle 10 (50ns - 55ns)
*	Reading 1111101011110001101001111010010111011110101110011110111001011010 from address 00000 (from port 1) during cycle 11 (55ns - 60ns)
*	Writing (partial) 1110000001101000001001011101101101100111001100110100011110001001  to  address 11110 with mask bit 01 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 1111101011110001101001111010010111011110101110011110111001011010 from address 00000 (from port 1) during cycle 14 (70ns - 75ns)
*	Writing 0110100111001011000011110100110000001111001000100010010000101010  to  address 00000 (from port 0) during cycle 16 (80ns - 85ns)
*	Writing (partial) 0010100000011010000110110110111001100110010010000010001010101000  to  address 11110 with mask bit 01 (from port 0) during cycle 17 (85ns - 90ns)
*	Writing (partial) 1111110111011100000001011101001110111100101001001000101001110111  to  address 00000 with mask bit 01 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 1011100010110101111100101000001001100110010010000010001010101000 from address 11110 (from port 1) during cycle 19 (95ns - 100ns)
*	Writing (partial) 0100110010111100000100111010000100110110110101111010010011101110  to  address 11110 with mask bit 01 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 0110100111001011000011110100110010111100101001001000101001110111 from address 00000 (from port 1) during cycle 20 (100ns - 105ns)
*	Writing (partial) 0101011101001011100100000110010010011111000111100001111100111000  to  address 11110 with mask bit 01 (from port 0) during cycle 21 (105ns - 110ns)
*	Writing (partial) 0011100101100100100001010111101110101010001100100011100010101000  to  address 11110 with mask bit 01 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 0000011111011110111000111111101110011000000010000100100000110101  to  address 00000 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 1011100010110101111100101000001010101010001100100011100010101000 from address 11110 (from port 1) during cycle 23 (115ns - 120ns)
*	Writing 0111111001011111001111111101101111000101100001011100111111011000  to  address 11110 (from port 0) during cycle 25 (125ns - 130ns)
*	Writing 1011110111010101111011111100001110100001010110010011011110010001  to  address 11110 (from port 0) during cycle 26 (130ns - 135ns)
*	Reading 1011110111010101111011111100001110100001010110010011011110010001 from address 11110 (from port 1) during cycle 27 (135ns - 140ns)
*	Reading 1011110111010101111011111100001110100001010110010011011110010001 from address 11110 (from port 1) during cycle 28 (140ns - 145ns)
*	Writing 1011011111110100101000001110001000011010110101000001000100101100  to  address 00000 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 1011110111010101111011111100001110100001010110010011011110010001 from address 11110 (from port 1) during cycle 30 (150ns - 155ns)
*	Writing (partial) 0101111011010101110010111111110011100101011000111101000010111111  to  address 11110 with mask bit 01 (from port 0) during cycle 32 (160ns - 165ns)
*	Reading 1011011111110100101000001110001000011010110101000001000100101100 from address 00000 (from port 1) during cycle 32 (160ns - 165ns)
*	Reading 1011011111110100101000001110001000011010110101000001000100101100 from address 00000 (from port 1) during cycle 33 (165ns - 170ns)
*	Writing (partial) 1001110101001011111000001111100010000101111101000111111100010110  to  address 00000 with mask bit 01 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing (partial) 1000001110011100110111010111001001000000010000011101000110110001  to  address 00000 with mask bit 01 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing (partial) 1001010100000001010110101000100011101000110011000000101100001110  to  address 11110 with mask bit 01 (from port 0) during cycle 40 (200ns - 205ns)
*	Writing 1110010010111100000001100110010111110101101011001011100001110011  to  address 00000 (from port 0) during cycle 43 (215ns - 220ns)
*	Writing 1111111010011000100001010101001011000110001101010001101110010110  to  address 00000 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing 0011000000101011110001011001110001010101010111101000010100011010  to  address 11110 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 1111111010011000100001010101001011000110001101010001101110010110 from address 00000 (from port 1) during cycle 45 (225ns - 230ns)
*	Writing 1111000110111111101101111000001101101100100011011000010000110100  to  address 11110 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 1111111010011000100001010101001011000110001101010001101110010110 from address 00000 (from port 1) during cycle 46 (230ns - 235ns)
*	Writing 1011001000100100001010101110010000011011011101011001110111110110  to  address 00000 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 0001011111000100111110110001001011001010111101100001010101000010  to  address 11110 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 1011001000100100001010101110010000011011011101011001110111110110 from address 00000 (from port 1) during cycle 49 (245ns - 250ns)
*	Writing 0110000101101011101100100110001100111111110010110110011011001011  to  address 00000 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 0110000101101011101100100110001100111111110010110110011011001011 from address 00000 (from port 1) during cycle 51 (255ns - 260ns)
*	Writing (partial) 1101101101001111010110111011111101000010110111111110110110110011  to  address 00000 with mask bit 01 (from port 0) during cycle 52 (260ns - 265ns)
*	Writing 1000001000001100101101101001110101111001000011100000101111000111  to  address 00000 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing 0111110011101001001011111001110100100100001100101110001101010110  to  address 00000 (from port 0) during cycle 55 (275ns - 280ns)
*	Writing (partial) 1001111111101111000011111001000100100011010111110001101010011101  to  address 11110 with mask bit 10 (from port 0) during cycle 56 (280ns - 285ns)
*	Writing 0111111111000011110100011001001000000110010111001100100011011111  to  address 00000 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 1001111111101111000011111001000111001010111101100001010101000010 from address 11110 (from port 1) during cycle 57 (285ns - 290ns)
*	Reading 0111111111000011110100011001001000000110010111001100100011011111 from address 00000 (from port 1) during cycle 58 (290ns - 295ns)
*	Writing (partial) 0010001111010001010110100011111111110100111101000001111110111110  to  address 00000 with mask bit 01 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing (partial) 1001010011110110110111110010110000010110111011111100000001010001  to  address 11110 with mask bit 01 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 0111111111000011110100011001001011110100111101000001111110111110 from address 00000 (from port 1) during cycle 60 (300ns - 305ns)
*	Reading 1001111111101111000011111001000100010110111011111100000001010001 from address 11110 (from port 1) during cycle 61 (305ns - 310ns)
*	Writing 0000110010111000100111110101100101010101010011110001110111110111  to  address 11110 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing (partial) 1011010101010000010011111010000011101000000000000100010001110111  to  address 11110 with mask bit 10 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing (partial) 0011001100111010110001010010100110110001110111010110000110011010  to  address 11110 with mask bit 01 (from port 0) during cycle 65 (325ns - 330ns)
*	Writing (partial) 1000010011101101001101110011110110001001000010110011101011001010  to  address 11110 with mask bit 01 (from port 0) during cycle 66 (330ns - 335ns)
*	Reading 0111111111000011110100011001001011110100111101000001111110111110 from address 00000 (from port 1) during cycle 66 (330ns - 335ns)
*	Writing 0110110101100010111011001011010110110010001111111001110110101011  to  address 11110 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 1000100000000000001000011011010110001001101010111100001100111110  to  address 11110 (from port 0) during cycle 70 (350ns - 355ns)
*	Writing 1101000010110110110010011010011000011010100100011010100001010101  to  address 11110 (from port 0) during cycle 71 (355ns - 360ns)
*	Reading 0111111111000011110100011001001011110100111101000001111110111110 from address 00000 (from port 1) during cycle 71 (355ns - 360ns)
*	Reading 0111111111000011110100011001001011110100111101000001111110111110 from address 00000 (from port 1) during cycle 73 (365ns - 370ns)
*	Writing 1101101011110101010100111101000101000001000011101111000011011001  to  address 00000 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing (partial) 0101100111011100001001000100001101000110110001111100100000011100  to  address 11110 with mask bit 01 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 1101101011110101010100111101000101000001000011101111000011011001 from address 00000 (from port 1) during cycle 77 (385ns - 390ns)
*	Writing (partial) 1100010000111111111110111000101101101110101100101011011010110101  to  address 00000 with mask bit 10 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing 1100010000100100110101100000100010010001100000110111000111110001  to  address 11110 (from port 0) during cycle 80 (400ns - 405ns)
*	Writing 1001000110000101100111111100100101111001100111010100111111101011  to  address 00000 (from port 0) during cycle 81 (405ns - 410ns)
*	Reading 1001000110000101100111111100100101111001100111010100111111101011 from address 00000 (from port 1) during cycle 82 (410ns - 415ns)
*	Writing 0101011000101101011110010011010001111000101101110101011111101011  to  address 11110 (from port 0) during cycle 83 (415ns - 420ns)
*	Writing (partial) 0110100010010110011011111000000111110100011010100010000111001101  to  address 11110 with mask bit 10 (from port 0) during cycle 84 (420ns - 425ns)
*	Reading 1001000110000101100111111100100101111001100111010100111111101011 from address 00000 (from port 1) during cycle 84 (420ns - 425ns)
*	Writing (partial) 1100000111101011110010100111001100111000011000000100001010011001  to  address 11110 with mask bit 01 (from port 0) during cycle 85 (425ns - 430ns)
*	Writing 0011001101101000100010110010000010101011101010000101001111000111  to  address 00000 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing (partial) 1100001001100101111111100010101111110001011100011100101101101010  to  address 11110 with mask bit 10 (from port 0) during cycle 88 (440ns - 445ns)
*	Writing 1111100000101110100100011001001100000010110110000101000010001010  to  address 00000 (from port 0) during cycle 89 (445ns - 450ns)
*	Writing 1110011101101001001011000000000101100101001110001010010100011001  to  address 00000 (from port 0) during cycle 90 (450ns - 455ns)
*	Reading 1110011101101001001011000000000101100101001110001010010100011001 from address 00000 (from port 1) during cycle 92 (460ns - 465ns)
*	Writing (partial) 0011000111100110010101100101011011011010011001100000011111101101  to  address 00000 with mask bit 01 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 1100001001100101111111100010101100111000011000000100001010011001 from address 11110 (from port 1) during cycle 93 (465ns - 470ns)
*	Writing 0110100111110001011110010101000011000100101011001111111011011001  to  address 11110 (from port 0) during cycle 94 (470ns - 475ns)
*	Writing (partial) 1001001111010111110010001100110101100110100100100011001110101111  to  address 11110 with mask bit 01 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 1110011101101001001011000000000111011010011001100000011111101101 from address 00000 (from port 1) during cycle 95 (475ns - 480ns)
*	Reading 0110100111110001011110010101000001100110100100100011001110101111 from address 11110 (from port 1) during cycle 96 (480ns - 485ns)
*	Writing 0110011011011111001010100100110110101111110000101111001010010111  to  address 00000 (from port 0) during cycle 97 (485ns - 490ns)
*	Writing (partial) 0101111110001110100011011010110010100110101101100010000000110111  to  address 11110 with mask bit 10 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 1110011100010000111001010001110000110101011010010010101110011001  to  address 00000 (from port 0) during cycle 99 (495ns - 500ns)
*	Writing 1100011000111010111101110110010000111000110100110011001000011000  to  address 00000 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 0101111110001110100011011010110001100110100100100011001110101111 from address 11110 (from port 1) during cycle 101 (505ns - 510ns)
*	Writing 0001110011100111100111010101011010000101101101010011111011001010  to  address 11110 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 1100011000111010111101110110010000111000110100110011001000011000 from address 00000 (from port 1) during cycle 103 (515ns - 520ns)
*	Writing (partial) 0111010101001000100001101100111101100100011110011010010100111000  to  address 11110 with mask bit 01 (from port 0) during cycle 104 (520ns - 525ns)
*	Writing 1000000000000101011000010010001100001100000100111001010001011001  to  address 11110 (from port 0) during cycle 105 (525ns - 530ns)
*	Writing 0001000100011000100001110001000011100011101111101110001001010111  to  address 11110 (from port 0) during cycle 106 (530ns - 535ns)
*	Writing 0111000111001101010101010001111110111100010100110000101110110011  to  address 00000 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 0001000100011000100001110001000011100011101111101110001001010111 from address 11110 (from port 1) during cycle 107 (535ns - 540ns)
*	Writing 1101101001001010011101001001000011010000100011010001111110001110  to  address 11110 (from port 0) during cycle 108 (540ns - 545ns)
*	Writing 0100100000011001111000111000110110110000100010010010001000110100  to  address 00000 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 1101101001001010011101001001000011010000100011010001111110001110 from address 11110 (from port 1) during cycle 109 (545ns - 550ns)
*	Writing 1101010110011001110000001110000111011100011100001101100101011001  to  address 00000 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 1101101001001010011101001001000011010000100011010001111110001110 from address 11110 (from port 1) during cycle 110 (550ns - 555ns)
*	Writing 1011100000101110010110000000100010111111010100010110010001010110  to  address 11110 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 1101010110011001110000001110000111011100011100001101100101011001 from address 00000 (from port 1) during cycle 111 (555ns - 560ns)
*	Writing 0100011110001010011100110110110011110000101001110110010001100001  to  address 11110 (from port 0) during cycle 113 (565ns - 570ns)
*	Writing 0010000110001100000100010010101001111001000011000010011001000111  to  address 11110 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing (partial) 0111110001100111011111110010010001000001110110000100101010000010  to  address 00000 with mask bit 01 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 0111000001000100000011110110010010100101100100000010001011001000  to  address 11110 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 1101010110011001110000001110000101000001110110000100101010000010 from address 00000 (from port 1) during cycle 118 (590ns - 595ns)
*	Writing (partial) 0110010101001110110110010100000101011111111000011001001110001010  to  address 00000 with mask bit 10 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 0111000001000100000011110110010010100101100100000010001011001000 from address 11110 (from port 1) during cycle 120 (600ns - 605ns)
*	Writing (partial) 0111001100111000101010010110110000011001000110100000111111100111  to  address 11110 with mask bit 01 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 0110010101001110110110010100000101000001110110000100101010000010 from address 00000 (from port 1) during cycle 121 (605ns - 610ns)
*	Writing 1111000011111001011001011011101110111010001110101011110011101111  to  address 11110 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 0110010101001110110110010100000101000001110110000100101010000010 from address 00000 (from port 1) during cycle 123 (615ns - 620ns)
*	Reading 1111000011111001011001011011101110111010001110101011110011101111 from address 11110 (from port 1) during cycle 125 (625ns - 630ns)
*	Reading 0110010101001110110110010100000101000001110110000100101010000010 from address 00000 (from port 1) during cycle 126 (630ns - 635ns)
*	Writing (partial) 0110000100000110010011001100101001100100011100000111010111001001  to  address 00000 with mask bit 01 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 0110010101001110110110010100000101100100011100000111010111001001 from address 00000 (from port 1) during cycle 128 (640ns - 645ns)
*	Writing 0010100010010010101100100000000010100000011100110000101000101100  to  address 11110 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 0010100010010010101100100000000010100000011100110000101000101100 from address 11110 (from port 1) during cycle 130 (650ns - 655ns)
*	Reading 0110010101001110110110010100000101100100011100000111010111001001 from address 00000 (from port 1) during cycle 131 (655ns - 660ns)
*	Writing (partial) 1110100100101100110100011000111010111000000101111001000010110110  to  address 00000 with mask bit 01 (from port 0) during cycle 132 (660ns - 665ns)
*	Writing 1100011000100000000010000111010110100000011000100110000110010001  to  address 00000 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing 1110100110001011101011011000000010110101001000111111010101111111  to  address 11110 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 1100011000100000000010000111010110100000011000100110000110010001 from address 00000 (from port 1) during cycle 134 (670ns - 675ns)
*	Reading 1100011000100000000010000111010110100000011000100110000110010001 from address 00000 (from port 1) during cycle 135 (675ns - 680ns)
*	Writing 1011011011101010100010110100100111001111110011101111001000011000  to  address 00000 (from port 0) during cycle 136 (680ns - 685ns)
*	Writing (partial) 0101010001111110111101000110001011101110010011000011010101110001  to  address 00000 with mask bit 10 (from port 0) during cycle 137 (685ns - 690ns)
*	Writing 0100011111011000010110111111001010000100100101000011110011000011  to  address 00000 (from port 0) during cycle 138 (690ns - 695ns)
*	Writing (partial) 1000110101101001011000001010010001010000101011111010100101010000  to  address 00000 with mask bit 10 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 1000010000001101100100000011001100011100001000111110000101011101  to  address 11110 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 1000110101101001011000001010010010000100100101000011110011000011 from address 00000 (from port 1) during cycle 142 (710ns - 715ns)
*	Reading 1000110101101001011000001010010010000100100101000011110011000011 from address 00000 (from port 1) during cycle 143 (715ns - 720ns)
*	Writing (partial) 0011010000101010001001001000111100010000110111110011101001001101  to  address 00000 with mask bit 10 (from port 0) during cycle 144 (720ns - 725ns)
*	Reading 1000010000001101100100000011001100011100001000111110000101011101 from address 11110 (from port 1) during cycle 144 (720ns - 725ns)
*	Writing 1110010110000111111100110010001110100011111010011101010001100001  to  address 00000 (from port 0) during cycle 145 (725ns - 730ns)
*	Reading 1000010000001101100100000011001100011100001000111110000101011101 from address 11110 (from port 1) during cycle 145 (725ns - 730ns)
*	Writing (partial) 0010101111011010000001101100000100000011011011000110110010101011  to  address 00000 with mask bit 01 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing (partial) 0101111111000110000011100111001100001101000001101111101000010111  to  address 11110 with mask bit 10 (from port 0) during cycle 148 (740ns - 745ns)
*	Reading 1110010110000111111100110010001100000011011011000110110010101011 from address 00000 (from port 1) during cycle 148 (740ns - 745ns)
*	Writing 1100010100001001100110010011011011000110100010110111110100011011  to  address 11110 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 1100010100001001100110010011011011000110100010110111110100011011 from address 11110 (from port 1) during cycle 150 (750ns - 755ns)
*	Reading 1110010110000111111100110010001100000011011011000110110010101011 from address 00000 (from port 1) during cycle 151 (755ns - 760ns)
*	Writing 0000100011001010010101101010000001110101010101111101110011001001  to  address 00000 (from port 0) during cycle 152 (760ns - 765ns)
*	Writing 1111010111101000110001111110100000001011011010010000110001101001  to  address 11110 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 0000100011001010010101101010000001110101010101111101110011001001 from address 00000 (from port 1) during cycle 153 (765ns - 770ns)
*	Reading 0000100011001010010101101010000001110101010101111101110011001001 from address 00000 (from port 1) during cycle 154 (770ns - 775ns)
*	Writing 1001110011101001110000010111100010100010110010011111011010010101  to  address 00000 (from port 0) during cycle 155 (775ns - 780ns)
*	Writing (partial) 0100011001100011000101111000011111100000000001101001010000011001  to  address 11110 with mask bit 01 (from port 0) during cycle 156 (780ns - 785ns)
*	Writing 1010101010011011010110101000101101000000010101001011100001111110  to  address 00000 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 1010101010011011010110101000101101000000010101001011100001111110 from address 00000 (from port 1) during cycle 158 (790ns - 795ns)
*	Reading 1111010111101000110001111110100011100000000001101001010000011001 from address 11110 (from port 1) during cycle 159 (795ns - 800ns)
*	Writing (partial) 1000101101111111001001010110010001110111000110110110001111101111  to  address 00000 with mask bit 10 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 1111010111101000110001111110100011100000000001101001010000011001 from address 11110 (from port 1) during cycle 160 (800ns - 805ns)
*	Writing 0000111111111010101101011100100101111111101101000111010011001000  to  address 00000 (from port 0) during cycle 161 (805ns - 810ns)
*	Writing (partial) 1001001110110101001001100101110100011100011101010101111110101101  to  address 11110 with mask bit 10 (from port 0) during cycle 162 (810ns - 815ns)
*	Writing 0001100000001000100100000011101000000010001100111101010111100010  to  address 11110 (from port 0) during cycle 163 (815ns - 820ns)
*	Writing 0010101001001101111000110001010100010010001101100000100110001000  to  address 11110 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 0000111111111010101101011100100101111111101101000111010011001000 from address 00000 (from port 1) during cycle 165 (825ns - 830ns)
*	Reading 0010101001001101111000110001010100010010001101100000100110001000 from address 11110 (from port 1) during cycle 166 (830ns - 835ns)
*	Writing 0001000111110111100000101101011111010101001100111110100110010011  to  address 11110 (from port 0) during cycle 167 (835ns - 840ns)
*	Writing (partial) 0101011111011111000101000101101010001110001001111001111000001011  to  address 11110 with mask bit 10 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing 0011100100101110101100100110110101010011111110110100011101011100  to  address 11110 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 0000111111111010101101011100100101111111101101000111010011001000 from address 00000 (from port 1) during cycle 169 (845ns - 850ns)
*	Reading 0011100100101110101100100110110101010011111110110100011101011100 from address 11110 (from port 1) during cycle 170 (850ns - 855ns)
*	Writing 0101010111000010000110010000001000110100011111110000100110010100  to  address 00000 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 0101010111000010000110010000001000110100011111110000100110010100 from address 00000 (from port 1) during cycle 172 (860ns - 865ns)
*	Writing (partial) 1001101110101100111001101100000100010011000000010110111010000101  to  address 11110 with mask bit 01 (from port 0) during cycle 173 (865ns - 870ns)
*	Writing 1000011111010011101011101111110001110001011101010111010101110011  to  address 11110 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 0101010111000010000110010000001000110100011111110000100110010100 from address 00000 (from port 1) during cycle 174 (870ns - 875ns)
*	Reading 0101010111000010000110010000001000110100011111110000100110010100 from address 00000 (from port 1) during cycle 175 (875ns - 880ns)
*	Writing 0011100100010011110010010010101101100101100101001111111011011011  to  address 11110 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing (partial) 0100000001011010100111011001010001110100100011111001000100101100  to  address 00000 with mask bit 01 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 1101111000000111000000011111010001000101101110000011010100010110  to  address 11110 (from port 0) during cycle 179 (895ns - 900ns)
*	Writing 1110011110001001110010101001001110110111000111000101011010011011  to  address 00000 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 1101111000000111000000011111010001000101101110000011010100010110 from address 11110 (from port 1) during cycle 180 (900ns - 905ns)
*	Writing 1101000011010111111001011011010001010001111100110001000100010010  to  address 11110 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 0100001011011000110110111010111101001001011100110000100001111100  to  address 00000 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing 1011011111000001010011001110111110001001110110100001110010110110  to  address 11110 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 1011011111000001010011001110111110001001110110100001110010110110 from address 11110 (from port 1) during cycle 186 (930ns - 935ns)
*	Writing (partial) 1001111100100111101001001010100010011001001101111001110101101110  to  address 00000 with mask bit 01 (from port 0) during cycle 187 (935ns - 940ns)
*	Reading 0100001011011000110110111010111110011001001101111001110101101110 from address 00000 (from port 1) during cycle 188 (940ns - 945ns)
*	Writing 1111101111101000001101011100010001001001110110111011100011100001  to  address 00000 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 1111001001100011111101110111110100011001110111100111001101101001  to  address 00000 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing (partial) 1100101100010100010110001011101010001101100001111011111111010111  to  address 11110 with mask bit 10 (from port 0) during cycle 194 (970ns - 975ns)
*	Writing 0101111101000011000010011110011010100110011111011001100111001011  to  address 11110 (from port 0) during cycle 195 (975ns - 980ns)
*	Writing 1010001111011101000100110000010101111110101011000011101010001100  to  address 11110 (from port 0) during cycle 196 (980ns - 985ns)
*	Writing 1001001111110100010101101100011001111000100111001010110001111101  to  address 11110 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 1111001001100011111101110111110100011001110111100111001101101001 from address 00000 (from port 1) during cycle 198 (990ns - 995ns)
*	Writing (partial) 0101011010101000000001000111011000000101110010010011100011100101  to  address 11110 with mask bit 10 (from port 0) during cycle 199 (995ns - 1000ns)
*	Writing (partial) 1100011011100000111010101011111011000001001110011011000100000111  to  address 00000 with mask bit 01 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 0101011010101000000001000111011001111000100111001010110001111101 from address 11110 (from port 1) during cycle 200 (1000ns - 1005ns)
*	Writing (partial) 1010011011101111011111010101000000110110000011000000011000101000  to  address 11110 with mask bit 01 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 1111001001100011111101110111110111000001001110011011000100000111 from address 00000 (from port 1) during cycle 203 (1015ns - 1020ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_4  a1_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0.9 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0.9 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0.9 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0.9 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0.9 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0.9 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0.9 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0.9 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0.9 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0.9 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0.9 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0.9 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0.9 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0.9 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0.9 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0.9 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0.9 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0.9 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0.9 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0.9 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0.9 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0.9 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0.9 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0.9 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0.9 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0.9 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0.9 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0.9 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0.9 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0.9 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0.9 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_0 Vdout1_0ck7 = 0 time = 40
.meas tran vdout1_0ck7 FIND v(dout1_0) AT=40.025n

* CHECK dout1_1 Vdout1_1ck7 = 0.9 time = 40
.meas tran vdout1_1ck7 FIND v(dout1_1) AT=40.025n

* CHECK dout1_2 Vdout1_2ck7 = 0.9 time = 40
.meas tran vdout1_2ck7 FIND v(dout1_2) AT=40.025n

* CHECK dout1_3 Vdout1_3ck7 = 0 time = 40
.meas tran vdout1_3ck7 FIND v(dout1_3) AT=40.025n

* CHECK dout1_4 Vdout1_4ck7 = 0 time = 40
.meas tran vdout1_4ck7 FIND v(dout1_4) AT=40.025n

* CHECK dout1_5 Vdout1_5ck7 = 0 time = 40
.meas tran vdout1_5ck7 FIND v(dout1_5) AT=40.025n

* CHECK dout1_6 Vdout1_6ck7 = 0 time = 40
.meas tran vdout1_6ck7 FIND v(dout1_6) AT=40.025n

* CHECK dout1_7 Vdout1_7ck7 = 0.9 time = 40
.meas tran vdout1_7ck7 FIND v(dout1_7) AT=40.025n

* CHECK dout1_8 Vdout1_8ck7 = 0.9 time = 40
.meas tran vdout1_8ck7 FIND v(dout1_8) AT=40.025n

* CHECK dout1_9 Vdout1_9ck7 = 0 time = 40
.meas tran vdout1_9ck7 FIND v(dout1_9) AT=40.025n

* CHECK dout1_10 Vdout1_10ck7 = 0.9 time = 40
.meas tran vdout1_10ck7 FIND v(dout1_10) AT=40.025n

* CHECK dout1_11 Vdout1_11ck7 = 0 time = 40
.meas tran vdout1_11ck7 FIND v(dout1_11) AT=40.025n

* CHECK dout1_12 Vdout1_12ck7 = 0.9 time = 40
.meas tran vdout1_12ck7 FIND v(dout1_12) AT=40.025n

* CHECK dout1_13 Vdout1_13ck7 = 0.9 time = 40
.meas tran vdout1_13ck7 FIND v(dout1_13) AT=40.025n

* CHECK dout1_14 Vdout1_14ck7 = 0.9 time = 40
.meas tran vdout1_14ck7 FIND v(dout1_14) AT=40.025n

* CHECK dout1_15 Vdout1_15ck7 = 0 time = 40
.meas tran vdout1_15ck7 FIND v(dout1_15) AT=40.025n

* CHECK dout1_16 Vdout1_16ck7 = 0 time = 40
.meas tran vdout1_16ck7 FIND v(dout1_16) AT=40.025n

* CHECK dout1_17 Vdout1_17ck7 = 0.9 time = 40
.meas tran vdout1_17ck7 FIND v(dout1_17) AT=40.025n

* CHECK dout1_18 Vdout1_18ck7 = 0.9 time = 40
.meas tran vdout1_18ck7 FIND v(dout1_18) AT=40.025n

* CHECK dout1_19 Vdout1_19ck7 = 0 time = 40
.meas tran vdout1_19ck7 FIND v(dout1_19) AT=40.025n

* CHECK dout1_20 Vdout1_20ck7 = 0 time = 40
.meas tran vdout1_20ck7 FIND v(dout1_20) AT=40.025n

* CHECK dout1_21 Vdout1_21ck7 = 0 time = 40
.meas tran vdout1_21ck7 FIND v(dout1_21) AT=40.025n

* CHECK dout1_22 Vdout1_22ck7 = 0 time = 40
.meas tran vdout1_22ck7 FIND v(dout1_22) AT=40.025n

* CHECK dout1_23 Vdout1_23ck7 = 0.9 time = 40
.meas tran vdout1_23ck7 FIND v(dout1_23) AT=40.025n

* CHECK dout1_24 Vdout1_24ck7 = 0 time = 40
.meas tran vdout1_24ck7 FIND v(dout1_24) AT=40.025n

* CHECK dout1_25 Vdout1_25ck7 = 0.9 time = 40
.meas tran vdout1_25ck7 FIND v(dout1_25) AT=40.025n

* CHECK dout1_26 Vdout1_26ck7 = 0.9 time = 40
.meas tran vdout1_26ck7 FIND v(dout1_26) AT=40.025n

* CHECK dout1_27 Vdout1_27ck7 = 0.9 time = 40
.meas tran vdout1_27ck7 FIND v(dout1_27) AT=40.025n

* CHECK dout1_28 Vdout1_28ck7 = 0.9 time = 40
.meas tran vdout1_28ck7 FIND v(dout1_28) AT=40.025n

* CHECK dout1_29 Vdout1_29ck7 = 0.9 time = 40
.meas tran vdout1_29ck7 FIND v(dout1_29) AT=40.025n

* CHECK dout1_30 Vdout1_30ck7 = 0.9 time = 40
.meas tran vdout1_30ck7 FIND v(dout1_30) AT=40.025n

* CHECK dout1_31 Vdout1_31ck7 = 0 time = 40
.meas tran vdout1_31ck7 FIND v(dout1_31) AT=40.025n

* CHECK dout1_32 Vdout1_32ck7 = 0 time = 40
.meas tran vdout1_32ck7 FIND v(dout1_32) AT=40.025n

* CHECK dout1_33 Vdout1_33ck7 = 0.9 time = 40
.meas tran vdout1_33ck7 FIND v(dout1_33) AT=40.025n

* CHECK dout1_34 Vdout1_34ck7 = 0.9 time = 40
.meas tran vdout1_34ck7 FIND v(dout1_34) AT=40.025n

* CHECK dout1_35 Vdout1_35ck7 = 0 time = 40
.meas tran vdout1_35ck7 FIND v(dout1_35) AT=40.025n

* CHECK dout1_36 Vdout1_36ck7 = 0.9 time = 40
.meas tran vdout1_36ck7 FIND v(dout1_36) AT=40.025n

* CHECK dout1_37 Vdout1_37ck7 = 0.9 time = 40
.meas tran vdout1_37ck7 FIND v(dout1_37) AT=40.025n

* CHECK dout1_38 Vdout1_38ck7 = 0 time = 40
.meas tran vdout1_38ck7 FIND v(dout1_38) AT=40.025n

* CHECK dout1_39 Vdout1_39ck7 = 0.9 time = 40
.meas tran vdout1_39ck7 FIND v(dout1_39) AT=40.025n

* CHECK dout1_40 Vdout1_40ck7 = 0 time = 40
.meas tran vdout1_40ck7 FIND v(dout1_40) AT=40.025n

* CHECK dout1_41 Vdout1_41ck7 = 0 time = 40
.meas tran vdout1_41ck7 FIND v(dout1_41) AT=40.025n

* CHECK dout1_42 Vdout1_42ck7 = 0 time = 40
.meas tran vdout1_42ck7 FIND v(dout1_42) AT=40.025n

* CHECK dout1_43 Vdout1_43ck7 = 0.9 time = 40
.meas tran vdout1_43ck7 FIND v(dout1_43) AT=40.025n

* CHECK dout1_44 Vdout1_44ck7 = 0.9 time = 40
.meas tran vdout1_44ck7 FIND v(dout1_44) AT=40.025n

* CHECK dout1_45 Vdout1_45ck7 = 0.9 time = 40
.meas tran vdout1_45ck7 FIND v(dout1_45) AT=40.025n

* CHECK dout1_46 Vdout1_46ck7 = 0 time = 40
.meas tran vdout1_46ck7 FIND v(dout1_46) AT=40.025n

* CHECK dout1_47 Vdout1_47ck7 = 0.9 time = 40
.meas tran vdout1_47ck7 FIND v(dout1_47) AT=40.025n

* CHECK dout1_48 Vdout1_48ck7 = 0.9 time = 40
.meas tran vdout1_48ck7 FIND v(dout1_48) AT=40.025n

* CHECK dout1_49 Vdout1_49ck7 = 0 time = 40
.meas tran vdout1_49ck7 FIND v(dout1_49) AT=40.025n

* CHECK dout1_50 Vdout1_50ck7 = 0.9 time = 40
.meas tran vdout1_50ck7 FIND v(dout1_50) AT=40.025n

* CHECK dout1_51 Vdout1_51ck7 = 0 time = 40
.meas tran vdout1_51ck7 FIND v(dout1_51) AT=40.025n

* CHECK dout1_52 Vdout1_52ck7 = 0.9 time = 40
.meas tran vdout1_52ck7 FIND v(dout1_52) AT=40.025n

* CHECK dout1_53 Vdout1_53ck7 = 0.9 time = 40
.meas tran vdout1_53ck7 FIND v(dout1_53) AT=40.025n

* CHECK dout1_54 Vdout1_54ck7 = 0.9 time = 40
.meas tran vdout1_54ck7 FIND v(dout1_54) AT=40.025n

* CHECK dout1_55 Vdout1_55ck7 = 0 time = 40
.meas tran vdout1_55ck7 FIND v(dout1_55) AT=40.025n

* CHECK dout1_56 Vdout1_56ck7 = 0 time = 40
.meas tran vdout1_56ck7 FIND v(dout1_56) AT=40.025n

* CHECK dout1_57 Vdout1_57ck7 = 0 time = 40
.meas tran vdout1_57ck7 FIND v(dout1_57) AT=40.025n

* CHECK dout1_58 Vdout1_58ck7 = 0.9 time = 40
.meas tran vdout1_58ck7 FIND v(dout1_58) AT=40.025n

* CHECK dout1_59 Vdout1_59ck7 = 0 time = 40
.meas tran vdout1_59ck7 FIND v(dout1_59) AT=40.025n

* CHECK dout1_60 Vdout1_60ck7 = 0 time = 40
.meas tran vdout1_60ck7 FIND v(dout1_60) AT=40.025n

* CHECK dout1_61 Vdout1_61ck7 = 0 time = 40
.meas tran vdout1_61ck7 FIND v(dout1_61) AT=40.025n

* CHECK dout1_62 Vdout1_62ck7 = 0.9 time = 40
.meas tran vdout1_62ck7 FIND v(dout1_62) AT=40.025n

* CHECK dout1_63 Vdout1_63ck7 = 0.9 time = 40
.meas tran vdout1_63ck7 FIND v(dout1_63) AT=40.025n

* CHECK dout1_0 Vdout1_0ck9 = 0 time = 50
.meas tran vdout1_0ck9 FIND v(dout1_0) AT=50.025n

* CHECK dout1_1 Vdout1_1ck9 = 0.9 time = 50
.meas tran vdout1_1ck9 FIND v(dout1_1) AT=50.025n

* CHECK dout1_2 Vdout1_2ck9 = 0.9 time = 50
.meas tran vdout1_2ck9 FIND v(dout1_2) AT=50.025n

* CHECK dout1_3 Vdout1_3ck9 = 0 time = 50
.meas tran vdout1_3ck9 FIND v(dout1_3) AT=50.025n

* CHECK dout1_4 Vdout1_4ck9 = 0 time = 50
.meas tran vdout1_4ck9 FIND v(dout1_4) AT=50.025n

* CHECK dout1_5 Vdout1_5ck9 = 0 time = 50
.meas tran vdout1_5ck9 FIND v(dout1_5) AT=50.025n

* CHECK dout1_6 Vdout1_6ck9 = 0 time = 50
.meas tran vdout1_6ck9 FIND v(dout1_6) AT=50.025n

* CHECK dout1_7 Vdout1_7ck9 = 0.9 time = 50
.meas tran vdout1_7ck9 FIND v(dout1_7) AT=50.025n

* CHECK dout1_8 Vdout1_8ck9 = 0.9 time = 50
.meas tran vdout1_8ck9 FIND v(dout1_8) AT=50.025n

* CHECK dout1_9 Vdout1_9ck9 = 0 time = 50
.meas tran vdout1_9ck9 FIND v(dout1_9) AT=50.025n

* CHECK dout1_10 Vdout1_10ck9 = 0.9 time = 50
.meas tran vdout1_10ck9 FIND v(dout1_10) AT=50.025n

* CHECK dout1_11 Vdout1_11ck9 = 0 time = 50
.meas tran vdout1_11ck9 FIND v(dout1_11) AT=50.025n

* CHECK dout1_12 Vdout1_12ck9 = 0.9 time = 50
.meas tran vdout1_12ck9 FIND v(dout1_12) AT=50.025n

* CHECK dout1_13 Vdout1_13ck9 = 0.9 time = 50
.meas tran vdout1_13ck9 FIND v(dout1_13) AT=50.025n

* CHECK dout1_14 Vdout1_14ck9 = 0.9 time = 50
.meas tran vdout1_14ck9 FIND v(dout1_14) AT=50.025n

* CHECK dout1_15 Vdout1_15ck9 = 0 time = 50
.meas tran vdout1_15ck9 FIND v(dout1_15) AT=50.025n

* CHECK dout1_16 Vdout1_16ck9 = 0 time = 50
.meas tran vdout1_16ck9 FIND v(dout1_16) AT=50.025n

* CHECK dout1_17 Vdout1_17ck9 = 0.9 time = 50
.meas tran vdout1_17ck9 FIND v(dout1_17) AT=50.025n

* CHECK dout1_18 Vdout1_18ck9 = 0.9 time = 50
.meas tran vdout1_18ck9 FIND v(dout1_18) AT=50.025n

* CHECK dout1_19 Vdout1_19ck9 = 0 time = 50
.meas tran vdout1_19ck9 FIND v(dout1_19) AT=50.025n

* CHECK dout1_20 Vdout1_20ck9 = 0 time = 50
.meas tran vdout1_20ck9 FIND v(dout1_20) AT=50.025n

* CHECK dout1_21 Vdout1_21ck9 = 0 time = 50
.meas tran vdout1_21ck9 FIND v(dout1_21) AT=50.025n

* CHECK dout1_22 Vdout1_22ck9 = 0 time = 50
.meas tran vdout1_22ck9 FIND v(dout1_22) AT=50.025n

* CHECK dout1_23 Vdout1_23ck9 = 0.9 time = 50
.meas tran vdout1_23ck9 FIND v(dout1_23) AT=50.025n

* CHECK dout1_24 Vdout1_24ck9 = 0 time = 50
.meas tran vdout1_24ck9 FIND v(dout1_24) AT=50.025n

* CHECK dout1_25 Vdout1_25ck9 = 0.9 time = 50
.meas tran vdout1_25ck9 FIND v(dout1_25) AT=50.025n

* CHECK dout1_26 Vdout1_26ck9 = 0.9 time = 50
.meas tran vdout1_26ck9 FIND v(dout1_26) AT=50.025n

* CHECK dout1_27 Vdout1_27ck9 = 0.9 time = 50
.meas tran vdout1_27ck9 FIND v(dout1_27) AT=50.025n

* CHECK dout1_28 Vdout1_28ck9 = 0.9 time = 50
.meas tran vdout1_28ck9 FIND v(dout1_28) AT=50.025n

* CHECK dout1_29 Vdout1_29ck9 = 0.9 time = 50
.meas tran vdout1_29ck9 FIND v(dout1_29) AT=50.025n

* CHECK dout1_30 Vdout1_30ck9 = 0.9 time = 50
.meas tran vdout1_30ck9 FIND v(dout1_30) AT=50.025n

* CHECK dout1_31 Vdout1_31ck9 = 0 time = 50
.meas tran vdout1_31ck9 FIND v(dout1_31) AT=50.025n

* CHECK dout1_32 Vdout1_32ck9 = 0 time = 50
.meas tran vdout1_32ck9 FIND v(dout1_32) AT=50.025n

* CHECK dout1_33 Vdout1_33ck9 = 0.9 time = 50
.meas tran vdout1_33ck9 FIND v(dout1_33) AT=50.025n

* CHECK dout1_34 Vdout1_34ck9 = 0.9 time = 50
.meas tran vdout1_34ck9 FIND v(dout1_34) AT=50.025n

* CHECK dout1_35 Vdout1_35ck9 = 0 time = 50
.meas tran vdout1_35ck9 FIND v(dout1_35) AT=50.025n

* CHECK dout1_36 Vdout1_36ck9 = 0.9 time = 50
.meas tran vdout1_36ck9 FIND v(dout1_36) AT=50.025n

* CHECK dout1_37 Vdout1_37ck9 = 0.9 time = 50
.meas tran vdout1_37ck9 FIND v(dout1_37) AT=50.025n

* CHECK dout1_38 Vdout1_38ck9 = 0 time = 50
.meas tran vdout1_38ck9 FIND v(dout1_38) AT=50.025n

* CHECK dout1_39 Vdout1_39ck9 = 0.9 time = 50
.meas tran vdout1_39ck9 FIND v(dout1_39) AT=50.025n

* CHECK dout1_40 Vdout1_40ck9 = 0 time = 50
.meas tran vdout1_40ck9 FIND v(dout1_40) AT=50.025n

* CHECK dout1_41 Vdout1_41ck9 = 0 time = 50
.meas tran vdout1_41ck9 FIND v(dout1_41) AT=50.025n

* CHECK dout1_42 Vdout1_42ck9 = 0 time = 50
.meas tran vdout1_42ck9 FIND v(dout1_42) AT=50.025n

* CHECK dout1_43 Vdout1_43ck9 = 0.9 time = 50
.meas tran vdout1_43ck9 FIND v(dout1_43) AT=50.025n

* CHECK dout1_44 Vdout1_44ck9 = 0.9 time = 50
.meas tran vdout1_44ck9 FIND v(dout1_44) AT=50.025n

* CHECK dout1_45 Vdout1_45ck9 = 0.9 time = 50
.meas tran vdout1_45ck9 FIND v(dout1_45) AT=50.025n

* CHECK dout1_46 Vdout1_46ck9 = 0 time = 50
.meas tran vdout1_46ck9 FIND v(dout1_46) AT=50.025n

* CHECK dout1_47 Vdout1_47ck9 = 0.9 time = 50
.meas tran vdout1_47ck9 FIND v(dout1_47) AT=50.025n

* CHECK dout1_48 Vdout1_48ck9 = 0.9 time = 50
.meas tran vdout1_48ck9 FIND v(dout1_48) AT=50.025n

* CHECK dout1_49 Vdout1_49ck9 = 0 time = 50
.meas tran vdout1_49ck9 FIND v(dout1_49) AT=50.025n

* CHECK dout1_50 Vdout1_50ck9 = 0.9 time = 50
.meas tran vdout1_50ck9 FIND v(dout1_50) AT=50.025n

* CHECK dout1_51 Vdout1_51ck9 = 0 time = 50
.meas tran vdout1_51ck9 FIND v(dout1_51) AT=50.025n

* CHECK dout1_52 Vdout1_52ck9 = 0.9 time = 50
.meas tran vdout1_52ck9 FIND v(dout1_52) AT=50.025n

* CHECK dout1_53 Vdout1_53ck9 = 0.9 time = 50
.meas tran vdout1_53ck9 FIND v(dout1_53) AT=50.025n

* CHECK dout1_54 Vdout1_54ck9 = 0.9 time = 50
.meas tran vdout1_54ck9 FIND v(dout1_54) AT=50.025n

* CHECK dout1_55 Vdout1_55ck9 = 0 time = 50
.meas tran vdout1_55ck9 FIND v(dout1_55) AT=50.025n

* CHECK dout1_56 Vdout1_56ck9 = 0 time = 50
.meas tran vdout1_56ck9 FIND v(dout1_56) AT=50.025n

* CHECK dout1_57 Vdout1_57ck9 = 0 time = 50
.meas tran vdout1_57ck9 FIND v(dout1_57) AT=50.025n

* CHECK dout1_58 Vdout1_58ck9 = 0.9 time = 50
.meas tran vdout1_58ck9 FIND v(dout1_58) AT=50.025n

* CHECK dout1_59 Vdout1_59ck9 = 0 time = 50
.meas tran vdout1_59ck9 FIND v(dout1_59) AT=50.025n

* CHECK dout1_60 Vdout1_60ck9 = 0 time = 50
.meas tran vdout1_60ck9 FIND v(dout1_60) AT=50.025n

* CHECK dout1_61 Vdout1_61ck9 = 0 time = 50
.meas tran vdout1_61ck9 FIND v(dout1_61) AT=50.025n

* CHECK dout1_62 Vdout1_62ck9 = 0.9 time = 50
.meas tran vdout1_62ck9 FIND v(dout1_62) AT=50.025n

* CHECK dout1_63 Vdout1_63ck9 = 0.9 time = 50
.meas tran vdout1_63ck9 FIND v(dout1_63) AT=50.025n

* CHECK dout1_0 Vdout1_0ck10 = 0 time = 55
.meas tran vdout1_0ck10 FIND v(dout1_0) AT=55.025n

* CHECK dout1_1 Vdout1_1ck10 = 0 time = 55
.meas tran vdout1_1ck10 FIND v(dout1_1) AT=55.025n

* CHECK dout1_2 Vdout1_2ck10 = 0.9 time = 55
.meas tran vdout1_2ck10 FIND v(dout1_2) AT=55.025n

* CHECK dout1_3 Vdout1_3ck10 = 0.9 time = 55
.meas tran vdout1_3ck10 FIND v(dout1_3) AT=55.025n

* CHECK dout1_4 Vdout1_4ck10 = 0 time = 55
.meas tran vdout1_4ck10 FIND v(dout1_4) AT=55.025n

* CHECK dout1_5 Vdout1_5ck10 = 0.9 time = 55
.meas tran vdout1_5ck10 FIND v(dout1_5) AT=55.025n

* CHECK dout1_6 Vdout1_6ck10 = 0 time = 55
.meas tran vdout1_6ck10 FIND v(dout1_6) AT=55.025n

* CHECK dout1_7 Vdout1_7ck10 = 0.9 time = 55
.meas tran vdout1_7ck10 FIND v(dout1_7) AT=55.025n

* CHECK dout1_8 Vdout1_8ck10 = 0.9 time = 55
.meas tran vdout1_8ck10 FIND v(dout1_8) AT=55.025n

* CHECK dout1_9 Vdout1_9ck10 = 0 time = 55
.meas tran vdout1_9ck10 FIND v(dout1_9) AT=55.025n

* CHECK dout1_10 Vdout1_10ck10 = 0.9 time = 55
.meas tran vdout1_10ck10 FIND v(dout1_10) AT=55.025n

* CHECK dout1_11 Vdout1_11ck10 = 0 time = 55
.meas tran vdout1_11ck10 FIND v(dout1_11) AT=55.025n

* CHECK dout1_12 Vdout1_12ck10 = 0 time = 55
.meas tran vdout1_12ck10 FIND v(dout1_12) AT=55.025n

* CHECK dout1_13 Vdout1_13ck10 = 0 time = 55
.meas tran vdout1_13ck10 FIND v(dout1_13) AT=55.025n

* CHECK dout1_14 Vdout1_14ck10 = 0 time = 55
.meas tran vdout1_14ck10 FIND v(dout1_14) AT=55.025n

* CHECK dout1_15 Vdout1_15ck10 = 0 time = 55
.meas tran vdout1_15ck10 FIND v(dout1_15) AT=55.025n

* CHECK dout1_16 Vdout1_16ck10 = 0.9 time = 55
.meas tran vdout1_16ck10 FIND v(dout1_16) AT=55.025n

* CHECK dout1_17 Vdout1_17ck10 = 0.9 time = 55
.meas tran vdout1_17ck10 FIND v(dout1_17) AT=55.025n

* CHECK dout1_18 Vdout1_18ck10 = 0 time = 55
.meas tran vdout1_18ck10 FIND v(dout1_18) AT=55.025n

* CHECK dout1_19 Vdout1_19ck10 = 0 time = 55
.meas tran vdout1_19ck10 FIND v(dout1_19) AT=55.025n

* CHECK dout1_20 Vdout1_20ck10 = 0 time = 55
.meas tran vdout1_20ck10 FIND v(dout1_20) AT=55.025n

* CHECK dout1_21 Vdout1_21ck10 = 0 time = 55
.meas tran vdout1_21ck10 FIND v(dout1_21) AT=55.025n

* CHECK dout1_22 Vdout1_22ck10 = 0.9 time = 55
.meas tran vdout1_22ck10 FIND v(dout1_22) AT=55.025n

* CHECK dout1_23 Vdout1_23ck10 = 0 time = 55
.meas tran vdout1_23ck10 FIND v(dout1_23) AT=55.025n

* CHECK dout1_24 Vdout1_24ck10 = 0 time = 55
.meas tran vdout1_24ck10 FIND v(dout1_24) AT=55.025n

* CHECK dout1_25 Vdout1_25ck10 = 0.9 time = 55
.meas tran vdout1_25ck10 FIND v(dout1_25) AT=55.025n

* CHECK dout1_26 Vdout1_26ck10 = 0.9 time = 55
.meas tran vdout1_26ck10 FIND v(dout1_26) AT=55.025n

* CHECK dout1_27 Vdout1_27ck10 = 0 time = 55
.meas tran vdout1_27ck10 FIND v(dout1_27) AT=55.025n

* CHECK dout1_28 Vdout1_28ck10 = 0.9 time = 55
.meas tran vdout1_28ck10 FIND v(dout1_28) AT=55.025n

* CHECK dout1_29 Vdout1_29ck10 = 0 time = 55
.meas tran vdout1_29ck10 FIND v(dout1_29) AT=55.025n

* CHECK dout1_30 Vdout1_30ck10 = 0.9 time = 55
.meas tran vdout1_30ck10 FIND v(dout1_30) AT=55.025n

* CHECK dout1_31 Vdout1_31ck10 = 0.9 time = 55
.meas tran vdout1_31ck10 FIND v(dout1_31) AT=55.025n

* CHECK dout1_32 Vdout1_32ck10 = 0 time = 55
.meas tran vdout1_32ck10 FIND v(dout1_32) AT=55.025n

* CHECK dout1_33 Vdout1_33ck10 = 0.9 time = 55
.meas tran vdout1_33ck10 FIND v(dout1_33) AT=55.025n

* CHECK dout1_34 Vdout1_34ck10 = 0 time = 55
.meas tran vdout1_34ck10 FIND v(dout1_34) AT=55.025n

* CHECK dout1_35 Vdout1_35ck10 = 0 time = 55
.meas tran vdout1_35ck10 FIND v(dout1_35) AT=55.025n

* CHECK dout1_36 Vdout1_36ck10 = 0 time = 55
.meas tran vdout1_36ck10 FIND v(dout1_36) AT=55.025n

* CHECK dout1_37 Vdout1_37ck10 = 0 time = 55
.meas tran vdout1_37ck10 FIND v(dout1_37) AT=55.025n

* CHECK dout1_38 Vdout1_38ck10 = 0 time = 55
.meas tran vdout1_38ck10 FIND v(dout1_38) AT=55.025n

* CHECK dout1_39 Vdout1_39ck10 = 0.9 time = 55
.meas tran vdout1_39ck10 FIND v(dout1_39) AT=55.025n

* CHECK dout1_40 Vdout1_40ck10 = 0 time = 55
.meas tran vdout1_40ck10 FIND v(dout1_40) AT=55.025n

* CHECK dout1_41 Vdout1_41ck10 = 0.9 time = 55
.meas tran vdout1_41ck10 FIND v(dout1_41) AT=55.025n

* CHECK dout1_42 Vdout1_42ck10 = 0 time = 55
.meas tran vdout1_42ck10 FIND v(dout1_42) AT=55.025n

* CHECK dout1_43 Vdout1_43ck10 = 0 time = 55
.meas tran vdout1_43ck10 FIND v(dout1_43) AT=55.025n

* CHECK dout1_44 Vdout1_44ck10 = 0.9 time = 55
.meas tran vdout1_44ck10 FIND v(dout1_44) AT=55.025n

* CHECK dout1_45 Vdout1_45ck10 = 0.9 time = 55
.meas tran vdout1_45ck10 FIND v(dout1_45) AT=55.025n

* CHECK dout1_46 Vdout1_46ck10 = 0.9 time = 55
.meas tran vdout1_46ck10 FIND v(dout1_46) AT=55.025n

* CHECK dout1_47 Vdout1_47ck10 = 0.9 time = 55
.meas tran vdout1_47ck10 FIND v(dout1_47) AT=55.025n

* CHECK dout1_48 Vdout1_48ck10 = 0.9 time = 55
.meas tran vdout1_48ck10 FIND v(dout1_48) AT=55.025n

* CHECK dout1_49 Vdout1_49ck10 = 0 time = 55
.meas tran vdout1_49ck10 FIND v(dout1_49) AT=55.025n

* CHECK dout1_50 Vdout1_50ck10 = 0.9 time = 55
.meas tran vdout1_50ck10 FIND v(dout1_50) AT=55.025n

* CHECK dout1_51 Vdout1_51ck10 = 0 time = 55
.meas tran vdout1_51ck10 FIND v(dout1_51) AT=55.025n

* CHECK dout1_52 Vdout1_52ck10 = 0.9 time = 55
.meas tran vdout1_52ck10 FIND v(dout1_52) AT=55.025n

* CHECK dout1_53 Vdout1_53ck10 = 0.9 time = 55
.meas tran vdout1_53ck10 FIND v(dout1_53) AT=55.025n

* CHECK dout1_54 Vdout1_54ck10 = 0 time = 55
.meas tran vdout1_54ck10 FIND v(dout1_54) AT=55.025n

* CHECK dout1_55 Vdout1_55ck10 = 0.9 time = 55
.meas tran vdout1_55ck10 FIND v(dout1_55) AT=55.025n

* CHECK dout1_56 Vdout1_56ck10 = 0 time = 55
.meas tran vdout1_56ck10 FIND v(dout1_56) AT=55.025n

* CHECK dout1_57 Vdout1_57ck10 = 0 time = 55
.meas tran vdout1_57ck10 FIND v(dout1_57) AT=55.025n

* CHECK dout1_58 Vdout1_58ck10 = 0 time = 55
.meas tran vdout1_58ck10 FIND v(dout1_58) AT=55.025n

* CHECK dout1_59 Vdout1_59ck10 = 0.9 time = 55
.meas tran vdout1_59ck10 FIND v(dout1_59) AT=55.025n

* CHECK dout1_60 Vdout1_60ck10 = 0.9 time = 55
.meas tran vdout1_60ck10 FIND v(dout1_60) AT=55.025n

* CHECK dout1_61 Vdout1_61ck10 = 0.9 time = 55
.meas tran vdout1_61ck10 FIND v(dout1_61) AT=55.025n

* CHECK dout1_62 Vdout1_62ck10 = 0 time = 55
.meas tran vdout1_62ck10 FIND v(dout1_62) AT=55.025n

* CHECK dout1_63 Vdout1_63ck10 = 0.9 time = 55
.meas tran vdout1_63ck10 FIND v(dout1_63) AT=55.025n

* CHECK dout1_0 Vdout1_0ck11 = 0 time = 60
.meas tran vdout1_0ck11 FIND v(dout1_0) AT=60.025n

* CHECK dout1_1 Vdout1_1ck11 = 0.9 time = 60
.meas tran vdout1_1ck11 FIND v(dout1_1) AT=60.025n

* CHECK dout1_2 Vdout1_2ck11 = 0 time = 60
.meas tran vdout1_2ck11 FIND v(dout1_2) AT=60.025n

* CHECK dout1_3 Vdout1_3ck11 = 0.9 time = 60
.meas tran vdout1_3ck11 FIND v(dout1_3) AT=60.025n

* CHECK dout1_4 Vdout1_4ck11 = 0.9 time = 60
.meas tran vdout1_4ck11 FIND v(dout1_4) AT=60.025n

* CHECK dout1_5 Vdout1_5ck11 = 0 time = 60
.meas tran vdout1_5ck11 FIND v(dout1_5) AT=60.025n

* CHECK dout1_6 Vdout1_6ck11 = 0.9 time = 60
.meas tran vdout1_6ck11 FIND v(dout1_6) AT=60.025n

* CHECK dout1_7 Vdout1_7ck11 = 0 time = 60
.meas tran vdout1_7ck11 FIND v(dout1_7) AT=60.025n

* CHECK dout1_8 Vdout1_8ck11 = 0 time = 60
.meas tran vdout1_8ck11 FIND v(dout1_8) AT=60.025n

* CHECK dout1_9 Vdout1_9ck11 = 0.9 time = 60
.meas tran vdout1_9ck11 FIND v(dout1_9) AT=60.025n

* CHECK dout1_10 Vdout1_10ck11 = 0.9 time = 60
.meas tran vdout1_10ck11 FIND v(dout1_10) AT=60.025n

* CHECK dout1_11 Vdout1_11ck11 = 0.9 time = 60
.meas tran vdout1_11ck11 FIND v(dout1_11) AT=60.025n

* CHECK dout1_12 Vdout1_12ck11 = 0 time = 60
.meas tran vdout1_12ck11 FIND v(dout1_12) AT=60.025n

* CHECK dout1_13 Vdout1_13ck11 = 0.9 time = 60
.meas tran vdout1_13ck11 FIND v(dout1_13) AT=60.025n

* CHECK dout1_14 Vdout1_14ck11 = 0.9 time = 60
.meas tran vdout1_14ck11 FIND v(dout1_14) AT=60.025n

* CHECK dout1_15 Vdout1_15ck11 = 0.9 time = 60
.meas tran vdout1_15ck11 FIND v(dout1_15) AT=60.025n

* CHECK dout1_16 Vdout1_16ck11 = 0.9 time = 60
.meas tran vdout1_16ck11 FIND v(dout1_16) AT=60.025n

* CHECK dout1_17 Vdout1_17ck11 = 0 time = 60
.meas tran vdout1_17ck11 FIND v(dout1_17) AT=60.025n

* CHECK dout1_18 Vdout1_18ck11 = 0 time = 60
.meas tran vdout1_18ck11 FIND v(dout1_18) AT=60.025n

* CHECK dout1_19 Vdout1_19ck11 = 0.9 time = 60
.meas tran vdout1_19ck11 FIND v(dout1_19) AT=60.025n

* CHECK dout1_20 Vdout1_20ck11 = 0.9 time = 60
.meas tran vdout1_20ck11 FIND v(dout1_20) AT=60.025n

* CHECK dout1_21 Vdout1_21ck11 = 0.9 time = 60
.meas tran vdout1_21ck11 FIND v(dout1_21) AT=60.025n

* CHECK dout1_22 Vdout1_22ck11 = 0 time = 60
.meas tran vdout1_22ck11 FIND v(dout1_22) AT=60.025n

* CHECK dout1_23 Vdout1_23ck11 = 0.9 time = 60
.meas tran vdout1_23ck11 FIND v(dout1_23) AT=60.025n

* CHECK dout1_24 Vdout1_24ck11 = 0 time = 60
.meas tran vdout1_24ck11 FIND v(dout1_24) AT=60.025n

* CHECK dout1_25 Vdout1_25ck11 = 0.9 time = 60
.meas tran vdout1_25ck11 FIND v(dout1_25) AT=60.025n

* CHECK dout1_26 Vdout1_26ck11 = 0.9 time = 60
.meas tran vdout1_26ck11 FIND v(dout1_26) AT=60.025n

* CHECK dout1_27 Vdout1_27ck11 = 0.9 time = 60
.meas tran vdout1_27ck11 FIND v(dout1_27) AT=60.025n

* CHECK dout1_28 Vdout1_28ck11 = 0.9 time = 60
.meas tran vdout1_28ck11 FIND v(dout1_28) AT=60.025n

* CHECK dout1_29 Vdout1_29ck11 = 0 time = 60
.meas tran vdout1_29ck11 FIND v(dout1_29) AT=60.025n

* CHECK dout1_30 Vdout1_30ck11 = 0.9 time = 60
.meas tran vdout1_30ck11 FIND v(dout1_30) AT=60.025n

* CHECK dout1_31 Vdout1_31ck11 = 0.9 time = 60
.meas tran vdout1_31ck11 FIND v(dout1_31) AT=60.025n

* CHECK dout1_32 Vdout1_32ck11 = 0.9 time = 60
.meas tran vdout1_32ck11 FIND v(dout1_32) AT=60.025n

* CHECK dout1_33 Vdout1_33ck11 = 0 time = 60
.meas tran vdout1_33ck11 FIND v(dout1_33) AT=60.025n

* CHECK dout1_34 Vdout1_34ck11 = 0.9 time = 60
.meas tran vdout1_34ck11 FIND v(dout1_34) AT=60.025n

* CHECK dout1_35 Vdout1_35ck11 = 0 time = 60
.meas tran vdout1_35ck11 FIND v(dout1_35) AT=60.025n

* CHECK dout1_36 Vdout1_36ck11 = 0 time = 60
.meas tran vdout1_36ck11 FIND v(dout1_36) AT=60.025n

* CHECK dout1_37 Vdout1_37ck11 = 0.9 time = 60
.meas tran vdout1_37ck11 FIND v(dout1_37) AT=60.025n

* CHECK dout1_38 Vdout1_38ck11 = 0 time = 60
.meas tran vdout1_38ck11 FIND v(dout1_38) AT=60.025n

* CHECK dout1_39 Vdout1_39ck11 = 0.9 time = 60
.meas tran vdout1_39ck11 FIND v(dout1_39) AT=60.025n

* CHECK dout1_40 Vdout1_40ck11 = 0.9 time = 60
.meas tran vdout1_40ck11 FIND v(dout1_40) AT=60.025n

* CHECK dout1_41 Vdout1_41ck11 = 0.9 time = 60
.meas tran vdout1_41ck11 FIND v(dout1_41) AT=60.025n

* CHECK dout1_42 Vdout1_42ck11 = 0.9 time = 60
.meas tran vdout1_42ck11 FIND v(dout1_42) AT=60.025n

* CHECK dout1_43 Vdout1_43ck11 = 0 time = 60
.meas tran vdout1_43ck11 FIND v(dout1_43) AT=60.025n

* CHECK dout1_44 Vdout1_44ck11 = 0 time = 60
.meas tran vdout1_44ck11 FIND v(dout1_44) AT=60.025n

* CHECK dout1_45 Vdout1_45ck11 = 0.9 time = 60
.meas tran vdout1_45ck11 FIND v(dout1_45) AT=60.025n

* CHECK dout1_46 Vdout1_46ck11 = 0 time = 60
.meas tran vdout1_46ck11 FIND v(dout1_46) AT=60.025n

* CHECK dout1_47 Vdout1_47ck11 = 0.9 time = 60
.meas tran vdout1_47ck11 FIND v(dout1_47) AT=60.025n

* CHECK dout1_48 Vdout1_48ck11 = 0.9 time = 60
.meas tran vdout1_48ck11 FIND v(dout1_48) AT=60.025n

* CHECK dout1_49 Vdout1_49ck11 = 0 time = 60
.meas tran vdout1_49ck11 FIND v(dout1_49) AT=60.025n

* CHECK dout1_50 Vdout1_50ck11 = 0 time = 60
.meas tran vdout1_50ck11 FIND v(dout1_50) AT=60.025n

* CHECK dout1_51 Vdout1_51ck11 = 0 time = 60
.meas tran vdout1_51ck11 FIND v(dout1_51) AT=60.025n

* CHECK dout1_52 Vdout1_52ck11 = 0.9 time = 60
.meas tran vdout1_52ck11 FIND v(dout1_52) AT=60.025n

* CHECK dout1_53 Vdout1_53ck11 = 0.9 time = 60
.meas tran vdout1_53ck11 FIND v(dout1_53) AT=60.025n

* CHECK dout1_54 Vdout1_54ck11 = 0.9 time = 60
.meas tran vdout1_54ck11 FIND v(dout1_54) AT=60.025n

* CHECK dout1_55 Vdout1_55ck11 = 0.9 time = 60
.meas tran vdout1_55ck11 FIND v(dout1_55) AT=60.025n

* CHECK dout1_56 Vdout1_56ck11 = 0 time = 60
.meas tran vdout1_56ck11 FIND v(dout1_56) AT=60.025n

* CHECK dout1_57 Vdout1_57ck11 = 0.9 time = 60
.meas tran vdout1_57ck11 FIND v(dout1_57) AT=60.025n

* CHECK dout1_58 Vdout1_58ck11 = 0 time = 60
.meas tran vdout1_58ck11 FIND v(dout1_58) AT=60.025n

* CHECK dout1_59 Vdout1_59ck11 = 0.9 time = 60
.meas tran vdout1_59ck11 FIND v(dout1_59) AT=60.025n

* CHECK dout1_60 Vdout1_60ck11 = 0.9 time = 60
.meas tran vdout1_60ck11 FIND v(dout1_60) AT=60.025n

* CHECK dout1_61 Vdout1_61ck11 = 0.9 time = 60
.meas tran vdout1_61ck11 FIND v(dout1_61) AT=60.025n

* CHECK dout1_62 Vdout1_62ck11 = 0.9 time = 60
.meas tran vdout1_62ck11 FIND v(dout1_62) AT=60.025n

* CHECK dout1_63 Vdout1_63ck11 = 0.9 time = 60
.meas tran vdout1_63ck11 FIND v(dout1_63) AT=60.025n

* CHECK dout1_0 Vdout1_0ck14 = 0 time = 75
.meas tran vdout1_0ck14 FIND v(dout1_0) AT=75.025n

* CHECK dout1_1 Vdout1_1ck14 = 0.9 time = 75
.meas tran vdout1_1ck14 FIND v(dout1_1) AT=75.025n

* CHECK dout1_2 Vdout1_2ck14 = 0 time = 75
.meas tran vdout1_2ck14 FIND v(dout1_2) AT=75.025n

* CHECK dout1_3 Vdout1_3ck14 = 0.9 time = 75
.meas tran vdout1_3ck14 FIND v(dout1_3) AT=75.025n

* CHECK dout1_4 Vdout1_4ck14 = 0.9 time = 75
.meas tran vdout1_4ck14 FIND v(dout1_4) AT=75.025n

* CHECK dout1_5 Vdout1_5ck14 = 0 time = 75
.meas tran vdout1_5ck14 FIND v(dout1_5) AT=75.025n

* CHECK dout1_6 Vdout1_6ck14 = 0.9 time = 75
.meas tran vdout1_6ck14 FIND v(dout1_6) AT=75.025n

* CHECK dout1_7 Vdout1_7ck14 = 0 time = 75
.meas tran vdout1_7ck14 FIND v(dout1_7) AT=75.025n

* CHECK dout1_8 Vdout1_8ck14 = 0 time = 75
.meas tran vdout1_8ck14 FIND v(dout1_8) AT=75.025n

* CHECK dout1_9 Vdout1_9ck14 = 0.9 time = 75
.meas tran vdout1_9ck14 FIND v(dout1_9) AT=75.025n

* CHECK dout1_10 Vdout1_10ck14 = 0.9 time = 75
.meas tran vdout1_10ck14 FIND v(dout1_10) AT=75.025n

* CHECK dout1_11 Vdout1_11ck14 = 0.9 time = 75
.meas tran vdout1_11ck14 FIND v(dout1_11) AT=75.025n

* CHECK dout1_12 Vdout1_12ck14 = 0 time = 75
.meas tran vdout1_12ck14 FIND v(dout1_12) AT=75.025n

* CHECK dout1_13 Vdout1_13ck14 = 0.9 time = 75
.meas tran vdout1_13ck14 FIND v(dout1_13) AT=75.025n

* CHECK dout1_14 Vdout1_14ck14 = 0.9 time = 75
.meas tran vdout1_14ck14 FIND v(dout1_14) AT=75.025n

* CHECK dout1_15 Vdout1_15ck14 = 0.9 time = 75
.meas tran vdout1_15ck14 FIND v(dout1_15) AT=75.025n

* CHECK dout1_16 Vdout1_16ck14 = 0.9 time = 75
.meas tran vdout1_16ck14 FIND v(dout1_16) AT=75.025n

* CHECK dout1_17 Vdout1_17ck14 = 0 time = 75
.meas tran vdout1_17ck14 FIND v(dout1_17) AT=75.025n

* CHECK dout1_18 Vdout1_18ck14 = 0 time = 75
.meas tran vdout1_18ck14 FIND v(dout1_18) AT=75.025n

* CHECK dout1_19 Vdout1_19ck14 = 0.9 time = 75
.meas tran vdout1_19ck14 FIND v(dout1_19) AT=75.025n

* CHECK dout1_20 Vdout1_20ck14 = 0.9 time = 75
.meas tran vdout1_20ck14 FIND v(dout1_20) AT=75.025n

* CHECK dout1_21 Vdout1_21ck14 = 0.9 time = 75
.meas tran vdout1_21ck14 FIND v(dout1_21) AT=75.025n

* CHECK dout1_22 Vdout1_22ck14 = 0 time = 75
.meas tran vdout1_22ck14 FIND v(dout1_22) AT=75.025n

* CHECK dout1_23 Vdout1_23ck14 = 0.9 time = 75
.meas tran vdout1_23ck14 FIND v(dout1_23) AT=75.025n

* CHECK dout1_24 Vdout1_24ck14 = 0 time = 75
.meas tran vdout1_24ck14 FIND v(dout1_24) AT=75.025n

* CHECK dout1_25 Vdout1_25ck14 = 0.9 time = 75
.meas tran vdout1_25ck14 FIND v(dout1_25) AT=75.025n

* CHECK dout1_26 Vdout1_26ck14 = 0.9 time = 75
.meas tran vdout1_26ck14 FIND v(dout1_26) AT=75.025n

* CHECK dout1_27 Vdout1_27ck14 = 0.9 time = 75
.meas tran vdout1_27ck14 FIND v(dout1_27) AT=75.025n

* CHECK dout1_28 Vdout1_28ck14 = 0.9 time = 75
.meas tran vdout1_28ck14 FIND v(dout1_28) AT=75.025n

* CHECK dout1_29 Vdout1_29ck14 = 0 time = 75
.meas tran vdout1_29ck14 FIND v(dout1_29) AT=75.025n

* CHECK dout1_30 Vdout1_30ck14 = 0.9 time = 75
.meas tran vdout1_30ck14 FIND v(dout1_30) AT=75.025n

* CHECK dout1_31 Vdout1_31ck14 = 0.9 time = 75
.meas tran vdout1_31ck14 FIND v(dout1_31) AT=75.025n

* CHECK dout1_32 Vdout1_32ck14 = 0.9 time = 75
.meas tran vdout1_32ck14 FIND v(dout1_32) AT=75.025n

* CHECK dout1_33 Vdout1_33ck14 = 0 time = 75
.meas tran vdout1_33ck14 FIND v(dout1_33) AT=75.025n

* CHECK dout1_34 Vdout1_34ck14 = 0.9 time = 75
.meas tran vdout1_34ck14 FIND v(dout1_34) AT=75.025n

* CHECK dout1_35 Vdout1_35ck14 = 0 time = 75
.meas tran vdout1_35ck14 FIND v(dout1_35) AT=75.025n

* CHECK dout1_36 Vdout1_36ck14 = 0 time = 75
.meas tran vdout1_36ck14 FIND v(dout1_36) AT=75.025n

* CHECK dout1_37 Vdout1_37ck14 = 0.9 time = 75
.meas tran vdout1_37ck14 FIND v(dout1_37) AT=75.025n

* CHECK dout1_38 Vdout1_38ck14 = 0 time = 75
.meas tran vdout1_38ck14 FIND v(dout1_38) AT=75.025n

* CHECK dout1_39 Vdout1_39ck14 = 0.9 time = 75
.meas tran vdout1_39ck14 FIND v(dout1_39) AT=75.025n

* CHECK dout1_40 Vdout1_40ck14 = 0.9 time = 75
.meas tran vdout1_40ck14 FIND v(dout1_40) AT=75.025n

* CHECK dout1_41 Vdout1_41ck14 = 0.9 time = 75
.meas tran vdout1_41ck14 FIND v(dout1_41) AT=75.025n

* CHECK dout1_42 Vdout1_42ck14 = 0.9 time = 75
.meas tran vdout1_42ck14 FIND v(dout1_42) AT=75.025n

* CHECK dout1_43 Vdout1_43ck14 = 0 time = 75
.meas tran vdout1_43ck14 FIND v(dout1_43) AT=75.025n

* CHECK dout1_44 Vdout1_44ck14 = 0 time = 75
.meas tran vdout1_44ck14 FIND v(dout1_44) AT=75.025n

* CHECK dout1_45 Vdout1_45ck14 = 0.9 time = 75
.meas tran vdout1_45ck14 FIND v(dout1_45) AT=75.025n

* CHECK dout1_46 Vdout1_46ck14 = 0 time = 75
.meas tran vdout1_46ck14 FIND v(dout1_46) AT=75.025n

* CHECK dout1_47 Vdout1_47ck14 = 0.9 time = 75
.meas tran vdout1_47ck14 FIND v(dout1_47) AT=75.025n

* CHECK dout1_48 Vdout1_48ck14 = 0.9 time = 75
.meas tran vdout1_48ck14 FIND v(dout1_48) AT=75.025n

* CHECK dout1_49 Vdout1_49ck14 = 0 time = 75
.meas tran vdout1_49ck14 FIND v(dout1_49) AT=75.025n

* CHECK dout1_50 Vdout1_50ck14 = 0 time = 75
.meas tran vdout1_50ck14 FIND v(dout1_50) AT=75.025n

* CHECK dout1_51 Vdout1_51ck14 = 0 time = 75
.meas tran vdout1_51ck14 FIND v(dout1_51) AT=75.025n

* CHECK dout1_52 Vdout1_52ck14 = 0.9 time = 75
.meas tran vdout1_52ck14 FIND v(dout1_52) AT=75.025n

* CHECK dout1_53 Vdout1_53ck14 = 0.9 time = 75
.meas tran vdout1_53ck14 FIND v(dout1_53) AT=75.025n

* CHECK dout1_54 Vdout1_54ck14 = 0.9 time = 75
.meas tran vdout1_54ck14 FIND v(dout1_54) AT=75.025n

* CHECK dout1_55 Vdout1_55ck14 = 0.9 time = 75
.meas tran vdout1_55ck14 FIND v(dout1_55) AT=75.025n

* CHECK dout1_56 Vdout1_56ck14 = 0 time = 75
.meas tran vdout1_56ck14 FIND v(dout1_56) AT=75.025n

* CHECK dout1_57 Vdout1_57ck14 = 0.9 time = 75
.meas tran vdout1_57ck14 FIND v(dout1_57) AT=75.025n

* CHECK dout1_58 Vdout1_58ck14 = 0 time = 75
.meas tran vdout1_58ck14 FIND v(dout1_58) AT=75.025n

* CHECK dout1_59 Vdout1_59ck14 = 0.9 time = 75
.meas tran vdout1_59ck14 FIND v(dout1_59) AT=75.025n

* CHECK dout1_60 Vdout1_60ck14 = 0.9 time = 75
.meas tran vdout1_60ck14 FIND v(dout1_60) AT=75.025n

* CHECK dout1_61 Vdout1_61ck14 = 0.9 time = 75
.meas tran vdout1_61ck14 FIND v(dout1_61) AT=75.025n

* CHECK dout1_62 Vdout1_62ck14 = 0.9 time = 75
.meas tran vdout1_62ck14 FIND v(dout1_62) AT=75.025n

* CHECK dout1_63 Vdout1_63ck14 = 0.9 time = 75
.meas tran vdout1_63ck14 FIND v(dout1_63) AT=75.025n

* CHECK dout1_0 Vdout1_0ck19 = 0 time = 100
.meas tran vdout1_0ck19 FIND v(dout1_0) AT=100.025n

* CHECK dout1_1 Vdout1_1ck19 = 0 time = 100
.meas tran vdout1_1ck19 FIND v(dout1_1) AT=100.025n

* CHECK dout1_2 Vdout1_2ck19 = 0 time = 100
.meas tran vdout1_2ck19 FIND v(dout1_2) AT=100.025n

* CHECK dout1_3 Vdout1_3ck19 = 0.9 time = 100
.meas tran vdout1_3ck19 FIND v(dout1_3) AT=100.025n

* CHECK dout1_4 Vdout1_4ck19 = 0 time = 100
.meas tran vdout1_4ck19 FIND v(dout1_4) AT=100.025n

* CHECK dout1_5 Vdout1_5ck19 = 0.9 time = 100
.meas tran vdout1_5ck19 FIND v(dout1_5) AT=100.025n

* CHECK dout1_6 Vdout1_6ck19 = 0 time = 100
.meas tran vdout1_6ck19 FIND v(dout1_6) AT=100.025n

* CHECK dout1_7 Vdout1_7ck19 = 0.9 time = 100
.meas tran vdout1_7ck19 FIND v(dout1_7) AT=100.025n

* CHECK dout1_8 Vdout1_8ck19 = 0 time = 100
.meas tran vdout1_8ck19 FIND v(dout1_8) AT=100.025n

* CHECK dout1_9 Vdout1_9ck19 = 0.9 time = 100
.meas tran vdout1_9ck19 FIND v(dout1_9) AT=100.025n

* CHECK dout1_10 Vdout1_10ck19 = 0 time = 100
.meas tran vdout1_10ck19 FIND v(dout1_10) AT=100.025n

* CHECK dout1_11 Vdout1_11ck19 = 0 time = 100
.meas tran vdout1_11ck19 FIND v(dout1_11) AT=100.025n

* CHECK dout1_12 Vdout1_12ck19 = 0 time = 100
.meas tran vdout1_12ck19 FIND v(dout1_12) AT=100.025n

* CHECK dout1_13 Vdout1_13ck19 = 0.9 time = 100
.meas tran vdout1_13ck19 FIND v(dout1_13) AT=100.025n

* CHECK dout1_14 Vdout1_14ck19 = 0 time = 100
.meas tran vdout1_14ck19 FIND v(dout1_14) AT=100.025n

* CHECK dout1_15 Vdout1_15ck19 = 0 time = 100
.meas tran vdout1_15ck19 FIND v(dout1_15) AT=100.025n

* CHECK dout1_16 Vdout1_16ck19 = 0 time = 100
.meas tran vdout1_16ck19 FIND v(dout1_16) AT=100.025n

* CHECK dout1_17 Vdout1_17ck19 = 0 time = 100
.meas tran vdout1_17ck19 FIND v(dout1_17) AT=100.025n

* CHECK dout1_18 Vdout1_18ck19 = 0 time = 100
.meas tran vdout1_18ck19 FIND v(dout1_18) AT=100.025n

* CHECK dout1_19 Vdout1_19ck19 = 0.9 time = 100
.meas tran vdout1_19ck19 FIND v(dout1_19) AT=100.025n

* CHECK dout1_20 Vdout1_20ck19 = 0 time = 100
.meas tran vdout1_20ck19 FIND v(dout1_20) AT=100.025n

* CHECK dout1_21 Vdout1_21ck19 = 0 time = 100
.meas tran vdout1_21ck19 FIND v(dout1_21) AT=100.025n

* CHECK dout1_22 Vdout1_22ck19 = 0.9 time = 100
.meas tran vdout1_22ck19 FIND v(dout1_22) AT=100.025n

* CHECK dout1_23 Vdout1_23ck19 = 0 time = 100
.meas tran vdout1_23ck19 FIND v(dout1_23) AT=100.025n

* CHECK dout1_24 Vdout1_24ck19 = 0 time = 100
.meas tran vdout1_24ck19 FIND v(dout1_24) AT=100.025n

* CHECK dout1_25 Vdout1_25ck19 = 0.9 time = 100
.meas tran vdout1_25ck19 FIND v(dout1_25) AT=100.025n

* CHECK dout1_26 Vdout1_26ck19 = 0.9 time = 100
.meas tran vdout1_26ck19 FIND v(dout1_26) AT=100.025n

* CHECK dout1_27 Vdout1_27ck19 = 0 time = 100
.meas tran vdout1_27ck19 FIND v(dout1_27) AT=100.025n

* CHECK dout1_28 Vdout1_28ck19 = 0 time = 100
.meas tran vdout1_28ck19 FIND v(dout1_28) AT=100.025n

* CHECK dout1_29 Vdout1_29ck19 = 0.9 time = 100
.meas tran vdout1_29ck19 FIND v(dout1_29) AT=100.025n

* CHECK dout1_30 Vdout1_30ck19 = 0.9 time = 100
.meas tran vdout1_30ck19 FIND v(dout1_30) AT=100.025n

* CHECK dout1_31 Vdout1_31ck19 = 0 time = 100
.meas tran vdout1_31ck19 FIND v(dout1_31) AT=100.025n

* CHECK dout1_32 Vdout1_32ck19 = 0 time = 100
.meas tran vdout1_32ck19 FIND v(dout1_32) AT=100.025n

* CHECK dout1_33 Vdout1_33ck19 = 0.9 time = 100
.meas tran vdout1_33ck19 FIND v(dout1_33) AT=100.025n

* CHECK dout1_34 Vdout1_34ck19 = 0 time = 100
.meas tran vdout1_34ck19 FIND v(dout1_34) AT=100.025n

* CHECK dout1_35 Vdout1_35ck19 = 0 time = 100
.meas tran vdout1_35ck19 FIND v(dout1_35) AT=100.025n

* CHECK dout1_36 Vdout1_36ck19 = 0 time = 100
.meas tran vdout1_36ck19 FIND v(dout1_36) AT=100.025n

* CHECK dout1_37 Vdout1_37ck19 = 0 time = 100
.meas tran vdout1_37ck19 FIND v(dout1_37) AT=100.025n

* CHECK dout1_38 Vdout1_38ck19 = 0 time = 100
.meas tran vdout1_38ck19 FIND v(dout1_38) AT=100.025n

* CHECK dout1_39 Vdout1_39ck19 = 0.9 time = 100
.meas tran vdout1_39ck19 FIND v(dout1_39) AT=100.025n

* CHECK dout1_40 Vdout1_40ck19 = 0 time = 100
.meas tran vdout1_40ck19 FIND v(dout1_40) AT=100.025n

* CHECK dout1_41 Vdout1_41ck19 = 0.9 time = 100
.meas tran vdout1_41ck19 FIND v(dout1_41) AT=100.025n

* CHECK dout1_42 Vdout1_42ck19 = 0 time = 100
.meas tran vdout1_42ck19 FIND v(dout1_42) AT=100.025n

* CHECK dout1_43 Vdout1_43ck19 = 0 time = 100
.meas tran vdout1_43ck19 FIND v(dout1_43) AT=100.025n

* CHECK dout1_44 Vdout1_44ck19 = 0.9 time = 100
.meas tran vdout1_44ck19 FIND v(dout1_44) AT=100.025n

* CHECK dout1_45 Vdout1_45ck19 = 0.9 time = 100
.meas tran vdout1_45ck19 FIND v(dout1_45) AT=100.025n

* CHECK dout1_46 Vdout1_46ck19 = 0.9 time = 100
.meas tran vdout1_46ck19 FIND v(dout1_46) AT=100.025n

* CHECK dout1_47 Vdout1_47ck19 = 0.9 time = 100
.meas tran vdout1_47ck19 FIND v(dout1_47) AT=100.025n

* CHECK dout1_48 Vdout1_48ck19 = 0.9 time = 100
.meas tran vdout1_48ck19 FIND v(dout1_48) AT=100.025n

* CHECK dout1_49 Vdout1_49ck19 = 0 time = 100
.meas tran vdout1_49ck19 FIND v(dout1_49) AT=100.025n

* CHECK dout1_50 Vdout1_50ck19 = 0.9 time = 100
.meas tran vdout1_50ck19 FIND v(dout1_50) AT=100.025n

* CHECK dout1_51 Vdout1_51ck19 = 0 time = 100
.meas tran vdout1_51ck19 FIND v(dout1_51) AT=100.025n

* CHECK dout1_52 Vdout1_52ck19 = 0.9 time = 100
.meas tran vdout1_52ck19 FIND v(dout1_52) AT=100.025n

* CHECK dout1_53 Vdout1_53ck19 = 0.9 time = 100
.meas tran vdout1_53ck19 FIND v(dout1_53) AT=100.025n

* CHECK dout1_54 Vdout1_54ck19 = 0 time = 100
.meas tran vdout1_54ck19 FIND v(dout1_54) AT=100.025n

* CHECK dout1_55 Vdout1_55ck19 = 0.9 time = 100
.meas tran vdout1_55ck19 FIND v(dout1_55) AT=100.025n

* CHECK dout1_56 Vdout1_56ck19 = 0 time = 100
.meas tran vdout1_56ck19 FIND v(dout1_56) AT=100.025n

* CHECK dout1_57 Vdout1_57ck19 = 0 time = 100
.meas tran vdout1_57ck19 FIND v(dout1_57) AT=100.025n

* CHECK dout1_58 Vdout1_58ck19 = 0 time = 100
.meas tran vdout1_58ck19 FIND v(dout1_58) AT=100.025n

* CHECK dout1_59 Vdout1_59ck19 = 0.9 time = 100
.meas tran vdout1_59ck19 FIND v(dout1_59) AT=100.025n

* CHECK dout1_60 Vdout1_60ck19 = 0.9 time = 100
.meas tran vdout1_60ck19 FIND v(dout1_60) AT=100.025n

* CHECK dout1_61 Vdout1_61ck19 = 0.9 time = 100
.meas tran vdout1_61ck19 FIND v(dout1_61) AT=100.025n

* CHECK dout1_62 Vdout1_62ck19 = 0 time = 100
.meas tran vdout1_62ck19 FIND v(dout1_62) AT=100.025n

* CHECK dout1_63 Vdout1_63ck19 = 0.9 time = 100
.meas tran vdout1_63ck19 FIND v(dout1_63) AT=100.025n

* CHECK dout1_0 Vdout1_0ck20 = 0.9 time = 105
.meas tran vdout1_0ck20 FIND v(dout1_0) AT=105.025n

* CHECK dout1_1 Vdout1_1ck20 = 0.9 time = 105
.meas tran vdout1_1ck20 FIND v(dout1_1) AT=105.025n

* CHECK dout1_2 Vdout1_2ck20 = 0.9 time = 105
.meas tran vdout1_2ck20 FIND v(dout1_2) AT=105.025n

* CHECK dout1_3 Vdout1_3ck20 = 0 time = 105
.meas tran vdout1_3ck20 FIND v(dout1_3) AT=105.025n

* CHECK dout1_4 Vdout1_4ck20 = 0.9 time = 105
.meas tran vdout1_4ck20 FIND v(dout1_4) AT=105.025n

* CHECK dout1_5 Vdout1_5ck20 = 0.9 time = 105
.meas tran vdout1_5ck20 FIND v(dout1_5) AT=105.025n

* CHECK dout1_6 Vdout1_6ck20 = 0.9 time = 105
.meas tran vdout1_6ck20 FIND v(dout1_6) AT=105.025n

* CHECK dout1_7 Vdout1_7ck20 = 0 time = 105
.meas tran vdout1_7ck20 FIND v(dout1_7) AT=105.025n

* CHECK dout1_8 Vdout1_8ck20 = 0 time = 105
.meas tran vdout1_8ck20 FIND v(dout1_8) AT=105.025n

* CHECK dout1_9 Vdout1_9ck20 = 0.9 time = 105
.meas tran vdout1_9ck20 FIND v(dout1_9) AT=105.025n

* CHECK dout1_10 Vdout1_10ck20 = 0 time = 105
.meas tran vdout1_10ck20 FIND v(dout1_10) AT=105.025n

* CHECK dout1_11 Vdout1_11ck20 = 0.9 time = 105
.meas tran vdout1_11ck20 FIND v(dout1_11) AT=105.025n

* CHECK dout1_12 Vdout1_12ck20 = 0 time = 105
.meas tran vdout1_12ck20 FIND v(dout1_12) AT=105.025n

* CHECK dout1_13 Vdout1_13ck20 = 0 time = 105
.meas tran vdout1_13ck20 FIND v(dout1_13) AT=105.025n

* CHECK dout1_14 Vdout1_14ck20 = 0 time = 105
.meas tran vdout1_14ck20 FIND v(dout1_14) AT=105.025n

* CHECK dout1_15 Vdout1_15ck20 = 0.9 time = 105
.meas tran vdout1_15ck20 FIND v(dout1_15) AT=105.025n

* CHECK dout1_16 Vdout1_16ck20 = 0 time = 105
.meas tran vdout1_16ck20 FIND v(dout1_16) AT=105.025n

* CHECK dout1_17 Vdout1_17ck20 = 0 time = 105
.meas tran vdout1_17ck20 FIND v(dout1_17) AT=105.025n

* CHECK dout1_18 Vdout1_18ck20 = 0.9 time = 105
.meas tran vdout1_18ck20 FIND v(dout1_18) AT=105.025n

* CHECK dout1_19 Vdout1_19ck20 = 0 time = 105
.meas tran vdout1_19ck20 FIND v(dout1_19) AT=105.025n

* CHECK dout1_20 Vdout1_20ck20 = 0 time = 105
.meas tran vdout1_20ck20 FIND v(dout1_20) AT=105.025n

* CHECK dout1_21 Vdout1_21ck20 = 0.9 time = 105
.meas tran vdout1_21ck20 FIND v(dout1_21) AT=105.025n

* CHECK dout1_22 Vdout1_22ck20 = 0 time = 105
.meas tran vdout1_22ck20 FIND v(dout1_22) AT=105.025n

* CHECK dout1_23 Vdout1_23ck20 = 0.9 time = 105
.meas tran vdout1_23ck20 FIND v(dout1_23) AT=105.025n

* CHECK dout1_24 Vdout1_24ck20 = 0 time = 105
.meas tran vdout1_24ck20 FIND v(dout1_24) AT=105.025n

* CHECK dout1_25 Vdout1_25ck20 = 0 time = 105
.meas tran vdout1_25ck20 FIND v(dout1_25) AT=105.025n

* CHECK dout1_26 Vdout1_26ck20 = 0.9 time = 105
.meas tran vdout1_26ck20 FIND v(dout1_26) AT=105.025n

* CHECK dout1_27 Vdout1_27ck20 = 0.9 time = 105
.meas tran vdout1_27ck20 FIND v(dout1_27) AT=105.025n

* CHECK dout1_28 Vdout1_28ck20 = 0.9 time = 105
.meas tran vdout1_28ck20 FIND v(dout1_28) AT=105.025n

* CHECK dout1_29 Vdout1_29ck20 = 0.9 time = 105
.meas tran vdout1_29ck20 FIND v(dout1_29) AT=105.025n

* CHECK dout1_30 Vdout1_30ck20 = 0 time = 105
.meas tran vdout1_30ck20 FIND v(dout1_30) AT=105.025n

* CHECK dout1_31 Vdout1_31ck20 = 0.9 time = 105
.meas tran vdout1_31ck20 FIND v(dout1_31) AT=105.025n

* CHECK dout1_32 Vdout1_32ck20 = 0 time = 105
.meas tran vdout1_32ck20 FIND v(dout1_32) AT=105.025n

* CHECK dout1_33 Vdout1_33ck20 = 0 time = 105
.meas tran vdout1_33ck20 FIND v(dout1_33) AT=105.025n

* CHECK dout1_34 Vdout1_34ck20 = 0.9 time = 105
.meas tran vdout1_34ck20 FIND v(dout1_34) AT=105.025n

* CHECK dout1_35 Vdout1_35ck20 = 0.9 time = 105
.meas tran vdout1_35ck20 FIND v(dout1_35) AT=105.025n

* CHECK dout1_36 Vdout1_36ck20 = 0 time = 105
.meas tran vdout1_36ck20 FIND v(dout1_36) AT=105.025n

* CHECK dout1_37 Vdout1_37ck20 = 0 time = 105
.meas tran vdout1_37ck20 FIND v(dout1_37) AT=105.025n

* CHECK dout1_38 Vdout1_38ck20 = 0.9 time = 105
.meas tran vdout1_38ck20 FIND v(dout1_38) AT=105.025n

* CHECK dout1_39 Vdout1_39ck20 = 0 time = 105
.meas tran vdout1_39ck20 FIND v(dout1_39) AT=105.025n

* CHECK dout1_40 Vdout1_40ck20 = 0.9 time = 105
.meas tran vdout1_40ck20 FIND v(dout1_40) AT=105.025n

* CHECK dout1_41 Vdout1_41ck20 = 0.9 time = 105
.meas tran vdout1_41ck20 FIND v(dout1_41) AT=105.025n

* CHECK dout1_42 Vdout1_42ck20 = 0.9 time = 105
.meas tran vdout1_42ck20 FIND v(dout1_42) AT=105.025n

* CHECK dout1_43 Vdout1_43ck20 = 0.9 time = 105
.meas tran vdout1_43ck20 FIND v(dout1_43) AT=105.025n

* CHECK dout1_44 Vdout1_44ck20 = 0 time = 105
.meas tran vdout1_44ck20 FIND v(dout1_44) AT=105.025n

* CHECK dout1_45 Vdout1_45ck20 = 0 time = 105
.meas tran vdout1_45ck20 FIND v(dout1_45) AT=105.025n

* CHECK dout1_46 Vdout1_46ck20 = 0 time = 105
.meas tran vdout1_46ck20 FIND v(dout1_46) AT=105.025n

* CHECK dout1_47 Vdout1_47ck20 = 0 time = 105
.meas tran vdout1_47ck20 FIND v(dout1_47) AT=105.025n

* CHECK dout1_48 Vdout1_48ck20 = 0.9 time = 105
.meas tran vdout1_48ck20 FIND v(dout1_48) AT=105.025n

* CHECK dout1_49 Vdout1_49ck20 = 0.9 time = 105
.meas tran vdout1_49ck20 FIND v(dout1_49) AT=105.025n

* CHECK dout1_50 Vdout1_50ck20 = 0 time = 105
.meas tran vdout1_50ck20 FIND v(dout1_50) AT=105.025n

* CHECK dout1_51 Vdout1_51ck20 = 0.9 time = 105
.meas tran vdout1_51ck20 FIND v(dout1_51) AT=105.025n

* CHECK dout1_52 Vdout1_52ck20 = 0 time = 105
.meas tran vdout1_52ck20 FIND v(dout1_52) AT=105.025n

* CHECK dout1_53 Vdout1_53ck20 = 0 time = 105
.meas tran vdout1_53ck20 FIND v(dout1_53) AT=105.025n

* CHECK dout1_54 Vdout1_54ck20 = 0.9 time = 105
.meas tran vdout1_54ck20 FIND v(dout1_54) AT=105.025n

* CHECK dout1_55 Vdout1_55ck20 = 0.9 time = 105
.meas tran vdout1_55ck20 FIND v(dout1_55) AT=105.025n

* CHECK dout1_56 Vdout1_56ck20 = 0.9 time = 105
.meas tran vdout1_56ck20 FIND v(dout1_56) AT=105.025n

* CHECK dout1_57 Vdout1_57ck20 = 0 time = 105
.meas tran vdout1_57ck20 FIND v(dout1_57) AT=105.025n

* CHECK dout1_58 Vdout1_58ck20 = 0 time = 105
.meas tran vdout1_58ck20 FIND v(dout1_58) AT=105.025n

* CHECK dout1_59 Vdout1_59ck20 = 0.9 time = 105
.meas tran vdout1_59ck20 FIND v(dout1_59) AT=105.025n

* CHECK dout1_60 Vdout1_60ck20 = 0 time = 105
.meas tran vdout1_60ck20 FIND v(dout1_60) AT=105.025n

* CHECK dout1_61 Vdout1_61ck20 = 0.9 time = 105
.meas tran vdout1_61ck20 FIND v(dout1_61) AT=105.025n

* CHECK dout1_62 Vdout1_62ck20 = 0.9 time = 105
.meas tran vdout1_62ck20 FIND v(dout1_62) AT=105.025n

* CHECK dout1_63 Vdout1_63ck20 = 0 time = 105
.meas tran vdout1_63ck20 FIND v(dout1_63) AT=105.025n

* CHECK dout1_0 Vdout1_0ck23 = 0 time = 120
.meas tran vdout1_0ck23 FIND v(dout1_0) AT=120.025n

* CHECK dout1_1 Vdout1_1ck23 = 0 time = 120
.meas tran vdout1_1ck23 FIND v(dout1_1) AT=120.025n

* CHECK dout1_2 Vdout1_2ck23 = 0 time = 120
.meas tran vdout1_2ck23 FIND v(dout1_2) AT=120.025n

* CHECK dout1_3 Vdout1_3ck23 = 0.9 time = 120
.meas tran vdout1_3ck23 FIND v(dout1_3) AT=120.025n

* CHECK dout1_4 Vdout1_4ck23 = 0 time = 120
.meas tran vdout1_4ck23 FIND v(dout1_4) AT=120.025n

* CHECK dout1_5 Vdout1_5ck23 = 0.9 time = 120
.meas tran vdout1_5ck23 FIND v(dout1_5) AT=120.025n

* CHECK dout1_6 Vdout1_6ck23 = 0 time = 120
.meas tran vdout1_6ck23 FIND v(dout1_6) AT=120.025n

* CHECK dout1_7 Vdout1_7ck23 = 0.9 time = 120
.meas tran vdout1_7ck23 FIND v(dout1_7) AT=120.025n

* CHECK dout1_8 Vdout1_8ck23 = 0 time = 120
.meas tran vdout1_8ck23 FIND v(dout1_8) AT=120.025n

* CHECK dout1_9 Vdout1_9ck23 = 0 time = 120
.meas tran vdout1_9ck23 FIND v(dout1_9) AT=120.025n

* CHECK dout1_10 Vdout1_10ck23 = 0 time = 120
.meas tran vdout1_10ck23 FIND v(dout1_10) AT=120.025n

* CHECK dout1_11 Vdout1_11ck23 = 0.9 time = 120
.meas tran vdout1_11ck23 FIND v(dout1_11) AT=120.025n

* CHECK dout1_12 Vdout1_12ck23 = 0.9 time = 120
.meas tran vdout1_12ck23 FIND v(dout1_12) AT=120.025n

* CHECK dout1_13 Vdout1_13ck23 = 0.9 time = 120
.meas tran vdout1_13ck23 FIND v(dout1_13) AT=120.025n

* CHECK dout1_14 Vdout1_14ck23 = 0 time = 120
.meas tran vdout1_14ck23 FIND v(dout1_14) AT=120.025n

* CHECK dout1_15 Vdout1_15ck23 = 0 time = 120
.meas tran vdout1_15ck23 FIND v(dout1_15) AT=120.025n

* CHECK dout1_16 Vdout1_16ck23 = 0 time = 120
.meas tran vdout1_16ck23 FIND v(dout1_16) AT=120.025n

* CHECK dout1_17 Vdout1_17ck23 = 0.9 time = 120
.meas tran vdout1_17ck23 FIND v(dout1_17) AT=120.025n

* CHECK dout1_18 Vdout1_18ck23 = 0 time = 120
.meas tran vdout1_18ck23 FIND v(dout1_18) AT=120.025n

* CHECK dout1_19 Vdout1_19ck23 = 0 time = 120
.meas tran vdout1_19ck23 FIND v(dout1_19) AT=120.025n

* CHECK dout1_20 Vdout1_20ck23 = 0.9 time = 120
.meas tran vdout1_20ck23 FIND v(dout1_20) AT=120.025n

* CHECK dout1_21 Vdout1_21ck23 = 0.9 time = 120
.meas tran vdout1_21ck23 FIND v(dout1_21) AT=120.025n

* CHECK dout1_22 Vdout1_22ck23 = 0 time = 120
.meas tran vdout1_22ck23 FIND v(dout1_22) AT=120.025n

* CHECK dout1_23 Vdout1_23ck23 = 0 time = 120
.meas tran vdout1_23ck23 FIND v(dout1_23) AT=120.025n

* CHECK dout1_24 Vdout1_24ck23 = 0 time = 120
.meas tran vdout1_24ck23 FIND v(dout1_24) AT=120.025n

* CHECK dout1_25 Vdout1_25ck23 = 0.9 time = 120
.meas tran vdout1_25ck23 FIND v(dout1_25) AT=120.025n

* CHECK dout1_26 Vdout1_26ck23 = 0 time = 120
.meas tran vdout1_26ck23 FIND v(dout1_26) AT=120.025n

* CHECK dout1_27 Vdout1_27ck23 = 0.9 time = 120
.meas tran vdout1_27ck23 FIND v(dout1_27) AT=120.025n

* CHECK dout1_28 Vdout1_28ck23 = 0 time = 120
.meas tran vdout1_28ck23 FIND v(dout1_28) AT=120.025n

* CHECK dout1_29 Vdout1_29ck23 = 0.9 time = 120
.meas tran vdout1_29ck23 FIND v(dout1_29) AT=120.025n

* CHECK dout1_30 Vdout1_30ck23 = 0 time = 120
.meas tran vdout1_30ck23 FIND v(dout1_30) AT=120.025n

* CHECK dout1_31 Vdout1_31ck23 = 0.9 time = 120
.meas tran vdout1_31ck23 FIND v(dout1_31) AT=120.025n

* CHECK dout1_32 Vdout1_32ck23 = 0 time = 120
.meas tran vdout1_32ck23 FIND v(dout1_32) AT=120.025n

* CHECK dout1_33 Vdout1_33ck23 = 0.9 time = 120
.meas tran vdout1_33ck23 FIND v(dout1_33) AT=120.025n

* CHECK dout1_34 Vdout1_34ck23 = 0 time = 120
.meas tran vdout1_34ck23 FIND v(dout1_34) AT=120.025n

* CHECK dout1_35 Vdout1_35ck23 = 0 time = 120
.meas tran vdout1_35ck23 FIND v(dout1_35) AT=120.025n

* CHECK dout1_36 Vdout1_36ck23 = 0 time = 120
.meas tran vdout1_36ck23 FIND v(dout1_36) AT=120.025n

* CHECK dout1_37 Vdout1_37ck23 = 0 time = 120
.meas tran vdout1_37ck23 FIND v(dout1_37) AT=120.025n

* CHECK dout1_38 Vdout1_38ck23 = 0 time = 120
.meas tran vdout1_38ck23 FIND v(dout1_38) AT=120.025n

* CHECK dout1_39 Vdout1_39ck23 = 0.9 time = 120
.meas tran vdout1_39ck23 FIND v(dout1_39) AT=120.025n

* CHECK dout1_40 Vdout1_40ck23 = 0 time = 120
.meas tran vdout1_40ck23 FIND v(dout1_40) AT=120.025n

* CHECK dout1_41 Vdout1_41ck23 = 0.9 time = 120
.meas tran vdout1_41ck23 FIND v(dout1_41) AT=120.025n

* CHECK dout1_42 Vdout1_42ck23 = 0 time = 120
.meas tran vdout1_42ck23 FIND v(dout1_42) AT=120.025n

* CHECK dout1_43 Vdout1_43ck23 = 0 time = 120
.meas tran vdout1_43ck23 FIND v(dout1_43) AT=120.025n

* CHECK dout1_44 Vdout1_44ck23 = 0.9 time = 120
.meas tran vdout1_44ck23 FIND v(dout1_44) AT=120.025n

* CHECK dout1_45 Vdout1_45ck23 = 0.9 time = 120
.meas tran vdout1_45ck23 FIND v(dout1_45) AT=120.025n

* CHECK dout1_46 Vdout1_46ck23 = 0.9 time = 120
.meas tran vdout1_46ck23 FIND v(dout1_46) AT=120.025n

* CHECK dout1_47 Vdout1_47ck23 = 0.9 time = 120
.meas tran vdout1_47ck23 FIND v(dout1_47) AT=120.025n

* CHECK dout1_48 Vdout1_48ck23 = 0.9 time = 120
.meas tran vdout1_48ck23 FIND v(dout1_48) AT=120.025n

* CHECK dout1_49 Vdout1_49ck23 = 0 time = 120
.meas tran vdout1_49ck23 FIND v(dout1_49) AT=120.025n

* CHECK dout1_50 Vdout1_50ck23 = 0.9 time = 120
.meas tran vdout1_50ck23 FIND v(dout1_50) AT=120.025n

* CHECK dout1_51 Vdout1_51ck23 = 0 time = 120
.meas tran vdout1_51ck23 FIND v(dout1_51) AT=120.025n

* CHECK dout1_52 Vdout1_52ck23 = 0.9 time = 120
.meas tran vdout1_52ck23 FIND v(dout1_52) AT=120.025n

* CHECK dout1_53 Vdout1_53ck23 = 0.9 time = 120
.meas tran vdout1_53ck23 FIND v(dout1_53) AT=120.025n

* CHECK dout1_54 Vdout1_54ck23 = 0 time = 120
.meas tran vdout1_54ck23 FIND v(dout1_54) AT=120.025n

* CHECK dout1_55 Vdout1_55ck23 = 0.9 time = 120
.meas tran vdout1_55ck23 FIND v(dout1_55) AT=120.025n

* CHECK dout1_56 Vdout1_56ck23 = 0 time = 120
.meas tran vdout1_56ck23 FIND v(dout1_56) AT=120.025n

* CHECK dout1_57 Vdout1_57ck23 = 0 time = 120
.meas tran vdout1_57ck23 FIND v(dout1_57) AT=120.025n

* CHECK dout1_58 Vdout1_58ck23 = 0 time = 120
.meas tran vdout1_58ck23 FIND v(dout1_58) AT=120.025n

* CHECK dout1_59 Vdout1_59ck23 = 0.9 time = 120
.meas tran vdout1_59ck23 FIND v(dout1_59) AT=120.025n

* CHECK dout1_60 Vdout1_60ck23 = 0.9 time = 120
.meas tran vdout1_60ck23 FIND v(dout1_60) AT=120.025n

* CHECK dout1_61 Vdout1_61ck23 = 0.9 time = 120
.meas tran vdout1_61ck23 FIND v(dout1_61) AT=120.025n

* CHECK dout1_62 Vdout1_62ck23 = 0 time = 120
.meas tran vdout1_62ck23 FIND v(dout1_62) AT=120.025n

* CHECK dout1_63 Vdout1_63ck23 = 0.9 time = 120
.meas tran vdout1_63ck23 FIND v(dout1_63) AT=120.025n

* CHECK dout1_0 Vdout1_0ck27 = 0.9 time = 140
.meas tran vdout1_0ck27 FIND v(dout1_0) AT=140.025n

* CHECK dout1_1 Vdout1_1ck27 = 0 time = 140
.meas tran vdout1_1ck27 FIND v(dout1_1) AT=140.025n

* CHECK dout1_2 Vdout1_2ck27 = 0 time = 140
.meas tran vdout1_2ck27 FIND v(dout1_2) AT=140.025n

* CHECK dout1_3 Vdout1_3ck27 = 0 time = 140
.meas tran vdout1_3ck27 FIND v(dout1_3) AT=140.025n

* CHECK dout1_4 Vdout1_4ck27 = 0.9 time = 140
.meas tran vdout1_4ck27 FIND v(dout1_4) AT=140.025n

* CHECK dout1_5 Vdout1_5ck27 = 0 time = 140
.meas tran vdout1_5ck27 FIND v(dout1_5) AT=140.025n

* CHECK dout1_6 Vdout1_6ck27 = 0 time = 140
.meas tran vdout1_6ck27 FIND v(dout1_6) AT=140.025n

* CHECK dout1_7 Vdout1_7ck27 = 0.9 time = 140
.meas tran vdout1_7ck27 FIND v(dout1_7) AT=140.025n

* CHECK dout1_8 Vdout1_8ck27 = 0.9 time = 140
.meas tran vdout1_8ck27 FIND v(dout1_8) AT=140.025n

* CHECK dout1_9 Vdout1_9ck27 = 0.9 time = 140
.meas tran vdout1_9ck27 FIND v(dout1_9) AT=140.025n

* CHECK dout1_10 Vdout1_10ck27 = 0.9 time = 140
.meas tran vdout1_10ck27 FIND v(dout1_10) AT=140.025n

* CHECK dout1_11 Vdout1_11ck27 = 0 time = 140
.meas tran vdout1_11ck27 FIND v(dout1_11) AT=140.025n

* CHECK dout1_12 Vdout1_12ck27 = 0.9 time = 140
.meas tran vdout1_12ck27 FIND v(dout1_12) AT=140.025n

* CHECK dout1_13 Vdout1_13ck27 = 0.9 time = 140
.meas tran vdout1_13ck27 FIND v(dout1_13) AT=140.025n

* CHECK dout1_14 Vdout1_14ck27 = 0 time = 140
.meas tran vdout1_14ck27 FIND v(dout1_14) AT=140.025n

* CHECK dout1_15 Vdout1_15ck27 = 0 time = 140
.meas tran vdout1_15ck27 FIND v(dout1_15) AT=140.025n

* CHECK dout1_16 Vdout1_16ck27 = 0.9 time = 140
.meas tran vdout1_16ck27 FIND v(dout1_16) AT=140.025n

* CHECK dout1_17 Vdout1_17ck27 = 0 time = 140
.meas tran vdout1_17ck27 FIND v(dout1_17) AT=140.025n

* CHECK dout1_18 Vdout1_18ck27 = 0 time = 140
.meas tran vdout1_18ck27 FIND v(dout1_18) AT=140.025n

* CHECK dout1_19 Vdout1_19ck27 = 0.9 time = 140
.meas tran vdout1_19ck27 FIND v(dout1_19) AT=140.025n

* CHECK dout1_20 Vdout1_20ck27 = 0.9 time = 140
.meas tran vdout1_20ck27 FIND v(dout1_20) AT=140.025n

* CHECK dout1_21 Vdout1_21ck27 = 0 time = 140
.meas tran vdout1_21ck27 FIND v(dout1_21) AT=140.025n

* CHECK dout1_22 Vdout1_22ck27 = 0.9 time = 140
.meas tran vdout1_22ck27 FIND v(dout1_22) AT=140.025n

* CHECK dout1_23 Vdout1_23ck27 = 0 time = 140
.meas tran vdout1_23ck27 FIND v(dout1_23) AT=140.025n

* CHECK dout1_24 Vdout1_24ck27 = 0.9 time = 140
.meas tran vdout1_24ck27 FIND v(dout1_24) AT=140.025n

* CHECK dout1_25 Vdout1_25ck27 = 0 time = 140
.meas tran vdout1_25ck27 FIND v(dout1_25) AT=140.025n

* CHECK dout1_26 Vdout1_26ck27 = 0 time = 140
.meas tran vdout1_26ck27 FIND v(dout1_26) AT=140.025n

* CHECK dout1_27 Vdout1_27ck27 = 0 time = 140
.meas tran vdout1_27ck27 FIND v(dout1_27) AT=140.025n

* CHECK dout1_28 Vdout1_28ck27 = 0 time = 140
.meas tran vdout1_28ck27 FIND v(dout1_28) AT=140.025n

* CHECK dout1_29 Vdout1_29ck27 = 0.9 time = 140
.meas tran vdout1_29ck27 FIND v(dout1_29) AT=140.025n

* CHECK dout1_30 Vdout1_30ck27 = 0 time = 140
.meas tran vdout1_30ck27 FIND v(dout1_30) AT=140.025n

* CHECK dout1_31 Vdout1_31ck27 = 0.9 time = 140
.meas tran vdout1_31ck27 FIND v(dout1_31) AT=140.025n

* CHECK dout1_32 Vdout1_32ck27 = 0.9 time = 140
.meas tran vdout1_32ck27 FIND v(dout1_32) AT=140.025n

* CHECK dout1_33 Vdout1_33ck27 = 0.9 time = 140
.meas tran vdout1_33ck27 FIND v(dout1_33) AT=140.025n

* CHECK dout1_34 Vdout1_34ck27 = 0 time = 140
.meas tran vdout1_34ck27 FIND v(dout1_34) AT=140.025n

* CHECK dout1_35 Vdout1_35ck27 = 0 time = 140
.meas tran vdout1_35ck27 FIND v(dout1_35) AT=140.025n

* CHECK dout1_36 Vdout1_36ck27 = 0 time = 140
.meas tran vdout1_36ck27 FIND v(dout1_36) AT=140.025n

* CHECK dout1_37 Vdout1_37ck27 = 0 time = 140
.meas tran vdout1_37ck27 FIND v(dout1_37) AT=140.025n

* CHECK dout1_38 Vdout1_38ck27 = 0.9 time = 140
.meas tran vdout1_38ck27 FIND v(dout1_38) AT=140.025n

* CHECK dout1_39 Vdout1_39ck27 = 0.9 time = 140
.meas tran vdout1_39ck27 FIND v(dout1_39) AT=140.025n

* CHECK dout1_40 Vdout1_40ck27 = 0.9 time = 140
.meas tran vdout1_40ck27 FIND v(dout1_40) AT=140.025n

* CHECK dout1_41 Vdout1_41ck27 = 0.9 time = 140
.meas tran vdout1_41ck27 FIND v(dout1_41) AT=140.025n

* CHECK dout1_42 Vdout1_42ck27 = 0.9 time = 140
.meas tran vdout1_42ck27 FIND v(dout1_42) AT=140.025n

* CHECK dout1_43 Vdout1_43ck27 = 0.9 time = 140
.meas tran vdout1_43ck27 FIND v(dout1_43) AT=140.025n

* CHECK dout1_44 Vdout1_44ck27 = 0 time = 140
.meas tran vdout1_44ck27 FIND v(dout1_44) AT=140.025n

* CHECK dout1_45 Vdout1_45ck27 = 0.9 time = 140
.meas tran vdout1_45ck27 FIND v(dout1_45) AT=140.025n

* CHECK dout1_46 Vdout1_46ck27 = 0.9 time = 140
.meas tran vdout1_46ck27 FIND v(dout1_46) AT=140.025n

* CHECK dout1_47 Vdout1_47ck27 = 0.9 time = 140
.meas tran vdout1_47ck27 FIND v(dout1_47) AT=140.025n

* CHECK dout1_48 Vdout1_48ck27 = 0.9 time = 140
.meas tran vdout1_48ck27 FIND v(dout1_48) AT=140.025n

* CHECK dout1_49 Vdout1_49ck27 = 0 time = 140
.meas tran vdout1_49ck27 FIND v(dout1_49) AT=140.025n

* CHECK dout1_50 Vdout1_50ck27 = 0.9 time = 140
.meas tran vdout1_50ck27 FIND v(dout1_50) AT=140.025n

* CHECK dout1_51 Vdout1_51ck27 = 0 time = 140
.meas tran vdout1_51ck27 FIND v(dout1_51) AT=140.025n

* CHECK dout1_52 Vdout1_52ck27 = 0.9 time = 140
.meas tran vdout1_52ck27 FIND v(dout1_52) AT=140.025n

* CHECK dout1_53 Vdout1_53ck27 = 0 time = 140
.meas tran vdout1_53ck27 FIND v(dout1_53) AT=140.025n

* CHECK dout1_54 Vdout1_54ck27 = 0.9 time = 140
.meas tran vdout1_54ck27 FIND v(dout1_54) AT=140.025n

* CHECK dout1_55 Vdout1_55ck27 = 0.9 time = 140
.meas tran vdout1_55ck27 FIND v(dout1_55) AT=140.025n

* CHECK dout1_56 Vdout1_56ck27 = 0.9 time = 140
.meas tran vdout1_56ck27 FIND v(dout1_56) AT=140.025n

* CHECK dout1_57 Vdout1_57ck27 = 0 time = 140
.meas tran vdout1_57ck27 FIND v(dout1_57) AT=140.025n

* CHECK dout1_58 Vdout1_58ck27 = 0.9 time = 140
.meas tran vdout1_58ck27 FIND v(dout1_58) AT=140.025n

* CHECK dout1_59 Vdout1_59ck27 = 0.9 time = 140
.meas tran vdout1_59ck27 FIND v(dout1_59) AT=140.025n

* CHECK dout1_60 Vdout1_60ck27 = 0.9 time = 140
.meas tran vdout1_60ck27 FIND v(dout1_60) AT=140.025n

* CHECK dout1_61 Vdout1_61ck27 = 0.9 time = 140
.meas tran vdout1_61ck27 FIND v(dout1_61) AT=140.025n

* CHECK dout1_62 Vdout1_62ck27 = 0 time = 140
.meas tran vdout1_62ck27 FIND v(dout1_62) AT=140.025n

* CHECK dout1_63 Vdout1_63ck27 = 0.9 time = 140
.meas tran vdout1_63ck27 FIND v(dout1_63) AT=140.025n

* CHECK dout1_0 Vdout1_0ck28 = 0.9 time = 145
.meas tran vdout1_0ck28 FIND v(dout1_0) AT=145.025n

* CHECK dout1_1 Vdout1_1ck28 = 0 time = 145
.meas tran vdout1_1ck28 FIND v(dout1_1) AT=145.025n

* CHECK dout1_2 Vdout1_2ck28 = 0 time = 145
.meas tran vdout1_2ck28 FIND v(dout1_2) AT=145.025n

* CHECK dout1_3 Vdout1_3ck28 = 0 time = 145
.meas tran vdout1_3ck28 FIND v(dout1_3) AT=145.025n

* CHECK dout1_4 Vdout1_4ck28 = 0.9 time = 145
.meas tran vdout1_4ck28 FIND v(dout1_4) AT=145.025n

* CHECK dout1_5 Vdout1_5ck28 = 0 time = 145
.meas tran vdout1_5ck28 FIND v(dout1_5) AT=145.025n

* CHECK dout1_6 Vdout1_6ck28 = 0 time = 145
.meas tran vdout1_6ck28 FIND v(dout1_6) AT=145.025n

* CHECK dout1_7 Vdout1_7ck28 = 0.9 time = 145
.meas tran vdout1_7ck28 FIND v(dout1_7) AT=145.025n

* CHECK dout1_8 Vdout1_8ck28 = 0.9 time = 145
.meas tran vdout1_8ck28 FIND v(dout1_8) AT=145.025n

* CHECK dout1_9 Vdout1_9ck28 = 0.9 time = 145
.meas tran vdout1_9ck28 FIND v(dout1_9) AT=145.025n

* CHECK dout1_10 Vdout1_10ck28 = 0.9 time = 145
.meas tran vdout1_10ck28 FIND v(dout1_10) AT=145.025n

* CHECK dout1_11 Vdout1_11ck28 = 0 time = 145
.meas tran vdout1_11ck28 FIND v(dout1_11) AT=145.025n

* CHECK dout1_12 Vdout1_12ck28 = 0.9 time = 145
.meas tran vdout1_12ck28 FIND v(dout1_12) AT=145.025n

* CHECK dout1_13 Vdout1_13ck28 = 0.9 time = 145
.meas tran vdout1_13ck28 FIND v(dout1_13) AT=145.025n

* CHECK dout1_14 Vdout1_14ck28 = 0 time = 145
.meas tran vdout1_14ck28 FIND v(dout1_14) AT=145.025n

* CHECK dout1_15 Vdout1_15ck28 = 0 time = 145
.meas tran vdout1_15ck28 FIND v(dout1_15) AT=145.025n

* CHECK dout1_16 Vdout1_16ck28 = 0.9 time = 145
.meas tran vdout1_16ck28 FIND v(dout1_16) AT=145.025n

* CHECK dout1_17 Vdout1_17ck28 = 0 time = 145
.meas tran vdout1_17ck28 FIND v(dout1_17) AT=145.025n

* CHECK dout1_18 Vdout1_18ck28 = 0 time = 145
.meas tran vdout1_18ck28 FIND v(dout1_18) AT=145.025n

* CHECK dout1_19 Vdout1_19ck28 = 0.9 time = 145
.meas tran vdout1_19ck28 FIND v(dout1_19) AT=145.025n

* CHECK dout1_20 Vdout1_20ck28 = 0.9 time = 145
.meas tran vdout1_20ck28 FIND v(dout1_20) AT=145.025n

* CHECK dout1_21 Vdout1_21ck28 = 0 time = 145
.meas tran vdout1_21ck28 FIND v(dout1_21) AT=145.025n

* CHECK dout1_22 Vdout1_22ck28 = 0.9 time = 145
.meas tran vdout1_22ck28 FIND v(dout1_22) AT=145.025n

* CHECK dout1_23 Vdout1_23ck28 = 0 time = 145
.meas tran vdout1_23ck28 FIND v(dout1_23) AT=145.025n

* CHECK dout1_24 Vdout1_24ck28 = 0.9 time = 145
.meas tran vdout1_24ck28 FIND v(dout1_24) AT=145.025n

* CHECK dout1_25 Vdout1_25ck28 = 0 time = 145
.meas tran vdout1_25ck28 FIND v(dout1_25) AT=145.025n

* CHECK dout1_26 Vdout1_26ck28 = 0 time = 145
.meas tran vdout1_26ck28 FIND v(dout1_26) AT=145.025n

* CHECK dout1_27 Vdout1_27ck28 = 0 time = 145
.meas tran vdout1_27ck28 FIND v(dout1_27) AT=145.025n

* CHECK dout1_28 Vdout1_28ck28 = 0 time = 145
.meas tran vdout1_28ck28 FIND v(dout1_28) AT=145.025n

* CHECK dout1_29 Vdout1_29ck28 = 0.9 time = 145
.meas tran vdout1_29ck28 FIND v(dout1_29) AT=145.025n

* CHECK dout1_30 Vdout1_30ck28 = 0 time = 145
.meas tran vdout1_30ck28 FIND v(dout1_30) AT=145.025n

* CHECK dout1_31 Vdout1_31ck28 = 0.9 time = 145
.meas tran vdout1_31ck28 FIND v(dout1_31) AT=145.025n

* CHECK dout1_32 Vdout1_32ck28 = 0.9 time = 145
.meas tran vdout1_32ck28 FIND v(dout1_32) AT=145.025n

* CHECK dout1_33 Vdout1_33ck28 = 0.9 time = 145
.meas tran vdout1_33ck28 FIND v(dout1_33) AT=145.025n

* CHECK dout1_34 Vdout1_34ck28 = 0 time = 145
.meas tran vdout1_34ck28 FIND v(dout1_34) AT=145.025n

* CHECK dout1_35 Vdout1_35ck28 = 0 time = 145
.meas tran vdout1_35ck28 FIND v(dout1_35) AT=145.025n

* CHECK dout1_36 Vdout1_36ck28 = 0 time = 145
.meas tran vdout1_36ck28 FIND v(dout1_36) AT=145.025n

* CHECK dout1_37 Vdout1_37ck28 = 0 time = 145
.meas tran vdout1_37ck28 FIND v(dout1_37) AT=145.025n

* CHECK dout1_38 Vdout1_38ck28 = 0.9 time = 145
.meas tran vdout1_38ck28 FIND v(dout1_38) AT=145.025n

* CHECK dout1_39 Vdout1_39ck28 = 0.9 time = 145
.meas tran vdout1_39ck28 FIND v(dout1_39) AT=145.025n

* CHECK dout1_40 Vdout1_40ck28 = 0.9 time = 145
.meas tran vdout1_40ck28 FIND v(dout1_40) AT=145.025n

* CHECK dout1_41 Vdout1_41ck28 = 0.9 time = 145
.meas tran vdout1_41ck28 FIND v(dout1_41) AT=145.025n

* CHECK dout1_42 Vdout1_42ck28 = 0.9 time = 145
.meas tran vdout1_42ck28 FIND v(dout1_42) AT=145.025n

* CHECK dout1_43 Vdout1_43ck28 = 0.9 time = 145
.meas tran vdout1_43ck28 FIND v(dout1_43) AT=145.025n

* CHECK dout1_44 Vdout1_44ck28 = 0 time = 145
.meas tran vdout1_44ck28 FIND v(dout1_44) AT=145.025n

* CHECK dout1_45 Vdout1_45ck28 = 0.9 time = 145
.meas tran vdout1_45ck28 FIND v(dout1_45) AT=145.025n

* CHECK dout1_46 Vdout1_46ck28 = 0.9 time = 145
.meas tran vdout1_46ck28 FIND v(dout1_46) AT=145.025n

* CHECK dout1_47 Vdout1_47ck28 = 0.9 time = 145
.meas tran vdout1_47ck28 FIND v(dout1_47) AT=145.025n

* CHECK dout1_48 Vdout1_48ck28 = 0.9 time = 145
.meas tran vdout1_48ck28 FIND v(dout1_48) AT=145.025n

* CHECK dout1_49 Vdout1_49ck28 = 0 time = 145
.meas tran vdout1_49ck28 FIND v(dout1_49) AT=145.025n

* CHECK dout1_50 Vdout1_50ck28 = 0.9 time = 145
.meas tran vdout1_50ck28 FIND v(dout1_50) AT=145.025n

* CHECK dout1_51 Vdout1_51ck28 = 0 time = 145
.meas tran vdout1_51ck28 FIND v(dout1_51) AT=145.025n

* CHECK dout1_52 Vdout1_52ck28 = 0.9 time = 145
.meas tran vdout1_52ck28 FIND v(dout1_52) AT=145.025n

* CHECK dout1_53 Vdout1_53ck28 = 0 time = 145
.meas tran vdout1_53ck28 FIND v(dout1_53) AT=145.025n

* CHECK dout1_54 Vdout1_54ck28 = 0.9 time = 145
.meas tran vdout1_54ck28 FIND v(dout1_54) AT=145.025n

* CHECK dout1_55 Vdout1_55ck28 = 0.9 time = 145
.meas tran vdout1_55ck28 FIND v(dout1_55) AT=145.025n

* CHECK dout1_56 Vdout1_56ck28 = 0.9 time = 145
.meas tran vdout1_56ck28 FIND v(dout1_56) AT=145.025n

* CHECK dout1_57 Vdout1_57ck28 = 0 time = 145
.meas tran vdout1_57ck28 FIND v(dout1_57) AT=145.025n

* CHECK dout1_58 Vdout1_58ck28 = 0.9 time = 145
.meas tran vdout1_58ck28 FIND v(dout1_58) AT=145.025n

* CHECK dout1_59 Vdout1_59ck28 = 0.9 time = 145
.meas tran vdout1_59ck28 FIND v(dout1_59) AT=145.025n

* CHECK dout1_60 Vdout1_60ck28 = 0.9 time = 145
.meas tran vdout1_60ck28 FIND v(dout1_60) AT=145.025n

* CHECK dout1_61 Vdout1_61ck28 = 0.9 time = 145
.meas tran vdout1_61ck28 FIND v(dout1_61) AT=145.025n

* CHECK dout1_62 Vdout1_62ck28 = 0 time = 145
.meas tran vdout1_62ck28 FIND v(dout1_62) AT=145.025n

* CHECK dout1_63 Vdout1_63ck28 = 0.9 time = 145
.meas tran vdout1_63ck28 FIND v(dout1_63) AT=145.025n

* CHECK dout1_0 Vdout1_0ck30 = 0.9 time = 155
.meas tran vdout1_0ck30 FIND v(dout1_0) AT=155.025n

* CHECK dout1_1 Vdout1_1ck30 = 0 time = 155
.meas tran vdout1_1ck30 FIND v(dout1_1) AT=155.025n

* CHECK dout1_2 Vdout1_2ck30 = 0 time = 155
.meas tran vdout1_2ck30 FIND v(dout1_2) AT=155.025n

* CHECK dout1_3 Vdout1_3ck30 = 0 time = 155
.meas tran vdout1_3ck30 FIND v(dout1_3) AT=155.025n

* CHECK dout1_4 Vdout1_4ck30 = 0.9 time = 155
.meas tran vdout1_4ck30 FIND v(dout1_4) AT=155.025n

* CHECK dout1_5 Vdout1_5ck30 = 0 time = 155
.meas tran vdout1_5ck30 FIND v(dout1_5) AT=155.025n

* CHECK dout1_6 Vdout1_6ck30 = 0 time = 155
.meas tran vdout1_6ck30 FIND v(dout1_6) AT=155.025n

* CHECK dout1_7 Vdout1_7ck30 = 0.9 time = 155
.meas tran vdout1_7ck30 FIND v(dout1_7) AT=155.025n

* CHECK dout1_8 Vdout1_8ck30 = 0.9 time = 155
.meas tran vdout1_8ck30 FIND v(dout1_8) AT=155.025n

* CHECK dout1_9 Vdout1_9ck30 = 0.9 time = 155
.meas tran vdout1_9ck30 FIND v(dout1_9) AT=155.025n

* CHECK dout1_10 Vdout1_10ck30 = 0.9 time = 155
.meas tran vdout1_10ck30 FIND v(dout1_10) AT=155.025n

* CHECK dout1_11 Vdout1_11ck30 = 0 time = 155
.meas tran vdout1_11ck30 FIND v(dout1_11) AT=155.025n

* CHECK dout1_12 Vdout1_12ck30 = 0.9 time = 155
.meas tran vdout1_12ck30 FIND v(dout1_12) AT=155.025n

* CHECK dout1_13 Vdout1_13ck30 = 0.9 time = 155
.meas tran vdout1_13ck30 FIND v(dout1_13) AT=155.025n

* CHECK dout1_14 Vdout1_14ck30 = 0 time = 155
.meas tran vdout1_14ck30 FIND v(dout1_14) AT=155.025n

* CHECK dout1_15 Vdout1_15ck30 = 0 time = 155
.meas tran vdout1_15ck30 FIND v(dout1_15) AT=155.025n

* CHECK dout1_16 Vdout1_16ck30 = 0.9 time = 155
.meas tran vdout1_16ck30 FIND v(dout1_16) AT=155.025n

* CHECK dout1_17 Vdout1_17ck30 = 0 time = 155
.meas tran vdout1_17ck30 FIND v(dout1_17) AT=155.025n

* CHECK dout1_18 Vdout1_18ck30 = 0 time = 155
.meas tran vdout1_18ck30 FIND v(dout1_18) AT=155.025n

* CHECK dout1_19 Vdout1_19ck30 = 0.9 time = 155
.meas tran vdout1_19ck30 FIND v(dout1_19) AT=155.025n

* CHECK dout1_20 Vdout1_20ck30 = 0.9 time = 155
.meas tran vdout1_20ck30 FIND v(dout1_20) AT=155.025n

* CHECK dout1_21 Vdout1_21ck30 = 0 time = 155
.meas tran vdout1_21ck30 FIND v(dout1_21) AT=155.025n

* CHECK dout1_22 Vdout1_22ck30 = 0.9 time = 155
.meas tran vdout1_22ck30 FIND v(dout1_22) AT=155.025n

* CHECK dout1_23 Vdout1_23ck30 = 0 time = 155
.meas tran vdout1_23ck30 FIND v(dout1_23) AT=155.025n

* CHECK dout1_24 Vdout1_24ck30 = 0.9 time = 155
.meas tran vdout1_24ck30 FIND v(dout1_24) AT=155.025n

* CHECK dout1_25 Vdout1_25ck30 = 0 time = 155
.meas tran vdout1_25ck30 FIND v(dout1_25) AT=155.025n

* CHECK dout1_26 Vdout1_26ck30 = 0 time = 155
.meas tran vdout1_26ck30 FIND v(dout1_26) AT=155.025n

* CHECK dout1_27 Vdout1_27ck30 = 0 time = 155
.meas tran vdout1_27ck30 FIND v(dout1_27) AT=155.025n

* CHECK dout1_28 Vdout1_28ck30 = 0 time = 155
.meas tran vdout1_28ck30 FIND v(dout1_28) AT=155.025n

* CHECK dout1_29 Vdout1_29ck30 = 0.9 time = 155
.meas tran vdout1_29ck30 FIND v(dout1_29) AT=155.025n

* CHECK dout1_30 Vdout1_30ck30 = 0 time = 155
.meas tran vdout1_30ck30 FIND v(dout1_30) AT=155.025n

* CHECK dout1_31 Vdout1_31ck30 = 0.9 time = 155
.meas tran vdout1_31ck30 FIND v(dout1_31) AT=155.025n

* CHECK dout1_32 Vdout1_32ck30 = 0.9 time = 155
.meas tran vdout1_32ck30 FIND v(dout1_32) AT=155.025n

* CHECK dout1_33 Vdout1_33ck30 = 0.9 time = 155
.meas tran vdout1_33ck30 FIND v(dout1_33) AT=155.025n

* CHECK dout1_34 Vdout1_34ck30 = 0 time = 155
.meas tran vdout1_34ck30 FIND v(dout1_34) AT=155.025n

* CHECK dout1_35 Vdout1_35ck30 = 0 time = 155
.meas tran vdout1_35ck30 FIND v(dout1_35) AT=155.025n

* CHECK dout1_36 Vdout1_36ck30 = 0 time = 155
.meas tran vdout1_36ck30 FIND v(dout1_36) AT=155.025n

* CHECK dout1_37 Vdout1_37ck30 = 0 time = 155
.meas tran vdout1_37ck30 FIND v(dout1_37) AT=155.025n

* CHECK dout1_38 Vdout1_38ck30 = 0.9 time = 155
.meas tran vdout1_38ck30 FIND v(dout1_38) AT=155.025n

* CHECK dout1_39 Vdout1_39ck30 = 0.9 time = 155
.meas tran vdout1_39ck30 FIND v(dout1_39) AT=155.025n

* CHECK dout1_40 Vdout1_40ck30 = 0.9 time = 155
.meas tran vdout1_40ck30 FIND v(dout1_40) AT=155.025n

* CHECK dout1_41 Vdout1_41ck30 = 0.9 time = 155
.meas tran vdout1_41ck30 FIND v(dout1_41) AT=155.025n

* CHECK dout1_42 Vdout1_42ck30 = 0.9 time = 155
.meas tran vdout1_42ck30 FIND v(dout1_42) AT=155.025n

* CHECK dout1_43 Vdout1_43ck30 = 0.9 time = 155
.meas tran vdout1_43ck30 FIND v(dout1_43) AT=155.025n

* CHECK dout1_44 Vdout1_44ck30 = 0 time = 155
.meas tran vdout1_44ck30 FIND v(dout1_44) AT=155.025n

* CHECK dout1_45 Vdout1_45ck30 = 0.9 time = 155
.meas tran vdout1_45ck30 FIND v(dout1_45) AT=155.025n

* CHECK dout1_46 Vdout1_46ck30 = 0.9 time = 155
.meas tran vdout1_46ck30 FIND v(dout1_46) AT=155.025n

* CHECK dout1_47 Vdout1_47ck30 = 0.9 time = 155
.meas tran vdout1_47ck30 FIND v(dout1_47) AT=155.025n

* CHECK dout1_48 Vdout1_48ck30 = 0.9 time = 155
.meas tran vdout1_48ck30 FIND v(dout1_48) AT=155.025n

* CHECK dout1_49 Vdout1_49ck30 = 0 time = 155
.meas tran vdout1_49ck30 FIND v(dout1_49) AT=155.025n

* CHECK dout1_50 Vdout1_50ck30 = 0.9 time = 155
.meas tran vdout1_50ck30 FIND v(dout1_50) AT=155.025n

* CHECK dout1_51 Vdout1_51ck30 = 0 time = 155
.meas tran vdout1_51ck30 FIND v(dout1_51) AT=155.025n

* CHECK dout1_52 Vdout1_52ck30 = 0.9 time = 155
.meas tran vdout1_52ck30 FIND v(dout1_52) AT=155.025n

* CHECK dout1_53 Vdout1_53ck30 = 0 time = 155
.meas tran vdout1_53ck30 FIND v(dout1_53) AT=155.025n

* CHECK dout1_54 Vdout1_54ck30 = 0.9 time = 155
.meas tran vdout1_54ck30 FIND v(dout1_54) AT=155.025n

* CHECK dout1_55 Vdout1_55ck30 = 0.9 time = 155
.meas tran vdout1_55ck30 FIND v(dout1_55) AT=155.025n

* CHECK dout1_56 Vdout1_56ck30 = 0.9 time = 155
.meas tran vdout1_56ck30 FIND v(dout1_56) AT=155.025n

* CHECK dout1_57 Vdout1_57ck30 = 0 time = 155
.meas tran vdout1_57ck30 FIND v(dout1_57) AT=155.025n

* CHECK dout1_58 Vdout1_58ck30 = 0.9 time = 155
.meas tran vdout1_58ck30 FIND v(dout1_58) AT=155.025n

* CHECK dout1_59 Vdout1_59ck30 = 0.9 time = 155
.meas tran vdout1_59ck30 FIND v(dout1_59) AT=155.025n

* CHECK dout1_60 Vdout1_60ck30 = 0.9 time = 155
.meas tran vdout1_60ck30 FIND v(dout1_60) AT=155.025n

* CHECK dout1_61 Vdout1_61ck30 = 0.9 time = 155
.meas tran vdout1_61ck30 FIND v(dout1_61) AT=155.025n

* CHECK dout1_62 Vdout1_62ck30 = 0 time = 155
.meas tran vdout1_62ck30 FIND v(dout1_62) AT=155.025n

* CHECK dout1_63 Vdout1_63ck30 = 0.9 time = 155
.meas tran vdout1_63ck30 FIND v(dout1_63) AT=155.025n

* CHECK dout1_0 Vdout1_0ck32 = 0 time = 165
.meas tran vdout1_0ck32 FIND v(dout1_0) AT=165.025n

* CHECK dout1_1 Vdout1_1ck32 = 0 time = 165
.meas tran vdout1_1ck32 FIND v(dout1_1) AT=165.025n

* CHECK dout1_2 Vdout1_2ck32 = 0.9 time = 165
.meas tran vdout1_2ck32 FIND v(dout1_2) AT=165.025n

* CHECK dout1_3 Vdout1_3ck32 = 0.9 time = 165
.meas tran vdout1_3ck32 FIND v(dout1_3) AT=165.025n

* CHECK dout1_4 Vdout1_4ck32 = 0 time = 165
.meas tran vdout1_4ck32 FIND v(dout1_4) AT=165.025n

* CHECK dout1_5 Vdout1_5ck32 = 0.9 time = 165
.meas tran vdout1_5ck32 FIND v(dout1_5) AT=165.025n

* CHECK dout1_6 Vdout1_6ck32 = 0 time = 165
.meas tran vdout1_6ck32 FIND v(dout1_6) AT=165.025n

* CHECK dout1_7 Vdout1_7ck32 = 0 time = 165
.meas tran vdout1_7ck32 FIND v(dout1_7) AT=165.025n

* CHECK dout1_8 Vdout1_8ck32 = 0.9 time = 165
.meas tran vdout1_8ck32 FIND v(dout1_8) AT=165.025n

* CHECK dout1_9 Vdout1_9ck32 = 0 time = 165
.meas tran vdout1_9ck32 FIND v(dout1_9) AT=165.025n

* CHECK dout1_10 Vdout1_10ck32 = 0 time = 165
.meas tran vdout1_10ck32 FIND v(dout1_10) AT=165.025n

* CHECK dout1_11 Vdout1_11ck32 = 0 time = 165
.meas tran vdout1_11ck32 FIND v(dout1_11) AT=165.025n

* CHECK dout1_12 Vdout1_12ck32 = 0.9 time = 165
.meas tran vdout1_12ck32 FIND v(dout1_12) AT=165.025n

* CHECK dout1_13 Vdout1_13ck32 = 0 time = 165
.meas tran vdout1_13ck32 FIND v(dout1_13) AT=165.025n

* CHECK dout1_14 Vdout1_14ck32 = 0 time = 165
.meas tran vdout1_14ck32 FIND v(dout1_14) AT=165.025n

* CHECK dout1_15 Vdout1_15ck32 = 0 time = 165
.meas tran vdout1_15ck32 FIND v(dout1_15) AT=165.025n

* CHECK dout1_16 Vdout1_16ck32 = 0 time = 165
.meas tran vdout1_16ck32 FIND v(dout1_16) AT=165.025n

* CHECK dout1_17 Vdout1_17ck32 = 0 time = 165
.meas tran vdout1_17ck32 FIND v(dout1_17) AT=165.025n

* CHECK dout1_18 Vdout1_18ck32 = 0.9 time = 165
.meas tran vdout1_18ck32 FIND v(dout1_18) AT=165.025n

* CHECK dout1_19 Vdout1_19ck32 = 0 time = 165
.meas tran vdout1_19ck32 FIND v(dout1_19) AT=165.025n

* CHECK dout1_20 Vdout1_20ck32 = 0.9 time = 165
.meas tran vdout1_20ck32 FIND v(dout1_20) AT=165.025n

* CHECK dout1_21 Vdout1_21ck32 = 0 time = 165
.meas tran vdout1_21ck32 FIND v(dout1_21) AT=165.025n

* CHECK dout1_22 Vdout1_22ck32 = 0.9 time = 165
.meas tran vdout1_22ck32 FIND v(dout1_22) AT=165.025n

* CHECK dout1_23 Vdout1_23ck32 = 0.9 time = 165
.meas tran vdout1_23ck32 FIND v(dout1_23) AT=165.025n

* CHECK dout1_24 Vdout1_24ck32 = 0 time = 165
.meas tran vdout1_24ck32 FIND v(dout1_24) AT=165.025n

* CHECK dout1_25 Vdout1_25ck32 = 0.9 time = 165
.meas tran vdout1_25ck32 FIND v(dout1_25) AT=165.025n

* CHECK dout1_26 Vdout1_26ck32 = 0 time = 165
.meas tran vdout1_26ck32 FIND v(dout1_26) AT=165.025n

* CHECK dout1_27 Vdout1_27ck32 = 0.9 time = 165
.meas tran vdout1_27ck32 FIND v(dout1_27) AT=165.025n

* CHECK dout1_28 Vdout1_28ck32 = 0.9 time = 165
.meas tran vdout1_28ck32 FIND v(dout1_28) AT=165.025n

* CHECK dout1_29 Vdout1_29ck32 = 0 time = 165
.meas tran vdout1_29ck32 FIND v(dout1_29) AT=165.025n

* CHECK dout1_30 Vdout1_30ck32 = 0 time = 165
.meas tran vdout1_30ck32 FIND v(dout1_30) AT=165.025n

* CHECK dout1_31 Vdout1_31ck32 = 0 time = 165
.meas tran vdout1_31ck32 FIND v(dout1_31) AT=165.025n

* CHECK dout1_32 Vdout1_32ck32 = 0 time = 165
.meas tran vdout1_32ck32 FIND v(dout1_32) AT=165.025n

* CHECK dout1_33 Vdout1_33ck32 = 0.9 time = 165
.meas tran vdout1_33ck32 FIND v(dout1_33) AT=165.025n

* CHECK dout1_34 Vdout1_34ck32 = 0 time = 165
.meas tran vdout1_34ck32 FIND v(dout1_34) AT=165.025n

* CHECK dout1_35 Vdout1_35ck32 = 0 time = 165
.meas tran vdout1_35ck32 FIND v(dout1_35) AT=165.025n

* CHECK dout1_36 Vdout1_36ck32 = 0 time = 165
.meas tran vdout1_36ck32 FIND v(dout1_36) AT=165.025n

* CHECK dout1_37 Vdout1_37ck32 = 0.9 time = 165
.meas tran vdout1_37ck32 FIND v(dout1_37) AT=165.025n

* CHECK dout1_38 Vdout1_38ck32 = 0.9 time = 165
.meas tran vdout1_38ck32 FIND v(dout1_38) AT=165.025n

* CHECK dout1_39 Vdout1_39ck32 = 0.9 time = 165
.meas tran vdout1_39ck32 FIND v(dout1_39) AT=165.025n

* CHECK dout1_40 Vdout1_40ck32 = 0 time = 165
.meas tran vdout1_40ck32 FIND v(dout1_40) AT=165.025n

* CHECK dout1_41 Vdout1_41ck32 = 0 time = 165
.meas tran vdout1_41ck32 FIND v(dout1_41) AT=165.025n

* CHECK dout1_42 Vdout1_42ck32 = 0 time = 165
.meas tran vdout1_42ck32 FIND v(dout1_42) AT=165.025n

* CHECK dout1_43 Vdout1_43ck32 = 0 time = 165
.meas tran vdout1_43ck32 FIND v(dout1_43) AT=165.025n

* CHECK dout1_44 Vdout1_44ck32 = 0 time = 165
.meas tran vdout1_44ck32 FIND v(dout1_44) AT=165.025n

* CHECK dout1_45 Vdout1_45ck32 = 0.9 time = 165
.meas tran vdout1_45ck32 FIND v(dout1_45) AT=165.025n

* CHECK dout1_46 Vdout1_46ck32 = 0 time = 165
.meas tran vdout1_46ck32 FIND v(dout1_46) AT=165.025n

* CHECK dout1_47 Vdout1_47ck32 = 0.9 time = 165
.meas tran vdout1_47ck32 FIND v(dout1_47) AT=165.025n

* CHECK dout1_48 Vdout1_48ck32 = 0 time = 165
.meas tran vdout1_48ck32 FIND v(dout1_48) AT=165.025n

* CHECK dout1_49 Vdout1_49ck32 = 0 time = 165
.meas tran vdout1_49ck32 FIND v(dout1_49) AT=165.025n

* CHECK dout1_50 Vdout1_50ck32 = 0.9 time = 165
.meas tran vdout1_50ck32 FIND v(dout1_50) AT=165.025n

* CHECK dout1_51 Vdout1_51ck32 = 0 time = 165
.meas tran vdout1_51ck32 FIND v(dout1_51) AT=165.025n

* CHECK dout1_52 Vdout1_52ck32 = 0.9 time = 165
.meas tran vdout1_52ck32 FIND v(dout1_52) AT=165.025n

* CHECK dout1_53 Vdout1_53ck32 = 0.9 time = 165
.meas tran vdout1_53ck32 FIND v(dout1_53) AT=165.025n

* CHECK dout1_54 Vdout1_54ck32 = 0.9 time = 165
.meas tran vdout1_54ck32 FIND v(dout1_54) AT=165.025n

* CHECK dout1_55 Vdout1_55ck32 = 0.9 time = 165
.meas tran vdout1_55ck32 FIND v(dout1_55) AT=165.025n

* CHECK dout1_56 Vdout1_56ck32 = 0.9 time = 165
.meas tran vdout1_56ck32 FIND v(dout1_56) AT=165.025n

* CHECK dout1_57 Vdout1_57ck32 = 0.9 time = 165
.meas tran vdout1_57ck32 FIND v(dout1_57) AT=165.025n

* CHECK dout1_58 Vdout1_58ck32 = 0.9 time = 165
.meas tran vdout1_58ck32 FIND v(dout1_58) AT=165.025n

* CHECK dout1_59 Vdout1_59ck32 = 0 time = 165
.meas tran vdout1_59ck32 FIND v(dout1_59) AT=165.025n

* CHECK dout1_60 Vdout1_60ck32 = 0.9 time = 165
.meas tran vdout1_60ck32 FIND v(dout1_60) AT=165.025n

* CHECK dout1_61 Vdout1_61ck32 = 0.9 time = 165
.meas tran vdout1_61ck32 FIND v(dout1_61) AT=165.025n

* CHECK dout1_62 Vdout1_62ck32 = 0 time = 165
.meas tran vdout1_62ck32 FIND v(dout1_62) AT=165.025n

* CHECK dout1_63 Vdout1_63ck32 = 0.9 time = 165
.meas tran vdout1_63ck32 FIND v(dout1_63) AT=165.025n

* CHECK dout1_0 Vdout1_0ck33 = 0 time = 170
.meas tran vdout1_0ck33 FIND v(dout1_0) AT=170.025n

* CHECK dout1_1 Vdout1_1ck33 = 0 time = 170
.meas tran vdout1_1ck33 FIND v(dout1_1) AT=170.025n

* CHECK dout1_2 Vdout1_2ck33 = 0.9 time = 170
.meas tran vdout1_2ck33 FIND v(dout1_2) AT=170.025n

* CHECK dout1_3 Vdout1_3ck33 = 0.9 time = 170
.meas tran vdout1_3ck33 FIND v(dout1_3) AT=170.025n

* CHECK dout1_4 Vdout1_4ck33 = 0 time = 170
.meas tran vdout1_4ck33 FIND v(dout1_4) AT=170.025n

* CHECK dout1_5 Vdout1_5ck33 = 0.9 time = 170
.meas tran vdout1_5ck33 FIND v(dout1_5) AT=170.025n

* CHECK dout1_6 Vdout1_6ck33 = 0 time = 170
.meas tran vdout1_6ck33 FIND v(dout1_6) AT=170.025n

* CHECK dout1_7 Vdout1_7ck33 = 0 time = 170
.meas tran vdout1_7ck33 FIND v(dout1_7) AT=170.025n

* CHECK dout1_8 Vdout1_8ck33 = 0.9 time = 170
.meas tran vdout1_8ck33 FIND v(dout1_8) AT=170.025n

* CHECK dout1_9 Vdout1_9ck33 = 0 time = 170
.meas tran vdout1_9ck33 FIND v(dout1_9) AT=170.025n

* CHECK dout1_10 Vdout1_10ck33 = 0 time = 170
.meas tran vdout1_10ck33 FIND v(dout1_10) AT=170.025n

* CHECK dout1_11 Vdout1_11ck33 = 0 time = 170
.meas tran vdout1_11ck33 FIND v(dout1_11) AT=170.025n

* CHECK dout1_12 Vdout1_12ck33 = 0.9 time = 170
.meas tran vdout1_12ck33 FIND v(dout1_12) AT=170.025n

* CHECK dout1_13 Vdout1_13ck33 = 0 time = 170
.meas tran vdout1_13ck33 FIND v(dout1_13) AT=170.025n

* CHECK dout1_14 Vdout1_14ck33 = 0 time = 170
.meas tran vdout1_14ck33 FIND v(dout1_14) AT=170.025n

* CHECK dout1_15 Vdout1_15ck33 = 0 time = 170
.meas tran vdout1_15ck33 FIND v(dout1_15) AT=170.025n

* CHECK dout1_16 Vdout1_16ck33 = 0 time = 170
.meas tran vdout1_16ck33 FIND v(dout1_16) AT=170.025n

* CHECK dout1_17 Vdout1_17ck33 = 0 time = 170
.meas tran vdout1_17ck33 FIND v(dout1_17) AT=170.025n

* CHECK dout1_18 Vdout1_18ck33 = 0.9 time = 170
.meas tran vdout1_18ck33 FIND v(dout1_18) AT=170.025n

* CHECK dout1_19 Vdout1_19ck33 = 0 time = 170
.meas tran vdout1_19ck33 FIND v(dout1_19) AT=170.025n

* CHECK dout1_20 Vdout1_20ck33 = 0.9 time = 170
.meas tran vdout1_20ck33 FIND v(dout1_20) AT=170.025n

* CHECK dout1_21 Vdout1_21ck33 = 0 time = 170
.meas tran vdout1_21ck33 FIND v(dout1_21) AT=170.025n

* CHECK dout1_22 Vdout1_22ck33 = 0.9 time = 170
.meas tran vdout1_22ck33 FIND v(dout1_22) AT=170.025n

* CHECK dout1_23 Vdout1_23ck33 = 0.9 time = 170
.meas tran vdout1_23ck33 FIND v(dout1_23) AT=170.025n

* CHECK dout1_24 Vdout1_24ck33 = 0 time = 170
.meas tran vdout1_24ck33 FIND v(dout1_24) AT=170.025n

* CHECK dout1_25 Vdout1_25ck33 = 0.9 time = 170
.meas tran vdout1_25ck33 FIND v(dout1_25) AT=170.025n

* CHECK dout1_26 Vdout1_26ck33 = 0 time = 170
.meas tran vdout1_26ck33 FIND v(dout1_26) AT=170.025n

* CHECK dout1_27 Vdout1_27ck33 = 0.9 time = 170
.meas tran vdout1_27ck33 FIND v(dout1_27) AT=170.025n

* CHECK dout1_28 Vdout1_28ck33 = 0.9 time = 170
.meas tran vdout1_28ck33 FIND v(dout1_28) AT=170.025n

* CHECK dout1_29 Vdout1_29ck33 = 0 time = 170
.meas tran vdout1_29ck33 FIND v(dout1_29) AT=170.025n

* CHECK dout1_30 Vdout1_30ck33 = 0 time = 170
.meas tran vdout1_30ck33 FIND v(dout1_30) AT=170.025n

* CHECK dout1_31 Vdout1_31ck33 = 0 time = 170
.meas tran vdout1_31ck33 FIND v(dout1_31) AT=170.025n

* CHECK dout1_32 Vdout1_32ck33 = 0 time = 170
.meas tran vdout1_32ck33 FIND v(dout1_32) AT=170.025n

* CHECK dout1_33 Vdout1_33ck33 = 0.9 time = 170
.meas tran vdout1_33ck33 FIND v(dout1_33) AT=170.025n

* CHECK dout1_34 Vdout1_34ck33 = 0 time = 170
.meas tran vdout1_34ck33 FIND v(dout1_34) AT=170.025n

* CHECK dout1_35 Vdout1_35ck33 = 0 time = 170
.meas tran vdout1_35ck33 FIND v(dout1_35) AT=170.025n

* CHECK dout1_36 Vdout1_36ck33 = 0 time = 170
.meas tran vdout1_36ck33 FIND v(dout1_36) AT=170.025n

* CHECK dout1_37 Vdout1_37ck33 = 0.9 time = 170
.meas tran vdout1_37ck33 FIND v(dout1_37) AT=170.025n

* CHECK dout1_38 Vdout1_38ck33 = 0.9 time = 170
.meas tran vdout1_38ck33 FIND v(dout1_38) AT=170.025n

* CHECK dout1_39 Vdout1_39ck33 = 0.9 time = 170
.meas tran vdout1_39ck33 FIND v(dout1_39) AT=170.025n

* CHECK dout1_40 Vdout1_40ck33 = 0 time = 170
.meas tran vdout1_40ck33 FIND v(dout1_40) AT=170.025n

* CHECK dout1_41 Vdout1_41ck33 = 0 time = 170
.meas tran vdout1_41ck33 FIND v(dout1_41) AT=170.025n

* CHECK dout1_42 Vdout1_42ck33 = 0 time = 170
.meas tran vdout1_42ck33 FIND v(dout1_42) AT=170.025n

* CHECK dout1_43 Vdout1_43ck33 = 0 time = 170
.meas tran vdout1_43ck33 FIND v(dout1_43) AT=170.025n

* CHECK dout1_44 Vdout1_44ck33 = 0 time = 170
.meas tran vdout1_44ck33 FIND v(dout1_44) AT=170.025n

* CHECK dout1_45 Vdout1_45ck33 = 0.9 time = 170
.meas tran vdout1_45ck33 FIND v(dout1_45) AT=170.025n

* CHECK dout1_46 Vdout1_46ck33 = 0 time = 170
.meas tran vdout1_46ck33 FIND v(dout1_46) AT=170.025n

* CHECK dout1_47 Vdout1_47ck33 = 0.9 time = 170
.meas tran vdout1_47ck33 FIND v(dout1_47) AT=170.025n

* CHECK dout1_48 Vdout1_48ck33 = 0 time = 170
.meas tran vdout1_48ck33 FIND v(dout1_48) AT=170.025n

* CHECK dout1_49 Vdout1_49ck33 = 0 time = 170
.meas tran vdout1_49ck33 FIND v(dout1_49) AT=170.025n

* CHECK dout1_50 Vdout1_50ck33 = 0.9 time = 170
.meas tran vdout1_50ck33 FIND v(dout1_50) AT=170.025n

* CHECK dout1_51 Vdout1_51ck33 = 0 time = 170
.meas tran vdout1_51ck33 FIND v(dout1_51) AT=170.025n

* CHECK dout1_52 Vdout1_52ck33 = 0.9 time = 170
.meas tran vdout1_52ck33 FIND v(dout1_52) AT=170.025n

* CHECK dout1_53 Vdout1_53ck33 = 0.9 time = 170
.meas tran vdout1_53ck33 FIND v(dout1_53) AT=170.025n

* CHECK dout1_54 Vdout1_54ck33 = 0.9 time = 170
.meas tran vdout1_54ck33 FIND v(dout1_54) AT=170.025n

* CHECK dout1_55 Vdout1_55ck33 = 0.9 time = 170
.meas tran vdout1_55ck33 FIND v(dout1_55) AT=170.025n

* CHECK dout1_56 Vdout1_56ck33 = 0.9 time = 170
.meas tran vdout1_56ck33 FIND v(dout1_56) AT=170.025n

* CHECK dout1_57 Vdout1_57ck33 = 0.9 time = 170
.meas tran vdout1_57ck33 FIND v(dout1_57) AT=170.025n

* CHECK dout1_58 Vdout1_58ck33 = 0.9 time = 170
.meas tran vdout1_58ck33 FIND v(dout1_58) AT=170.025n

* CHECK dout1_59 Vdout1_59ck33 = 0 time = 170
.meas tran vdout1_59ck33 FIND v(dout1_59) AT=170.025n

* CHECK dout1_60 Vdout1_60ck33 = 0.9 time = 170
.meas tran vdout1_60ck33 FIND v(dout1_60) AT=170.025n

* CHECK dout1_61 Vdout1_61ck33 = 0.9 time = 170
.meas tran vdout1_61ck33 FIND v(dout1_61) AT=170.025n

* CHECK dout1_62 Vdout1_62ck33 = 0 time = 170
.meas tran vdout1_62ck33 FIND v(dout1_62) AT=170.025n

* CHECK dout1_63 Vdout1_63ck33 = 0.9 time = 170
.meas tran vdout1_63ck33 FIND v(dout1_63) AT=170.025n

* CHECK dout1_0 Vdout1_0ck45 = 0 time = 230
.meas tran vdout1_0ck45 FIND v(dout1_0) AT=230.025n

* CHECK dout1_1 Vdout1_1ck45 = 0.9 time = 230
.meas tran vdout1_1ck45 FIND v(dout1_1) AT=230.025n

* CHECK dout1_2 Vdout1_2ck45 = 0.9 time = 230
.meas tran vdout1_2ck45 FIND v(dout1_2) AT=230.025n

* CHECK dout1_3 Vdout1_3ck45 = 0 time = 230
.meas tran vdout1_3ck45 FIND v(dout1_3) AT=230.025n

* CHECK dout1_4 Vdout1_4ck45 = 0.9 time = 230
.meas tran vdout1_4ck45 FIND v(dout1_4) AT=230.025n

* CHECK dout1_5 Vdout1_5ck45 = 0 time = 230
.meas tran vdout1_5ck45 FIND v(dout1_5) AT=230.025n

* CHECK dout1_6 Vdout1_6ck45 = 0 time = 230
.meas tran vdout1_6ck45 FIND v(dout1_6) AT=230.025n

* CHECK dout1_7 Vdout1_7ck45 = 0.9 time = 230
.meas tran vdout1_7ck45 FIND v(dout1_7) AT=230.025n

* CHECK dout1_8 Vdout1_8ck45 = 0.9 time = 230
.meas tran vdout1_8ck45 FIND v(dout1_8) AT=230.025n

* CHECK dout1_9 Vdout1_9ck45 = 0.9 time = 230
.meas tran vdout1_9ck45 FIND v(dout1_9) AT=230.025n

* CHECK dout1_10 Vdout1_10ck45 = 0 time = 230
.meas tran vdout1_10ck45 FIND v(dout1_10) AT=230.025n

* CHECK dout1_11 Vdout1_11ck45 = 0.9 time = 230
.meas tran vdout1_11ck45 FIND v(dout1_11) AT=230.025n

* CHECK dout1_12 Vdout1_12ck45 = 0.9 time = 230
.meas tran vdout1_12ck45 FIND v(dout1_12) AT=230.025n

* CHECK dout1_13 Vdout1_13ck45 = 0 time = 230
.meas tran vdout1_13ck45 FIND v(dout1_13) AT=230.025n

* CHECK dout1_14 Vdout1_14ck45 = 0 time = 230
.meas tran vdout1_14ck45 FIND v(dout1_14) AT=230.025n

* CHECK dout1_15 Vdout1_15ck45 = 0 time = 230
.meas tran vdout1_15ck45 FIND v(dout1_15) AT=230.025n

* CHECK dout1_16 Vdout1_16ck45 = 0.9 time = 230
.meas tran vdout1_16ck45 FIND v(dout1_16) AT=230.025n

* CHECK dout1_17 Vdout1_17ck45 = 0 time = 230
.meas tran vdout1_17ck45 FIND v(dout1_17) AT=230.025n

* CHECK dout1_18 Vdout1_18ck45 = 0.9 time = 230
.meas tran vdout1_18ck45 FIND v(dout1_18) AT=230.025n

* CHECK dout1_19 Vdout1_19ck45 = 0 time = 230
.meas tran vdout1_19ck45 FIND v(dout1_19) AT=230.025n

* CHECK dout1_20 Vdout1_20ck45 = 0.9 time = 230
.meas tran vdout1_20ck45 FIND v(dout1_20) AT=230.025n

* CHECK dout1_21 Vdout1_21ck45 = 0.9 time = 230
.meas tran vdout1_21ck45 FIND v(dout1_21) AT=230.025n

* CHECK dout1_22 Vdout1_22ck45 = 0 time = 230
.meas tran vdout1_22ck45 FIND v(dout1_22) AT=230.025n

* CHECK dout1_23 Vdout1_23ck45 = 0 time = 230
.meas tran vdout1_23ck45 FIND v(dout1_23) AT=230.025n

* CHECK dout1_24 Vdout1_24ck45 = 0 time = 230
.meas tran vdout1_24ck45 FIND v(dout1_24) AT=230.025n

* CHECK dout1_25 Vdout1_25ck45 = 0.9 time = 230
.meas tran vdout1_25ck45 FIND v(dout1_25) AT=230.025n

* CHECK dout1_26 Vdout1_26ck45 = 0.9 time = 230
.meas tran vdout1_26ck45 FIND v(dout1_26) AT=230.025n

* CHECK dout1_27 Vdout1_27ck45 = 0 time = 230
.meas tran vdout1_27ck45 FIND v(dout1_27) AT=230.025n

* CHECK dout1_28 Vdout1_28ck45 = 0 time = 230
.meas tran vdout1_28ck45 FIND v(dout1_28) AT=230.025n

* CHECK dout1_29 Vdout1_29ck45 = 0 time = 230
.meas tran vdout1_29ck45 FIND v(dout1_29) AT=230.025n

* CHECK dout1_30 Vdout1_30ck45 = 0.9 time = 230
.meas tran vdout1_30ck45 FIND v(dout1_30) AT=230.025n

* CHECK dout1_31 Vdout1_31ck45 = 0.9 time = 230
.meas tran vdout1_31ck45 FIND v(dout1_31) AT=230.025n

* CHECK dout1_32 Vdout1_32ck45 = 0 time = 230
.meas tran vdout1_32ck45 FIND v(dout1_32) AT=230.025n

* CHECK dout1_33 Vdout1_33ck45 = 0.9 time = 230
.meas tran vdout1_33ck45 FIND v(dout1_33) AT=230.025n

* CHECK dout1_34 Vdout1_34ck45 = 0 time = 230
.meas tran vdout1_34ck45 FIND v(dout1_34) AT=230.025n

* CHECK dout1_35 Vdout1_35ck45 = 0 time = 230
.meas tran vdout1_35ck45 FIND v(dout1_35) AT=230.025n

* CHECK dout1_36 Vdout1_36ck45 = 0.9 time = 230
.meas tran vdout1_36ck45 FIND v(dout1_36) AT=230.025n

* CHECK dout1_37 Vdout1_37ck45 = 0 time = 230
.meas tran vdout1_37ck45 FIND v(dout1_37) AT=230.025n

* CHECK dout1_38 Vdout1_38ck45 = 0.9 time = 230
.meas tran vdout1_38ck45 FIND v(dout1_38) AT=230.025n

* CHECK dout1_39 Vdout1_39ck45 = 0 time = 230
.meas tran vdout1_39ck45 FIND v(dout1_39) AT=230.025n

* CHECK dout1_40 Vdout1_40ck45 = 0.9 time = 230
.meas tran vdout1_40ck45 FIND v(dout1_40) AT=230.025n

* CHECK dout1_41 Vdout1_41ck45 = 0 time = 230
.meas tran vdout1_41ck45 FIND v(dout1_41) AT=230.025n

* CHECK dout1_42 Vdout1_42ck45 = 0.9 time = 230
.meas tran vdout1_42ck45 FIND v(dout1_42) AT=230.025n

* CHECK dout1_43 Vdout1_43ck45 = 0 time = 230
.meas tran vdout1_43ck45 FIND v(dout1_43) AT=230.025n

* CHECK dout1_44 Vdout1_44ck45 = 0 time = 230
.meas tran vdout1_44ck45 FIND v(dout1_44) AT=230.025n

* CHECK dout1_45 Vdout1_45ck45 = 0 time = 230
.meas tran vdout1_45ck45 FIND v(dout1_45) AT=230.025n

* CHECK dout1_46 Vdout1_46ck45 = 0 time = 230
.meas tran vdout1_46ck45 FIND v(dout1_46) AT=230.025n

* CHECK dout1_47 Vdout1_47ck45 = 0.9 time = 230
.meas tran vdout1_47ck45 FIND v(dout1_47) AT=230.025n

* CHECK dout1_48 Vdout1_48ck45 = 0 time = 230
.meas tran vdout1_48ck45 FIND v(dout1_48) AT=230.025n

* CHECK dout1_49 Vdout1_49ck45 = 0 time = 230
.meas tran vdout1_49ck45 FIND v(dout1_49) AT=230.025n

* CHECK dout1_50 Vdout1_50ck45 = 0 time = 230
.meas tran vdout1_50ck45 FIND v(dout1_50) AT=230.025n

* CHECK dout1_51 Vdout1_51ck45 = 0.9 time = 230
.meas tran vdout1_51ck45 FIND v(dout1_51) AT=230.025n

* CHECK dout1_52 Vdout1_52ck45 = 0.9 time = 230
.meas tran vdout1_52ck45 FIND v(dout1_52) AT=230.025n

* CHECK dout1_53 Vdout1_53ck45 = 0 time = 230
.meas tran vdout1_53ck45 FIND v(dout1_53) AT=230.025n

* CHECK dout1_54 Vdout1_54ck45 = 0 time = 230
.meas tran vdout1_54ck45 FIND v(dout1_54) AT=230.025n

* CHECK dout1_55 Vdout1_55ck45 = 0.9 time = 230
.meas tran vdout1_55ck45 FIND v(dout1_55) AT=230.025n

* CHECK dout1_56 Vdout1_56ck45 = 0 time = 230
.meas tran vdout1_56ck45 FIND v(dout1_56) AT=230.025n

* CHECK dout1_57 Vdout1_57ck45 = 0.9 time = 230
.meas tran vdout1_57ck45 FIND v(dout1_57) AT=230.025n

* CHECK dout1_58 Vdout1_58ck45 = 0.9 time = 230
.meas tran vdout1_58ck45 FIND v(dout1_58) AT=230.025n

* CHECK dout1_59 Vdout1_59ck45 = 0.9 time = 230
.meas tran vdout1_59ck45 FIND v(dout1_59) AT=230.025n

* CHECK dout1_60 Vdout1_60ck45 = 0.9 time = 230
.meas tran vdout1_60ck45 FIND v(dout1_60) AT=230.025n

* CHECK dout1_61 Vdout1_61ck45 = 0.9 time = 230
.meas tran vdout1_61ck45 FIND v(dout1_61) AT=230.025n

* CHECK dout1_62 Vdout1_62ck45 = 0.9 time = 230
.meas tran vdout1_62ck45 FIND v(dout1_62) AT=230.025n

* CHECK dout1_63 Vdout1_63ck45 = 0.9 time = 230
.meas tran vdout1_63ck45 FIND v(dout1_63) AT=230.025n

* CHECK dout1_0 Vdout1_0ck46 = 0 time = 235
.meas tran vdout1_0ck46 FIND v(dout1_0) AT=235.025n

* CHECK dout1_1 Vdout1_1ck46 = 0.9 time = 235
.meas tran vdout1_1ck46 FIND v(dout1_1) AT=235.025n

* CHECK dout1_2 Vdout1_2ck46 = 0.9 time = 235
.meas tran vdout1_2ck46 FIND v(dout1_2) AT=235.025n

* CHECK dout1_3 Vdout1_3ck46 = 0 time = 235
.meas tran vdout1_3ck46 FIND v(dout1_3) AT=235.025n

* CHECK dout1_4 Vdout1_4ck46 = 0.9 time = 235
.meas tran vdout1_4ck46 FIND v(dout1_4) AT=235.025n

* CHECK dout1_5 Vdout1_5ck46 = 0 time = 235
.meas tran vdout1_5ck46 FIND v(dout1_5) AT=235.025n

* CHECK dout1_6 Vdout1_6ck46 = 0 time = 235
.meas tran vdout1_6ck46 FIND v(dout1_6) AT=235.025n

* CHECK dout1_7 Vdout1_7ck46 = 0.9 time = 235
.meas tran vdout1_7ck46 FIND v(dout1_7) AT=235.025n

* CHECK dout1_8 Vdout1_8ck46 = 0.9 time = 235
.meas tran vdout1_8ck46 FIND v(dout1_8) AT=235.025n

* CHECK dout1_9 Vdout1_9ck46 = 0.9 time = 235
.meas tran vdout1_9ck46 FIND v(dout1_9) AT=235.025n

* CHECK dout1_10 Vdout1_10ck46 = 0 time = 235
.meas tran vdout1_10ck46 FIND v(dout1_10) AT=235.025n

* CHECK dout1_11 Vdout1_11ck46 = 0.9 time = 235
.meas tran vdout1_11ck46 FIND v(dout1_11) AT=235.025n

* CHECK dout1_12 Vdout1_12ck46 = 0.9 time = 235
.meas tran vdout1_12ck46 FIND v(dout1_12) AT=235.025n

* CHECK dout1_13 Vdout1_13ck46 = 0 time = 235
.meas tran vdout1_13ck46 FIND v(dout1_13) AT=235.025n

* CHECK dout1_14 Vdout1_14ck46 = 0 time = 235
.meas tran vdout1_14ck46 FIND v(dout1_14) AT=235.025n

* CHECK dout1_15 Vdout1_15ck46 = 0 time = 235
.meas tran vdout1_15ck46 FIND v(dout1_15) AT=235.025n

* CHECK dout1_16 Vdout1_16ck46 = 0.9 time = 235
.meas tran vdout1_16ck46 FIND v(dout1_16) AT=235.025n

* CHECK dout1_17 Vdout1_17ck46 = 0 time = 235
.meas tran vdout1_17ck46 FIND v(dout1_17) AT=235.025n

* CHECK dout1_18 Vdout1_18ck46 = 0.9 time = 235
.meas tran vdout1_18ck46 FIND v(dout1_18) AT=235.025n

* CHECK dout1_19 Vdout1_19ck46 = 0 time = 235
.meas tran vdout1_19ck46 FIND v(dout1_19) AT=235.025n

* CHECK dout1_20 Vdout1_20ck46 = 0.9 time = 235
.meas tran vdout1_20ck46 FIND v(dout1_20) AT=235.025n

* CHECK dout1_21 Vdout1_21ck46 = 0.9 time = 235
.meas tran vdout1_21ck46 FIND v(dout1_21) AT=235.025n

* CHECK dout1_22 Vdout1_22ck46 = 0 time = 235
.meas tran vdout1_22ck46 FIND v(dout1_22) AT=235.025n

* CHECK dout1_23 Vdout1_23ck46 = 0 time = 235
.meas tran vdout1_23ck46 FIND v(dout1_23) AT=235.025n

* CHECK dout1_24 Vdout1_24ck46 = 0 time = 235
.meas tran vdout1_24ck46 FIND v(dout1_24) AT=235.025n

* CHECK dout1_25 Vdout1_25ck46 = 0.9 time = 235
.meas tran vdout1_25ck46 FIND v(dout1_25) AT=235.025n

* CHECK dout1_26 Vdout1_26ck46 = 0.9 time = 235
.meas tran vdout1_26ck46 FIND v(dout1_26) AT=235.025n

* CHECK dout1_27 Vdout1_27ck46 = 0 time = 235
.meas tran vdout1_27ck46 FIND v(dout1_27) AT=235.025n

* CHECK dout1_28 Vdout1_28ck46 = 0 time = 235
.meas tran vdout1_28ck46 FIND v(dout1_28) AT=235.025n

* CHECK dout1_29 Vdout1_29ck46 = 0 time = 235
.meas tran vdout1_29ck46 FIND v(dout1_29) AT=235.025n

* CHECK dout1_30 Vdout1_30ck46 = 0.9 time = 235
.meas tran vdout1_30ck46 FIND v(dout1_30) AT=235.025n

* CHECK dout1_31 Vdout1_31ck46 = 0.9 time = 235
.meas tran vdout1_31ck46 FIND v(dout1_31) AT=235.025n

* CHECK dout1_32 Vdout1_32ck46 = 0 time = 235
.meas tran vdout1_32ck46 FIND v(dout1_32) AT=235.025n

* CHECK dout1_33 Vdout1_33ck46 = 0.9 time = 235
.meas tran vdout1_33ck46 FIND v(dout1_33) AT=235.025n

* CHECK dout1_34 Vdout1_34ck46 = 0 time = 235
.meas tran vdout1_34ck46 FIND v(dout1_34) AT=235.025n

* CHECK dout1_35 Vdout1_35ck46 = 0 time = 235
.meas tran vdout1_35ck46 FIND v(dout1_35) AT=235.025n

* CHECK dout1_36 Vdout1_36ck46 = 0.9 time = 235
.meas tran vdout1_36ck46 FIND v(dout1_36) AT=235.025n

* CHECK dout1_37 Vdout1_37ck46 = 0 time = 235
.meas tran vdout1_37ck46 FIND v(dout1_37) AT=235.025n

* CHECK dout1_38 Vdout1_38ck46 = 0.9 time = 235
.meas tran vdout1_38ck46 FIND v(dout1_38) AT=235.025n

* CHECK dout1_39 Vdout1_39ck46 = 0 time = 235
.meas tran vdout1_39ck46 FIND v(dout1_39) AT=235.025n

* CHECK dout1_40 Vdout1_40ck46 = 0.9 time = 235
.meas tran vdout1_40ck46 FIND v(dout1_40) AT=235.025n

* CHECK dout1_41 Vdout1_41ck46 = 0 time = 235
.meas tran vdout1_41ck46 FIND v(dout1_41) AT=235.025n

* CHECK dout1_42 Vdout1_42ck46 = 0.9 time = 235
.meas tran vdout1_42ck46 FIND v(dout1_42) AT=235.025n

* CHECK dout1_43 Vdout1_43ck46 = 0 time = 235
.meas tran vdout1_43ck46 FIND v(dout1_43) AT=235.025n

* CHECK dout1_44 Vdout1_44ck46 = 0 time = 235
.meas tran vdout1_44ck46 FIND v(dout1_44) AT=235.025n

* CHECK dout1_45 Vdout1_45ck46 = 0 time = 235
.meas tran vdout1_45ck46 FIND v(dout1_45) AT=235.025n

* CHECK dout1_46 Vdout1_46ck46 = 0 time = 235
.meas tran vdout1_46ck46 FIND v(dout1_46) AT=235.025n

* CHECK dout1_47 Vdout1_47ck46 = 0.9 time = 235
.meas tran vdout1_47ck46 FIND v(dout1_47) AT=235.025n

* CHECK dout1_48 Vdout1_48ck46 = 0 time = 235
.meas tran vdout1_48ck46 FIND v(dout1_48) AT=235.025n

* CHECK dout1_49 Vdout1_49ck46 = 0 time = 235
.meas tran vdout1_49ck46 FIND v(dout1_49) AT=235.025n

* CHECK dout1_50 Vdout1_50ck46 = 0 time = 235
.meas tran vdout1_50ck46 FIND v(dout1_50) AT=235.025n

* CHECK dout1_51 Vdout1_51ck46 = 0.9 time = 235
.meas tran vdout1_51ck46 FIND v(dout1_51) AT=235.025n

* CHECK dout1_52 Vdout1_52ck46 = 0.9 time = 235
.meas tran vdout1_52ck46 FIND v(dout1_52) AT=235.025n

* CHECK dout1_53 Vdout1_53ck46 = 0 time = 235
.meas tran vdout1_53ck46 FIND v(dout1_53) AT=235.025n

* CHECK dout1_54 Vdout1_54ck46 = 0 time = 235
.meas tran vdout1_54ck46 FIND v(dout1_54) AT=235.025n

* CHECK dout1_55 Vdout1_55ck46 = 0.9 time = 235
.meas tran vdout1_55ck46 FIND v(dout1_55) AT=235.025n

* CHECK dout1_56 Vdout1_56ck46 = 0 time = 235
.meas tran vdout1_56ck46 FIND v(dout1_56) AT=235.025n

* CHECK dout1_57 Vdout1_57ck46 = 0.9 time = 235
.meas tran vdout1_57ck46 FIND v(dout1_57) AT=235.025n

* CHECK dout1_58 Vdout1_58ck46 = 0.9 time = 235
.meas tran vdout1_58ck46 FIND v(dout1_58) AT=235.025n

* CHECK dout1_59 Vdout1_59ck46 = 0.9 time = 235
.meas tran vdout1_59ck46 FIND v(dout1_59) AT=235.025n

* CHECK dout1_60 Vdout1_60ck46 = 0.9 time = 235
.meas tran vdout1_60ck46 FIND v(dout1_60) AT=235.025n

* CHECK dout1_61 Vdout1_61ck46 = 0.9 time = 235
.meas tran vdout1_61ck46 FIND v(dout1_61) AT=235.025n

* CHECK dout1_62 Vdout1_62ck46 = 0.9 time = 235
.meas tran vdout1_62ck46 FIND v(dout1_62) AT=235.025n

* CHECK dout1_63 Vdout1_63ck46 = 0.9 time = 235
.meas tran vdout1_63ck46 FIND v(dout1_63) AT=235.025n

* CHECK dout1_0 Vdout1_0ck49 = 0 time = 250
.meas tran vdout1_0ck49 FIND v(dout1_0) AT=250.025n

* CHECK dout1_1 Vdout1_1ck49 = 0.9 time = 250
.meas tran vdout1_1ck49 FIND v(dout1_1) AT=250.025n

* CHECK dout1_2 Vdout1_2ck49 = 0.9 time = 250
.meas tran vdout1_2ck49 FIND v(dout1_2) AT=250.025n

* CHECK dout1_3 Vdout1_3ck49 = 0 time = 250
.meas tran vdout1_3ck49 FIND v(dout1_3) AT=250.025n

* CHECK dout1_4 Vdout1_4ck49 = 0.9 time = 250
.meas tran vdout1_4ck49 FIND v(dout1_4) AT=250.025n

* CHECK dout1_5 Vdout1_5ck49 = 0.9 time = 250
.meas tran vdout1_5ck49 FIND v(dout1_5) AT=250.025n

* CHECK dout1_6 Vdout1_6ck49 = 0.9 time = 250
.meas tran vdout1_6ck49 FIND v(dout1_6) AT=250.025n

* CHECK dout1_7 Vdout1_7ck49 = 0.9 time = 250
.meas tran vdout1_7ck49 FIND v(dout1_7) AT=250.025n

* CHECK dout1_8 Vdout1_8ck49 = 0.9 time = 250
.meas tran vdout1_8ck49 FIND v(dout1_8) AT=250.025n

* CHECK dout1_9 Vdout1_9ck49 = 0 time = 250
.meas tran vdout1_9ck49 FIND v(dout1_9) AT=250.025n

* CHECK dout1_10 Vdout1_10ck49 = 0.9 time = 250
.meas tran vdout1_10ck49 FIND v(dout1_10) AT=250.025n

* CHECK dout1_11 Vdout1_11ck49 = 0.9 time = 250
.meas tran vdout1_11ck49 FIND v(dout1_11) AT=250.025n

* CHECK dout1_12 Vdout1_12ck49 = 0.9 time = 250
.meas tran vdout1_12ck49 FIND v(dout1_12) AT=250.025n

* CHECK dout1_13 Vdout1_13ck49 = 0 time = 250
.meas tran vdout1_13ck49 FIND v(dout1_13) AT=250.025n

* CHECK dout1_14 Vdout1_14ck49 = 0 time = 250
.meas tran vdout1_14ck49 FIND v(dout1_14) AT=250.025n

* CHECK dout1_15 Vdout1_15ck49 = 0.9 time = 250
.meas tran vdout1_15ck49 FIND v(dout1_15) AT=250.025n

* CHECK dout1_16 Vdout1_16ck49 = 0.9 time = 250
.meas tran vdout1_16ck49 FIND v(dout1_16) AT=250.025n

* CHECK dout1_17 Vdout1_17ck49 = 0 time = 250
.meas tran vdout1_17ck49 FIND v(dout1_17) AT=250.025n

* CHECK dout1_18 Vdout1_18ck49 = 0.9 time = 250
.meas tran vdout1_18ck49 FIND v(dout1_18) AT=250.025n

* CHECK dout1_19 Vdout1_19ck49 = 0 time = 250
.meas tran vdout1_19ck49 FIND v(dout1_19) AT=250.025n

* CHECK dout1_20 Vdout1_20ck49 = 0.9 time = 250
.meas tran vdout1_20ck49 FIND v(dout1_20) AT=250.025n

* CHECK dout1_21 Vdout1_21ck49 = 0.9 time = 250
.meas tran vdout1_21ck49 FIND v(dout1_21) AT=250.025n

* CHECK dout1_22 Vdout1_22ck49 = 0.9 time = 250
.meas tran vdout1_22ck49 FIND v(dout1_22) AT=250.025n

* CHECK dout1_23 Vdout1_23ck49 = 0 time = 250
.meas tran vdout1_23ck49 FIND v(dout1_23) AT=250.025n

* CHECK dout1_24 Vdout1_24ck49 = 0.9 time = 250
.meas tran vdout1_24ck49 FIND v(dout1_24) AT=250.025n

* CHECK dout1_25 Vdout1_25ck49 = 0.9 time = 250
.meas tran vdout1_25ck49 FIND v(dout1_25) AT=250.025n

* CHECK dout1_26 Vdout1_26ck49 = 0 time = 250
.meas tran vdout1_26ck49 FIND v(dout1_26) AT=250.025n

* CHECK dout1_27 Vdout1_27ck49 = 0.9 time = 250
.meas tran vdout1_27ck49 FIND v(dout1_27) AT=250.025n

* CHECK dout1_28 Vdout1_28ck49 = 0.9 time = 250
.meas tran vdout1_28ck49 FIND v(dout1_28) AT=250.025n

* CHECK dout1_29 Vdout1_29ck49 = 0 time = 250
.meas tran vdout1_29ck49 FIND v(dout1_29) AT=250.025n

* CHECK dout1_30 Vdout1_30ck49 = 0 time = 250
.meas tran vdout1_30ck49 FIND v(dout1_30) AT=250.025n

* CHECK dout1_31 Vdout1_31ck49 = 0 time = 250
.meas tran vdout1_31ck49 FIND v(dout1_31) AT=250.025n

* CHECK dout1_32 Vdout1_32ck49 = 0 time = 250
.meas tran vdout1_32ck49 FIND v(dout1_32) AT=250.025n

* CHECK dout1_33 Vdout1_33ck49 = 0 time = 250
.meas tran vdout1_33ck49 FIND v(dout1_33) AT=250.025n

* CHECK dout1_34 Vdout1_34ck49 = 0.9 time = 250
.meas tran vdout1_34ck49 FIND v(dout1_34) AT=250.025n

* CHECK dout1_35 Vdout1_35ck49 = 0 time = 250
.meas tran vdout1_35ck49 FIND v(dout1_35) AT=250.025n

* CHECK dout1_36 Vdout1_36ck49 = 0 time = 250
.meas tran vdout1_36ck49 FIND v(dout1_36) AT=250.025n

* CHECK dout1_37 Vdout1_37ck49 = 0.9 time = 250
.meas tran vdout1_37ck49 FIND v(dout1_37) AT=250.025n

* CHECK dout1_38 Vdout1_38ck49 = 0.9 time = 250
.meas tran vdout1_38ck49 FIND v(dout1_38) AT=250.025n

* CHECK dout1_39 Vdout1_39ck49 = 0.9 time = 250
.meas tran vdout1_39ck49 FIND v(dout1_39) AT=250.025n

* CHECK dout1_40 Vdout1_40ck49 = 0 time = 250
.meas tran vdout1_40ck49 FIND v(dout1_40) AT=250.025n

* CHECK dout1_41 Vdout1_41ck49 = 0.9 time = 250
.meas tran vdout1_41ck49 FIND v(dout1_41) AT=250.025n

* CHECK dout1_42 Vdout1_42ck49 = 0 time = 250
.meas tran vdout1_42ck49 FIND v(dout1_42) AT=250.025n

* CHECK dout1_43 Vdout1_43ck49 = 0.9 time = 250
.meas tran vdout1_43ck49 FIND v(dout1_43) AT=250.025n

* CHECK dout1_44 Vdout1_44ck49 = 0 time = 250
.meas tran vdout1_44ck49 FIND v(dout1_44) AT=250.025n

* CHECK dout1_45 Vdout1_45ck49 = 0.9 time = 250
.meas tran vdout1_45ck49 FIND v(dout1_45) AT=250.025n

* CHECK dout1_46 Vdout1_46ck49 = 0 time = 250
.meas tran vdout1_46ck49 FIND v(dout1_46) AT=250.025n

* CHECK dout1_47 Vdout1_47ck49 = 0 time = 250
.meas tran vdout1_47ck49 FIND v(dout1_47) AT=250.025n

* CHECK dout1_48 Vdout1_48ck49 = 0 time = 250
.meas tran vdout1_48ck49 FIND v(dout1_48) AT=250.025n

* CHECK dout1_49 Vdout1_49ck49 = 0 time = 250
.meas tran vdout1_49ck49 FIND v(dout1_49) AT=250.025n

* CHECK dout1_50 Vdout1_50ck49 = 0.9 time = 250
.meas tran vdout1_50ck49 FIND v(dout1_50) AT=250.025n

* CHECK dout1_51 Vdout1_51ck49 = 0 time = 250
.meas tran vdout1_51ck49 FIND v(dout1_51) AT=250.025n

* CHECK dout1_52 Vdout1_52ck49 = 0 time = 250
.meas tran vdout1_52ck49 FIND v(dout1_52) AT=250.025n

* CHECK dout1_53 Vdout1_53ck49 = 0.9 time = 250
.meas tran vdout1_53ck49 FIND v(dout1_53) AT=250.025n

* CHECK dout1_54 Vdout1_54ck49 = 0 time = 250
.meas tran vdout1_54ck49 FIND v(dout1_54) AT=250.025n

* CHECK dout1_55 Vdout1_55ck49 = 0 time = 250
.meas tran vdout1_55ck49 FIND v(dout1_55) AT=250.025n

* CHECK dout1_56 Vdout1_56ck49 = 0 time = 250
.meas tran vdout1_56ck49 FIND v(dout1_56) AT=250.025n

* CHECK dout1_57 Vdout1_57ck49 = 0.9 time = 250
.meas tran vdout1_57ck49 FIND v(dout1_57) AT=250.025n

* CHECK dout1_58 Vdout1_58ck49 = 0 time = 250
.meas tran vdout1_58ck49 FIND v(dout1_58) AT=250.025n

* CHECK dout1_59 Vdout1_59ck49 = 0 time = 250
.meas tran vdout1_59ck49 FIND v(dout1_59) AT=250.025n

* CHECK dout1_60 Vdout1_60ck49 = 0.9 time = 250
.meas tran vdout1_60ck49 FIND v(dout1_60) AT=250.025n

* CHECK dout1_61 Vdout1_61ck49 = 0.9 time = 250
.meas tran vdout1_61ck49 FIND v(dout1_61) AT=250.025n

* CHECK dout1_62 Vdout1_62ck49 = 0 time = 250
.meas tran vdout1_62ck49 FIND v(dout1_62) AT=250.025n

* CHECK dout1_63 Vdout1_63ck49 = 0.9 time = 250
.meas tran vdout1_63ck49 FIND v(dout1_63) AT=250.025n

* CHECK dout1_0 Vdout1_0ck51 = 0.9 time = 260
.meas tran vdout1_0ck51 FIND v(dout1_0) AT=260.025n

* CHECK dout1_1 Vdout1_1ck51 = 0.9 time = 260
.meas tran vdout1_1ck51 FIND v(dout1_1) AT=260.025n

* CHECK dout1_2 Vdout1_2ck51 = 0 time = 260
.meas tran vdout1_2ck51 FIND v(dout1_2) AT=260.025n

* CHECK dout1_3 Vdout1_3ck51 = 0.9 time = 260
.meas tran vdout1_3ck51 FIND v(dout1_3) AT=260.025n

* CHECK dout1_4 Vdout1_4ck51 = 0 time = 260
.meas tran vdout1_4ck51 FIND v(dout1_4) AT=260.025n

* CHECK dout1_5 Vdout1_5ck51 = 0 time = 260
.meas tran vdout1_5ck51 FIND v(dout1_5) AT=260.025n

* CHECK dout1_6 Vdout1_6ck51 = 0.9 time = 260
.meas tran vdout1_6ck51 FIND v(dout1_6) AT=260.025n

* CHECK dout1_7 Vdout1_7ck51 = 0.9 time = 260
.meas tran vdout1_7ck51 FIND v(dout1_7) AT=260.025n

* CHECK dout1_8 Vdout1_8ck51 = 0 time = 260
.meas tran vdout1_8ck51 FIND v(dout1_8) AT=260.025n

* CHECK dout1_9 Vdout1_9ck51 = 0.9 time = 260
.meas tran vdout1_9ck51 FIND v(dout1_9) AT=260.025n

* CHECK dout1_10 Vdout1_10ck51 = 0.9 time = 260
.meas tran vdout1_10ck51 FIND v(dout1_10) AT=260.025n

* CHECK dout1_11 Vdout1_11ck51 = 0 time = 260
.meas tran vdout1_11ck51 FIND v(dout1_11) AT=260.025n

* CHECK dout1_12 Vdout1_12ck51 = 0 time = 260
.meas tran vdout1_12ck51 FIND v(dout1_12) AT=260.025n

* CHECK dout1_13 Vdout1_13ck51 = 0.9 time = 260
.meas tran vdout1_13ck51 FIND v(dout1_13) AT=260.025n

* CHECK dout1_14 Vdout1_14ck51 = 0.9 time = 260
.meas tran vdout1_14ck51 FIND v(dout1_14) AT=260.025n

* CHECK dout1_15 Vdout1_15ck51 = 0 time = 260
.meas tran vdout1_15ck51 FIND v(dout1_15) AT=260.025n

* CHECK dout1_16 Vdout1_16ck51 = 0.9 time = 260
.meas tran vdout1_16ck51 FIND v(dout1_16) AT=260.025n

* CHECK dout1_17 Vdout1_17ck51 = 0.9 time = 260
.meas tran vdout1_17ck51 FIND v(dout1_17) AT=260.025n

* CHECK dout1_18 Vdout1_18ck51 = 0 time = 260
.meas tran vdout1_18ck51 FIND v(dout1_18) AT=260.025n

* CHECK dout1_19 Vdout1_19ck51 = 0.9 time = 260
.meas tran vdout1_19ck51 FIND v(dout1_19) AT=260.025n

* CHECK dout1_20 Vdout1_20ck51 = 0 time = 260
.meas tran vdout1_20ck51 FIND v(dout1_20) AT=260.025n

* CHECK dout1_21 Vdout1_21ck51 = 0 time = 260
.meas tran vdout1_21ck51 FIND v(dout1_21) AT=260.025n

* CHECK dout1_22 Vdout1_22ck51 = 0.9 time = 260
.meas tran vdout1_22ck51 FIND v(dout1_22) AT=260.025n

* CHECK dout1_23 Vdout1_23ck51 = 0.9 time = 260
.meas tran vdout1_23ck51 FIND v(dout1_23) AT=260.025n

* CHECK dout1_24 Vdout1_24ck51 = 0.9 time = 260
.meas tran vdout1_24ck51 FIND v(dout1_24) AT=260.025n

* CHECK dout1_25 Vdout1_25ck51 = 0.9 time = 260
.meas tran vdout1_25ck51 FIND v(dout1_25) AT=260.025n

* CHECK dout1_26 Vdout1_26ck51 = 0.9 time = 260
.meas tran vdout1_26ck51 FIND v(dout1_26) AT=260.025n

* CHECK dout1_27 Vdout1_27ck51 = 0.9 time = 260
.meas tran vdout1_27ck51 FIND v(dout1_27) AT=260.025n

* CHECK dout1_28 Vdout1_28ck51 = 0.9 time = 260
.meas tran vdout1_28ck51 FIND v(dout1_28) AT=260.025n

* CHECK dout1_29 Vdout1_29ck51 = 0.9 time = 260
.meas tran vdout1_29ck51 FIND v(dout1_29) AT=260.025n

* CHECK dout1_30 Vdout1_30ck51 = 0 time = 260
.meas tran vdout1_30ck51 FIND v(dout1_30) AT=260.025n

* CHECK dout1_31 Vdout1_31ck51 = 0 time = 260
.meas tran vdout1_31ck51 FIND v(dout1_31) AT=260.025n

* CHECK dout1_32 Vdout1_32ck51 = 0.9 time = 260
.meas tran vdout1_32ck51 FIND v(dout1_32) AT=260.025n

* CHECK dout1_33 Vdout1_33ck51 = 0.9 time = 260
.meas tran vdout1_33ck51 FIND v(dout1_33) AT=260.025n

* CHECK dout1_34 Vdout1_34ck51 = 0 time = 260
.meas tran vdout1_34ck51 FIND v(dout1_34) AT=260.025n

* CHECK dout1_35 Vdout1_35ck51 = 0 time = 260
.meas tran vdout1_35ck51 FIND v(dout1_35) AT=260.025n

* CHECK dout1_36 Vdout1_36ck51 = 0 time = 260
.meas tran vdout1_36ck51 FIND v(dout1_36) AT=260.025n

* CHECK dout1_37 Vdout1_37ck51 = 0.9 time = 260
.meas tran vdout1_37ck51 FIND v(dout1_37) AT=260.025n

* CHECK dout1_38 Vdout1_38ck51 = 0.9 time = 260
.meas tran vdout1_38ck51 FIND v(dout1_38) AT=260.025n

* CHECK dout1_39 Vdout1_39ck51 = 0 time = 260
.meas tran vdout1_39ck51 FIND v(dout1_39) AT=260.025n

* CHECK dout1_40 Vdout1_40ck51 = 0 time = 260
.meas tran vdout1_40ck51 FIND v(dout1_40) AT=260.025n

* CHECK dout1_41 Vdout1_41ck51 = 0.9 time = 260
.meas tran vdout1_41ck51 FIND v(dout1_41) AT=260.025n

* CHECK dout1_42 Vdout1_42ck51 = 0 time = 260
.meas tran vdout1_42ck51 FIND v(dout1_42) AT=260.025n

* CHECK dout1_43 Vdout1_43ck51 = 0 time = 260
.meas tran vdout1_43ck51 FIND v(dout1_43) AT=260.025n

* CHECK dout1_44 Vdout1_44ck51 = 0.9 time = 260
.meas tran vdout1_44ck51 FIND v(dout1_44) AT=260.025n

* CHECK dout1_45 Vdout1_45ck51 = 0.9 time = 260
.meas tran vdout1_45ck51 FIND v(dout1_45) AT=260.025n

* CHECK dout1_46 Vdout1_46ck51 = 0 time = 260
.meas tran vdout1_46ck51 FIND v(dout1_46) AT=260.025n

* CHECK dout1_47 Vdout1_47ck51 = 0.9 time = 260
.meas tran vdout1_47ck51 FIND v(dout1_47) AT=260.025n

* CHECK dout1_48 Vdout1_48ck51 = 0.9 time = 260
.meas tran vdout1_48ck51 FIND v(dout1_48) AT=260.025n

* CHECK dout1_49 Vdout1_49ck51 = 0.9 time = 260
.meas tran vdout1_49ck51 FIND v(dout1_49) AT=260.025n

* CHECK dout1_50 Vdout1_50ck51 = 0 time = 260
.meas tran vdout1_50ck51 FIND v(dout1_50) AT=260.025n

* CHECK dout1_51 Vdout1_51ck51 = 0.9 time = 260
.meas tran vdout1_51ck51 FIND v(dout1_51) AT=260.025n

* CHECK dout1_52 Vdout1_52ck51 = 0 time = 260
.meas tran vdout1_52ck51 FIND v(dout1_52) AT=260.025n

* CHECK dout1_53 Vdout1_53ck51 = 0.9 time = 260
.meas tran vdout1_53ck51 FIND v(dout1_53) AT=260.025n

* CHECK dout1_54 Vdout1_54ck51 = 0.9 time = 260
.meas tran vdout1_54ck51 FIND v(dout1_54) AT=260.025n

* CHECK dout1_55 Vdout1_55ck51 = 0 time = 260
.meas tran vdout1_55ck51 FIND v(dout1_55) AT=260.025n

* CHECK dout1_56 Vdout1_56ck51 = 0.9 time = 260
.meas tran vdout1_56ck51 FIND v(dout1_56) AT=260.025n

* CHECK dout1_57 Vdout1_57ck51 = 0 time = 260
.meas tran vdout1_57ck51 FIND v(dout1_57) AT=260.025n

* CHECK dout1_58 Vdout1_58ck51 = 0 time = 260
.meas tran vdout1_58ck51 FIND v(dout1_58) AT=260.025n

* CHECK dout1_59 Vdout1_59ck51 = 0 time = 260
.meas tran vdout1_59ck51 FIND v(dout1_59) AT=260.025n

* CHECK dout1_60 Vdout1_60ck51 = 0 time = 260
.meas tran vdout1_60ck51 FIND v(dout1_60) AT=260.025n

* CHECK dout1_61 Vdout1_61ck51 = 0.9 time = 260
.meas tran vdout1_61ck51 FIND v(dout1_61) AT=260.025n

* CHECK dout1_62 Vdout1_62ck51 = 0.9 time = 260
.meas tran vdout1_62ck51 FIND v(dout1_62) AT=260.025n

* CHECK dout1_63 Vdout1_63ck51 = 0 time = 260
.meas tran vdout1_63ck51 FIND v(dout1_63) AT=260.025n

* CHECK dout1_0 Vdout1_0ck57 = 0 time = 290
.meas tran vdout1_0ck57 FIND v(dout1_0) AT=290.025n

* CHECK dout1_1 Vdout1_1ck57 = 0.9 time = 290
.meas tran vdout1_1ck57 FIND v(dout1_1) AT=290.025n

* CHECK dout1_2 Vdout1_2ck57 = 0 time = 290
.meas tran vdout1_2ck57 FIND v(dout1_2) AT=290.025n

* CHECK dout1_3 Vdout1_3ck57 = 0 time = 290
.meas tran vdout1_3ck57 FIND v(dout1_3) AT=290.025n

* CHECK dout1_4 Vdout1_4ck57 = 0 time = 290
.meas tran vdout1_4ck57 FIND v(dout1_4) AT=290.025n

* CHECK dout1_5 Vdout1_5ck57 = 0 time = 290
.meas tran vdout1_5ck57 FIND v(dout1_5) AT=290.025n

* CHECK dout1_6 Vdout1_6ck57 = 0.9 time = 290
.meas tran vdout1_6ck57 FIND v(dout1_6) AT=290.025n

* CHECK dout1_7 Vdout1_7ck57 = 0 time = 290
.meas tran vdout1_7ck57 FIND v(dout1_7) AT=290.025n

* CHECK dout1_8 Vdout1_8ck57 = 0.9 time = 290
.meas tran vdout1_8ck57 FIND v(dout1_8) AT=290.025n

* CHECK dout1_9 Vdout1_9ck57 = 0 time = 290
.meas tran vdout1_9ck57 FIND v(dout1_9) AT=290.025n

* CHECK dout1_10 Vdout1_10ck57 = 0.9 time = 290
.meas tran vdout1_10ck57 FIND v(dout1_10) AT=290.025n

* CHECK dout1_11 Vdout1_11ck57 = 0 time = 290
.meas tran vdout1_11ck57 FIND v(dout1_11) AT=290.025n

* CHECK dout1_12 Vdout1_12ck57 = 0.9 time = 290
.meas tran vdout1_12ck57 FIND v(dout1_12) AT=290.025n

* CHECK dout1_13 Vdout1_13ck57 = 0 time = 290
.meas tran vdout1_13ck57 FIND v(dout1_13) AT=290.025n

* CHECK dout1_14 Vdout1_14ck57 = 0 time = 290
.meas tran vdout1_14ck57 FIND v(dout1_14) AT=290.025n

* CHECK dout1_15 Vdout1_15ck57 = 0 time = 290
.meas tran vdout1_15ck57 FIND v(dout1_15) AT=290.025n

* CHECK dout1_16 Vdout1_16ck57 = 0 time = 290
.meas tran vdout1_16ck57 FIND v(dout1_16) AT=290.025n

* CHECK dout1_17 Vdout1_17ck57 = 0.9 time = 290
.meas tran vdout1_17ck57 FIND v(dout1_17) AT=290.025n

* CHECK dout1_18 Vdout1_18ck57 = 0.9 time = 290
.meas tran vdout1_18ck57 FIND v(dout1_18) AT=290.025n

* CHECK dout1_19 Vdout1_19ck57 = 0 time = 290
.meas tran vdout1_19ck57 FIND v(dout1_19) AT=290.025n

* CHECK dout1_20 Vdout1_20ck57 = 0.9 time = 290
.meas tran vdout1_20ck57 FIND v(dout1_20) AT=290.025n

* CHECK dout1_21 Vdout1_21ck57 = 0.9 time = 290
.meas tran vdout1_21ck57 FIND v(dout1_21) AT=290.025n

* CHECK dout1_22 Vdout1_22ck57 = 0.9 time = 290
.meas tran vdout1_22ck57 FIND v(dout1_22) AT=290.025n

* CHECK dout1_23 Vdout1_23ck57 = 0.9 time = 290
.meas tran vdout1_23ck57 FIND v(dout1_23) AT=290.025n

* CHECK dout1_24 Vdout1_24ck57 = 0 time = 290
.meas tran vdout1_24ck57 FIND v(dout1_24) AT=290.025n

* CHECK dout1_25 Vdout1_25ck57 = 0.9 time = 290
.meas tran vdout1_25ck57 FIND v(dout1_25) AT=290.025n

* CHECK dout1_26 Vdout1_26ck57 = 0 time = 290
.meas tran vdout1_26ck57 FIND v(dout1_26) AT=290.025n

* CHECK dout1_27 Vdout1_27ck57 = 0.9 time = 290
.meas tran vdout1_27ck57 FIND v(dout1_27) AT=290.025n

* CHECK dout1_28 Vdout1_28ck57 = 0 time = 290
.meas tran vdout1_28ck57 FIND v(dout1_28) AT=290.025n

* CHECK dout1_29 Vdout1_29ck57 = 0 time = 290
.meas tran vdout1_29ck57 FIND v(dout1_29) AT=290.025n

* CHECK dout1_30 Vdout1_30ck57 = 0.9 time = 290
.meas tran vdout1_30ck57 FIND v(dout1_30) AT=290.025n

* CHECK dout1_31 Vdout1_31ck57 = 0.9 time = 290
.meas tran vdout1_31ck57 FIND v(dout1_31) AT=290.025n

* CHECK dout1_32 Vdout1_32ck57 = 0.9 time = 290
.meas tran vdout1_32ck57 FIND v(dout1_32) AT=290.025n

* CHECK dout1_33 Vdout1_33ck57 = 0 time = 290
.meas tran vdout1_33ck57 FIND v(dout1_33) AT=290.025n

* CHECK dout1_34 Vdout1_34ck57 = 0 time = 290
.meas tran vdout1_34ck57 FIND v(dout1_34) AT=290.025n

* CHECK dout1_35 Vdout1_35ck57 = 0 time = 290
.meas tran vdout1_35ck57 FIND v(dout1_35) AT=290.025n

* CHECK dout1_36 Vdout1_36ck57 = 0.9 time = 290
.meas tran vdout1_36ck57 FIND v(dout1_36) AT=290.025n

* CHECK dout1_37 Vdout1_37ck57 = 0 time = 290
.meas tran vdout1_37ck57 FIND v(dout1_37) AT=290.025n

* CHECK dout1_38 Vdout1_38ck57 = 0 time = 290
.meas tran vdout1_38ck57 FIND v(dout1_38) AT=290.025n

* CHECK dout1_39 Vdout1_39ck57 = 0.9 time = 290
.meas tran vdout1_39ck57 FIND v(dout1_39) AT=290.025n

* CHECK dout1_40 Vdout1_40ck57 = 0.9 time = 290
.meas tran vdout1_40ck57 FIND v(dout1_40) AT=290.025n

* CHECK dout1_41 Vdout1_41ck57 = 0.9 time = 290
.meas tran vdout1_41ck57 FIND v(dout1_41) AT=290.025n

* CHECK dout1_42 Vdout1_42ck57 = 0.9 time = 290
.meas tran vdout1_42ck57 FIND v(dout1_42) AT=290.025n

* CHECK dout1_43 Vdout1_43ck57 = 0.9 time = 290
.meas tran vdout1_43ck57 FIND v(dout1_43) AT=290.025n

* CHECK dout1_44 Vdout1_44ck57 = 0 time = 290
.meas tran vdout1_44ck57 FIND v(dout1_44) AT=290.025n

* CHECK dout1_45 Vdout1_45ck57 = 0 time = 290
.meas tran vdout1_45ck57 FIND v(dout1_45) AT=290.025n

* CHECK dout1_46 Vdout1_46ck57 = 0 time = 290
.meas tran vdout1_46ck57 FIND v(dout1_46) AT=290.025n

* CHECK dout1_47 Vdout1_47ck57 = 0 time = 290
.meas tran vdout1_47ck57 FIND v(dout1_47) AT=290.025n

* CHECK dout1_48 Vdout1_48ck57 = 0.9 time = 290
.meas tran vdout1_48ck57 FIND v(dout1_48) AT=290.025n

* CHECK dout1_49 Vdout1_49ck57 = 0.9 time = 290
.meas tran vdout1_49ck57 FIND v(dout1_49) AT=290.025n

* CHECK dout1_50 Vdout1_50ck57 = 0.9 time = 290
.meas tran vdout1_50ck57 FIND v(dout1_50) AT=290.025n

* CHECK dout1_51 Vdout1_51ck57 = 0.9 time = 290
.meas tran vdout1_51ck57 FIND v(dout1_51) AT=290.025n

* CHECK dout1_52 Vdout1_52ck57 = 0 time = 290
.meas tran vdout1_52ck57 FIND v(dout1_52) AT=290.025n

* CHECK dout1_53 Vdout1_53ck57 = 0.9 time = 290
.meas tran vdout1_53ck57 FIND v(dout1_53) AT=290.025n

* CHECK dout1_54 Vdout1_54ck57 = 0.9 time = 290
.meas tran vdout1_54ck57 FIND v(dout1_54) AT=290.025n

* CHECK dout1_55 Vdout1_55ck57 = 0.9 time = 290
.meas tran vdout1_55ck57 FIND v(dout1_55) AT=290.025n

* CHECK dout1_56 Vdout1_56ck57 = 0.9 time = 290
.meas tran vdout1_56ck57 FIND v(dout1_56) AT=290.025n

* CHECK dout1_57 Vdout1_57ck57 = 0.9 time = 290
.meas tran vdout1_57ck57 FIND v(dout1_57) AT=290.025n

* CHECK dout1_58 Vdout1_58ck57 = 0.9 time = 290
.meas tran vdout1_58ck57 FIND v(dout1_58) AT=290.025n

* CHECK dout1_59 Vdout1_59ck57 = 0.9 time = 290
.meas tran vdout1_59ck57 FIND v(dout1_59) AT=290.025n

* CHECK dout1_60 Vdout1_60ck57 = 0.9 time = 290
.meas tran vdout1_60ck57 FIND v(dout1_60) AT=290.025n

* CHECK dout1_61 Vdout1_61ck57 = 0 time = 290
.meas tran vdout1_61ck57 FIND v(dout1_61) AT=290.025n

* CHECK dout1_62 Vdout1_62ck57 = 0 time = 290
.meas tran vdout1_62ck57 FIND v(dout1_62) AT=290.025n

* CHECK dout1_63 Vdout1_63ck57 = 0.9 time = 290
.meas tran vdout1_63ck57 FIND v(dout1_63) AT=290.025n

* CHECK dout1_0 Vdout1_0ck58 = 0.9 time = 295
.meas tran vdout1_0ck58 FIND v(dout1_0) AT=295.025n

* CHECK dout1_1 Vdout1_1ck58 = 0.9 time = 295
.meas tran vdout1_1ck58 FIND v(dout1_1) AT=295.025n

* CHECK dout1_2 Vdout1_2ck58 = 0.9 time = 295
.meas tran vdout1_2ck58 FIND v(dout1_2) AT=295.025n

* CHECK dout1_3 Vdout1_3ck58 = 0.9 time = 295
.meas tran vdout1_3ck58 FIND v(dout1_3) AT=295.025n

* CHECK dout1_4 Vdout1_4ck58 = 0.9 time = 295
.meas tran vdout1_4ck58 FIND v(dout1_4) AT=295.025n

* CHECK dout1_5 Vdout1_5ck58 = 0 time = 295
.meas tran vdout1_5ck58 FIND v(dout1_5) AT=295.025n

* CHECK dout1_6 Vdout1_6ck58 = 0.9 time = 295
.meas tran vdout1_6ck58 FIND v(dout1_6) AT=295.025n

* CHECK dout1_7 Vdout1_7ck58 = 0.9 time = 295
.meas tran vdout1_7ck58 FIND v(dout1_7) AT=295.025n

* CHECK dout1_8 Vdout1_8ck58 = 0 time = 295
.meas tran vdout1_8ck58 FIND v(dout1_8) AT=295.025n

* CHECK dout1_9 Vdout1_9ck58 = 0 time = 295
.meas tran vdout1_9ck58 FIND v(dout1_9) AT=295.025n

* CHECK dout1_10 Vdout1_10ck58 = 0 time = 295
.meas tran vdout1_10ck58 FIND v(dout1_10) AT=295.025n

* CHECK dout1_11 Vdout1_11ck58 = 0.9 time = 295
.meas tran vdout1_11ck58 FIND v(dout1_11) AT=295.025n

* CHECK dout1_12 Vdout1_12ck58 = 0 time = 295
.meas tran vdout1_12ck58 FIND v(dout1_12) AT=295.025n

* CHECK dout1_13 Vdout1_13ck58 = 0 time = 295
.meas tran vdout1_13ck58 FIND v(dout1_13) AT=295.025n

* CHECK dout1_14 Vdout1_14ck58 = 0.9 time = 295
.meas tran vdout1_14ck58 FIND v(dout1_14) AT=295.025n

* CHECK dout1_15 Vdout1_15ck58 = 0.9 time = 295
.meas tran vdout1_15ck58 FIND v(dout1_15) AT=295.025n

* CHECK dout1_16 Vdout1_16ck58 = 0 time = 295
.meas tran vdout1_16ck58 FIND v(dout1_16) AT=295.025n

* CHECK dout1_17 Vdout1_17ck58 = 0 time = 295
.meas tran vdout1_17ck58 FIND v(dout1_17) AT=295.025n

* CHECK dout1_18 Vdout1_18ck58 = 0.9 time = 295
.meas tran vdout1_18ck58 FIND v(dout1_18) AT=295.025n

* CHECK dout1_19 Vdout1_19ck58 = 0.9 time = 295
.meas tran vdout1_19ck58 FIND v(dout1_19) AT=295.025n

* CHECK dout1_20 Vdout1_20ck58 = 0.9 time = 295
.meas tran vdout1_20ck58 FIND v(dout1_20) AT=295.025n

* CHECK dout1_21 Vdout1_21ck58 = 0 time = 295
.meas tran vdout1_21ck58 FIND v(dout1_21) AT=295.025n

* CHECK dout1_22 Vdout1_22ck58 = 0.9 time = 295
.meas tran vdout1_22ck58 FIND v(dout1_22) AT=295.025n

* CHECK dout1_23 Vdout1_23ck58 = 0 time = 295
.meas tran vdout1_23ck58 FIND v(dout1_23) AT=295.025n

* CHECK dout1_24 Vdout1_24ck58 = 0 time = 295
.meas tran vdout1_24ck58 FIND v(dout1_24) AT=295.025n

* CHECK dout1_25 Vdout1_25ck58 = 0.9 time = 295
.meas tran vdout1_25ck58 FIND v(dout1_25) AT=295.025n

* CHECK dout1_26 Vdout1_26ck58 = 0.9 time = 295
.meas tran vdout1_26ck58 FIND v(dout1_26) AT=295.025n

* CHECK dout1_27 Vdout1_27ck58 = 0 time = 295
.meas tran vdout1_27ck58 FIND v(dout1_27) AT=295.025n

* CHECK dout1_28 Vdout1_28ck58 = 0 time = 295
.meas tran vdout1_28ck58 FIND v(dout1_28) AT=295.025n

* CHECK dout1_29 Vdout1_29ck58 = 0 time = 295
.meas tran vdout1_29ck58 FIND v(dout1_29) AT=295.025n

* CHECK dout1_30 Vdout1_30ck58 = 0 time = 295
.meas tran vdout1_30ck58 FIND v(dout1_30) AT=295.025n

* CHECK dout1_31 Vdout1_31ck58 = 0 time = 295
.meas tran vdout1_31ck58 FIND v(dout1_31) AT=295.025n

* CHECK dout1_32 Vdout1_32ck58 = 0 time = 295
.meas tran vdout1_32ck58 FIND v(dout1_32) AT=295.025n

* CHECK dout1_33 Vdout1_33ck58 = 0.9 time = 295
.meas tran vdout1_33ck58 FIND v(dout1_33) AT=295.025n

* CHECK dout1_34 Vdout1_34ck58 = 0 time = 295
.meas tran vdout1_34ck58 FIND v(dout1_34) AT=295.025n

* CHECK dout1_35 Vdout1_35ck58 = 0 time = 295
.meas tran vdout1_35ck58 FIND v(dout1_35) AT=295.025n

* CHECK dout1_36 Vdout1_36ck58 = 0.9 time = 295
.meas tran vdout1_36ck58 FIND v(dout1_36) AT=295.025n

* CHECK dout1_37 Vdout1_37ck58 = 0 time = 295
.meas tran vdout1_37ck58 FIND v(dout1_37) AT=295.025n

* CHECK dout1_38 Vdout1_38ck58 = 0 time = 295
.meas tran vdout1_38ck58 FIND v(dout1_38) AT=295.025n

* CHECK dout1_39 Vdout1_39ck58 = 0.9 time = 295
.meas tran vdout1_39ck58 FIND v(dout1_39) AT=295.025n

* CHECK dout1_40 Vdout1_40ck58 = 0.9 time = 295
.meas tran vdout1_40ck58 FIND v(dout1_40) AT=295.025n

* CHECK dout1_41 Vdout1_41ck58 = 0 time = 295
.meas tran vdout1_41ck58 FIND v(dout1_41) AT=295.025n

* CHECK dout1_42 Vdout1_42ck58 = 0 time = 295
.meas tran vdout1_42ck58 FIND v(dout1_42) AT=295.025n

* CHECK dout1_43 Vdout1_43ck58 = 0 time = 295
.meas tran vdout1_43ck58 FIND v(dout1_43) AT=295.025n

* CHECK dout1_44 Vdout1_44ck58 = 0.9 time = 295
.meas tran vdout1_44ck58 FIND v(dout1_44) AT=295.025n

* CHECK dout1_45 Vdout1_45ck58 = 0 time = 295
.meas tran vdout1_45ck58 FIND v(dout1_45) AT=295.025n

* CHECK dout1_46 Vdout1_46ck58 = 0.9 time = 295
.meas tran vdout1_46ck58 FIND v(dout1_46) AT=295.025n

* CHECK dout1_47 Vdout1_47ck58 = 0.9 time = 295
.meas tran vdout1_47ck58 FIND v(dout1_47) AT=295.025n

* CHECK dout1_48 Vdout1_48ck58 = 0.9 time = 295
.meas tran vdout1_48ck58 FIND v(dout1_48) AT=295.025n

* CHECK dout1_49 Vdout1_49ck58 = 0.9 time = 295
.meas tran vdout1_49ck58 FIND v(dout1_49) AT=295.025n

* CHECK dout1_50 Vdout1_50ck58 = 0 time = 295
.meas tran vdout1_50ck58 FIND v(dout1_50) AT=295.025n

* CHECK dout1_51 Vdout1_51ck58 = 0 time = 295
.meas tran vdout1_51ck58 FIND v(dout1_51) AT=295.025n

* CHECK dout1_52 Vdout1_52ck58 = 0 time = 295
.meas tran vdout1_52ck58 FIND v(dout1_52) AT=295.025n

* CHECK dout1_53 Vdout1_53ck58 = 0 time = 295
.meas tran vdout1_53ck58 FIND v(dout1_53) AT=295.025n

* CHECK dout1_54 Vdout1_54ck58 = 0.9 time = 295
.meas tran vdout1_54ck58 FIND v(dout1_54) AT=295.025n

* CHECK dout1_55 Vdout1_55ck58 = 0.9 time = 295
.meas tran vdout1_55ck58 FIND v(dout1_55) AT=295.025n

* CHECK dout1_56 Vdout1_56ck58 = 0.9 time = 295
.meas tran vdout1_56ck58 FIND v(dout1_56) AT=295.025n

* CHECK dout1_57 Vdout1_57ck58 = 0.9 time = 295
.meas tran vdout1_57ck58 FIND v(dout1_57) AT=295.025n

* CHECK dout1_58 Vdout1_58ck58 = 0.9 time = 295
.meas tran vdout1_58ck58 FIND v(dout1_58) AT=295.025n

* CHECK dout1_59 Vdout1_59ck58 = 0.9 time = 295
.meas tran vdout1_59ck58 FIND v(dout1_59) AT=295.025n

* CHECK dout1_60 Vdout1_60ck58 = 0.9 time = 295
.meas tran vdout1_60ck58 FIND v(dout1_60) AT=295.025n

* CHECK dout1_61 Vdout1_61ck58 = 0.9 time = 295
.meas tran vdout1_61ck58 FIND v(dout1_61) AT=295.025n

* CHECK dout1_62 Vdout1_62ck58 = 0.9 time = 295
.meas tran vdout1_62ck58 FIND v(dout1_62) AT=295.025n

* CHECK dout1_63 Vdout1_63ck58 = 0 time = 295
.meas tran vdout1_63ck58 FIND v(dout1_63) AT=295.025n

* CHECK dout1_0 Vdout1_0ck60 = 0 time = 305
.meas tran vdout1_0ck60 FIND v(dout1_0) AT=305.025n

* CHECK dout1_1 Vdout1_1ck60 = 0.9 time = 305
.meas tran vdout1_1ck60 FIND v(dout1_1) AT=305.025n

* CHECK dout1_2 Vdout1_2ck60 = 0.9 time = 305
.meas tran vdout1_2ck60 FIND v(dout1_2) AT=305.025n

* CHECK dout1_3 Vdout1_3ck60 = 0.9 time = 305
.meas tran vdout1_3ck60 FIND v(dout1_3) AT=305.025n

* CHECK dout1_4 Vdout1_4ck60 = 0.9 time = 305
.meas tran vdout1_4ck60 FIND v(dout1_4) AT=305.025n

* CHECK dout1_5 Vdout1_5ck60 = 0.9 time = 305
.meas tran vdout1_5ck60 FIND v(dout1_5) AT=305.025n

* CHECK dout1_6 Vdout1_6ck60 = 0 time = 305
.meas tran vdout1_6ck60 FIND v(dout1_6) AT=305.025n

* CHECK dout1_7 Vdout1_7ck60 = 0.9 time = 305
.meas tran vdout1_7ck60 FIND v(dout1_7) AT=305.025n

* CHECK dout1_8 Vdout1_8ck60 = 0.9 time = 305
.meas tran vdout1_8ck60 FIND v(dout1_8) AT=305.025n

* CHECK dout1_9 Vdout1_9ck60 = 0.9 time = 305
.meas tran vdout1_9ck60 FIND v(dout1_9) AT=305.025n

* CHECK dout1_10 Vdout1_10ck60 = 0.9 time = 305
.meas tran vdout1_10ck60 FIND v(dout1_10) AT=305.025n

* CHECK dout1_11 Vdout1_11ck60 = 0.9 time = 305
.meas tran vdout1_11ck60 FIND v(dout1_11) AT=305.025n

* CHECK dout1_12 Vdout1_12ck60 = 0.9 time = 305
.meas tran vdout1_12ck60 FIND v(dout1_12) AT=305.025n

* CHECK dout1_13 Vdout1_13ck60 = 0 time = 305
.meas tran vdout1_13ck60 FIND v(dout1_13) AT=305.025n

* CHECK dout1_14 Vdout1_14ck60 = 0 time = 305
.meas tran vdout1_14ck60 FIND v(dout1_14) AT=305.025n

* CHECK dout1_15 Vdout1_15ck60 = 0 time = 305
.meas tran vdout1_15ck60 FIND v(dout1_15) AT=305.025n

* CHECK dout1_16 Vdout1_16ck60 = 0 time = 305
.meas tran vdout1_16ck60 FIND v(dout1_16) AT=305.025n

* CHECK dout1_17 Vdout1_17ck60 = 0 time = 305
.meas tran vdout1_17ck60 FIND v(dout1_17) AT=305.025n

* CHECK dout1_18 Vdout1_18ck60 = 0.9 time = 305
.meas tran vdout1_18ck60 FIND v(dout1_18) AT=305.025n

* CHECK dout1_19 Vdout1_19ck60 = 0 time = 305
.meas tran vdout1_19ck60 FIND v(dout1_19) AT=305.025n

* CHECK dout1_20 Vdout1_20ck60 = 0.9 time = 305
.meas tran vdout1_20ck60 FIND v(dout1_20) AT=305.025n

* CHECK dout1_21 Vdout1_21ck60 = 0.9 time = 305
.meas tran vdout1_21ck60 FIND v(dout1_21) AT=305.025n

* CHECK dout1_22 Vdout1_22ck60 = 0.9 time = 305
.meas tran vdout1_22ck60 FIND v(dout1_22) AT=305.025n

* CHECK dout1_23 Vdout1_23ck60 = 0.9 time = 305
.meas tran vdout1_23ck60 FIND v(dout1_23) AT=305.025n

* CHECK dout1_24 Vdout1_24ck60 = 0 time = 305
.meas tran vdout1_24ck60 FIND v(dout1_24) AT=305.025n

* CHECK dout1_25 Vdout1_25ck60 = 0 time = 305
.meas tran vdout1_25ck60 FIND v(dout1_25) AT=305.025n

* CHECK dout1_26 Vdout1_26ck60 = 0.9 time = 305
.meas tran vdout1_26ck60 FIND v(dout1_26) AT=305.025n

* CHECK dout1_27 Vdout1_27ck60 = 0 time = 305
.meas tran vdout1_27ck60 FIND v(dout1_27) AT=305.025n

* CHECK dout1_28 Vdout1_28ck60 = 0.9 time = 305
.meas tran vdout1_28ck60 FIND v(dout1_28) AT=305.025n

* CHECK dout1_29 Vdout1_29ck60 = 0.9 time = 305
.meas tran vdout1_29ck60 FIND v(dout1_29) AT=305.025n

* CHECK dout1_30 Vdout1_30ck60 = 0.9 time = 305
.meas tran vdout1_30ck60 FIND v(dout1_30) AT=305.025n

* CHECK dout1_31 Vdout1_31ck60 = 0.9 time = 305
.meas tran vdout1_31ck60 FIND v(dout1_31) AT=305.025n

* CHECK dout1_32 Vdout1_32ck60 = 0 time = 305
.meas tran vdout1_32ck60 FIND v(dout1_32) AT=305.025n

* CHECK dout1_33 Vdout1_33ck60 = 0.9 time = 305
.meas tran vdout1_33ck60 FIND v(dout1_33) AT=305.025n

* CHECK dout1_34 Vdout1_34ck60 = 0 time = 305
.meas tran vdout1_34ck60 FIND v(dout1_34) AT=305.025n

* CHECK dout1_35 Vdout1_35ck60 = 0 time = 305
.meas tran vdout1_35ck60 FIND v(dout1_35) AT=305.025n

* CHECK dout1_36 Vdout1_36ck60 = 0.9 time = 305
.meas tran vdout1_36ck60 FIND v(dout1_36) AT=305.025n

* CHECK dout1_37 Vdout1_37ck60 = 0 time = 305
.meas tran vdout1_37ck60 FIND v(dout1_37) AT=305.025n

* CHECK dout1_38 Vdout1_38ck60 = 0 time = 305
.meas tran vdout1_38ck60 FIND v(dout1_38) AT=305.025n

* CHECK dout1_39 Vdout1_39ck60 = 0.9 time = 305
.meas tran vdout1_39ck60 FIND v(dout1_39) AT=305.025n

* CHECK dout1_40 Vdout1_40ck60 = 0.9 time = 305
.meas tran vdout1_40ck60 FIND v(dout1_40) AT=305.025n

* CHECK dout1_41 Vdout1_41ck60 = 0 time = 305
.meas tran vdout1_41ck60 FIND v(dout1_41) AT=305.025n

* CHECK dout1_42 Vdout1_42ck60 = 0 time = 305
.meas tran vdout1_42ck60 FIND v(dout1_42) AT=305.025n

* CHECK dout1_43 Vdout1_43ck60 = 0 time = 305
.meas tran vdout1_43ck60 FIND v(dout1_43) AT=305.025n

* CHECK dout1_44 Vdout1_44ck60 = 0.9 time = 305
.meas tran vdout1_44ck60 FIND v(dout1_44) AT=305.025n

* CHECK dout1_45 Vdout1_45ck60 = 0 time = 305
.meas tran vdout1_45ck60 FIND v(dout1_45) AT=305.025n

* CHECK dout1_46 Vdout1_46ck60 = 0.9 time = 305
.meas tran vdout1_46ck60 FIND v(dout1_46) AT=305.025n

* CHECK dout1_47 Vdout1_47ck60 = 0.9 time = 305
.meas tran vdout1_47ck60 FIND v(dout1_47) AT=305.025n

* CHECK dout1_48 Vdout1_48ck60 = 0.9 time = 305
.meas tran vdout1_48ck60 FIND v(dout1_48) AT=305.025n

* CHECK dout1_49 Vdout1_49ck60 = 0.9 time = 305
.meas tran vdout1_49ck60 FIND v(dout1_49) AT=305.025n

* CHECK dout1_50 Vdout1_50ck60 = 0 time = 305
.meas tran vdout1_50ck60 FIND v(dout1_50) AT=305.025n

* CHECK dout1_51 Vdout1_51ck60 = 0 time = 305
.meas tran vdout1_51ck60 FIND v(dout1_51) AT=305.025n

* CHECK dout1_52 Vdout1_52ck60 = 0 time = 305
.meas tran vdout1_52ck60 FIND v(dout1_52) AT=305.025n

* CHECK dout1_53 Vdout1_53ck60 = 0 time = 305
.meas tran vdout1_53ck60 FIND v(dout1_53) AT=305.025n

* CHECK dout1_54 Vdout1_54ck60 = 0.9 time = 305
.meas tran vdout1_54ck60 FIND v(dout1_54) AT=305.025n

* CHECK dout1_55 Vdout1_55ck60 = 0.9 time = 305
.meas tran vdout1_55ck60 FIND v(dout1_55) AT=305.025n

* CHECK dout1_56 Vdout1_56ck60 = 0.9 time = 305
.meas tran vdout1_56ck60 FIND v(dout1_56) AT=305.025n

* CHECK dout1_57 Vdout1_57ck60 = 0.9 time = 305
.meas tran vdout1_57ck60 FIND v(dout1_57) AT=305.025n

* CHECK dout1_58 Vdout1_58ck60 = 0.9 time = 305
.meas tran vdout1_58ck60 FIND v(dout1_58) AT=305.025n

* CHECK dout1_59 Vdout1_59ck60 = 0.9 time = 305
.meas tran vdout1_59ck60 FIND v(dout1_59) AT=305.025n

* CHECK dout1_60 Vdout1_60ck60 = 0.9 time = 305
.meas tran vdout1_60ck60 FIND v(dout1_60) AT=305.025n

* CHECK dout1_61 Vdout1_61ck60 = 0.9 time = 305
.meas tran vdout1_61ck60 FIND v(dout1_61) AT=305.025n

* CHECK dout1_62 Vdout1_62ck60 = 0.9 time = 305
.meas tran vdout1_62ck60 FIND v(dout1_62) AT=305.025n

* CHECK dout1_63 Vdout1_63ck60 = 0 time = 305
.meas tran vdout1_63ck60 FIND v(dout1_63) AT=305.025n

* CHECK dout1_0 Vdout1_0ck61 = 0.9 time = 310
.meas tran vdout1_0ck61 FIND v(dout1_0) AT=310.025n

* CHECK dout1_1 Vdout1_1ck61 = 0 time = 310
.meas tran vdout1_1ck61 FIND v(dout1_1) AT=310.025n

* CHECK dout1_2 Vdout1_2ck61 = 0 time = 310
.meas tran vdout1_2ck61 FIND v(dout1_2) AT=310.025n

* CHECK dout1_3 Vdout1_3ck61 = 0 time = 310
.meas tran vdout1_3ck61 FIND v(dout1_3) AT=310.025n

* CHECK dout1_4 Vdout1_4ck61 = 0.9 time = 310
.meas tran vdout1_4ck61 FIND v(dout1_4) AT=310.025n

* CHECK dout1_5 Vdout1_5ck61 = 0 time = 310
.meas tran vdout1_5ck61 FIND v(dout1_5) AT=310.025n

* CHECK dout1_6 Vdout1_6ck61 = 0.9 time = 310
.meas tran vdout1_6ck61 FIND v(dout1_6) AT=310.025n

* CHECK dout1_7 Vdout1_7ck61 = 0 time = 310
.meas tran vdout1_7ck61 FIND v(dout1_7) AT=310.025n

* CHECK dout1_8 Vdout1_8ck61 = 0 time = 310
.meas tran vdout1_8ck61 FIND v(dout1_8) AT=310.025n

* CHECK dout1_9 Vdout1_9ck61 = 0 time = 310
.meas tran vdout1_9ck61 FIND v(dout1_9) AT=310.025n

* CHECK dout1_10 Vdout1_10ck61 = 0 time = 310
.meas tran vdout1_10ck61 FIND v(dout1_10) AT=310.025n

* CHECK dout1_11 Vdout1_11ck61 = 0 time = 310
.meas tran vdout1_11ck61 FIND v(dout1_11) AT=310.025n

* CHECK dout1_12 Vdout1_12ck61 = 0 time = 310
.meas tran vdout1_12ck61 FIND v(dout1_12) AT=310.025n

* CHECK dout1_13 Vdout1_13ck61 = 0 time = 310
.meas tran vdout1_13ck61 FIND v(dout1_13) AT=310.025n

* CHECK dout1_14 Vdout1_14ck61 = 0.9 time = 310
.meas tran vdout1_14ck61 FIND v(dout1_14) AT=310.025n

* CHECK dout1_15 Vdout1_15ck61 = 0.9 time = 310
.meas tran vdout1_15ck61 FIND v(dout1_15) AT=310.025n

* CHECK dout1_16 Vdout1_16ck61 = 0.9 time = 310
.meas tran vdout1_16ck61 FIND v(dout1_16) AT=310.025n

* CHECK dout1_17 Vdout1_17ck61 = 0.9 time = 310
.meas tran vdout1_17ck61 FIND v(dout1_17) AT=310.025n

* CHECK dout1_18 Vdout1_18ck61 = 0.9 time = 310
.meas tran vdout1_18ck61 FIND v(dout1_18) AT=310.025n

* CHECK dout1_19 Vdout1_19ck61 = 0.9 time = 310
.meas tran vdout1_19ck61 FIND v(dout1_19) AT=310.025n

* CHECK dout1_20 Vdout1_20ck61 = 0 time = 310
.meas tran vdout1_20ck61 FIND v(dout1_20) AT=310.025n

* CHECK dout1_21 Vdout1_21ck61 = 0.9 time = 310
.meas tran vdout1_21ck61 FIND v(dout1_21) AT=310.025n

* CHECK dout1_22 Vdout1_22ck61 = 0.9 time = 310
.meas tran vdout1_22ck61 FIND v(dout1_22) AT=310.025n

* CHECK dout1_23 Vdout1_23ck61 = 0.9 time = 310
.meas tran vdout1_23ck61 FIND v(dout1_23) AT=310.025n

* CHECK dout1_24 Vdout1_24ck61 = 0 time = 310
.meas tran vdout1_24ck61 FIND v(dout1_24) AT=310.025n

* CHECK dout1_25 Vdout1_25ck61 = 0.9 time = 310
.meas tran vdout1_25ck61 FIND v(dout1_25) AT=310.025n

* CHECK dout1_26 Vdout1_26ck61 = 0.9 time = 310
.meas tran vdout1_26ck61 FIND v(dout1_26) AT=310.025n

* CHECK dout1_27 Vdout1_27ck61 = 0 time = 310
.meas tran vdout1_27ck61 FIND v(dout1_27) AT=310.025n

* CHECK dout1_28 Vdout1_28ck61 = 0.9 time = 310
.meas tran vdout1_28ck61 FIND v(dout1_28) AT=310.025n

* CHECK dout1_29 Vdout1_29ck61 = 0 time = 310
.meas tran vdout1_29ck61 FIND v(dout1_29) AT=310.025n

* CHECK dout1_30 Vdout1_30ck61 = 0 time = 310
.meas tran vdout1_30ck61 FIND v(dout1_30) AT=310.025n

* CHECK dout1_31 Vdout1_31ck61 = 0 time = 310
.meas tran vdout1_31ck61 FIND v(dout1_31) AT=310.025n

* CHECK dout1_32 Vdout1_32ck61 = 0.9 time = 310
.meas tran vdout1_32ck61 FIND v(dout1_32) AT=310.025n

* CHECK dout1_33 Vdout1_33ck61 = 0 time = 310
.meas tran vdout1_33ck61 FIND v(dout1_33) AT=310.025n

* CHECK dout1_34 Vdout1_34ck61 = 0 time = 310
.meas tran vdout1_34ck61 FIND v(dout1_34) AT=310.025n

* CHECK dout1_35 Vdout1_35ck61 = 0 time = 310
.meas tran vdout1_35ck61 FIND v(dout1_35) AT=310.025n

* CHECK dout1_36 Vdout1_36ck61 = 0.9 time = 310
.meas tran vdout1_36ck61 FIND v(dout1_36) AT=310.025n

* CHECK dout1_37 Vdout1_37ck61 = 0 time = 310
.meas tran vdout1_37ck61 FIND v(dout1_37) AT=310.025n

* CHECK dout1_38 Vdout1_38ck61 = 0 time = 310
.meas tran vdout1_38ck61 FIND v(dout1_38) AT=310.025n

* CHECK dout1_39 Vdout1_39ck61 = 0.9 time = 310
.meas tran vdout1_39ck61 FIND v(dout1_39) AT=310.025n

* CHECK dout1_40 Vdout1_40ck61 = 0.9 time = 310
.meas tran vdout1_40ck61 FIND v(dout1_40) AT=310.025n

* CHECK dout1_41 Vdout1_41ck61 = 0.9 time = 310
.meas tran vdout1_41ck61 FIND v(dout1_41) AT=310.025n

* CHECK dout1_42 Vdout1_42ck61 = 0.9 time = 310
.meas tran vdout1_42ck61 FIND v(dout1_42) AT=310.025n

* CHECK dout1_43 Vdout1_43ck61 = 0.9 time = 310
.meas tran vdout1_43ck61 FIND v(dout1_43) AT=310.025n

* CHECK dout1_44 Vdout1_44ck61 = 0 time = 310
.meas tran vdout1_44ck61 FIND v(dout1_44) AT=310.025n

* CHECK dout1_45 Vdout1_45ck61 = 0 time = 310
.meas tran vdout1_45ck61 FIND v(dout1_45) AT=310.025n

* CHECK dout1_46 Vdout1_46ck61 = 0 time = 310
.meas tran vdout1_46ck61 FIND v(dout1_46) AT=310.025n

* CHECK dout1_47 Vdout1_47ck61 = 0 time = 310
.meas tran vdout1_47ck61 FIND v(dout1_47) AT=310.025n

* CHECK dout1_48 Vdout1_48ck61 = 0.9 time = 310
.meas tran vdout1_48ck61 FIND v(dout1_48) AT=310.025n

* CHECK dout1_49 Vdout1_49ck61 = 0.9 time = 310
.meas tran vdout1_49ck61 FIND v(dout1_49) AT=310.025n

* CHECK dout1_50 Vdout1_50ck61 = 0.9 time = 310
.meas tran vdout1_50ck61 FIND v(dout1_50) AT=310.025n

* CHECK dout1_51 Vdout1_51ck61 = 0.9 time = 310
.meas tran vdout1_51ck61 FIND v(dout1_51) AT=310.025n

* CHECK dout1_52 Vdout1_52ck61 = 0 time = 310
.meas tran vdout1_52ck61 FIND v(dout1_52) AT=310.025n

* CHECK dout1_53 Vdout1_53ck61 = 0.9 time = 310
.meas tran vdout1_53ck61 FIND v(dout1_53) AT=310.025n

* CHECK dout1_54 Vdout1_54ck61 = 0.9 time = 310
.meas tran vdout1_54ck61 FIND v(dout1_54) AT=310.025n

* CHECK dout1_55 Vdout1_55ck61 = 0.9 time = 310
.meas tran vdout1_55ck61 FIND v(dout1_55) AT=310.025n

* CHECK dout1_56 Vdout1_56ck61 = 0.9 time = 310
.meas tran vdout1_56ck61 FIND v(dout1_56) AT=310.025n

* CHECK dout1_57 Vdout1_57ck61 = 0.9 time = 310
.meas tran vdout1_57ck61 FIND v(dout1_57) AT=310.025n

* CHECK dout1_58 Vdout1_58ck61 = 0.9 time = 310
.meas tran vdout1_58ck61 FIND v(dout1_58) AT=310.025n

* CHECK dout1_59 Vdout1_59ck61 = 0.9 time = 310
.meas tran vdout1_59ck61 FIND v(dout1_59) AT=310.025n

* CHECK dout1_60 Vdout1_60ck61 = 0.9 time = 310
.meas tran vdout1_60ck61 FIND v(dout1_60) AT=310.025n

* CHECK dout1_61 Vdout1_61ck61 = 0 time = 310
.meas tran vdout1_61ck61 FIND v(dout1_61) AT=310.025n

* CHECK dout1_62 Vdout1_62ck61 = 0 time = 310
.meas tran vdout1_62ck61 FIND v(dout1_62) AT=310.025n

* CHECK dout1_63 Vdout1_63ck61 = 0.9 time = 310
.meas tran vdout1_63ck61 FIND v(dout1_63) AT=310.025n

* CHECK dout1_0 Vdout1_0ck66 = 0 time = 335
.meas tran vdout1_0ck66 FIND v(dout1_0) AT=335.025n

* CHECK dout1_1 Vdout1_1ck66 = 0.9 time = 335
.meas tran vdout1_1ck66 FIND v(dout1_1) AT=335.025n

* CHECK dout1_2 Vdout1_2ck66 = 0.9 time = 335
.meas tran vdout1_2ck66 FIND v(dout1_2) AT=335.025n

* CHECK dout1_3 Vdout1_3ck66 = 0.9 time = 335
.meas tran vdout1_3ck66 FIND v(dout1_3) AT=335.025n

* CHECK dout1_4 Vdout1_4ck66 = 0.9 time = 335
.meas tran vdout1_4ck66 FIND v(dout1_4) AT=335.025n

* CHECK dout1_5 Vdout1_5ck66 = 0.9 time = 335
.meas tran vdout1_5ck66 FIND v(dout1_5) AT=335.025n

* CHECK dout1_6 Vdout1_6ck66 = 0 time = 335
.meas tran vdout1_6ck66 FIND v(dout1_6) AT=335.025n

* CHECK dout1_7 Vdout1_7ck66 = 0.9 time = 335
.meas tran vdout1_7ck66 FIND v(dout1_7) AT=335.025n

* CHECK dout1_8 Vdout1_8ck66 = 0.9 time = 335
.meas tran vdout1_8ck66 FIND v(dout1_8) AT=335.025n

* CHECK dout1_9 Vdout1_9ck66 = 0.9 time = 335
.meas tran vdout1_9ck66 FIND v(dout1_9) AT=335.025n

* CHECK dout1_10 Vdout1_10ck66 = 0.9 time = 335
.meas tran vdout1_10ck66 FIND v(dout1_10) AT=335.025n

* CHECK dout1_11 Vdout1_11ck66 = 0.9 time = 335
.meas tran vdout1_11ck66 FIND v(dout1_11) AT=335.025n

* CHECK dout1_12 Vdout1_12ck66 = 0.9 time = 335
.meas tran vdout1_12ck66 FIND v(dout1_12) AT=335.025n

* CHECK dout1_13 Vdout1_13ck66 = 0 time = 335
.meas tran vdout1_13ck66 FIND v(dout1_13) AT=335.025n

* CHECK dout1_14 Vdout1_14ck66 = 0 time = 335
.meas tran vdout1_14ck66 FIND v(dout1_14) AT=335.025n

* CHECK dout1_15 Vdout1_15ck66 = 0 time = 335
.meas tran vdout1_15ck66 FIND v(dout1_15) AT=335.025n

* CHECK dout1_16 Vdout1_16ck66 = 0 time = 335
.meas tran vdout1_16ck66 FIND v(dout1_16) AT=335.025n

* CHECK dout1_17 Vdout1_17ck66 = 0 time = 335
.meas tran vdout1_17ck66 FIND v(dout1_17) AT=335.025n

* CHECK dout1_18 Vdout1_18ck66 = 0.9 time = 335
.meas tran vdout1_18ck66 FIND v(dout1_18) AT=335.025n

* CHECK dout1_19 Vdout1_19ck66 = 0 time = 335
.meas tran vdout1_19ck66 FIND v(dout1_19) AT=335.025n

* CHECK dout1_20 Vdout1_20ck66 = 0.9 time = 335
.meas tran vdout1_20ck66 FIND v(dout1_20) AT=335.025n

* CHECK dout1_21 Vdout1_21ck66 = 0.9 time = 335
.meas tran vdout1_21ck66 FIND v(dout1_21) AT=335.025n

* CHECK dout1_22 Vdout1_22ck66 = 0.9 time = 335
.meas tran vdout1_22ck66 FIND v(dout1_22) AT=335.025n

* CHECK dout1_23 Vdout1_23ck66 = 0.9 time = 335
.meas tran vdout1_23ck66 FIND v(dout1_23) AT=335.025n

* CHECK dout1_24 Vdout1_24ck66 = 0 time = 335
.meas tran vdout1_24ck66 FIND v(dout1_24) AT=335.025n

* CHECK dout1_25 Vdout1_25ck66 = 0 time = 335
.meas tran vdout1_25ck66 FIND v(dout1_25) AT=335.025n

* CHECK dout1_26 Vdout1_26ck66 = 0.9 time = 335
.meas tran vdout1_26ck66 FIND v(dout1_26) AT=335.025n

* CHECK dout1_27 Vdout1_27ck66 = 0 time = 335
.meas tran vdout1_27ck66 FIND v(dout1_27) AT=335.025n

* CHECK dout1_28 Vdout1_28ck66 = 0.9 time = 335
.meas tran vdout1_28ck66 FIND v(dout1_28) AT=335.025n

* CHECK dout1_29 Vdout1_29ck66 = 0.9 time = 335
.meas tran vdout1_29ck66 FIND v(dout1_29) AT=335.025n

* CHECK dout1_30 Vdout1_30ck66 = 0.9 time = 335
.meas tran vdout1_30ck66 FIND v(dout1_30) AT=335.025n

* CHECK dout1_31 Vdout1_31ck66 = 0.9 time = 335
.meas tran vdout1_31ck66 FIND v(dout1_31) AT=335.025n

* CHECK dout1_32 Vdout1_32ck66 = 0 time = 335
.meas tran vdout1_32ck66 FIND v(dout1_32) AT=335.025n

* CHECK dout1_33 Vdout1_33ck66 = 0.9 time = 335
.meas tran vdout1_33ck66 FIND v(dout1_33) AT=335.025n

* CHECK dout1_34 Vdout1_34ck66 = 0 time = 335
.meas tran vdout1_34ck66 FIND v(dout1_34) AT=335.025n

* CHECK dout1_35 Vdout1_35ck66 = 0 time = 335
.meas tran vdout1_35ck66 FIND v(dout1_35) AT=335.025n

* CHECK dout1_36 Vdout1_36ck66 = 0.9 time = 335
.meas tran vdout1_36ck66 FIND v(dout1_36) AT=335.025n

* CHECK dout1_37 Vdout1_37ck66 = 0 time = 335
.meas tran vdout1_37ck66 FIND v(dout1_37) AT=335.025n

* CHECK dout1_38 Vdout1_38ck66 = 0 time = 335
.meas tran vdout1_38ck66 FIND v(dout1_38) AT=335.025n

* CHECK dout1_39 Vdout1_39ck66 = 0.9 time = 335
.meas tran vdout1_39ck66 FIND v(dout1_39) AT=335.025n

* CHECK dout1_40 Vdout1_40ck66 = 0.9 time = 335
.meas tran vdout1_40ck66 FIND v(dout1_40) AT=335.025n

* CHECK dout1_41 Vdout1_41ck66 = 0 time = 335
.meas tran vdout1_41ck66 FIND v(dout1_41) AT=335.025n

* CHECK dout1_42 Vdout1_42ck66 = 0 time = 335
.meas tran vdout1_42ck66 FIND v(dout1_42) AT=335.025n

* CHECK dout1_43 Vdout1_43ck66 = 0 time = 335
.meas tran vdout1_43ck66 FIND v(dout1_43) AT=335.025n

* CHECK dout1_44 Vdout1_44ck66 = 0.9 time = 335
.meas tran vdout1_44ck66 FIND v(dout1_44) AT=335.025n

* CHECK dout1_45 Vdout1_45ck66 = 0 time = 335
.meas tran vdout1_45ck66 FIND v(dout1_45) AT=335.025n

* CHECK dout1_46 Vdout1_46ck66 = 0.9 time = 335
.meas tran vdout1_46ck66 FIND v(dout1_46) AT=335.025n

* CHECK dout1_47 Vdout1_47ck66 = 0.9 time = 335
.meas tran vdout1_47ck66 FIND v(dout1_47) AT=335.025n

* CHECK dout1_48 Vdout1_48ck66 = 0.9 time = 335
.meas tran vdout1_48ck66 FIND v(dout1_48) AT=335.025n

* CHECK dout1_49 Vdout1_49ck66 = 0.9 time = 335
.meas tran vdout1_49ck66 FIND v(dout1_49) AT=335.025n

* CHECK dout1_50 Vdout1_50ck66 = 0 time = 335
.meas tran vdout1_50ck66 FIND v(dout1_50) AT=335.025n

* CHECK dout1_51 Vdout1_51ck66 = 0 time = 335
.meas tran vdout1_51ck66 FIND v(dout1_51) AT=335.025n

* CHECK dout1_52 Vdout1_52ck66 = 0 time = 335
.meas tran vdout1_52ck66 FIND v(dout1_52) AT=335.025n

* CHECK dout1_53 Vdout1_53ck66 = 0 time = 335
.meas tran vdout1_53ck66 FIND v(dout1_53) AT=335.025n

* CHECK dout1_54 Vdout1_54ck66 = 0.9 time = 335
.meas tran vdout1_54ck66 FIND v(dout1_54) AT=335.025n

* CHECK dout1_55 Vdout1_55ck66 = 0.9 time = 335
.meas tran vdout1_55ck66 FIND v(dout1_55) AT=335.025n

* CHECK dout1_56 Vdout1_56ck66 = 0.9 time = 335
.meas tran vdout1_56ck66 FIND v(dout1_56) AT=335.025n

* CHECK dout1_57 Vdout1_57ck66 = 0.9 time = 335
.meas tran vdout1_57ck66 FIND v(dout1_57) AT=335.025n

* CHECK dout1_58 Vdout1_58ck66 = 0.9 time = 335
.meas tran vdout1_58ck66 FIND v(dout1_58) AT=335.025n

* CHECK dout1_59 Vdout1_59ck66 = 0.9 time = 335
.meas tran vdout1_59ck66 FIND v(dout1_59) AT=335.025n

* CHECK dout1_60 Vdout1_60ck66 = 0.9 time = 335
.meas tran vdout1_60ck66 FIND v(dout1_60) AT=335.025n

* CHECK dout1_61 Vdout1_61ck66 = 0.9 time = 335
.meas tran vdout1_61ck66 FIND v(dout1_61) AT=335.025n

* CHECK dout1_62 Vdout1_62ck66 = 0.9 time = 335
.meas tran vdout1_62ck66 FIND v(dout1_62) AT=335.025n

* CHECK dout1_63 Vdout1_63ck66 = 0 time = 335
.meas tran vdout1_63ck66 FIND v(dout1_63) AT=335.025n

* CHECK dout1_0 Vdout1_0ck71 = 0 time = 360
.meas tran vdout1_0ck71 FIND v(dout1_0) AT=360.025n

* CHECK dout1_1 Vdout1_1ck71 = 0.9 time = 360
.meas tran vdout1_1ck71 FIND v(dout1_1) AT=360.025n

* CHECK dout1_2 Vdout1_2ck71 = 0.9 time = 360
.meas tran vdout1_2ck71 FIND v(dout1_2) AT=360.025n

* CHECK dout1_3 Vdout1_3ck71 = 0.9 time = 360
.meas tran vdout1_3ck71 FIND v(dout1_3) AT=360.025n

* CHECK dout1_4 Vdout1_4ck71 = 0.9 time = 360
.meas tran vdout1_4ck71 FIND v(dout1_4) AT=360.025n

* CHECK dout1_5 Vdout1_5ck71 = 0.9 time = 360
.meas tran vdout1_5ck71 FIND v(dout1_5) AT=360.025n

* CHECK dout1_6 Vdout1_6ck71 = 0 time = 360
.meas tran vdout1_6ck71 FIND v(dout1_6) AT=360.025n

* CHECK dout1_7 Vdout1_7ck71 = 0.9 time = 360
.meas tran vdout1_7ck71 FIND v(dout1_7) AT=360.025n

* CHECK dout1_8 Vdout1_8ck71 = 0.9 time = 360
.meas tran vdout1_8ck71 FIND v(dout1_8) AT=360.025n

* CHECK dout1_9 Vdout1_9ck71 = 0.9 time = 360
.meas tran vdout1_9ck71 FIND v(dout1_9) AT=360.025n

* CHECK dout1_10 Vdout1_10ck71 = 0.9 time = 360
.meas tran vdout1_10ck71 FIND v(dout1_10) AT=360.025n

* CHECK dout1_11 Vdout1_11ck71 = 0.9 time = 360
.meas tran vdout1_11ck71 FIND v(dout1_11) AT=360.025n

* CHECK dout1_12 Vdout1_12ck71 = 0.9 time = 360
.meas tran vdout1_12ck71 FIND v(dout1_12) AT=360.025n

* CHECK dout1_13 Vdout1_13ck71 = 0 time = 360
.meas tran vdout1_13ck71 FIND v(dout1_13) AT=360.025n

* CHECK dout1_14 Vdout1_14ck71 = 0 time = 360
.meas tran vdout1_14ck71 FIND v(dout1_14) AT=360.025n

* CHECK dout1_15 Vdout1_15ck71 = 0 time = 360
.meas tran vdout1_15ck71 FIND v(dout1_15) AT=360.025n

* CHECK dout1_16 Vdout1_16ck71 = 0 time = 360
.meas tran vdout1_16ck71 FIND v(dout1_16) AT=360.025n

* CHECK dout1_17 Vdout1_17ck71 = 0 time = 360
.meas tran vdout1_17ck71 FIND v(dout1_17) AT=360.025n

* CHECK dout1_18 Vdout1_18ck71 = 0.9 time = 360
.meas tran vdout1_18ck71 FIND v(dout1_18) AT=360.025n

* CHECK dout1_19 Vdout1_19ck71 = 0 time = 360
.meas tran vdout1_19ck71 FIND v(dout1_19) AT=360.025n

* CHECK dout1_20 Vdout1_20ck71 = 0.9 time = 360
.meas tran vdout1_20ck71 FIND v(dout1_20) AT=360.025n

* CHECK dout1_21 Vdout1_21ck71 = 0.9 time = 360
.meas tran vdout1_21ck71 FIND v(dout1_21) AT=360.025n

* CHECK dout1_22 Vdout1_22ck71 = 0.9 time = 360
.meas tran vdout1_22ck71 FIND v(dout1_22) AT=360.025n

* CHECK dout1_23 Vdout1_23ck71 = 0.9 time = 360
.meas tran vdout1_23ck71 FIND v(dout1_23) AT=360.025n

* CHECK dout1_24 Vdout1_24ck71 = 0 time = 360
.meas tran vdout1_24ck71 FIND v(dout1_24) AT=360.025n

* CHECK dout1_25 Vdout1_25ck71 = 0 time = 360
.meas tran vdout1_25ck71 FIND v(dout1_25) AT=360.025n

* CHECK dout1_26 Vdout1_26ck71 = 0.9 time = 360
.meas tran vdout1_26ck71 FIND v(dout1_26) AT=360.025n

* CHECK dout1_27 Vdout1_27ck71 = 0 time = 360
.meas tran vdout1_27ck71 FIND v(dout1_27) AT=360.025n

* CHECK dout1_28 Vdout1_28ck71 = 0.9 time = 360
.meas tran vdout1_28ck71 FIND v(dout1_28) AT=360.025n

* CHECK dout1_29 Vdout1_29ck71 = 0.9 time = 360
.meas tran vdout1_29ck71 FIND v(dout1_29) AT=360.025n

* CHECK dout1_30 Vdout1_30ck71 = 0.9 time = 360
.meas tran vdout1_30ck71 FIND v(dout1_30) AT=360.025n

* CHECK dout1_31 Vdout1_31ck71 = 0.9 time = 360
.meas tran vdout1_31ck71 FIND v(dout1_31) AT=360.025n

* CHECK dout1_32 Vdout1_32ck71 = 0 time = 360
.meas tran vdout1_32ck71 FIND v(dout1_32) AT=360.025n

* CHECK dout1_33 Vdout1_33ck71 = 0.9 time = 360
.meas tran vdout1_33ck71 FIND v(dout1_33) AT=360.025n

* CHECK dout1_34 Vdout1_34ck71 = 0 time = 360
.meas tran vdout1_34ck71 FIND v(dout1_34) AT=360.025n

* CHECK dout1_35 Vdout1_35ck71 = 0 time = 360
.meas tran vdout1_35ck71 FIND v(dout1_35) AT=360.025n

* CHECK dout1_36 Vdout1_36ck71 = 0.9 time = 360
.meas tran vdout1_36ck71 FIND v(dout1_36) AT=360.025n

* CHECK dout1_37 Vdout1_37ck71 = 0 time = 360
.meas tran vdout1_37ck71 FIND v(dout1_37) AT=360.025n

* CHECK dout1_38 Vdout1_38ck71 = 0 time = 360
.meas tran vdout1_38ck71 FIND v(dout1_38) AT=360.025n

* CHECK dout1_39 Vdout1_39ck71 = 0.9 time = 360
.meas tran vdout1_39ck71 FIND v(dout1_39) AT=360.025n

* CHECK dout1_40 Vdout1_40ck71 = 0.9 time = 360
.meas tran vdout1_40ck71 FIND v(dout1_40) AT=360.025n

* CHECK dout1_41 Vdout1_41ck71 = 0 time = 360
.meas tran vdout1_41ck71 FIND v(dout1_41) AT=360.025n

* CHECK dout1_42 Vdout1_42ck71 = 0 time = 360
.meas tran vdout1_42ck71 FIND v(dout1_42) AT=360.025n

* CHECK dout1_43 Vdout1_43ck71 = 0 time = 360
.meas tran vdout1_43ck71 FIND v(dout1_43) AT=360.025n

* CHECK dout1_44 Vdout1_44ck71 = 0.9 time = 360
.meas tran vdout1_44ck71 FIND v(dout1_44) AT=360.025n

* CHECK dout1_45 Vdout1_45ck71 = 0 time = 360
.meas tran vdout1_45ck71 FIND v(dout1_45) AT=360.025n

* CHECK dout1_46 Vdout1_46ck71 = 0.9 time = 360
.meas tran vdout1_46ck71 FIND v(dout1_46) AT=360.025n

* CHECK dout1_47 Vdout1_47ck71 = 0.9 time = 360
.meas tran vdout1_47ck71 FIND v(dout1_47) AT=360.025n

* CHECK dout1_48 Vdout1_48ck71 = 0.9 time = 360
.meas tran vdout1_48ck71 FIND v(dout1_48) AT=360.025n

* CHECK dout1_49 Vdout1_49ck71 = 0.9 time = 360
.meas tran vdout1_49ck71 FIND v(dout1_49) AT=360.025n

* CHECK dout1_50 Vdout1_50ck71 = 0 time = 360
.meas tran vdout1_50ck71 FIND v(dout1_50) AT=360.025n

* CHECK dout1_51 Vdout1_51ck71 = 0 time = 360
.meas tran vdout1_51ck71 FIND v(dout1_51) AT=360.025n

* CHECK dout1_52 Vdout1_52ck71 = 0 time = 360
.meas tran vdout1_52ck71 FIND v(dout1_52) AT=360.025n

* CHECK dout1_53 Vdout1_53ck71 = 0 time = 360
.meas tran vdout1_53ck71 FIND v(dout1_53) AT=360.025n

* CHECK dout1_54 Vdout1_54ck71 = 0.9 time = 360
.meas tran vdout1_54ck71 FIND v(dout1_54) AT=360.025n

* CHECK dout1_55 Vdout1_55ck71 = 0.9 time = 360
.meas tran vdout1_55ck71 FIND v(dout1_55) AT=360.025n

* CHECK dout1_56 Vdout1_56ck71 = 0.9 time = 360
.meas tran vdout1_56ck71 FIND v(dout1_56) AT=360.025n

* CHECK dout1_57 Vdout1_57ck71 = 0.9 time = 360
.meas tran vdout1_57ck71 FIND v(dout1_57) AT=360.025n

* CHECK dout1_58 Vdout1_58ck71 = 0.9 time = 360
.meas tran vdout1_58ck71 FIND v(dout1_58) AT=360.025n

* CHECK dout1_59 Vdout1_59ck71 = 0.9 time = 360
.meas tran vdout1_59ck71 FIND v(dout1_59) AT=360.025n

* CHECK dout1_60 Vdout1_60ck71 = 0.9 time = 360
.meas tran vdout1_60ck71 FIND v(dout1_60) AT=360.025n

* CHECK dout1_61 Vdout1_61ck71 = 0.9 time = 360
.meas tran vdout1_61ck71 FIND v(dout1_61) AT=360.025n

* CHECK dout1_62 Vdout1_62ck71 = 0.9 time = 360
.meas tran vdout1_62ck71 FIND v(dout1_62) AT=360.025n

* CHECK dout1_63 Vdout1_63ck71 = 0 time = 360
.meas tran vdout1_63ck71 FIND v(dout1_63) AT=360.025n

* CHECK dout1_0 Vdout1_0ck73 = 0 time = 370
.meas tran vdout1_0ck73 FIND v(dout1_0) AT=370.025n

* CHECK dout1_1 Vdout1_1ck73 = 0.9 time = 370
.meas tran vdout1_1ck73 FIND v(dout1_1) AT=370.025n

* CHECK dout1_2 Vdout1_2ck73 = 0.9 time = 370
.meas tran vdout1_2ck73 FIND v(dout1_2) AT=370.025n

* CHECK dout1_3 Vdout1_3ck73 = 0.9 time = 370
.meas tran vdout1_3ck73 FIND v(dout1_3) AT=370.025n

* CHECK dout1_4 Vdout1_4ck73 = 0.9 time = 370
.meas tran vdout1_4ck73 FIND v(dout1_4) AT=370.025n

* CHECK dout1_5 Vdout1_5ck73 = 0.9 time = 370
.meas tran vdout1_5ck73 FIND v(dout1_5) AT=370.025n

* CHECK dout1_6 Vdout1_6ck73 = 0 time = 370
.meas tran vdout1_6ck73 FIND v(dout1_6) AT=370.025n

* CHECK dout1_7 Vdout1_7ck73 = 0.9 time = 370
.meas tran vdout1_7ck73 FIND v(dout1_7) AT=370.025n

* CHECK dout1_8 Vdout1_8ck73 = 0.9 time = 370
.meas tran vdout1_8ck73 FIND v(dout1_8) AT=370.025n

* CHECK dout1_9 Vdout1_9ck73 = 0.9 time = 370
.meas tran vdout1_9ck73 FIND v(dout1_9) AT=370.025n

* CHECK dout1_10 Vdout1_10ck73 = 0.9 time = 370
.meas tran vdout1_10ck73 FIND v(dout1_10) AT=370.025n

* CHECK dout1_11 Vdout1_11ck73 = 0.9 time = 370
.meas tran vdout1_11ck73 FIND v(dout1_11) AT=370.025n

* CHECK dout1_12 Vdout1_12ck73 = 0.9 time = 370
.meas tran vdout1_12ck73 FIND v(dout1_12) AT=370.025n

* CHECK dout1_13 Vdout1_13ck73 = 0 time = 370
.meas tran vdout1_13ck73 FIND v(dout1_13) AT=370.025n

* CHECK dout1_14 Vdout1_14ck73 = 0 time = 370
.meas tran vdout1_14ck73 FIND v(dout1_14) AT=370.025n

* CHECK dout1_15 Vdout1_15ck73 = 0 time = 370
.meas tran vdout1_15ck73 FIND v(dout1_15) AT=370.025n

* CHECK dout1_16 Vdout1_16ck73 = 0 time = 370
.meas tran vdout1_16ck73 FIND v(dout1_16) AT=370.025n

* CHECK dout1_17 Vdout1_17ck73 = 0 time = 370
.meas tran vdout1_17ck73 FIND v(dout1_17) AT=370.025n

* CHECK dout1_18 Vdout1_18ck73 = 0.9 time = 370
.meas tran vdout1_18ck73 FIND v(dout1_18) AT=370.025n

* CHECK dout1_19 Vdout1_19ck73 = 0 time = 370
.meas tran vdout1_19ck73 FIND v(dout1_19) AT=370.025n

* CHECK dout1_20 Vdout1_20ck73 = 0.9 time = 370
.meas tran vdout1_20ck73 FIND v(dout1_20) AT=370.025n

* CHECK dout1_21 Vdout1_21ck73 = 0.9 time = 370
.meas tran vdout1_21ck73 FIND v(dout1_21) AT=370.025n

* CHECK dout1_22 Vdout1_22ck73 = 0.9 time = 370
.meas tran vdout1_22ck73 FIND v(dout1_22) AT=370.025n

* CHECK dout1_23 Vdout1_23ck73 = 0.9 time = 370
.meas tran vdout1_23ck73 FIND v(dout1_23) AT=370.025n

* CHECK dout1_24 Vdout1_24ck73 = 0 time = 370
.meas tran vdout1_24ck73 FIND v(dout1_24) AT=370.025n

* CHECK dout1_25 Vdout1_25ck73 = 0 time = 370
.meas tran vdout1_25ck73 FIND v(dout1_25) AT=370.025n

* CHECK dout1_26 Vdout1_26ck73 = 0.9 time = 370
.meas tran vdout1_26ck73 FIND v(dout1_26) AT=370.025n

* CHECK dout1_27 Vdout1_27ck73 = 0 time = 370
.meas tran vdout1_27ck73 FIND v(dout1_27) AT=370.025n

* CHECK dout1_28 Vdout1_28ck73 = 0.9 time = 370
.meas tran vdout1_28ck73 FIND v(dout1_28) AT=370.025n

* CHECK dout1_29 Vdout1_29ck73 = 0.9 time = 370
.meas tran vdout1_29ck73 FIND v(dout1_29) AT=370.025n

* CHECK dout1_30 Vdout1_30ck73 = 0.9 time = 370
.meas tran vdout1_30ck73 FIND v(dout1_30) AT=370.025n

* CHECK dout1_31 Vdout1_31ck73 = 0.9 time = 370
.meas tran vdout1_31ck73 FIND v(dout1_31) AT=370.025n

* CHECK dout1_32 Vdout1_32ck73 = 0 time = 370
.meas tran vdout1_32ck73 FIND v(dout1_32) AT=370.025n

* CHECK dout1_33 Vdout1_33ck73 = 0.9 time = 370
.meas tran vdout1_33ck73 FIND v(dout1_33) AT=370.025n

* CHECK dout1_34 Vdout1_34ck73 = 0 time = 370
.meas tran vdout1_34ck73 FIND v(dout1_34) AT=370.025n

* CHECK dout1_35 Vdout1_35ck73 = 0 time = 370
.meas tran vdout1_35ck73 FIND v(dout1_35) AT=370.025n

* CHECK dout1_36 Vdout1_36ck73 = 0.9 time = 370
.meas tran vdout1_36ck73 FIND v(dout1_36) AT=370.025n

* CHECK dout1_37 Vdout1_37ck73 = 0 time = 370
.meas tran vdout1_37ck73 FIND v(dout1_37) AT=370.025n

* CHECK dout1_38 Vdout1_38ck73 = 0 time = 370
.meas tran vdout1_38ck73 FIND v(dout1_38) AT=370.025n

* CHECK dout1_39 Vdout1_39ck73 = 0.9 time = 370
.meas tran vdout1_39ck73 FIND v(dout1_39) AT=370.025n

* CHECK dout1_40 Vdout1_40ck73 = 0.9 time = 370
.meas tran vdout1_40ck73 FIND v(dout1_40) AT=370.025n

* CHECK dout1_41 Vdout1_41ck73 = 0 time = 370
.meas tran vdout1_41ck73 FIND v(dout1_41) AT=370.025n

* CHECK dout1_42 Vdout1_42ck73 = 0 time = 370
.meas tran vdout1_42ck73 FIND v(dout1_42) AT=370.025n

* CHECK dout1_43 Vdout1_43ck73 = 0 time = 370
.meas tran vdout1_43ck73 FIND v(dout1_43) AT=370.025n

* CHECK dout1_44 Vdout1_44ck73 = 0.9 time = 370
.meas tran vdout1_44ck73 FIND v(dout1_44) AT=370.025n

* CHECK dout1_45 Vdout1_45ck73 = 0 time = 370
.meas tran vdout1_45ck73 FIND v(dout1_45) AT=370.025n

* CHECK dout1_46 Vdout1_46ck73 = 0.9 time = 370
.meas tran vdout1_46ck73 FIND v(dout1_46) AT=370.025n

* CHECK dout1_47 Vdout1_47ck73 = 0.9 time = 370
.meas tran vdout1_47ck73 FIND v(dout1_47) AT=370.025n

* CHECK dout1_48 Vdout1_48ck73 = 0.9 time = 370
.meas tran vdout1_48ck73 FIND v(dout1_48) AT=370.025n

* CHECK dout1_49 Vdout1_49ck73 = 0.9 time = 370
.meas tran vdout1_49ck73 FIND v(dout1_49) AT=370.025n

* CHECK dout1_50 Vdout1_50ck73 = 0 time = 370
.meas tran vdout1_50ck73 FIND v(dout1_50) AT=370.025n

* CHECK dout1_51 Vdout1_51ck73 = 0 time = 370
.meas tran vdout1_51ck73 FIND v(dout1_51) AT=370.025n

* CHECK dout1_52 Vdout1_52ck73 = 0 time = 370
.meas tran vdout1_52ck73 FIND v(dout1_52) AT=370.025n

* CHECK dout1_53 Vdout1_53ck73 = 0 time = 370
.meas tran vdout1_53ck73 FIND v(dout1_53) AT=370.025n

* CHECK dout1_54 Vdout1_54ck73 = 0.9 time = 370
.meas tran vdout1_54ck73 FIND v(dout1_54) AT=370.025n

* CHECK dout1_55 Vdout1_55ck73 = 0.9 time = 370
.meas tran vdout1_55ck73 FIND v(dout1_55) AT=370.025n

* CHECK dout1_56 Vdout1_56ck73 = 0.9 time = 370
.meas tran vdout1_56ck73 FIND v(dout1_56) AT=370.025n

* CHECK dout1_57 Vdout1_57ck73 = 0.9 time = 370
.meas tran vdout1_57ck73 FIND v(dout1_57) AT=370.025n

* CHECK dout1_58 Vdout1_58ck73 = 0.9 time = 370
.meas tran vdout1_58ck73 FIND v(dout1_58) AT=370.025n

* CHECK dout1_59 Vdout1_59ck73 = 0.9 time = 370
.meas tran vdout1_59ck73 FIND v(dout1_59) AT=370.025n

* CHECK dout1_60 Vdout1_60ck73 = 0.9 time = 370
.meas tran vdout1_60ck73 FIND v(dout1_60) AT=370.025n

* CHECK dout1_61 Vdout1_61ck73 = 0.9 time = 370
.meas tran vdout1_61ck73 FIND v(dout1_61) AT=370.025n

* CHECK dout1_62 Vdout1_62ck73 = 0.9 time = 370
.meas tran vdout1_62ck73 FIND v(dout1_62) AT=370.025n

* CHECK dout1_63 Vdout1_63ck73 = 0 time = 370
.meas tran vdout1_63ck73 FIND v(dout1_63) AT=370.025n

* CHECK dout1_0 Vdout1_0ck77 = 0.9 time = 390
.meas tran vdout1_0ck77 FIND v(dout1_0) AT=390.025n

* CHECK dout1_1 Vdout1_1ck77 = 0 time = 390
.meas tran vdout1_1ck77 FIND v(dout1_1) AT=390.025n

* CHECK dout1_2 Vdout1_2ck77 = 0 time = 390
.meas tran vdout1_2ck77 FIND v(dout1_2) AT=390.025n

* CHECK dout1_3 Vdout1_3ck77 = 0.9 time = 390
.meas tran vdout1_3ck77 FIND v(dout1_3) AT=390.025n

* CHECK dout1_4 Vdout1_4ck77 = 0.9 time = 390
.meas tran vdout1_4ck77 FIND v(dout1_4) AT=390.025n

* CHECK dout1_5 Vdout1_5ck77 = 0 time = 390
.meas tran vdout1_5ck77 FIND v(dout1_5) AT=390.025n

* CHECK dout1_6 Vdout1_6ck77 = 0.9 time = 390
.meas tran vdout1_6ck77 FIND v(dout1_6) AT=390.025n

* CHECK dout1_7 Vdout1_7ck77 = 0.9 time = 390
.meas tran vdout1_7ck77 FIND v(dout1_7) AT=390.025n

* CHECK dout1_8 Vdout1_8ck77 = 0 time = 390
.meas tran vdout1_8ck77 FIND v(dout1_8) AT=390.025n

* CHECK dout1_9 Vdout1_9ck77 = 0 time = 390
.meas tran vdout1_9ck77 FIND v(dout1_9) AT=390.025n

* CHECK dout1_10 Vdout1_10ck77 = 0 time = 390
.meas tran vdout1_10ck77 FIND v(dout1_10) AT=390.025n

* CHECK dout1_11 Vdout1_11ck77 = 0 time = 390
.meas tran vdout1_11ck77 FIND v(dout1_11) AT=390.025n

* CHECK dout1_12 Vdout1_12ck77 = 0.9 time = 390
.meas tran vdout1_12ck77 FIND v(dout1_12) AT=390.025n

* CHECK dout1_13 Vdout1_13ck77 = 0.9 time = 390
.meas tran vdout1_13ck77 FIND v(dout1_13) AT=390.025n

* CHECK dout1_14 Vdout1_14ck77 = 0.9 time = 390
.meas tran vdout1_14ck77 FIND v(dout1_14) AT=390.025n

* CHECK dout1_15 Vdout1_15ck77 = 0.9 time = 390
.meas tran vdout1_15ck77 FIND v(dout1_15) AT=390.025n

* CHECK dout1_16 Vdout1_16ck77 = 0 time = 390
.meas tran vdout1_16ck77 FIND v(dout1_16) AT=390.025n

* CHECK dout1_17 Vdout1_17ck77 = 0.9 time = 390
.meas tran vdout1_17ck77 FIND v(dout1_17) AT=390.025n

* CHECK dout1_18 Vdout1_18ck77 = 0.9 time = 390
.meas tran vdout1_18ck77 FIND v(dout1_18) AT=390.025n

* CHECK dout1_19 Vdout1_19ck77 = 0.9 time = 390
.meas tran vdout1_19ck77 FIND v(dout1_19) AT=390.025n

* CHECK dout1_20 Vdout1_20ck77 = 0 time = 390
.meas tran vdout1_20ck77 FIND v(dout1_20) AT=390.025n

* CHECK dout1_21 Vdout1_21ck77 = 0 time = 390
.meas tran vdout1_21ck77 FIND v(dout1_21) AT=390.025n

* CHECK dout1_22 Vdout1_22ck77 = 0 time = 390
.meas tran vdout1_22ck77 FIND v(dout1_22) AT=390.025n

* CHECK dout1_23 Vdout1_23ck77 = 0 time = 390
.meas tran vdout1_23ck77 FIND v(dout1_23) AT=390.025n

* CHECK dout1_24 Vdout1_24ck77 = 0.9 time = 390
.meas tran vdout1_24ck77 FIND v(dout1_24) AT=390.025n

* CHECK dout1_25 Vdout1_25ck77 = 0 time = 390
.meas tran vdout1_25ck77 FIND v(dout1_25) AT=390.025n

* CHECK dout1_26 Vdout1_26ck77 = 0 time = 390
.meas tran vdout1_26ck77 FIND v(dout1_26) AT=390.025n

* CHECK dout1_27 Vdout1_27ck77 = 0 time = 390
.meas tran vdout1_27ck77 FIND v(dout1_27) AT=390.025n

* CHECK dout1_28 Vdout1_28ck77 = 0 time = 390
.meas tran vdout1_28ck77 FIND v(dout1_28) AT=390.025n

* CHECK dout1_29 Vdout1_29ck77 = 0 time = 390
.meas tran vdout1_29ck77 FIND v(dout1_29) AT=390.025n

* CHECK dout1_30 Vdout1_30ck77 = 0.9 time = 390
.meas tran vdout1_30ck77 FIND v(dout1_30) AT=390.025n

* CHECK dout1_31 Vdout1_31ck77 = 0 time = 390
.meas tran vdout1_31ck77 FIND v(dout1_31) AT=390.025n

* CHECK dout1_32 Vdout1_32ck77 = 0.9 time = 390
.meas tran vdout1_32ck77 FIND v(dout1_32) AT=390.025n

* CHECK dout1_33 Vdout1_33ck77 = 0 time = 390
.meas tran vdout1_33ck77 FIND v(dout1_33) AT=390.025n

* CHECK dout1_34 Vdout1_34ck77 = 0 time = 390
.meas tran vdout1_34ck77 FIND v(dout1_34) AT=390.025n

* CHECK dout1_35 Vdout1_35ck77 = 0 time = 390
.meas tran vdout1_35ck77 FIND v(dout1_35) AT=390.025n

* CHECK dout1_36 Vdout1_36ck77 = 0.9 time = 390
.meas tran vdout1_36ck77 FIND v(dout1_36) AT=390.025n

* CHECK dout1_37 Vdout1_37ck77 = 0 time = 390
.meas tran vdout1_37ck77 FIND v(dout1_37) AT=390.025n

* CHECK dout1_38 Vdout1_38ck77 = 0.9 time = 390
.meas tran vdout1_38ck77 FIND v(dout1_38) AT=390.025n

* CHECK dout1_39 Vdout1_39ck77 = 0.9 time = 390
.meas tran vdout1_39ck77 FIND v(dout1_39) AT=390.025n

* CHECK dout1_40 Vdout1_40ck77 = 0.9 time = 390
.meas tran vdout1_40ck77 FIND v(dout1_40) AT=390.025n

* CHECK dout1_41 Vdout1_41ck77 = 0.9 time = 390
.meas tran vdout1_41ck77 FIND v(dout1_41) AT=390.025n

* CHECK dout1_42 Vdout1_42ck77 = 0 time = 390
.meas tran vdout1_42ck77 FIND v(dout1_42) AT=390.025n

* CHECK dout1_43 Vdout1_43ck77 = 0 time = 390
.meas tran vdout1_43ck77 FIND v(dout1_43) AT=390.025n

* CHECK dout1_44 Vdout1_44ck77 = 0.9 time = 390
.meas tran vdout1_44ck77 FIND v(dout1_44) AT=390.025n

* CHECK dout1_45 Vdout1_45ck77 = 0 time = 390
.meas tran vdout1_45ck77 FIND v(dout1_45) AT=390.025n

* CHECK dout1_46 Vdout1_46ck77 = 0.9 time = 390
.meas tran vdout1_46ck77 FIND v(dout1_46) AT=390.025n

* CHECK dout1_47 Vdout1_47ck77 = 0 time = 390
.meas tran vdout1_47ck77 FIND v(dout1_47) AT=390.025n

* CHECK dout1_48 Vdout1_48ck77 = 0.9 time = 390
.meas tran vdout1_48ck77 FIND v(dout1_48) AT=390.025n

* CHECK dout1_49 Vdout1_49ck77 = 0 time = 390
.meas tran vdout1_49ck77 FIND v(dout1_49) AT=390.025n

* CHECK dout1_50 Vdout1_50ck77 = 0.9 time = 390
.meas tran vdout1_50ck77 FIND v(dout1_50) AT=390.025n

* CHECK dout1_51 Vdout1_51ck77 = 0 time = 390
.meas tran vdout1_51ck77 FIND v(dout1_51) AT=390.025n

* CHECK dout1_52 Vdout1_52ck77 = 0.9 time = 390
.meas tran vdout1_52ck77 FIND v(dout1_52) AT=390.025n

* CHECK dout1_53 Vdout1_53ck77 = 0.9 time = 390
.meas tran vdout1_53ck77 FIND v(dout1_53) AT=390.025n

* CHECK dout1_54 Vdout1_54ck77 = 0.9 time = 390
.meas tran vdout1_54ck77 FIND v(dout1_54) AT=390.025n

* CHECK dout1_55 Vdout1_55ck77 = 0.9 time = 390
.meas tran vdout1_55ck77 FIND v(dout1_55) AT=390.025n

* CHECK dout1_56 Vdout1_56ck77 = 0 time = 390
.meas tran vdout1_56ck77 FIND v(dout1_56) AT=390.025n

* CHECK dout1_57 Vdout1_57ck77 = 0.9 time = 390
.meas tran vdout1_57ck77 FIND v(dout1_57) AT=390.025n

* CHECK dout1_58 Vdout1_58ck77 = 0 time = 390
.meas tran vdout1_58ck77 FIND v(dout1_58) AT=390.025n

* CHECK dout1_59 Vdout1_59ck77 = 0.9 time = 390
.meas tran vdout1_59ck77 FIND v(dout1_59) AT=390.025n

* CHECK dout1_60 Vdout1_60ck77 = 0.9 time = 390
.meas tran vdout1_60ck77 FIND v(dout1_60) AT=390.025n

* CHECK dout1_61 Vdout1_61ck77 = 0 time = 390
.meas tran vdout1_61ck77 FIND v(dout1_61) AT=390.025n

* CHECK dout1_62 Vdout1_62ck77 = 0.9 time = 390
.meas tran vdout1_62ck77 FIND v(dout1_62) AT=390.025n

* CHECK dout1_63 Vdout1_63ck77 = 0.9 time = 390
.meas tran vdout1_63ck77 FIND v(dout1_63) AT=390.025n

* CHECK dout1_0 Vdout1_0ck82 = 0.9 time = 415
.meas tran vdout1_0ck82 FIND v(dout1_0) AT=415.025n

* CHECK dout1_1 Vdout1_1ck82 = 0.9 time = 415
.meas tran vdout1_1ck82 FIND v(dout1_1) AT=415.025n

* CHECK dout1_2 Vdout1_2ck82 = 0 time = 415
.meas tran vdout1_2ck82 FIND v(dout1_2) AT=415.025n

* CHECK dout1_3 Vdout1_3ck82 = 0.9 time = 415
.meas tran vdout1_3ck82 FIND v(dout1_3) AT=415.025n

* CHECK dout1_4 Vdout1_4ck82 = 0 time = 415
.meas tran vdout1_4ck82 FIND v(dout1_4) AT=415.025n

* CHECK dout1_5 Vdout1_5ck82 = 0.9 time = 415
.meas tran vdout1_5ck82 FIND v(dout1_5) AT=415.025n

* CHECK dout1_6 Vdout1_6ck82 = 0.9 time = 415
.meas tran vdout1_6ck82 FIND v(dout1_6) AT=415.025n

* CHECK dout1_7 Vdout1_7ck82 = 0.9 time = 415
.meas tran vdout1_7ck82 FIND v(dout1_7) AT=415.025n

* CHECK dout1_8 Vdout1_8ck82 = 0.9 time = 415
.meas tran vdout1_8ck82 FIND v(dout1_8) AT=415.025n

* CHECK dout1_9 Vdout1_9ck82 = 0.9 time = 415
.meas tran vdout1_9ck82 FIND v(dout1_9) AT=415.025n

* CHECK dout1_10 Vdout1_10ck82 = 0.9 time = 415
.meas tran vdout1_10ck82 FIND v(dout1_10) AT=415.025n

* CHECK dout1_11 Vdout1_11ck82 = 0.9 time = 415
.meas tran vdout1_11ck82 FIND v(dout1_11) AT=415.025n

* CHECK dout1_12 Vdout1_12ck82 = 0 time = 415
.meas tran vdout1_12ck82 FIND v(dout1_12) AT=415.025n

* CHECK dout1_13 Vdout1_13ck82 = 0 time = 415
.meas tran vdout1_13ck82 FIND v(dout1_13) AT=415.025n

* CHECK dout1_14 Vdout1_14ck82 = 0.9 time = 415
.meas tran vdout1_14ck82 FIND v(dout1_14) AT=415.025n

* CHECK dout1_15 Vdout1_15ck82 = 0 time = 415
.meas tran vdout1_15ck82 FIND v(dout1_15) AT=415.025n

* CHECK dout1_16 Vdout1_16ck82 = 0.9 time = 415
.meas tran vdout1_16ck82 FIND v(dout1_16) AT=415.025n

* CHECK dout1_17 Vdout1_17ck82 = 0 time = 415
.meas tran vdout1_17ck82 FIND v(dout1_17) AT=415.025n

* CHECK dout1_18 Vdout1_18ck82 = 0.9 time = 415
.meas tran vdout1_18ck82 FIND v(dout1_18) AT=415.025n

* CHECK dout1_19 Vdout1_19ck82 = 0.9 time = 415
.meas tran vdout1_19ck82 FIND v(dout1_19) AT=415.025n

* CHECK dout1_20 Vdout1_20ck82 = 0.9 time = 415
.meas tran vdout1_20ck82 FIND v(dout1_20) AT=415.025n

* CHECK dout1_21 Vdout1_21ck82 = 0 time = 415
.meas tran vdout1_21ck82 FIND v(dout1_21) AT=415.025n

* CHECK dout1_22 Vdout1_22ck82 = 0 time = 415
.meas tran vdout1_22ck82 FIND v(dout1_22) AT=415.025n

* CHECK dout1_23 Vdout1_23ck82 = 0.9 time = 415
.meas tran vdout1_23ck82 FIND v(dout1_23) AT=415.025n

* CHECK dout1_24 Vdout1_24ck82 = 0.9 time = 415
.meas tran vdout1_24ck82 FIND v(dout1_24) AT=415.025n

* CHECK dout1_25 Vdout1_25ck82 = 0 time = 415
.meas tran vdout1_25ck82 FIND v(dout1_25) AT=415.025n

* CHECK dout1_26 Vdout1_26ck82 = 0 time = 415
.meas tran vdout1_26ck82 FIND v(dout1_26) AT=415.025n

* CHECK dout1_27 Vdout1_27ck82 = 0.9 time = 415
.meas tran vdout1_27ck82 FIND v(dout1_27) AT=415.025n

* CHECK dout1_28 Vdout1_28ck82 = 0.9 time = 415
.meas tran vdout1_28ck82 FIND v(dout1_28) AT=415.025n

* CHECK dout1_29 Vdout1_29ck82 = 0.9 time = 415
.meas tran vdout1_29ck82 FIND v(dout1_29) AT=415.025n

* CHECK dout1_30 Vdout1_30ck82 = 0.9 time = 415
.meas tran vdout1_30ck82 FIND v(dout1_30) AT=415.025n

* CHECK dout1_31 Vdout1_31ck82 = 0 time = 415
.meas tran vdout1_31ck82 FIND v(dout1_31) AT=415.025n

* CHECK dout1_32 Vdout1_32ck82 = 0.9 time = 415
.meas tran vdout1_32ck82 FIND v(dout1_32) AT=415.025n

* CHECK dout1_33 Vdout1_33ck82 = 0 time = 415
.meas tran vdout1_33ck82 FIND v(dout1_33) AT=415.025n

* CHECK dout1_34 Vdout1_34ck82 = 0 time = 415
.meas tran vdout1_34ck82 FIND v(dout1_34) AT=415.025n

* CHECK dout1_35 Vdout1_35ck82 = 0.9 time = 415
.meas tran vdout1_35ck82 FIND v(dout1_35) AT=415.025n

* CHECK dout1_36 Vdout1_36ck82 = 0 time = 415
.meas tran vdout1_36ck82 FIND v(dout1_36) AT=415.025n

* CHECK dout1_37 Vdout1_37ck82 = 0 time = 415
.meas tran vdout1_37ck82 FIND v(dout1_37) AT=415.025n

* CHECK dout1_38 Vdout1_38ck82 = 0.9 time = 415
.meas tran vdout1_38ck82 FIND v(dout1_38) AT=415.025n

* CHECK dout1_39 Vdout1_39ck82 = 0.9 time = 415
.meas tran vdout1_39ck82 FIND v(dout1_39) AT=415.025n

* CHECK dout1_40 Vdout1_40ck82 = 0.9 time = 415
.meas tran vdout1_40ck82 FIND v(dout1_40) AT=415.025n

* CHECK dout1_41 Vdout1_41ck82 = 0.9 time = 415
.meas tran vdout1_41ck82 FIND v(dout1_41) AT=415.025n

* CHECK dout1_42 Vdout1_42ck82 = 0.9 time = 415
.meas tran vdout1_42ck82 FIND v(dout1_42) AT=415.025n

* CHECK dout1_43 Vdout1_43ck82 = 0.9 time = 415
.meas tran vdout1_43ck82 FIND v(dout1_43) AT=415.025n

* CHECK dout1_44 Vdout1_44ck82 = 0.9 time = 415
.meas tran vdout1_44ck82 FIND v(dout1_44) AT=415.025n

* CHECK dout1_45 Vdout1_45ck82 = 0 time = 415
.meas tran vdout1_45ck82 FIND v(dout1_45) AT=415.025n

* CHECK dout1_46 Vdout1_46ck82 = 0 time = 415
.meas tran vdout1_46ck82 FIND v(dout1_46) AT=415.025n

* CHECK dout1_47 Vdout1_47ck82 = 0.9 time = 415
.meas tran vdout1_47ck82 FIND v(dout1_47) AT=415.025n

* CHECK dout1_48 Vdout1_48ck82 = 0.9 time = 415
.meas tran vdout1_48ck82 FIND v(dout1_48) AT=415.025n

* CHECK dout1_49 Vdout1_49ck82 = 0 time = 415
.meas tran vdout1_49ck82 FIND v(dout1_49) AT=415.025n

* CHECK dout1_50 Vdout1_50ck82 = 0.9 time = 415
.meas tran vdout1_50ck82 FIND v(dout1_50) AT=415.025n

* CHECK dout1_51 Vdout1_51ck82 = 0 time = 415
.meas tran vdout1_51ck82 FIND v(dout1_51) AT=415.025n

* CHECK dout1_52 Vdout1_52ck82 = 0 time = 415
.meas tran vdout1_52ck82 FIND v(dout1_52) AT=415.025n

* CHECK dout1_53 Vdout1_53ck82 = 0 time = 415
.meas tran vdout1_53ck82 FIND v(dout1_53) AT=415.025n

* CHECK dout1_54 Vdout1_54ck82 = 0 time = 415
.meas tran vdout1_54ck82 FIND v(dout1_54) AT=415.025n

* CHECK dout1_55 Vdout1_55ck82 = 0.9 time = 415
.meas tran vdout1_55ck82 FIND v(dout1_55) AT=415.025n

* CHECK dout1_56 Vdout1_56ck82 = 0.9 time = 415
.meas tran vdout1_56ck82 FIND v(dout1_56) AT=415.025n

* CHECK dout1_57 Vdout1_57ck82 = 0 time = 415
.meas tran vdout1_57ck82 FIND v(dout1_57) AT=415.025n

* CHECK dout1_58 Vdout1_58ck82 = 0 time = 415
.meas tran vdout1_58ck82 FIND v(dout1_58) AT=415.025n

* CHECK dout1_59 Vdout1_59ck82 = 0 time = 415
.meas tran vdout1_59ck82 FIND v(dout1_59) AT=415.025n

* CHECK dout1_60 Vdout1_60ck82 = 0.9 time = 415
.meas tran vdout1_60ck82 FIND v(dout1_60) AT=415.025n

* CHECK dout1_61 Vdout1_61ck82 = 0 time = 415
.meas tran vdout1_61ck82 FIND v(dout1_61) AT=415.025n

* CHECK dout1_62 Vdout1_62ck82 = 0 time = 415
.meas tran vdout1_62ck82 FIND v(dout1_62) AT=415.025n

* CHECK dout1_63 Vdout1_63ck82 = 0.9 time = 415
.meas tran vdout1_63ck82 FIND v(dout1_63) AT=415.025n

* CHECK dout1_0 Vdout1_0ck84 = 0.9 time = 425
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=425.025n

* CHECK dout1_1 Vdout1_1ck84 = 0.9 time = 425
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=425.025n

* CHECK dout1_2 Vdout1_2ck84 = 0 time = 425
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=425.025n

* CHECK dout1_3 Vdout1_3ck84 = 0.9 time = 425
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=425.025n

* CHECK dout1_4 Vdout1_4ck84 = 0 time = 425
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=425.025n

* CHECK dout1_5 Vdout1_5ck84 = 0.9 time = 425
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=425.025n

* CHECK dout1_6 Vdout1_6ck84 = 0.9 time = 425
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=425.025n

* CHECK dout1_7 Vdout1_7ck84 = 0.9 time = 425
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=425.025n

* CHECK dout1_8 Vdout1_8ck84 = 0.9 time = 425
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=425.025n

* CHECK dout1_9 Vdout1_9ck84 = 0.9 time = 425
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=425.025n

* CHECK dout1_10 Vdout1_10ck84 = 0.9 time = 425
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=425.025n

* CHECK dout1_11 Vdout1_11ck84 = 0.9 time = 425
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=425.025n

* CHECK dout1_12 Vdout1_12ck84 = 0 time = 425
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=425.025n

* CHECK dout1_13 Vdout1_13ck84 = 0 time = 425
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=425.025n

* CHECK dout1_14 Vdout1_14ck84 = 0.9 time = 425
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=425.025n

* CHECK dout1_15 Vdout1_15ck84 = 0 time = 425
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=425.025n

* CHECK dout1_16 Vdout1_16ck84 = 0.9 time = 425
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=425.025n

* CHECK dout1_17 Vdout1_17ck84 = 0 time = 425
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=425.025n

* CHECK dout1_18 Vdout1_18ck84 = 0.9 time = 425
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=425.025n

* CHECK dout1_19 Vdout1_19ck84 = 0.9 time = 425
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=425.025n

* CHECK dout1_20 Vdout1_20ck84 = 0.9 time = 425
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=425.025n

* CHECK dout1_21 Vdout1_21ck84 = 0 time = 425
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=425.025n

* CHECK dout1_22 Vdout1_22ck84 = 0 time = 425
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=425.025n

* CHECK dout1_23 Vdout1_23ck84 = 0.9 time = 425
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=425.025n

* CHECK dout1_24 Vdout1_24ck84 = 0.9 time = 425
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=425.025n

* CHECK dout1_25 Vdout1_25ck84 = 0 time = 425
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=425.025n

* CHECK dout1_26 Vdout1_26ck84 = 0 time = 425
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=425.025n

* CHECK dout1_27 Vdout1_27ck84 = 0.9 time = 425
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=425.025n

* CHECK dout1_28 Vdout1_28ck84 = 0.9 time = 425
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=425.025n

* CHECK dout1_29 Vdout1_29ck84 = 0.9 time = 425
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=425.025n

* CHECK dout1_30 Vdout1_30ck84 = 0.9 time = 425
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=425.025n

* CHECK dout1_31 Vdout1_31ck84 = 0 time = 425
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=425.025n

* CHECK dout1_32 Vdout1_32ck84 = 0.9 time = 425
.meas tran vdout1_32ck84 FIND v(dout1_32) AT=425.025n

* CHECK dout1_33 Vdout1_33ck84 = 0 time = 425
.meas tran vdout1_33ck84 FIND v(dout1_33) AT=425.025n

* CHECK dout1_34 Vdout1_34ck84 = 0 time = 425
.meas tran vdout1_34ck84 FIND v(dout1_34) AT=425.025n

* CHECK dout1_35 Vdout1_35ck84 = 0.9 time = 425
.meas tran vdout1_35ck84 FIND v(dout1_35) AT=425.025n

* CHECK dout1_36 Vdout1_36ck84 = 0 time = 425
.meas tran vdout1_36ck84 FIND v(dout1_36) AT=425.025n

* CHECK dout1_37 Vdout1_37ck84 = 0 time = 425
.meas tran vdout1_37ck84 FIND v(dout1_37) AT=425.025n

* CHECK dout1_38 Vdout1_38ck84 = 0.9 time = 425
.meas tran vdout1_38ck84 FIND v(dout1_38) AT=425.025n

* CHECK dout1_39 Vdout1_39ck84 = 0.9 time = 425
.meas tran vdout1_39ck84 FIND v(dout1_39) AT=425.025n

* CHECK dout1_40 Vdout1_40ck84 = 0.9 time = 425
.meas tran vdout1_40ck84 FIND v(dout1_40) AT=425.025n

* CHECK dout1_41 Vdout1_41ck84 = 0.9 time = 425
.meas tran vdout1_41ck84 FIND v(dout1_41) AT=425.025n

* CHECK dout1_42 Vdout1_42ck84 = 0.9 time = 425
.meas tran vdout1_42ck84 FIND v(dout1_42) AT=425.025n

* CHECK dout1_43 Vdout1_43ck84 = 0.9 time = 425
.meas tran vdout1_43ck84 FIND v(dout1_43) AT=425.025n

* CHECK dout1_44 Vdout1_44ck84 = 0.9 time = 425
.meas tran vdout1_44ck84 FIND v(dout1_44) AT=425.025n

* CHECK dout1_45 Vdout1_45ck84 = 0 time = 425
.meas tran vdout1_45ck84 FIND v(dout1_45) AT=425.025n

* CHECK dout1_46 Vdout1_46ck84 = 0 time = 425
.meas tran vdout1_46ck84 FIND v(dout1_46) AT=425.025n

* CHECK dout1_47 Vdout1_47ck84 = 0.9 time = 425
.meas tran vdout1_47ck84 FIND v(dout1_47) AT=425.025n

* CHECK dout1_48 Vdout1_48ck84 = 0.9 time = 425
.meas tran vdout1_48ck84 FIND v(dout1_48) AT=425.025n

* CHECK dout1_49 Vdout1_49ck84 = 0 time = 425
.meas tran vdout1_49ck84 FIND v(dout1_49) AT=425.025n

* CHECK dout1_50 Vdout1_50ck84 = 0.9 time = 425
.meas tran vdout1_50ck84 FIND v(dout1_50) AT=425.025n

* CHECK dout1_51 Vdout1_51ck84 = 0 time = 425
.meas tran vdout1_51ck84 FIND v(dout1_51) AT=425.025n

* CHECK dout1_52 Vdout1_52ck84 = 0 time = 425
.meas tran vdout1_52ck84 FIND v(dout1_52) AT=425.025n

* CHECK dout1_53 Vdout1_53ck84 = 0 time = 425
.meas tran vdout1_53ck84 FIND v(dout1_53) AT=425.025n

* CHECK dout1_54 Vdout1_54ck84 = 0 time = 425
.meas tran vdout1_54ck84 FIND v(dout1_54) AT=425.025n

* CHECK dout1_55 Vdout1_55ck84 = 0.9 time = 425
.meas tran vdout1_55ck84 FIND v(dout1_55) AT=425.025n

* CHECK dout1_56 Vdout1_56ck84 = 0.9 time = 425
.meas tran vdout1_56ck84 FIND v(dout1_56) AT=425.025n

* CHECK dout1_57 Vdout1_57ck84 = 0 time = 425
.meas tran vdout1_57ck84 FIND v(dout1_57) AT=425.025n

* CHECK dout1_58 Vdout1_58ck84 = 0 time = 425
.meas tran vdout1_58ck84 FIND v(dout1_58) AT=425.025n

* CHECK dout1_59 Vdout1_59ck84 = 0 time = 425
.meas tran vdout1_59ck84 FIND v(dout1_59) AT=425.025n

* CHECK dout1_60 Vdout1_60ck84 = 0.9 time = 425
.meas tran vdout1_60ck84 FIND v(dout1_60) AT=425.025n

* CHECK dout1_61 Vdout1_61ck84 = 0 time = 425
.meas tran vdout1_61ck84 FIND v(dout1_61) AT=425.025n

* CHECK dout1_62 Vdout1_62ck84 = 0 time = 425
.meas tran vdout1_62ck84 FIND v(dout1_62) AT=425.025n

* CHECK dout1_63 Vdout1_63ck84 = 0.9 time = 425
.meas tran vdout1_63ck84 FIND v(dout1_63) AT=425.025n

* CHECK dout1_0 Vdout1_0ck92 = 0.9 time = 465
.meas tran vdout1_0ck92 FIND v(dout1_0) AT=465.025n

* CHECK dout1_1 Vdout1_1ck92 = 0 time = 465
.meas tran vdout1_1ck92 FIND v(dout1_1) AT=465.025n

* CHECK dout1_2 Vdout1_2ck92 = 0 time = 465
.meas tran vdout1_2ck92 FIND v(dout1_2) AT=465.025n

* CHECK dout1_3 Vdout1_3ck92 = 0.9 time = 465
.meas tran vdout1_3ck92 FIND v(dout1_3) AT=465.025n

* CHECK dout1_4 Vdout1_4ck92 = 0.9 time = 465
.meas tran vdout1_4ck92 FIND v(dout1_4) AT=465.025n

* CHECK dout1_5 Vdout1_5ck92 = 0 time = 465
.meas tran vdout1_5ck92 FIND v(dout1_5) AT=465.025n

* CHECK dout1_6 Vdout1_6ck92 = 0 time = 465
.meas tran vdout1_6ck92 FIND v(dout1_6) AT=465.025n

* CHECK dout1_7 Vdout1_7ck92 = 0 time = 465
.meas tran vdout1_7ck92 FIND v(dout1_7) AT=465.025n

* CHECK dout1_8 Vdout1_8ck92 = 0.9 time = 465
.meas tran vdout1_8ck92 FIND v(dout1_8) AT=465.025n

* CHECK dout1_9 Vdout1_9ck92 = 0 time = 465
.meas tran vdout1_9ck92 FIND v(dout1_9) AT=465.025n

* CHECK dout1_10 Vdout1_10ck92 = 0.9 time = 465
.meas tran vdout1_10ck92 FIND v(dout1_10) AT=465.025n

* CHECK dout1_11 Vdout1_11ck92 = 0 time = 465
.meas tran vdout1_11ck92 FIND v(dout1_11) AT=465.025n

* CHECK dout1_12 Vdout1_12ck92 = 0 time = 465
.meas tran vdout1_12ck92 FIND v(dout1_12) AT=465.025n

* CHECK dout1_13 Vdout1_13ck92 = 0.9 time = 465
.meas tran vdout1_13ck92 FIND v(dout1_13) AT=465.025n

* CHECK dout1_14 Vdout1_14ck92 = 0 time = 465
.meas tran vdout1_14ck92 FIND v(dout1_14) AT=465.025n

* CHECK dout1_15 Vdout1_15ck92 = 0.9 time = 465
.meas tran vdout1_15ck92 FIND v(dout1_15) AT=465.025n

* CHECK dout1_16 Vdout1_16ck92 = 0 time = 465
.meas tran vdout1_16ck92 FIND v(dout1_16) AT=465.025n

* CHECK dout1_17 Vdout1_17ck92 = 0 time = 465
.meas tran vdout1_17ck92 FIND v(dout1_17) AT=465.025n

* CHECK dout1_18 Vdout1_18ck92 = 0 time = 465
.meas tran vdout1_18ck92 FIND v(dout1_18) AT=465.025n

* CHECK dout1_19 Vdout1_19ck92 = 0.9 time = 465
.meas tran vdout1_19ck92 FIND v(dout1_19) AT=465.025n

* CHECK dout1_20 Vdout1_20ck92 = 0.9 time = 465
.meas tran vdout1_20ck92 FIND v(dout1_20) AT=465.025n

* CHECK dout1_21 Vdout1_21ck92 = 0.9 time = 465
.meas tran vdout1_21ck92 FIND v(dout1_21) AT=465.025n

* CHECK dout1_22 Vdout1_22ck92 = 0 time = 465
.meas tran vdout1_22ck92 FIND v(dout1_22) AT=465.025n

* CHECK dout1_23 Vdout1_23ck92 = 0 time = 465
.meas tran vdout1_23ck92 FIND v(dout1_23) AT=465.025n

* CHECK dout1_24 Vdout1_24ck92 = 0.9 time = 465
.meas tran vdout1_24ck92 FIND v(dout1_24) AT=465.025n

* CHECK dout1_25 Vdout1_25ck92 = 0 time = 465
.meas tran vdout1_25ck92 FIND v(dout1_25) AT=465.025n

* CHECK dout1_26 Vdout1_26ck92 = 0.9 time = 465
.meas tran vdout1_26ck92 FIND v(dout1_26) AT=465.025n

* CHECK dout1_27 Vdout1_27ck92 = 0 time = 465
.meas tran vdout1_27ck92 FIND v(dout1_27) AT=465.025n

* CHECK dout1_28 Vdout1_28ck92 = 0 time = 465
.meas tran vdout1_28ck92 FIND v(dout1_28) AT=465.025n

* CHECK dout1_29 Vdout1_29ck92 = 0.9 time = 465
.meas tran vdout1_29ck92 FIND v(dout1_29) AT=465.025n

* CHECK dout1_30 Vdout1_30ck92 = 0.9 time = 465
.meas tran vdout1_30ck92 FIND v(dout1_30) AT=465.025n

* CHECK dout1_31 Vdout1_31ck92 = 0 time = 465
.meas tran vdout1_31ck92 FIND v(dout1_31) AT=465.025n

* CHECK dout1_32 Vdout1_32ck92 = 0.9 time = 465
.meas tran vdout1_32ck92 FIND v(dout1_32) AT=465.025n

* CHECK dout1_33 Vdout1_33ck92 = 0 time = 465
.meas tran vdout1_33ck92 FIND v(dout1_33) AT=465.025n

* CHECK dout1_34 Vdout1_34ck92 = 0 time = 465
.meas tran vdout1_34ck92 FIND v(dout1_34) AT=465.025n

* CHECK dout1_35 Vdout1_35ck92 = 0 time = 465
.meas tran vdout1_35ck92 FIND v(dout1_35) AT=465.025n

* CHECK dout1_36 Vdout1_36ck92 = 0 time = 465
.meas tran vdout1_36ck92 FIND v(dout1_36) AT=465.025n

* CHECK dout1_37 Vdout1_37ck92 = 0 time = 465
.meas tran vdout1_37ck92 FIND v(dout1_37) AT=465.025n

* CHECK dout1_38 Vdout1_38ck92 = 0 time = 465
.meas tran vdout1_38ck92 FIND v(dout1_38) AT=465.025n

* CHECK dout1_39 Vdout1_39ck92 = 0 time = 465
.meas tran vdout1_39ck92 FIND v(dout1_39) AT=465.025n

* CHECK dout1_40 Vdout1_40ck92 = 0 time = 465
.meas tran vdout1_40ck92 FIND v(dout1_40) AT=465.025n

* CHECK dout1_41 Vdout1_41ck92 = 0 time = 465
.meas tran vdout1_41ck92 FIND v(dout1_41) AT=465.025n

* CHECK dout1_42 Vdout1_42ck92 = 0.9 time = 465
.meas tran vdout1_42ck92 FIND v(dout1_42) AT=465.025n

* CHECK dout1_43 Vdout1_43ck92 = 0.9 time = 465
.meas tran vdout1_43ck92 FIND v(dout1_43) AT=465.025n

* CHECK dout1_44 Vdout1_44ck92 = 0 time = 465
.meas tran vdout1_44ck92 FIND v(dout1_44) AT=465.025n

* CHECK dout1_45 Vdout1_45ck92 = 0.9 time = 465
.meas tran vdout1_45ck92 FIND v(dout1_45) AT=465.025n

* CHECK dout1_46 Vdout1_46ck92 = 0 time = 465
.meas tran vdout1_46ck92 FIND v(dout1_46) AT=465.025n

* CHECK dout1_47 Vdout1_47ck92 = 0 time = 465
.meas tran vdout1_47ck92 FIND v(dout1_47) AT=465.025n

* CHECK dout1_48 Vdout1_48ck92 = 0.9 time = 465
.meas tran vdout1_48ck92 FIND v(dout1_48) AT=465.025n

* CHECK dout1_49 Vdout1_49ck92 = 0 time = 465
.meas tran vdout1_49ck92 FIND v(dout1_49) AT=465.025n

* CHECK dout1_50 Vdout1_50ck92 = 0 time = 465
.meas tran vdout1_50ck92 FIND v(dout1_50) AT=465.025n

* CHECK dout1_51 Vdout1_51ck92 = 0.9 time = 465
.meas tran vdout1_51ck92 FIND v(dout1_51) AT=465.025n

* CHECK dout1_52 Vdout1_52ck92 = 0 time = 465
.meas tran vdout1_52ck92 FIND v(dout1_52) AT=465.025n

* CHECK dout1_53 Vdout1_53ck92 = 0.9 time = 465
.meas tran vdout1_53ck92 FIND v(dout1_53) AT=465.025n

* CHECK dout1_54 Vdout1_54ck92 = 0.9 time = 465
.meas tran vdout1_54ck92 FIND v(dout1_54) AT=465.025n

* CHECK dout1_55 Vdout1_55ck92 = 0 time = 465
.meas tran vdout1_55ck92 FIND v(dout1_55) AT=465.025n

* CHECK dout1_56 Vdout1_56ck92 = 0.9 time = 465
.meas tran vdout1_56ck92 FIND v(dout1_56) AT=465.025n

* CHECK dout1_57 Vdout1_57ck92 = 0.9 time = 465
.meas tran vdout1_57ck92 FIND v(dout1_57) AT=465.025n

* CHECK dout1_58 Vdout1_58ck92 = 0.9 time = 465
.meas tran vdout1_58ck92 FIND v(dout1_58) AT=465.025n

* CHECK dout1_59 Vdout1_59ck92 = 0 time = 465
.meas tran vdout1_59ck92 FIND v(dout1_59) AT=465.025n

* CHECK dout1_60 Vdout1_60ck92 = 0 time = 465
.meas tran vdout1_60ck92 FIND v(dout1_60) AT=465.025n

* CHECK dout1_61 Vdout1_61ck92 = 0.9 time = 465
.meas tran vdout1_61ck92 FIND v(dout1_61) AT=465.025n

* CHECK dout1_62 Vdout1_62ck92 = 0.9 time = 465
.meas tran vdout1_62ck92 FIND v(dout1_62) AT=465.025n

* CHECK dout1_63 Vdout1_63ck92 = 0.9 time = 465
.meas tran vdout1_63ck92 FIND v(dout1_63) AT=465.025n

* CHECK dout1_0 Vdout1_0ck93 = 0.9 time = 470
.meas tran vdout1_0ck93 FIND v(dout1_0) AT=470.025n

* CHECK dout1_1 Vdout1_1ck93 = 0 time = 470
.meas tran vdout1_1ck93 FIND v(dout1_1) AT=470.025n

* CHECK dout1_2 Vdout1_2ck93 = 0 time = 470
.meas tran vdout1_2ck93 FIND v(dout1_2) AT=470.025n

* CHECK dout1_3 Vdout1_3ck93 = 0.9 time = 470
.meas tran vdout1_3ck93 FIND v(dout1_3) AT=470.025n

* CHECK dout1_4 Vdout1_4ck93 = 0.9 time = 470
.meas tran vdout1_4ck93 FIND v(dout1_4) AT=470.025n

* CHECK dout1_5 Vdout1_5ck93 = 0 time = 470
.meas tran vdout1_5ck93 FIND v(dout1_5) AT=470.025n

* CHECK dout1_6 Vdout1_6ck93 = 0 time = 470
.meas tran vdout1_6ck93 FIND v(dout1_6) AT=470.025n

* CHECK dout1_7 Vdout1_7ck93 = 0.9 time = 470
.meas tran vdout1_7ck93 FIND v(dout1_7) AT=470.025n

* CHECK dout1_8 Vdout1_8ck93 = 0 time = 470
.meas tran vdout1_8ck93 FIND v(dout1_8) AT=470.025n

* CHECK dout1_9 Vdout1_9ck93 = 0.9 time = 470
.meas tran vdout1_9ck93 FIND v(dout1_9) AT=470.025n

* CHECK dout1_10 Vdout1_10ck93 = 0 time = 470
.meas tran vdout1_10ck93 FIND v(dout1_10) AT=470.025n

* CHECK dout1_11 Vdout1_11ck93 = 0 time = 470
.meas tran vdout1_11ck93 FIND v(dout1_11) AT=470.025n

* CHECK dout1_12 Vdout1_12ck93 = 0 time = 470
.meas tran vdout1_12ck93 FIND v(dout1_12) AT=470.025n

* CHECK dout1_13 Vdout1_13ck93 = 0 time = 470
.meas tran vdout1_13ck93 FIND v(dout1_13) AT=470.025n

* CHECK dout1_14 Vdout1_14ck93 = 0.9 time = 470
.meas tran vdout1_14ck93 FIND v(dout1_14) AT=470.025n

* CHECK dout1_15 Vdout1_15ck93 = 0 time = 470
.meas tran vdout1_15ck93 FIND v(dout1_15) AT=470.025n

* CHECK dout1_16 Vdout1_16ck93 = 0 time = 470
.meas tran vdout1_16ck93 FIND v(dout1_16) AT=470.025n

* CHECK dout1_17 Vdout1_17ck93 = 0 time = 470
.meas tran vdout1_17ck93 FIND v(dout1_17) AT=470.025n

* CHECK dout1_18 Vdout1_18ck93 = 0 time = 470
.meas tran vdout1_18ck93 FIND v(dout1_18) AT=470.025n

* CHECK dout1_19 Vdout1_19ck93 = 0 time = 470
.meas tran vdout1_19ck93 FIND v(dout1_19) AT=470.025n

* CHECK dout1_20 Vdout1_20ck93 = 0 time = 470
.meas tran vdout1_20ck93 FIND v(dout1_20) AT=470.025n

* CHECK dout1_21 Vdout1_21ck93 = 0.9 time = 470
.meas tran vdout1_21ck93 FIND v(dout1_21) AT=470.025n

* CHECK dout1_22 Vdout1_22ck93 = 0.9 time = 470
.meas tran vdout1_22ck93 FIND v(dout1_22) AT=470.025n

* CHECK dout1_23 Vdout1_23ck93 = 0 time = 470
.meas tran vdout1_23ck93 FIND v(dout1_23) AT=470.025n

* CHECK dout1_24 Vdout1_24ck93 = 0 time = 470
.meas tran vdout1_24ck93 FIND v(dout1_24) AT=470.025n

* CHECK dout1_25 Vdout1_25ck93 = 0 time = 470
.meas tran vdout1_25ck93 FIND v(dout1_25) AT=470.025n

* CHECK dout1_26 Vdout1_26ck93 = 0 time = 470
.meas tran vdout1_26ck93 FIND v(dout1_26) AT=470.025n

* CHECK dout1_27 Vdout1_27ck93 = 0.9 time = 470
.meas tran vdout1_27ck93 FIND v(dout1_27) AT=470.025n

* CHECK dout1_28 Vdout1_28ck93 = 0.9 time = 470
.meas tran vdout1_28ck93 FIND v(dout1_28) AT=470.025n

* CHECK dout1_29 Vdout1_29ck93 = 0.9 time = 470
.meas tran vdout1_29ck93 FIND v(dout1_29) AT=470.025n

* CHECK dout1_30 Vdout1_30ck93 = 0 time = 470
.meas tran vdout1_30ck93 FIND v(dout1_30) AT=470.025n

* CHECK dout1_31 Vdout1_31ck93 = 0 time = 470
.meas tran vdout1_31ck93 FIND v(dout1_31) AT=470.025n

* CHECK dout1_32 Vdout1_32ck93 = 0.9 time = 470
.meas tran vdout1_32ck93 FIND v(dout1_32) AT=470.025n

* CHECK dout1_33 Vdout1_33ck93 = 0.9 time = 470
.meas tran vdout1_33ck93 FIND v(dout1_33) AT=470.025n

* CHECK dout1_34 Vdout1_34ck93 = 0 time = 470
.meas tran vdout1_34ck93 FIND v(dout1_34) AT=470.025n

* CHECK dout1_35 Vdout1_35ck93 = 0.9 time = 470
.meas tran vdout1_35ck93 FIND v(dout1_35) AT=470.025n

* CHECK dout1_36 Vdout1_36ck93 = 0 time = 470
.meas tran vdout1_36ck93 FIND v(dout1_36) AT=470.025n

* CHECK dout1_37 Vdout1_37ck93 = 0.9 time = 470
.meas tran vdout1_37ck93 FIND v(dout1_37) AT=470.025n

* CHECK dout1_38 Vdout1_38ck93 = 0 time = 470
.meas tran vdout1_38ck93 FIND v(dout1_38) AT=470.025n

* CHECK dout1_39 Vdout1_39ck93 = 0 time = 470
.meas tran vdout1_39ck93 FIND v(dout1_39) AT=470.025n

* CHECK dout1_40 Vdout1_40ck93 = 0 time = 470
.meas tran vdout1_40ck93 FIND v(dout1_40) AT=470.025n

* CHECK dout1_41 Vdout1_41ck93 = 0.9 time = 470
.meas tran vdout1_41ck93 FIND v(dout1_41) AT=470.025n

* CHECK dout1_42 Vdout1_42ck93 = 0.9 time = 470
.meas tran vdout1_42ck93 FIND v(dout1_42) AT=470.025n

* CHECK dout1_43 Vdout1_43ck93 = 0.9 time = 470
.meas tran vdout1_43ck93 FIND v(dout1_43) AT=470.025n

* CHECK dout1_44 Vdout1_44ck93 = 0.9 time = 470
.meas tran vdout1_44ck93 FIND v(dout1_44) AT=470.025n

* CHECK dout1_45 Vdout1_45ck93 = 0.9 time = 470
.meas tran vdout1_45ck93 FIND v(dout1_45) AT=470.025n

* CHECK dout1_46 Vdout1_46ck93 = 0.9 time = 470
.meas tran vdout1_46ck93 FIND v(dout1_46) AT=470.025n

* CHECK dout1_47 Vdout1_47ck93 = 0.9 time = 470
.meas tran vdout1_47ck93 FIND v(dout1_47) AT=470.025n

* CHECK dout1_48 Vdout1_48ck93 = 0.9 time = 470
.meas tran vdout1_48ck93 FIND v(dout1_48) AT=470.025n

* CHECK dout1_49 Vdout1_49ck93 = 0 time = 470
.meas tran vdout1_49ck93 FIND v(dout1_49) AT=470.025n

* CHECK dout1_50 Vdout1_50ck93 = 0.9 time = 470
.meas tran vdout1_50ck93 FIND v(dout1_50) AT=470.025n

* CHECK dout1_51 Vdout1_51ck93 = 0 time = 470
.meas tran vdout1_51ck93 FIND v(dout1_51) AT=470.025n

* CHECK dout1_52 Vdout1_52ck93 = 0 time = 470
.meas tran vdout1_52ck93 FIND v(dout1_52) AT=470.025n

* CHECK dout1_53 Vdout1_53ck93 = 0.9 time = 470
.meas tran vdout1_53ck93 FIND v(dout1_53) AT=470.025n

* CHECK dout1_54 Vdout1_54ck93 = 0.9 time = 470
.meas tran vdout1_54ck93 FIND v(dout1_54) AT=470.025n

* CHECK dout1_55 Vdout1_55ck93 = 0 time = 470
.meas tran vdout1_55ck93 FIND v(dout1_55) AT=470.025n

* CHECK dout1_56 Vdout1_56ck93 = 0 time = 470
.meas tran vdout1_56ck93 FIND v(dout1_56) AT=470.025n

* CHECK dout1_57 Vdout1_57ck93 = 0.9 time = 470
.meas tran vdout1_57ck93 FIND v(dout1_57) AT=470.025n

* CHECK dout1_58 Vdout1_58ck93 = 0 time = 470
.meas tran vdout1_58ck93 FIND v(dout1_58) AT=470.025n

* CHECK dout1_59 Vdout1_59ck93 = 0 time = 470
.meas tran vdout1_59ck93 FIND v(dout1_59) AT=470.025n

* CHECK dout1_60 Vdout1_60ck93 = 0 time = 470
.meas tran vdout1_60ck93 FIND v(dout1_60) AT=470.025n

* CHECK dout1_61 Vdout1_61ck93 = 0 time = 470
.meas tran vdout1_61ck93 FIND v(dout1_61) AT=470.025n

* CHECK dout1_62 Vdout1_62ck93 = 0.9 time = 470
.meas tran vdout1_62ck93 FIND v(dout1_62) AT=470.025n

* CHECK dout1_63 Vdout1_63ck93 = 0.9 time = 470
.meas tran vdout1_63ck93 FIND v(dout1_63) AT=470.025n

* CHECK dout1_0 Vdout1_0ck95 = 0.9 time = 480
.meas tran vdout1_0ck95 FIND v(dout1_0) AT=480.025n

* CHECK dout1_1 Vdout1_1ck95 = 0 time = 480
.meas tran vdout1_1ck95 FIND v(dout1_1) AT=480.025n

* CHECK dout1_2 Vdout1_2ck95 = 0.9 time = 480
.meas tran vdout1_2ck95 FIND v(dout1_2) AT=480.025n

* CHECK dout1_3 Vdout1_3ck95 = 0.9 time = 480
.meas tran vdout1_3ck95 FIND v(dout1_3) AT=480.025n

* CHECK dout1_4 Vdout1_4ck95 = 0 time = 480
.meas tran vdout1_4ck95 FIND v(dout1_4) AT=480.025n

* CHECK dout1_5 Vdout1_5ck95 = 0.9 time = 480
.meas tran vdout1_5ck95 FIND v(dout1_5) AT=480.025n

* CHECK dout1_6 Vdout1_6ck95 = 0.9 time = 480
.meas tran vdout1_6ck95 FIND v(dout1_6) AT=480.025n

* CHECK dout1_7 Vdout1_7ck95 = 0.9 time = 480
.meas tran vdout1_7ck95 FIND v(dout1_7) AT=480.025n

* CHECK dout1_8 Vdout1_8ck95 = 0.9 time = 480
.meas tran vdout1_8ck95 FIND v(dout1_8) AT=480.025n

* CHECK dout1_9 Vdout1_9ck95 = 0.9 time = 480
.meas tran vdout1_9ck95 FIND v(dout1_9) AT=480.025n

* CHECK dout1_10 Vdout1_10ck95 = 0.9 time = 480
.meas tran vdout1_10ck95 FIND v(dout1_10) AT=480.025n

* CHECK dout1_11 Vdout1_11ck95 = 0 time = 480
.meas tran vdout1_11ck95 FIND v(dout1_11) AT=480.025n

* CHECK dout1_12 Vdout1_12ck95 = 0 time = 480
.meas tran vdout1_12ck95 FIND v(dout1_12) AT=480.025n

* CHECK dout1_13 Vdout1_13ck95 = 0 time = 480
.meas tran vdout1_13ck95 FIND v(dout1_13) AT=480.025n

* CHECK dout1_14 Vdout1_14ck95 = 0 time = 480
.meas tran vdout1_14ck95 FIND v(dout1_14) AT=480.025n

* CHECK dout1_15 Vdout1_15ck95 = 0 time = 480
.meas tran vdout1_15ck95 FIND v(dout1_15) AT=480.025n

* CHECK dout1_16 Vdout1_16ck95 = 0 time = 480
.meas tran vdout1_16ck95 FIND v(dout1_16) AT=480.025n

* CHECK dout1_17 Vdout1_17ck95 = 0.9 time = 480
.meas tran vdout1_17ck95 FIND v(dout1_17) AT=480.025n

* CHECK dout1_18 Vdout1_18ck95 = 0.9 time = 480
.meas tran vdout1_18ck95 FIND v(dout1_18) AT=480.025n

* CHECK dout1_19 Vdout1_19ck95 = 0 time = 480
.meas tran vdout1_19ck95 FIND v(dout1_19) AT=480.025n

* CHECK dout1_20 Vdout1_20ck95 = 0 time = 480
.meas tran vdout1_20ck95 FIND v(dout1_20) AT=480.025n

* CHECK dout1_21 Vdout1_21ck95 = 0.9 time = 480
.meas tran vdout1_21ck95 FIND v(dout1_21) AT=480.025n

* CHECK dout1_22 Vdout1_22ck95 = 0.9 time = 480
.meas tran vdout1_22ck95 FIND v(dout1_22) AT=480.025n

* CHECK dout1_23 Vdout1_23ck95 = 0 time = 480
.meas tran vdout1_23ck95 FIND v(dout1_23) AT=480.025n

* CHECK dout1_24 Vdout1_24ck95 = 0 time = 480
.meas tran vdout1_24ck95 FIND v(dout1_24) AT=480.025n

* CHECK dout1_25 Vdout1_25ck95 = 0.9 time = 480
.meas tran vdout1_25ck95 FIND v(dout1_25) AT=480.025n

* CHECK dout1_26 Vdout1_26ck95 = 0 time = 480
.meas tran vdout1_26ck95 FIND v(dout1_26) AT=480.025n

* CHECK dout1_27 Vdout1_27ck95 = 0.9 time = 480
.meas tran vdout1_27ck95 FIND v(dout1_27) AT=480.025n

* CHECK dout1_28 Vdout1_28ck95 = 0.9 time = 480
.meas tran vdout1_28ck95 FIND v(dout1_28) AT=480.025n

* CHECK dout1_29 Vdout1_29ck95 = 0 time = 480
.meas tran vdout1_29ck95 FIND v(dout1_29) AT=480.025n

* CHECK dout1_30 Vdout1_30ck95 = 0.9 time = 480
.meas tran vdout1_30ck95 FIND v(dout1_30) AT=480.025n

* CHECK dout1_31 Vdout1_31ck95 = 0.9 time = 480
.meas tran vdout1_31ck95 FIND v(dout1_31) AT=480.025n

* CHECK dout1_32 Vdout1_32ck95 = 0.9 time = 480
.meas tran vdout1_32ck95 FIND v(dout1_32) AT=480.025n

* CHECK dout1_33 Vdout1_33ck95 = 0 time = 480
.meas tran vdout1_33ck95 FIND v(dout1_33) AT=480.025n

* CHECK dout1_34 Vdout1_34ck95 = 0 time = 480
.meas tran vdout1_34ck95 FIND v(dout1_34) AT=480.025n

* CHECK dout1_35 Vdout1_35ck95 = 0 time = 480
.meas tran vdout1_35ck95 FIND v(dout1_35) AT=480.025n

* CHECK dout1_36 Vdout1_36ck95 = 0 time = 480
.meas tran vdout1_36ck95 FIND v(dout1_36) AT=480.025n

* CHECK dout1_37 Vdout1_37ck95 = 0 time = 480
.meas tran vdout1_37ck95 FIND v(dout1_37) AT=480.025n

* CHECK dout1_38 Vdout1_38ck95 = 0 time = 480
.meas tran vdout1_38ck95 FIND v(dout1_38) AT=480.025n

* CHECK dout1_39 Vdout1_39ck95 = 0 time = 480
.meas tran vdout1_39ck95 FIND v(dout1_39) AT=480.025n

* CHECK dout1_40 Vdout1_40ck95 = 0 time = 480
.meas tran vdout1_40ck95 FIND v(dout1_40) AT=480.025n

* CHECK dout1_41 Vdout1_41ck95 = 0 time = 480
.meas tran vdout1_41ck95 FIND v(dout1_41) AT=480.025n

* CHECK dout1_42 Vdout1_42ck95 = 0.9 time = 480
.meas tran vdout1_42ck95 FIND v(dout1_42) AT=480.025n

* CHECK dout1_43 Vdout1_43ck95 = 0.9 time = 480
.meas tran vdout1_43ck95 FIND v(dout1_43) AT=480.025n

* CHECK dout1_44 Vdout1_44ck95 = 0 time = 480
.meas tran vdout1_44ck95 FIND v(dout1_44) AT=480.025n

* CHECK dout1_45 Vdout1_45ck95 = 0.9 time = 480
.meas tran vdout1_45ck95 FIND v(dout1_45) AT=480.025n

* CHECK dout1_46 Vdout1_46ck95 = 0 time = 480
.meas tran vdout1_46ck95 FIND v(dout1_46) AT=480.025n

* CHECK dout1_47 Vdout1_47ck95 = 0 time = 480
.meas tran vdout1_47ck95 FIND v(dout1_47) AT=480.025n

* CHECK dout1_48 Vdout1_48ck95 = 0.9 time = 480
.meas tran vdout1_48ck95 FIND v(dout1_48) AT=480.025n

* CHECK dout1_49 Vdout1_49ck95 = 0 time = 480
.meas tran vdout1_49ck95 FIND v(dout1_49) AT=480.025n

* CHECK dout1_50 Vdout1_50ck95 = 0 time = 480
.meas tran vdout1_50ck95 FIND v(dout1_50) AT=480.025n

* CHECK dout1_51 Vdout1_51ck95 = 0.9 time = 480
.meas tran vdout1_51ck95 FIND v(dout1_51) AT=480.025n

* CHECK dout1_52 Vdout1_52ck95 = 0 time = 480
.meas tran vdout1_52ck95 FIND v(dout1_52) AT=480.025n

* CHECK dout1_53 Vdout1_53ck95 = 0.9 time = 480
.meas tran vdout1_53ck95 FIND v(dout1_53) AT=480.025n

* CHECK dout1_54 Vdout1_54ck95 = 0.9 time = 480
.meas tran vdout1_54ck95 FIND v(dout1_54) AT=480.025n

* CHECK dout1_55 Vdout1_55ck95 = 0 time = 480
.meas tran vdout1_55ck95 FIND v(dout1_55) AT=480.025n

* CHECK dout1_56 Vdout1_56ck95 = 0.9 time = 480
.meas tran vdout1_56ck95 FIND v(dout1_56) AT=480.025n

* CHECK dout1_57 Vdout1_57ck95 = 0.9 time = 480
.meas tran vdout1_57ck95 FIND v(dout1_57) AT=480.025n

* CHECK dout1_58 Vdout1_58ck95 = 0.9 time = 480
.meas tran vdout1_58ck95 FIND v(dout1_58) AT=480.025n

* CHECK dout1_59 Vdout1_59ck95 = 0 time = 480
.meas tran vdout1_59ck95 FIND v(dout1_59) AT=480.025n

* CHECK dout1_60 Vdout1_60ck95 = 0 time = 480
.meas tran vdout1_60ck95 FIND v(dout1_60) AT=480.025n

* CHECK dout1_61 Vdout1_61ck95 = 0.9 time = 480
.meas tran vdout1_61ck95 FIND v(dout1_61) AT=480.025n

* CHECK dout1_62 Vdout1_62ck95 = 0.9 time = 480
.meas tran vdout1_62ck95 FIND v(dout1_62) AT=480.025n

* CHECK dout1_63 Vdout1_63ck95 = 0.9 time = 480
.meas tran vdout1_63ck95 FIND v(dout1_63) AT=480.025n

* CHECK dout1_0 Vdout1_0ck96 = 0.9 time = 485
.meas tran vdout1_0ck96 FIND v(dout1_0) AT=485.025n

* CHECK dout1_1 Vdout1_1ck96 = 0.9 time = 485
.meas tran vdout1_1ck96 FIND v(dout1_1) AT=485.025n

* CHECK dout1_2 Vdout1_2ck96 = 0.9 time = 485
.meas tran vdout1_2ck96 FIND v(dout1_2) AT=485.025n

* CHECK dout1_3 Vdout1_3ck96 = 0.9 time = 485
.meas tran vdout1_3ck96 FIND v(dout1_3) AT=485.025n

* CHECK dout1_4 Vdout1_4ck96 = 0 time = 485
.meas tran vdout1_4ck96 FIND v(dout1_4) AT=485.025n

* CHECK dout1_5 Vdout1_5ck96 = 0.9 time = 485
.meas tran vdout1_5ck96 FIND v(dout1_5) AT=485.025n

* CHECK dout1_6 Vdout1_6ck96 = 0 time = 485
.meas tran vdout1_6ck96 FIND v(dout1_6) AT=485.025n

* CHECK dout1_7 Vdout1_7ck96 = 0.9 time = 485
.meas tran vdout1_7ck96 FIND v(dout1_7) AT=485.025n

* CHECK dout1_8 Vdout1_8ck96 = 0.9 time = 485
.meas tran vdout1_8ck96 FIND v(dout1_8) AT=485.025n

* CHECK dout1_9 Vdout1_9ck96 = 0.9 time = 485
.meas tran vdout1_9ck96 FIND v(dout1_9) AT=485.025n

* CHECK dout1_10 Vdout1_10ck96 = 0 time = 485
.meas tran vdout1_10ck96 FIND v(dout1_10) AT=485.025n

* CHECK dout1_11 Vdout1_11ck96 = 0 time = 485
.meas tran vdout1_11ck96 FIND v(dout1_11) AT=485.025n

* CHECK dout1_12 Vdout1_12ck96 = 0.9 time = 485
.meas tran vdout1_12ck96 FIND v(dout1_12) AT=485.025n

* CHECK dout1_13 Vdout1_13ck96 = 0.9 time = 485
.meas tran vdout1_13ck96 FIND v(dout1_13) AT=485.025n

* CHECK dout1_14 Vdout1_14ck96 = 0 time = 485
.meas tran vdout1_14ck96 FIND v(dout1_14) AT=485.025n

* CHECK dout1_15 Vdout1_15ck96 = 0 time = 485
.meas tran vdout1_15ck96 FIND v(dout1_15) AT=485.025n

* CHECK dout1_16 Vdout1_16ck96 = 0 time = 485
.meas tran vdout1_16ck96 FIND v(dout1_16) AT=485.025n

* CHECK dout1_17 Vdout1_17ck96 = 0.9 time = 485
.meas tran vdout1_17ck96 FIND v(dout1_17) AT=485.025n

* CHECK dout1_18 Vdout1_18ck96 = 0 time = 485
.meas tran vdout1_18ck96 FIND v(dout1_18) AT=485.025n

* CHECK dout1_19 Vdout1_19ck96 = 0 time = 485
.meas tran vdout1_19ck96 FIND v(dout1_19) AT=485.025n

* CHECK dout1_20 Vdout1_20ck96 = 0.9 time = 485
.meas tran vdout1_20ck96 FIND v(dout1_20) AT=485.025n

* CHECK dout1_21 Vdout1_21ck96 = 0 time = 485
.meas tran vdout1_21ck96 FIND v(dout1_21) AT=485.025n

* CHECK dout1_22 Vdout1_22ck96 = 0 time = 485
.meas tran vdout1_22ck96 FIND v(dout1_22) AT=485.025n

* CHECK dout1_23 Vdout1_23ck96 = 0.9 time = 485
.meas tran vdout1_23ck96 FIND v(dout1_23) AT=485.025n

* CHECK dout1_24 Vdout1_24ck96 = 0 time = 485
.meas tran vdout1_24ck96 FIND v(dout1_24) AT=485.025n

* CHECK dout1_25 Vdout1_25ck96 = 0.9 time = 485
.meas tran vdout1_25ck96 FIND v(dout1_25) AT=485.025n

* CHECK dout1_26 Vdout1_26ck96 = 0.9 time = 485
.meas tran vdout1_26ck96 FIND v(dout1_26) AT=485.025n

* CHECK dout1_27 Vdout1_27ck96 = 0 time = 485
.meas tran vdout1_27ck96 FIND v(dout1_27) AT=485.025n

* CHECK dout1_28 Vdout1_28ck96 = 0 time = 485
.meas tran vdout1_28ck96 FIND v(dout1_28) AT=485.025n

* CHECK dout1_29 Vdout1_29ck96 = 0.9 time = 485
.meas tran vdout1_29ck96 FIND v(dout1_29) AT=485.025n

* CHECK dout1_30 Vdout1_30ck96 = 0.9 time = 485
.meas tran vdout1_30ck96 FIND v(dout1_30) AT=485.025n

* CHECK dout1_31 Vdout1_31ck96 = 0 time = 485
.meas tran vdout1_31ck96 FIND v(dout1_31) AT=485.025n

* CHECK dout1_32 Vdout1_32ck96 = 0 time = 485
.meas tran vdout1_32ck96 FIND v(dout1_32) AT=485.025n

* CHECK dout1_33 Vdout1_33ck96 = 0 time = 485
.meas tran vdout1_33ck96 FIND v(dout1_33) AT=485.025n

* CHECK dout1_34 Vdout1_34ck96 = 0 time = 485
.meas tran vdout1_34ck96 FIND v(dout1_34) AT=485.025n

* CHECK dout1_35 Vdout1_35ck96 = 0 time = 485
.meas tran vdout1_35ck96 FIND v(dout1_35) AT=485.025n

* CHECK dout1_36 Vdout1_36ck96 = 0.9 time = 485
.meas tran vdout1_36ck96 FIND v(dout1_36) AT=485.025n

* CHECK dout1_37 Vdout1_37ck96 = 0 time = 485
.meas tran vdout1_37ck96 FIND v(dout1_37) AT=485.025n

* CHECK dout1_38 Vdout1_38ck96 = 0.9 time = 485
.meas tran vdout1_38ck96 FIND v(dout1_38) AT=485.025n

* CHECK dout1_39 Vdout1_39ck96 = 0 time = 485
.meas tran vdout1_39ck96 FIND v(dout1_39) AT=485.025n

* CHECK dout1_40 Vdout1_40ck96 = 0.9 time = 485
.meas tran vdout1_40ck96 FIND v(dout1_40) AT=485.025n

* CHECK dout1_41 Vdout1_41ck96 = 0 time = 485
.meas tran vdout1_41ck96 FIND v(dout1_41) AT=485.025n

* CHECK dout1_42 Vdout1_42ck96 = 0 time = 485
.meas tran vdout1_42ck96 FIND v(dout1_42) AT=485.025n

* CHECK dout1_43 Vdout1_43ck96 = 0.9 time = 485
.meas tran vdout1_43ck96 FIND v(dout1_43) AT=485.025n

* CHECK dout1_44 Vdout1_44ck96 = 0.9 time = 485
.meas tran vdout1_44ck96 FIND v(dout1_44) AT=485.025n

* CHECK dout1_45 Vdout1_45ck96 = 0.9 time = 485
.meas tran vdout1_45ck96 FIND v(dout1_45) AT=485.025n

* CHECK dout1_46 Vdout1_46ck96 = 0.9 time = 485
.meas tran vdout1_46ck96 FIND v(dout1_46) AT=485.025n

* CHECK dout1_47 Vdout1_47ck96 = 0 time = 485
.meas tran vdout1_47ck96 FIND v(dout1_47) AT=485.025n

* CHECK dout1_48 Vdout1_48ck96 = 0.9 time = 485
.meas tran vdout1_48ck96 FIND v(dout1_48) AT=485.025n

* CHECK dout1_49 Vdout1_49ck96 = 0 time = 485
.meas tran vdout1_49ck96 FIND v(dout1_49) AT=485.025n

* CHECK dout1_50 Vdout1_50ck96 = 0 time = 485
.meas tran vdout1_50ck96 FIND v(dout1_50) AT=485.025n

* CHECK dout1_51 Vdout1_51ck96 = 0 time = 485
.meas tran vdout1_51ck96 FIND v(dout1_51) AT=485.025n

* CHECK dout1_52 Vdout1_52ck96 = 0.9 time = 485
.meas tran vdout1_52ck96 FIND v(dout1_52) AT=485.025n

* CHECK dout1_53 Vdout1_53ck96 = 0.9 time = 485
.meas tran vdout1_53ck96 FIND v(dout1_53) AT=485.025n

* CHECK dout1_54 Vdout1_54ck96 = 0.9 time = 485
.meas tran vdout1_54ck96 FIND v(dout1_54) AT=485.025n

* CHECK dout1_55 Vdout1_55ck96 = 0.9 time = 485
.meas tran vdout1_55ck96 FIND v(dout1_55) AT=485.025n

* CHECK dout1_56 Vdout1_56ck96 = 0.9 time = 485
.meas tran vdout1_56ck96 FIND v(dout1_56) AT=485.025n

* CHECK dout1_57 Vdout1_57ck96 = 0 time = 485
.meas tran vdout1_57ck96 FIND v(dout1_57) AT=485.025n

* CHECK dout1_58 Vdout1_58ck96 = 0 time = 485
.meas tran vdout1_58ck96 FIND v(dout1_58) AT=485.025n

* CHECK dout1_59 Vdout1_59ck96 = 0.9 time = 485
.meas tran vdout1_59ck96 FIND v(dout1_59) AT=485.025n

* CHECK dout1_60 Vdout1_60ck96 = 0 time = 485
.meas tran vdout1_60ck96 FIND v(dout1_60) AT=485.025n

* CHECK dout1_61 Vdout1_61ck96 = 0.9 time = 485
.meas tran vdout1_61ck96 FIND v(dout1_61) AT=485.025n

* CHECK dout1_62 Vdout1_62ck96 = 0.9 time = 485
.meas tran vdout1_62ck96 FIND v(dout1_62) AT=485.025n

* CHECK dout1_63 Vdout1_63ck96 = 0 time = 485
.meas tran vdout1_63ck96 FIND v(dout1_63) AT=485.025n

* CHECK dout1_0 Vdout1_0ck101 = 0.9 time = 510
.meas tran vdout1_0ck101 FIND v(dout1_0) AT=510.025n

* CHECK dout1_1 Vdout1_1ck101 = 0.9 time = 510
.meas tran vdout1_1ck101 FIND v(dout1_1) AT=510.025n

* CHECK dout1_2 Vdout1_2ck101 = 0.9 time = 510
.meas tran vdout1_2ck101 FIND v(dout1_2) AT=510.025n

* CHECK dout1_3 Vdout1_3ck101 = 0.9 time = 510
.meas tran vdout1_3ck101 FIND v(dout1_3) AT=510.025n

* CHECK dout1_4 Vdout1_4ck101 = 0 time = 510
.meas tran vdout1_4ck101 FIND v(dout1_4) AT=510.025n

* CHECK dout1_5 Vdout1_5ck101 = 0.9 time = 510
.meas tran vdout1_5ck101 FIND v(dout1_5) AT=510.025n

* CHECK dout1_6 Vdout1_6ck101 = 0 time = 510
.meas tran vdout1_6ck101 FIND v(dout1_6) AT=510.025n

* CHECK dout1_7 Vdout1_7ck101 = 0.9 time = 510
.meas tran vdout1_7ck101 FIND v(dout1_7) AT=510.025n

* CHECK dout1_8 Vdout1_8ck101 = 0.9 time = 510
.meas tran vdout1_8ck101 FIND v(dout1_8) AT=510.025n

* CHECK dout1_9 Vdout1_9ck101 = 0.9 time = 510
.meas tran vdout1_9ck101 FIND v(dout1_9) AT=510.025n

* CHECK dout1_10 Vdout1_10ck101 = 0 time = 510
.meas tran vdout1_10ck101 FIND v(dout1_10) AT=510.025n

* CHECK dout1_11 Vdout1_11ck101 = 0 time = 510
.meas tran vdout1_11ck101 FIND v(dout1_11) AT=510.025n

* CHECK dout1_12 Vdout1_12ck101 = 0.9 time = 510
.meas tran vdout1_12ck101 FIND v(dout1_12) AT=510.025n

* CHECK dout1_13 Vdout1_13ck101 = 0.9 time = 510
.meas tran vdout1_13ck101 FIND v(dout1_13) AT=510.025n

* CHECK dout1_14 Vdout1_14ck101 = 0 time = 510
.meas tran vdout1_14ck101 FIND v(dout1_14) AT=510.025n

* CHECK dout1_15 Vdout1_15ck101 = 0 time = 510
.meas tran vdout1_15ck101 FIND v(dout1_15) AT=510.025n

* CHECK dout1_16 Vdout1_16ck101 = 0 time = 510
.meas tran vdout1_16ck101 FIND v(dout1_16) AT=510.025n

* CHECK dout1_17 Vdout1_17ck101 = 0.9 time = 510
.meas tran vdout1_17ck101 FIND v(dout1_17) AT=510.025n

* CHECK dout1_18 Vdout1_18ck101 = 0 time = 510
.meas tran vdout1_18ck101 FIND v(dout1_18) AT=510.025n

* CHECK dout1_19 Vdout1_19ck101 = 0 time = 510
.meas tran vdout1_19ck101 FIND v(dout1_19) AT=510.025n

* CHECK dout1_20 Vdout1_20ck101 = 0.9 time = 510
.meas tran vdout1_20ck101 FIND v(dout1_20) AT=510.025n

* CHECK dout1_21 Vdout1_21ck101 = 0 time = 510
.meas tran vdout1_21ck101 FIND v(dout1_21) AT=510.025n

* CHECK dout1_22 Vdout1_22ck101 = 0 time = 510
.meas tran vdout1_22ck101 FIND v(dout1_22) AT=510.025n

* CHECK dout1_23 Vdout1_23ck101 = 0.9 time = 510
.meas tran vdout1_23ck101 FIND v(dout1_23) AT=510.025n

* CHECK dout1_24 Vdout1_24ck101 = 0 time = 510
.meas tran vdout1_24ck101 FIND v(dout1_24) AT=510.025n

* CHECK dout1_25 Vdout1_25ck101 = 0.9 time = 510
.meas tran vdout1_25ck101 FIND v(dout1_25) AT=510.025n

* CHECK dout1_26 Vdout1_26ck101 = 0.9 time = 510
.meas tran vdout1_26ck101 FIND v(dout1_26) AT=510.025n

* CHECK dout1_27 Vdout1_27ck101 = 0 time = 510
.meas tran vdout1_27ck101 FIND v(dout1_27) AT=510.025n

* CHECK dout1_28 Vdout1_28ck101 = 0 time = 510
.meas tran vdout1_28ck101 FIND v(dout1_28) AT=510.025n

* CHECK dout1_29 Vdout1_29ck101 = 0.9 time = 510
.meas tran vdout1_29ck101 FIND v(dout1_29) AT=510.025n

* CHECK dout1_30 Vdout1_30ck101 = 0.9 time = 510
.meas tran vdout1_30ck101 FIND v(dout1_30) AT=510.025n

* CHECK dout1_31 Vdout1_31ck101 = 0 time = 510
.meas tran vdout1_31ck101 FIND v(dout1_31) AT=510.025n

* CHECK dout1_32 Vdout1_32ck101 = 0 time = 510
.meas tran vdout1_32ck101 FIND v(dout1_32) AT=510.025n

* CHECK dout1_33 Vdout1_33ck101 = 0 time = 510
.meas tran vdout1_33ck101 FIND v(dout1_33) AT=510.025n

* CHECK dout1_34 Vdout1_34ck101 = 0.9 time = 510
.meas tran vdout1_34ck101 FIND v(dout1_34) AT=510.025n

* CHECK dout1_35 Vdout1_35ck101 = 0.9 time = 510
.meas tran vdout1_35ck101 FIND v(dout1_35) AT=510.025n

* CHECK dout1_36 Vdout1_36ck101 = 0 time = 510
.meas tran vdout1_36ck101 FIND v(dout1_36) AT=510.025n

* CHECK dout1_37 Vdout1_37ck101 = 0.9 time = 510
.meas tran vdout1_37ck101 FIND v(dout1_37) AT=510.025n

* CHECK dout1_38 Vdout1_38ck101 = 0 time = 510
.meas tran vdout1_38ck101 FIND v(dout1_38) AT=510.025n

* CHECK dout1_39 Vdout1_39ck101 = 0.9 time = 510
.meas tran vdout1_39ck101 FIND v(dout1_39) AT=510.025n

* CHECK dout1_40 Vdout1_40ck101 = 0.9 time = 510
.meas tran vdout1_40ck101 FIND v(dout1_40) AT=510.025n

* CHECK dout1_41 Vdout1_41ck101 = 0 time = 510
.meas tran vdout1_41ck101 FIND v(dout1_41) AT=510.025n

* CHECK dout1_42 Vdout1_42ck101 = 0.9 time = 510
.meas tran vdout1_42ck101 FIND v(dout1_42) AT=510.025n

* CHECK dout1_43 Vdout1_43ck101 = 0.9 time = 510
.meas tran vdout1_43ck101 FIND v(dout1_43) AT=510.025n

* CHECK dout1_44 Vdout1_44ck101 = 0 time = 510
.meas tran vdout1_44ck101 FIND v(dout1_44) AT=510.025n

* CHECK dout1_45 Vdout1_45ck101 = 0 time = 510
.meas tran vdout1_45ck101 FIND v(dout1_45) AT=510.025n

* CHECK dout1_46 Vdout1_46ck101 = 0 time = 510
.meas tran vdout1_46ck101 FIND v(dout1_46) AT=510.025n

* CHECK dout1_47 Vdout1_47ck101 = 0.9 time = 510
.meas tran vdout1_47ck101 FIND v(dout1_47) AT=510.025n

* CHECK dout1_48 Vdout1_48ck101 = 0 time = 510
.meas tran vdout1_48ck101 FIND v(dout1_48) AT=510.025n

* CHECK dout1_49 Vdout1_49ck101 = 0.9 time = 510
.meas tran vdout1_49ck101 FIND v(dout1_49) AT=510.025n

* CHECK dout1_50 Vdout1_50ck101 = 0.9 time = 510
.meas tran vdout1_50ck101 FIND v(dout1_50) AT=510.025n

* CHECK dout1_51 Vdout1_51ck101 = 0.9 time = 510
.meas tran vdout1_51ck101 FIND v(dout1_51) AT=510.025n

* CHECK dout1_52 Vdout1_52ck101 = 0 time = 510
.meas tran vdout1_52ck101 FIND v(dout1_52) AT=510.025n

* CHECK dout1_53 Vdout1_53ck101 = 0 time = 510
.meas tran vdout1_53ck101 FIND v(dout1_53) AT=510.025n

* CHECK dout1_54 Vdout1_54ck101 = 0 time = 510
.meas tran vdout1_54ck101 FIND v(dout1_54) AT=510.025n

* CHECK dout1_55 Vdout1_55ck101 = 0.9 time = 510
.meas tran vdout1_55ck101 FIND v(dout1_55) AT=510.025n

* CHECK dout1_56 Vdout1_56ck101 = 0.9 time = 510
.meas tran vdout1_56ck101 FIND v(dout1_56) AT=510.025n

* CHECK dout1_57 Vdout1_57ck101 = 0.9 time = 510
.meas tran vdout1_57ck101 FIND v(dout1_57) AT=510.025n

* CHECK dout1_58 Vdout1_58ck101 = 0.9 time = 510
.meas tran vdout1_58ck101 FIND v(dout1_58) AT=510.025n

* CHECK dout1_59 Vdout1_59ck101 = 0.9 time = 510
.meas tran vdout1_59ck101 FIND v(dout1_59) AT=510.025n

* CHECK dout1_60 Vdout1_60ck101 = 0.9 time = 510
.meas tran vdout1_60ck101 FIND v(dout1_60) AT=510.025n

* CHECK dout1_61 Vdout1_61ck101 = 0 time = 510
.meas tran vdout1_61ck101 FIND v(dout1_61) AT=510.025n

* CHECK dout1_62 Vdout1_62ck101 = 0.9 time = 510
.meas tran vdout1_62ck101 FIND v(dout1_62) AT=510.025n

* CHECK dout1_63 Vdout1_63ck101 = 0 time = 510
.meas tran vdout1_63ck101 FIND v(dout1_63) AT=510.025n

* CHECK dout1_0 Vdout1_0ck103 = 0 time = 520
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=520.025n

* CHECK dout1_1 Vdout1_1ck103 = 0 time = 520
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=520.025n

* CHECK dout1_2 Vdout1_2ck103 = 0 time = 520
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=520.025n

* CHECK dout1_3 Vdout1_3ck103 = 0.9 time = 520
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=520.025n

* CHECK dout1_4 Vdout1_4ck103 = 0.9 time = 520
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=520.025n

* CHECK dout1_5 Vdout1_5ck103 = 0 time = 520
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=520.025n

* CHECK dout1_6 Vdout1_6ck103 = 0 time = 520
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=520.025n

* CHECK dout1_7 Vdout1_7ck103 = 0 time = 520
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=520.025n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 520
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=520.025n

* CHECK dout1_9 Vdout1_9ck103 = 0.9 time = 520
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=520.025n

* CHECK dout1_10 Vdout1_10ck103 = 0 time = 520
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=520.025n

* CHECK dout1_11 Vdout1_11ck103 = 0 time = 520
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=520.025n

* CHECK dout1_12 Vdout1_12ck103 = 0.9 time = 520
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=520.025n

* CHECK dout1_13 Vdout1_13ck103 = 0.9 time = 520
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=520.025n

* CHECK dout1_14 Vdout1_14ck103 = 0 time = 520
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=520.025n

* CHECK dout1_15 Vdout1_15ck103 = 0 time = 520
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=520.025n

* CHECK dout1_16 Vdout1_16ck103 = 0.9 time = 520
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=520.025n

* CHECK dout1_17 Vdout1_17ck103 = 0.9 time = 520
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=520.025n

* CHECK dout1_18 Vdout1_18ck103 = 0 time = 520
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=520.025n

* CHECK dout1_19 Vdout1_19ck103 = 0 time = 520
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=520.025n

* CHECK dout1_20 Vdout1_20ck103 = 0.9 time = 520
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=520.025n

* CHECK dout1_21 Vdout1_21ck103 = 0 time = 520
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=520.025n

* CHECK dout1_22 Vdout1_22ck103 = 0.9 time = 520
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=520.025n

* CHECK dout1_23 Vdout1_23ck103 = 0.9 time = 520
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=520.025n

* CHECK dout1_24 Vdout1_24ck103 = 0 time = 520
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=520.025n

* CHECK dout1_25 Vdout1_25ck103 = 0 time = 520
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=520.025n

* CHECK dout1_26 Vdout1_26ck103 = 0 time = 520
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=520.025n

* CHECK dout1_27 Vdout1_27ck103 = 0.9 time = 520
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=520.025n

* CHECK dout1_28 Vdout1_28ck103 = 0.9 time = 520
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=520.025n

* CHECK dout1_29 Vdout1_29ck103 = 0.9 time = 520
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=520.025n

* CHECK dout1_30 Vdout1_30ck103 = 0 time = 520
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=520.025n

* CHECK dout1_31 Vdout1_31ck103 = 0 time = 520
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=520.025n

* CHECK dout1_32 Vdout1_32ck103 = 0 time = 520
.meas tran vdout1_32ck103 FIND v(dout1_32) AT=520.025n

* CHECK dout1_33 Vdout1_33ck103 = 0 time = 520
.meas tran vdout1_33ck103 FIND v(dout1_33) AT=520.025n

* CHECK dout1_34 Vdout1_34ck103 = 0.9 time = 520
.meas tran vdout1_34ck103 FIND v(dout1_34) AT=520.025n

* CHECK dout1_35 Vdout1_35ck103 = 0 time = 520
.meas tran vdout1_35ck103 FIND v(dout1_35) AT=520.025n

* CHECK dout1_36 Vdout1_36ck103 = 0 time = 520
.meas tran vdout1_36ck103 FIND v(dout1_36) AT=520.025n

* CHECK dout1_37 Vdout1_37ck103 = 0.9 time = 520
.meas tran vdout1_37ck103 FIND v(dout1_37) AT=520.025n

* CHECK dout1_38 Vdout1_38ck103 = 0.9 time = 520
.meas tran vdout1_38ck103 FIND v(dout1_38) AT=520.025n

* CHECK dout1_39 Vdout1_39ck103 = 0 time = 520
.meas tran vdout1_39ck103 FIND v(dout1_39) AT=520.025n

* CHECK dout1_40 Vdout1_40ck103 = 0.9 time = 520
.meas tran vdout1_40ck103 FIND v(dout1_40) AT=520.025n

* CHECK dout1_41 Vdout1_41ck103 = 0.9 time = 520
.meas tran vdout1_41ck103 FIND v(dout1_41) AT=520.025n

* CHECK dout1_42 Vdout1_42ck103 = 0.9 time = 520
.meas tran vdout1_42ck103 FIND v(dout1_42) AT=520.025n

* CHECK dout1_43 Vdout1_43ck103 = 0 time = 520
.meas tran vdout1_43ck103 FIND v(dout1_43) AT=520.025n

* CHECK dout1_44 Vdout1_44ck103 = 0.9 time = 520
.meas tran vdout1_44ck103 FIND v(dout1_44) AT=520.025n

* CHECK dout1_45 Vdout1_45ck103 = 0.9 time = 520
.meas tran vdout1_45ck103 FIND v(dout1_45) AT=520.025n

* CHECK dout1_46 Vdout1_46ck103 = 0.9 time = 520
.meas tran vdout1_46ck103 FIND v(dout1_46) AT=520.025n

* CHECK dout1_47 Vdout1_47ck103 = 0.9 time = 520
.meas tran vdout1_47ck103 FIND v(dout1_47) AT=520.025n

* CHECK dout1_48 Vdout1_48ck103 = 0 time = 520
.meas tran vdout1_48ck103 FIND v(dout1_48) AT=520.025n

* CHECK dout1_49 Vdout1_49ck103 = 0.9 time = 520
.meas tran vdout1_49ck103 FIND v(dout1_49) AT=520.025n

* CHECK dout1_50 Vdout1_50ck103 = 0 time = 520
.meas tran vdout1_50ck103 FIND v(dout1_50) AT=520.025n

* CHECK dout1_51 Vdout1_51ck103 = 0.9 time = 520
.meas tran vdout1_51ck103 FIND v(dout1_51) AT=520.025n

* CHECK dout1_52 Vdout1_52ck103 = 0.9 time = 520
.meas tran vdout1_52ck103 FIND v(dout1_52) AT=520.025n

* CHECK dout1_53 Vdout1_53ck103 = 0.9 time = 520
.meas tran vdout1_53ck103 FIND v(dout1_53) AT=520.025n

* CHECK dout1_54 Vdout1_54ck103 = 0 time = 520
.meas tran vdout1_54ck103 FIND v(dout1_54) AT=520.025n

* CHECK dout1_55 Vdout1_55ck103 = 0 time = 520
.meas tran vdout1_55ck103 FIND v(dout1_55) AT=520.025n

* CHECK dout1_56 Vdout1_56ck103 = 0 time = 520
.meas tran vdout1_56ck103 FIND v(dout1_56) AT=520.025n

* CHECK dout1_57 Vdout1_57ck103 = 0.9 time = 520
.meas tran vdout1_57ck103 FIND v(dout1_57) AT=520.025n

* CHECK dout1_58 Vdout1_58ck103 = 0.9 time = 520
.meas tran vdout1_58ck103 FIND v(dout1_58) AT=520.025n

* CHECK dout1_59 Vdout1_59ck103 = 0 time = 520
.meas tran vdout1_59ck103 FIND v(dout1_59) AT=520.025n

* CHECK dout1_60 Vdout1_60ck103 = 0 time = 520
.meas tran vdout1_60ck103 FIND v(dout1_60) AT=520.025n

* CHECK dout1_61 Vdout1_61ck103 = 0 time = 520
.meas tran vdout1_61ck103 FIND v(dout1_61) AT=520.025n

* CHECK dout1_62 Vdout1_62ck103 = 0.9 time = 520
.meas tran vdout1_62ck103 FIND v(dout1_62) AT=520.025n

* CHECK dout1_63 Vdout1_63ck103 = 0.9 time = 520
.meas tran vdout1_63ck103 FIND v(dout1_63) AT=520.025n

* CHECK dout1_0 Vdout1_0ck107 = 0.9 time = 540
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=540.025n

* CHECK dout1_1 Vdout1_1ck107 = 0.9 time = 540
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=540.025n

* CHECK dout1_2 Vdout1_2ck107 = 0.9 time = 540
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=540.025n

* CHECK dout1_3 Vdout1_3ck107 = 0 time = 540
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=540.025n

* CHECK dout1_4 Vdout1_4ck107 = 0.9 time = 540
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=540.025n

* CHECK dout1_5 Vdout1_5ck107 = 0 time = 540
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=540.025n

* CHECK dout1_6 Vdout1_6ck107 = 0.9 time = 540
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=540.025n

* CHECK dout1_7 Vdout1_7ck107 = 0 time = 540
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=540.025n

* CHECK dout1_8 Vdout1_8ck107 = 0 time = 540
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=540.025n

* CHECK dout1_9 Vdout1_9ck107 = 0.9 time = 540
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=540.025n

* CHECK dout1_10 Vdout1_10ck107 = 0 time = 540
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=540.025n

* CHECK dout1_11 Vdout1_11ck107 = 0 time = 540
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=540.025n

* CHECK dout1_12 Vdout1_12ck107 = 0 time = 540
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=540.025n

* CHECK dout1_13 Vdout1_13ck107 = 0.9 time = 540
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=540.025n

* CHECK dout1_14 Vdout1_14ck107 = 0.9 time = 540
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=540.025n

* CHECK dout1_15 Vdout1_15ck107 = 0.9 time = 540
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=540.025n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 540
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=540.025n

* CHECK dout1_17 Vdout1_17ck107 = 0.9 time = 540
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=540.025n

* CHECK dout1_18 Vdout1_18ck107 = 0.9 time = 540
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=540.025n

* CHECK dout1_19 Vdout1_19ck107 = 0.9 time = 540
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=540.025n

* CHECK dout1_20 Vdout1_20ck107 = 0.9 time = 540
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=540.025n

* CHECK dout1_21 Vdout1_21ck107 = 0.9 time = 540
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=540.025n

* CHECK dout1_22 Vdout1_22ck107 = 0 time = 540
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=540.025n

* CHECK dout1_23 Vdout1_23ck107 = 0.9 time = 540
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=540.025n

* CHECK dout1_24 Vdout1_24ck107 = 0.9 time = 540
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=540.025n

* CHECK dout1_25 Vdout1_25ck107 = 0.9 time = 540
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=540.025n

* CHECK dout1_26 Vdout1_26ck107 = 0 time = 540
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=540.025n

* CHECK dout1_27 Vdout1_27ck107 = 0 time = 540
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=540.025n

* CHECK dout1_28 Vdout1_28ck107 = 0 time = 540
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=540.025n

* CHECK dout1_29 Vdout1_29ck107 = 0.9 time = 540
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=540.025n

* CHECK dout1_30 Vdout1_30ck107 = 0.9 time = 540
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=540.025n

* CHECK dout1_31 Vdout1_31ck107 = 0.9 time = 540
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=540.025n

* CHECK dout1_32 Vdout1_32ck107 = 0 time = 540
.meas tran vdout1_32ck107 FIND v(dout1_32) AT=540.025n

* CHECK dout1_33 Vdout1_33ck107 = 0 time = 540
.meas tran vdout1_33ck107 FIND v(dout1_33) AT=540.025n

* CHECK dout1_34 Vdout1_34ck107 = 0 time = 540
.meas tran vdout1_34ck107 FIND v(dout1_34) AT=540.025n

* CHECK dout1_35 Vdout1_35ck107 = 0 time = 540
.meas tran vdout1_35ck107 FIND v(dout1_35) AT=540.025n

* CHECK dout1_36 Vdout1_36ck107 = 0.9 time = 540
.meas tran vdout1_36ck107 FIND v(dout1_36) AT=540.025n

* CHECK dout1_37 Vdout1_37ck107 = 0 time = 540
.meas tran vdout1_37ck107 FIND v(dout1_37) AT=540.025n

* CHECK dout1_38 Vdout1_38ck107 = 0 time = 540
.meas tran vdout1_38ck107 FIND v(dout1_38) AT=540.025n

* CHECK dout1_39 Vdout1_39ck107 = 0 time = 540
.meas tran vdout1_39ck107 FIND v(dout1_39) AT=540.025n

* CHECK dout1_40 Vdout1_40ck107 = 0.9 time = 540
.meas tran vdout1_40ck107 FIND v(dout1_40) AT=540.025n

* CHECK dout1_41 Vdout1_41ck107 = 0.9 time = 540
.meas tran vdout1_41ck107 FIND v(dout1_41) AT=540.025n

* CHECK dout1_42 Vdout1_42ck107 = 0.9 time = 540
.meas tran vdout1_42ck107 FIND v(dout1_42) AT=540.025n

* CHECK dout1_43 Vdout1_43ck107 = 0 time = 540
.meas tran vdout1_43ck107 FIND v(dout1_43) AT=540.025n

* CHECK dout1_44 Vdout1_44ck107 = 0 time = 540
.meas tran vdout1_44ck107 FIND v(dout1_44) AT=540.025n

* CHECK dout1_45 Vdout1_45ck107 = 0 time = 540
.meas tran vdout1_45ck107 FIND v(dout1_45) AT=540.025n

* CHECK dout1_46 Vdout1_46ck107 = 0 time = 540
.meas tran vdout1_46ck107 FIND v(dout1_46) AT=540.025n

* CHECK dout1_47 Vdout1_47ck107 = 0.9 time = 540
.meas tran vdout1_47ck107 FIND v(dout1_47) AT=540.025n

* CHECK dout1_48 Vdout1_48ck107 = 0 time = 540
.meas tran vdout1_48ck107 FIND v(dout1_48) AT=540.025n

* CHECK dout1_49 Vdout1_49ck107 = 0 time = 540
.meas tran vdout1_49ck107 FIND v(dout1_49) AT=540.025n

* CHECK dout1_50 Vdout1_50ck107 = 0 time = 540
.meas tran vdout1_50ck107 FIND v(dout1_50) AT=540.025n

* CHECK dout1_51 Vdout1_51ck107 = 0.9 time = 540
.meas tran vdout1_51ck107 FIND v(dout1_51) AT=540.025n

* CHECK dout1_52 Vdout1_52ck107 = 0.9 time = 540
.meas tran vdout1_52ck107 FIND v(dout1_52) AT=540.025n

* CHECK dout1_53 Vdout1_53ck107 = 0 time = 540
.meas tran vdout1_53ck107 FIND v(dout1_53) AT=540.025n

* CHECK dout1_54 Vdout1_54ck107 = 0 time = 540
.meas tran vdout1_54ck107 FIND v(dout1_54) AT=540.025n

* CHECK dout1_55 Vdout1_55ck107 = 0 time = 540
.meas tran vdout1_55ck107 FIND v(dout1_55) AT=540.025n

* CHECK dout1_56 Vdout1_56ck107 = 0.9 time = 540
.meas tran vdout1_56ck107 FIND v(dout1_56) AT=540.025n

* CHECK dout1_57 Vdout1_57ck107 = 0 time = 540
.meas tran vdout1_57ck107 FIND v(dout1_57) AT=540.025n

* CHECK dout1_58 Vdout1_58ck107 = 0 time = 540
.meas tran vdout1_58ck107 FIND v(dout1_58) AT=540.025n

* CHECK dout1_59 Vdout1_59ck107 = 0 time = 540
.meas tran vdout1_59ck107 FIND v(dout1_59) AT=540.025n

* CHECK dout1_60 Vdout1_60ck107 = 0.9 time = 540
.meas tran vdout1_60ck107 FIND v(dout1_60) AT=540.025n

* CHECK dout1_61 Vdout1_61ck107 = 0 time = 540
.meas tran vdout1_61ck107 FIND v(dout1_61) AT=540.025n

* CHECK dout1_62 Vdout1_62ck107 = 0 time = 540
.meas tran vdout1_62ck107 FIND v(dout1_62) AT=540.025n

* CHECK dout1_63 Vdout1_63ck107 = 0 time = 540
.meas tran vdout1_63ck107 FIND v(dout1_63) AT=540.025n

* CHECK dout1_0 Vdout1_0ck109 = 0 time = 550
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=550.025n

* CHECK dout1_1 Vdout1_1ck109 = 0.9 time = 550
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=550.025n

* CHECK dout1_2 Vdout1_2ck109 = 0.9 time = 550
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=550.025n

* CHECK dout1_3 Vdout1_3ck109 = 0.9 time = 550
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=550.025n

* CHECK dout1_4 Vdout1_4ck109 = 0 time = 550
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=550.025n

* CHECK dout1_5 Vdout1_5ck109 = 0 time = 550
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=550.025n

* CHECK dout1_6 Vdout1_6ck109 = 0 time = 550
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=550.025n

* CHECK dout1_7 Vdout1_7ck109 = 0.9 time = 550
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=550.025n

* CHECK dout1_8 Vdout1_8ck109 = 0.9 time = 550
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=550.025n

* CHECK dout1_9 Vdout1_9ck109 = 0.9 time = 550
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=550.025n

* CHECK dout1_10 Vdout1_10ck109 = 0.9 time = 550
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=550.025n

* CHECK dout1_11 Vdout1_11ck109 = 0.9 time = 550
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=550.025n

* CHECK dout1_12 Vdout1_12ck109 = 0.9 time = 550
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=550.025n

* CHECK dout1_13 Vdout1_13ck109 = 0 time = 550
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=550.025n

* CHECK dout1_14 Vdout1_14ck109 = 0 time = 550
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=550.025n

* CHECK dout1_15 Vdout1_15ck109 = 0 time = 550
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=550.025n

* CHECK dout1_16 Vdout1_16ck109 = 0.9 time = 550
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=550.025n

* CHECK dout1_17 Vdout1_17ck109 = 0 time = 550
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=550.025n

* CHECK dout1_18 Vdout1_18ck109 = 0.9 time = 550
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=550.025n

* CHECK dout1_19 Vdout1_19ck109 = 0.9 time = 550
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=550.025n

* CHECK dout1_20 Vdout1_20ck109 = 0 time = 550
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=550.025n

* CHECK dout1_21 Vdout1_21ck109 = 0 time = 550
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=550.025n

* CHECK dout1_22 Vdout1_22ck109 = 0 time = 550
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=550.025n

* CHECK dout1_23 Vdout1_23ck109 = 0.9 time = 550
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=550.025n

* CHECK dout1_24 Vdout1_24ck109 = 0 time = 550
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=550.025n

* CHECK dout1_25 Vdout1_25ck109 = 0 time = 550
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=550.025n

* CHECK dout1_26 Vdout1_26ck109 = 0 time = 550
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=550.025n

* CHECK dout1_27 Vdout1_27ck109 = 0 time = 550
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=550.025n

* CHECK dout1_28 Vdout1_28ck109 = 0.9 time = 550
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=550.025n

* CHECK dout1_29 Vdout1_29ck109 = 0 time = 550
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=550.025n

* CHECK dout1_30 Vdout1_30ck109 = 0.9 time = 550
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=550.025n

* CHECK dout1_31 Vdout1_31ck109 = 0.9 time = 550
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=550.025n

* CHECK dout1_32 Vdout1_32ck109 = 0 time = 550
.meas tran vdout1_32ck109 FIND v(dout1_32) AT=550.025n

* CHECK dout1_33 Vdout1_33ck109 = 0 time = 550
.meas tran vdout1_33ck109 FIND v(dout1_33) AT=550.025n

* CHECK dout1_34 Vdout1_34ck109 = 0 time = 550
.meas tran vdout1_34ck109 FIND v(dout1_34) AT=550.025n

* CHECK dout1_35 Vdout1_35ck109 = 0 time = 550
.meas tran vdout1_35ck109 FIND v(dout1_35) AT=550.025n

* CHECK dout1_36 Vdout1_36ck109 = 0.9 time = 550
.meas tran vdout1_36ck109 FIND v(dout1_36) AT=550.025n

* CHECK dout1_37 Vdout1_37ck109 = 0 time = 550
.meas tran vdout1_37ck109 FIND v(dout1_37) AT=550.025n

* CHECK dout1_38 Vdout1_38ck109 = 0 time = 550
.meas tran vdout1_38ck109 FIND v(dout1_38) AT=550.025n

* CHECK dout1_39 Vdout1_39ck109 = 0.9 time = 550
.meas tran vdout1_39ck109 FIND v(dout1_39) AT=550.025n

* CHECK dout1_40 Vdout1_40ck109 = 0 time = 550
.meas tran vdout1_40ck109 FIND v(dout1_40) AT=550.025n

* CHECK dout1_41 Vdout1_41ck109 = 0 time = 550
.meas tran vdout1_41ck109 FIND v(dout1_41) AT=550.025n

* CHECK dout1_42 Vdout1_42ck109 = 0.9 time = 550
.meas tran vdout1_42ck109 FIND v(dout1_42) AT=550.025n

* CHECK dout1_43 Vdout1_43ck109 = 0 time = 550
.meas tran vdout1_43ck109 FIND v(dout1_43) AT=550.025n

* CHECK dout1_44 Vdout1_44ck109 = 0.9 time = 550
.meas tran vdout1_44ck109 FIND v(dout1_44) AT=550.025n

* CHECK dout1_45 Vdout1_45ck109 = 0.9 time = 550
.meas tran vdout1_45ck109 FIND v(dout1_45) AT=550.025n

* CHECK dout1_46 Vdout1_46ck109 = 0.9 time = 550
.meas tran vdout1_46ck109 FIND v(dout1_46) AT=550.025n

* CHECK dout1_47 Vdout1_47ck109 = 0 time = 550
.meas tran vdout1_47ck109 FIND v(dout1_47) AT=550.025n

* CHECK dout1_48 Vdout1_48ck109 = 0 time = 550
.meas tran vdout1_48ck109 FIND v(dout1_48) AT=550.025n

* CHECK dout1_49 Vdout1_49ck109 = 0.9 time = 550
.meas tran vdout1_49ck109 FIND v(dout1_49) AT=550.025n

* CHECK dout1_50 Vdout1_50ck109 = 0 time = 550
.meas tran vdout1_50ck109 FIND v(dout1_50) AT=550.025n

* CHECK dout1_51 Vdout1_51ck109 = 0.9 time = 550
.meas tran vdout1_51ck109 FIND v(dout1_51) AT=550.025n

* CHECK dout1_52 Vdout1_52ck109 = 0 time = 550
.meas tran vdout1_52ck109 FIND v(dout1_52) AT=550.025n

* CHECK dout1_53 Vdout1_53ck109 = 0 time = 550
.meas tran vdout1_53ck109 FIND v(dout1_53) AT=550.025n

* CHECK dout1_54 Vdout1_54ck109 = 0.9 time = 550
.meas tran vdout1_54ck109 FIND v(dout1_54) AT=550.025n

* CHECK dout1_55 Vdout1_55ck109 = 0 time = 550
.meas tran vdout1_55ck109 FIND v(dout1_55) AT=550.025n

* CHECK dout1_56 Vdout1_56ck109 = 0 time = 550
.meas tran vdout1_56ck109 FIND v(dout1_56) AT=550.025n

* CHECK dout1_57 Vdout1_57ck109 = 0.9 time = 550
.meas tran vdout1_57ck109 FIND v(dout1_57) AT=550.025n

* CHECK dout1_58 Vdout1_58ck109 = 0 time = 550
.meas tran vdout1_58ck109 FIND v(dout1_58) AT=550.025n

* CHECK dout1_59 Vdout1_59ck109 = 0.9 time = 550
.meas tran vdout1_59ck109 FIND v(dout1_59) AT=550.025n

* CHECK dout1_60 Vdout1_60ck109 = 0.9 time = 550
.meas tran vdout1_60ck109 FIND v(dout1_60) AT=550.025n

* CHECK dout1_61 Vdout1_61ck109 = 0 time = 550
.meas tran vdout1_61ck109 FIND v(dout1_61) AT=550.025n

* CHECK dout1_62 Vdout1_62ck109 = 0.9 time = 550
.meas tran vdout1_62ck109 FIND v(dout1_62) AT=550.025n

* CHECK dout1_63 Vdout1_63ck109 = 0.9 time = 550
.meas tran vdout1_63ck109 FIND v(dout1_63) AT=550.025n

* CHECK dout1_0 Vdout1_0ck110 = 0 time = 555
.meas tran vdout1_0ck110 FIND v(dout1_0) AT=555.025n

* CHECK dout1_1 Vdout1_1ck110 = 0.9 time = 555
.meas tran vdout1_1ck110 FIND v(dout1_1) AT=555.025n

* CHECK dout1_2 Vdout1_2ck110 = 0.9 time = 555
.meas tran vdout1_2ck110 FIND v(dout1_2) AT=555.025n

* CHECK dout1_3 Vdout1_3ck110 = 0.9 time = 555
.meas tran vdout1_3ck110 FIND v(dout1_3) AT=555.025n

* CHECK dout1_4 Vdout1_4ck110 = 0 time = 555
.meas tran vdout1_4ck110 FIND v(dout1_4) AT=555.025n

* CHECK dout1_5 Vdout1_5ck110 = 0 time = 555
.meas tran vdout1_5ck110 FIND v(dout1_5) AT=555.025n

* CHECK dout1_6 Vdout1_6ck110 = 0 time = 555
.meas tran vdout1_6ck110 FIND v(dout1_6) AT=555.025n

* CHECK dout1_7 Vdout1_7ck110 = 0.9 time = 555
.meas tran vdout1_7ck110 FIND v(dout1_7) AT=555.025n

* CHECK dout1_8 Vdout1_8ck110 = 0.9 time = 555
.meas tran vdout1_8ck110 FIND v(dout1_8) AT=555.025n

* CHECK dout1_9 Vdout1_9ck110 = 0.9 time = 555
.meas tran vdout1_9ck110 FIND v(dout1_9) AT=555.025n

* CHECK dout1_10 Vdout1_10ck110 = 0.9 time = 555
.meas tran vdout1_10ck110 FIND v(dout1_10) AT=555.025n

* CHECK dout1_11 Vdout1_11ck110 = 0.9 time = 555
.meas tran vdout1_11ck110 FIND v(dout1_11) AT=555.025n

* CHECK dout1_12 Vdout1_12ck110 = 0.9 time = 555
.meas tran vdout1_12ck110 FIND v(dout1_12) AT=555.025n

* CHECK dout1_13 Vdout1_13ck110 = 0 time = 555
.meas tran vdout1_13ck110 FIND v(dout1_13) AT=555.025n

* CHECK dout1_14 Vdout1_14ck110 = 0 time = 555
.meas tran vdout1_14ck110 FIND v(dout1_14) AT=555.025n

* CHECK dout1_15 Vdout1_15ck110 = 0 time = 555
.meas tran vdout1_15ck110 FIND v(dout1_15) AT=555.025n

* CHECK dout1_16 Vdout1_16ck110 = 0.9 time = 555
.meas tran vdout1_16ck110 FIND v(dout1_16) AT=555.025n

* CHECK dout1_17 Vdout1_17ck110 = 0 time = 555
.meas tran vdout1_17ck110 FIND v(dout1_17) AT=555.025n

* CHECK dout1_18 Vdout1_18ck110 = 0.9 time = 555
.meas tran vdout1_18ck110 FIND v(dout1_18) AT=555.025n

* CHECK dout1_19 Vdout1_19ck110 = 0.9 time = 555
.meas tran vdout1_19ck110 FIND v(dout1_19) AT=555.025n

* CHECK dout1_20 Vdout1_20ck110 = 0 time = 555
.meas tran vdout1_20ck110 FIND v(dout1_20) AT=555.025n

* CHECK dout1_21 Vdout1_21ck110 = 0 time = 555
.meas tran vdout1_21ck110 FIND v(dout1_21) AT=555.025n

* CHECK dout1_22 Vdout1_22ck110 = 0 time = 555
.meas tran vdout1_22ck110 FIND v(dout1_22) AT=555.025n

* CHECK dout1_23 Vdout1_23ck110 = 0.9 time = 555
.meas tran vdout1_23ck110 FIND v(dout1_23) AT=555.025n

* CHECK dout1_24 Vdout1_24ck110 = 0 time = 555
.meas tran vdout1_24ck110 FIND v(dout1_24) AT=555.025n

* CHECK dout1_25 Vdout1_25ck110 = 0 time = 555
.meas tran vdout1_25ck110 FIND v(dout1_25) AT=555.025n

* CHECK dout1_26 Vdout1_26ck110 = 0 time = 555
.meas tran vdout1_26ck110 FIND v(dout1_26) AT=555.025n

* CHECK dout1_27 Vdout1_27ck110 = 0 time = 555
.meas tran vdout1_27ck110 FIND v(dout1_27) AT=555.025n

* CHECK dout1_28 Vdout1_28ck110 = 0.9 time = 555
.meas tran vdout1_28ck110 FIND v(dout1_28) AT=555.025n

* CHECK dout1_29 Vdout1_29ck110 = 0 time = 555
.meas tran vdout1_29ck110 FIND v(dout1_29) AT=555.025n

* CHECK dout1_30 Vdout1_30ck110 = 0.9 time = 555
.meas tran vdout1_30ck110 FIND v(dout1_30) AT=555.025n

* CHECK dout1_31 Vdout1_31ck110 = 0.9 time = 555
.meas tran vdout1_31ck110 FIND v(dout1_31) AT=555.025n

* CHECK dout1_32 Vdout1_32ck110 = 0 time = 555
.meas tran vdout1_32ck110 FIND v(dout1_32) AT=555.025n

* CHECK dout1_33 Vdout1_33ck110 = 0 time = 555
.meas tran vdout1_33ck110 FIND v(dout1_33) AT=555.025n

* CHECK dout1_34 Vdout1_34ck110 = 0 time = 555
.meas tran vdout1_34ck110 FIND v(dout1_34) AT=555.025n

* CHECK dout1_35 Vdout1_35ck110 = 0 time = 555
.meas tran vdout1_35ck110 FIND v(dout1_35) AT=555.025n

* CHECK dout1_36 Vdout1_36ck110 = 0.9 time = 555
.meas tran vdout1_36ck110 FIND v(dout1_36) AT=555.025n

* CHECK dout1_37 Vdout1_37ck110 = 0 time = 555
.meas tran vdout1_37ck110 FIND v(dout1_37) AT=555.025n

* CHECK dout1_38 Vdout1_38ck110 = 0 time = 555
.meas tran vdout1_38ck110 FIND v(dout1_38) AT=555.025n

* CHECK dout1_39 Vdout1_39ck110 = 0.9 time = 555
.meas tran vdout1_39ck110 FIND v(dout1_39) AT=555.025n

* CHECK dout1_40 Vdout1_40ck110 = 0 time = 555
.meas tran vdout1_40ck110 FIND v(dout1_40) AT=555.025n

* CHECK dout1_41 Vdout1_41ck110 = 0 time = 555
.meas tran vdout1_41ck110 FIND v(dout1_41) AT=555.025n

* CHECK dout1_42 Vdout1_42ck110 = 0.9 time = 555
.meas tran vdout1_42ck110 FIND v(dout1_42) AT=555.025n

* CHECK dout1_43 Vdout1_43ck110 = 0 time = 555
.meas tran vdout1_43ck110 FIND v(dout1_43) AT=555.025n

* CHECK dout1_44 Vdout1_44ck110 = 0.9 time = 555
.meas tran vdout1_44ck110 FIND v(dout1_44) AT=555.025n

* CHECK dout1_45 Vdout1_45ck110 = 0.9 time = 555
.meas tran vdout1_45ck110 FIND v(dout1_45) AT=555.025n

* CHECK dout1_46 Vdout1_46ck110 = 0.9 time = 555
.meas tran vdout1_46ck110 FIND v(dout1_46) AT=555.025n

* CHECK dout1_47 Vdout1_47ck110 = 0 time = 555
.meas tran vdout1_47ck110 FIND v(dout1_47) AT=555.025n

* CHECK dout1_48 Vdout1_48ck110 = 0 time = 555
.meas tran vdout1_48ck110 FIND v(dout1_48) AT=555.025n

* CHECK dout1_49 Vdout1_49ck110 = 0.9 time = 555
.meas tran vdout1_49ck110 FIND v(dout1_49) AT=555.025n

* CHECK dout1_50 Vdout1_50ck110 = 0 time = 555
.meas tran vdout1_50ck110 FIND v(dout1_50) AT=555.025n

* CHECK dout1_51 Vdout1_51ck110 = 0.9 time = 555
.meas tran vdout1_51ck110 FIND v(dout1_51) AT=555.025n

* CHECK dout1_52 Vdout1_52ck110 = 0 time = 555
.meas tran vdout1_52ck110 FIND v(dout1_52) AT=555.025n

* CHECK dout1_53 Vdout1_53ck110 = 0 time = 555
.meas tran vdout1_53ck110 FIND v(dout1_53) AT=555.025n

* CHECK dout1_54 Vdout1_54ck110 = 0.9 time = 555
.meas tran vdout1_54ck110 FIND v(dout1_54) AT=555.025n

* CHECK dout1_55 Vdout1_55ck110 = 0 time = 555
.meas tran vdout1_55ck110 FIND v(dout1_55) AT=555.025n

* CHECK dout1_56 Vdout1_56ck110 = 0 time = 555
.meas tran vdout1_56ck110 FIND v(dout1_56) AT=555.025n

* CHECK dout1_57 Vdout1_57ck110 = 0.9 time = 555
.meas tran vdout1_57ck110 FIND v(dout1_57) AT=555.025n

* CHECK dout1_58 Vdout1_58ck110 = 0 time = 555
.meas tran vdout1_58ck110 FIND v(dout1_58) AT=555.025n

* CHECK dout1_59 Vdout1_59ck110 = 0.9 time = 555
.meas tran vdout1_59ck110 FIND v(dout1_59) AT=555.025n

* CHECK dout1_60 Vdout1_60ck110 = 0.9 time = 555
.meas tran vdout1_60ck110 FIND v(dout1_60) AT=555.025n

* CHECK dout1_61 Vdout1_61ck110 = 0 time = 555
.meas tran vdout1_61ck110 FIND v(dout1_61) AT=555.025n

* CHECK dout1_62 Vdout1_62ck110 = 0.9 time = 555
.meas tran vdout1_62ck110 FIND v(dout1_62) AT=555.025n

* CHECK dout1_63 Vdout1_63ck110 = 0.9 time = 555
.meas tran vdout1_63ck110 FIND v(dout1_63) AT=555.025n

* CHECK dout1_0 Vdout1_0ck111 = 0.9 time = 560
.meas tran vdout1_0ck111 FIND v(dout1_0) AT=560.025n

* CHECK dout1_1 Vdout1_1ck111 = 0 time = 560
.meas tran vdout1_1ck111 FIND v(dout1_1) AT=560.025n

* CHECK dout1_2 Vdout1_2ck111 = 0 time = 560
.meas tran vdout1_2ck111 FIND v(dout1_2) AT=560.025n

* CHECK dout1_3 Vdout1_3ck111 = 0.9 time = 560
.meas tran vdout1_3ck111 FIND v(dout1_3) AT=560.025n

* CHECK dout1_4 Vdout1_4ck111 = 0.9 time = 560
.meas tran vdout1_4ck111 FIND v(dout1_4) AT=560.025n

* CHECK dout1_5 Vdout1_5ck111 = 0 time = 560
.meas tran vdout1_5ck111 FIND v(dout1_5) AT=560.025n

* CHECK dout1_6 Vdout1_6ck111 = 0.9 time = 560
.meas tran vdout1_6ck111 FIND v(dout1_6) AT=560.025n

* CHECK dout1_7 Vdout1_7ck111 = 0 time = 560
.meas tran vdout1_7ck111 FIND v(dout1_7) AT=560.025n

* CHECK dout1_8 Vdout1_8ck111 = 0.9 time = 560
.meas tran vdout1_8ck111 FIND v(dout1_8) AT=560.025n

* CHECK dout1_9 Vdout1_9ck111 = 0 time = 560
.meas tran vdout1_9ck111 FIND v(dout1_9) AT=560.025n

* CHECK dout1_10 Vdout1_10ck111 = 0 time = 560
.meas tran vdout1_10ck111 FIND v(dout1_10) AT=560.025n

* CHECK dout1_11 Vdout1_11ck111 = 0.9 time = 560
.meas tran vdout1_11ck111 FIND v(dout1_11) AT=560.025n

* CHECK dout1_12 Vdout1_12ck111 = 0.9 time = 560
.meas tran vdout1_12ck111 FIND v(dout1_12) AT=560.025n

* CHECK dout1_13 Vdout1_13ck111 = 0 time = 560
.meas tran vdout1_13ck111 FIND v(dout1_13) AT=560.025n

* CHECK dout1_14 Vdout1_14ck111 = 0.9 time = 560
.meas tran vdout1_14ck111 FIND v(dout1_14) AT=560.025n

* CHECK dout1_15 Vdout1_15ck111 = 0.9 time = 560
.meas tran vdout1_15ck111 FIND v(dout1_15) AT=560.025n

* CHECK dout1_16 Vdout1_16ck111 = 0 time = 560
.meas tran vdout1_16ck111 FIND v(dout1_16) AT=560.025n

* CHECK dout1_17 Vdout1_17ck111 = 0 time = 560
.meas tran vdout1_17ck111 FIND v(dout1_17) AT=560.025n

* CHECK dout1_18 Vdout1_18ck111 = 0 time = 560
.meas tran vdout1_18ck111 FIND v(dout1_18) AT=560.025n

* CHECK dout1_19 Vdout1_19ck111 = 0 time = 560
.meas tran vdout1_19ck111 FIND v(dout1_19) AT=560.025n

* CHECK dout1_20 Vdout1_20ck111 = 0.9 time = 560
.meas tran vdout1_20ck111 FIND v(dout1_20) AT=560.025n

* CHECK dout1_21 Vdout1_21ck111 = 0.9 time = 560
.meas tran vdout1_21ck111 FIND v(dout1_21) AT=560.025n

* CHECK dout1_22 Vdout1_22ck111 = 0.9 time = 560
.meas tran vdout1_22ck111 FIND v(dout1_22) AT=560.025n

* CHECK dout1_23 Vdout1_23ck111 = 0 time = 560
.meas tran vdout1_23ck111 FIND v(dout1_23) AT=560.025n

* CHECK dout1_24 Vdout1_24ck111 = 0 time = 560
.meas tran vdout1_24ck111 FIND v(dout1_24) AT=560.025n

* CHECK dout1_25 Vdout1_25ck111 = 0 time = 560
.meas tran vdout1_25ck111 FIND v(dout1_25) AT=560.025n

* CHECK dout1_26 Vdout1_26ck111 = 0.9 time = 560
.meas tran vdout1_26ck111 FIND v(dout1_26) AT=560.025n

* CHECK dout1_27 Vdout1_27ck111 = 0.9 time = 560
.meas tran vdout1_27ck111 FIND v(dout1_27) AT=560.025n

* CHECK dout1_28 Vdout1_28ck111 = 0.9 time = 560
.meas tran vdout1_28ck111 FIND v(dout1_28) AT=560.025n

* CHECK dout1_29 Vdout1_29ck111 = 0 time = 560
.meas tran vdout1_29ck111 FIND v(dout1_29) AT=560.025n

* CHECK dout1_30 Vdout1_30ck111 = 0.9 time = 560
.meas tran vdout1_30ck111 FIND v(dout1_30) AT=560.025n

* CHECK dout1_31 Vdout1_31ck111 = 0.9 time = 560
.meas tran vdout1_31ck111 FIND v(dout1_31) AT=560.025n

* CHECK dout1_32 Vdout1_32ck111 = 0.9 time = 560
.meas tran vdout1_32ck111 FIND v(dout1_32) AT=560.025n

* CHECK dout1_33 Vdout1_33ck111 = 0 time = 560
.meas tran vdout1_33ck111 FIND v(dout1_33) AT=560.025n

* CHECK dout1_34 Vdout1_34ck111 = 0 time = 560
.meas tran vdout1_34ck111 FIND v(dout1_34) AT=560.025n

* CHECK dout1_35 Vdout1_35ck111 = 0 time = 560
.meas tran vdout1_35ck111 FIND v(dout1_35) AT=560.025n

* CHECK dout1_36 Vdout1_36ck111 = 0 time = 560
.meas tran vdout1_36ck111 FIND v(dout1_36) AT=560.025n

* CHECK dout1_37 Vdout1_37ck111 = 0.9 time = 560
.meas tran vdout1_37ck111 FIND v(dout1_37) AT=560.025n

* CHECK dout1_38 Vdout1_38ck111 = 0.9 time = 560
.meas tran vdout1_38ck111 FIND v(dout1_38) AT=560.025n

* CHECK dout1_39 Vdout1_39ck111 = 0.9 time = 560
.meas tran vdout1_39ck111 FIND v(dout1_39) AT=560.025n

* CHECK dout1_40 Vdout1_40ck111 = 0 time = 560
.meas tran vdout1_40ck111 FIND v(dout1_40) AT=560.025n

* CHECK dout1_41 Vdout1_41ck111 = 0 time = 560
.meas tran vdout1_41ck111 FIND v(dout1_41) AT=560.025n

* CHECK dout1_42 Vdout1_42ck111 = 0 time = 560
.meas tran vdout1_42ck111 FIND v(dout1_42) AT=560.025n

* CHECK dout1_43 Vdout1_43ck111 = 0 time = 560
.meas tran vdout1_43ck111 FIND v(dout1_43) AT=560.025n

* CHECK dout1_44 Vdout1_44ck111 = 0 time = 560
.meas tran vdout1_44ck111 FIND v(dout1_44) AT=560.025n

* CHECK dout1_45 Vdout1_45ck111 = 0 time = 560
.meas tran vdout1_45ck111 FIND v(dout1_45) AT=560.025n

* CHECK dout1_46 Vdout1_46ck111 = 0.9 time = 560
.meas tran vdout1_46ck111 FIND v(dout1_46) AT=560.025n

* CHECK dout1_47 Vdout1_47ck111 = 0.9 time = 560
.meas tran vdout1_47ck111 FIND v(dout1_47) AT=560.025n

* CHECK dout1_48 Vdout1_48ck111 = 0.9 time = 560
.meas tran vdout1_48ck111 FIND v(dout1_48) AT=560.025n

* CHECK dout1_49 Vdout1_49ck111 = 0 time = 560
.meas tran vdout1_49ck111 FIND v(dout1_49) AT=560.025n

* CHECK dout1_50 Vdout1_50ck111 = 0 time = 560
.meas tran vdout1_50ck111 FIND v(dout1_50) AT=560.025n

* CHECK dout1_51 Vdout1_51ck111 = 0.9 time = 560
.meas tran vdout1_51ck111 FIND v(dout1_51) AT=560.025n

* CHECK dout1_52 Vdout1_52ck111 = 0.9 time = 560
.meas tran vdout1_52ck111 FIND v(dout1_52) AT=560.025n

* CHECK dout1_53 Vdout1_53ck111 = 0 time = 560
.meas tran vdout1_53ck111 FIND v(dout1_53) AT=560.025n

* CHECK dout1_54 Vdout1_54ck111 = 0 time = 560
.meas tran vdout1_54ck111 FIND v(dout1_54) AT=560.025n

* CHECK dout1_55 Vdout1_55ck111 = 0.9 time = 560
.meas tran vdout1_55ck111 FIND v(dout1_55) AT=560.025n

* CHECK dout1_56 Vdout1_56ck111 = 0.9 time = 560
.meas tran vdout1_56ck111 FIND v(dout1_56) AT=560.025n

* CHECK dout1_57 Vdout1_57ck111 = 0 time = 560
.meas tran vdout1_57ck111 FIND v(dout1_57) AT=560.025n

* CHECK dout1_58 Vdout1_58ck111 = 0.9 time = 560
.meas tran vdout1_58ck111 FIND v(dout1_58) AT=560.025n

* CHECK dout1_59 Vdout1_59ck111 = 0 time = 560
.meas tran vdout1_59ck111 FIND v(dout1_59) AT=560.025n

* CHECK dout1_60 Vdout1_60ck111 = 0.9 time = 560
.meas tran vdout1_60ck111 FIND v(dout1_60) AT=560.025n

* CHECK dout1_61 Vdout1_61ck111 = 0 time = 560
.meas tran vdout1_61ck111 FIND v(dout1_61) AT=560.025n

* CHECK dout1_62 Vdout1_62ck111 = 0.9 time = 560
.meas tran vdout1_62ck111 FIND v(dout1_62) AT=560.025n

* CHECK dout1_63 Vdout1_63ck111 = 0.9 time = 560
.meas tran vdout1_63ck111 FIND v(dout1_63) AT=560.025n

* CHECK dout1_0 Vdout1_0ck118 = 0 time = 595
.meas tran vdout1_0ck118 FIND v(dout1_0) AT=595.025n

* CHECK dout1_1 Vdout1_1ck118 = 0.9 time = 595
.meas tran vdout1_1ck118 FIND v(dout1_1) AT=595.025n

* CHECK dout1_2 Vdout1_2ck118 = 0 time = 595
.meas tran vdout1_2ck118 FIND v(dout1_2) AT=595.025n

* CHECK dout1_3 Vdout1_3ck118 = 0 time = 595
.meas tran vdout1_3ck118 FIND v(dout1_3) AT=595.025n

* CHECK dout1_4 Vdout1_4ck118 = 0 time = 595
.meas tran vdout1_4ck118 FIND v(dout1_4) AT=595.025n

* CHECK dout1_5 Vdout1_5ck118 = 0 time = 595
.meas tran vdout1_5ck118 FIND v(dout1_5) AT=595.025n

* CHECK dout1_6 Vdout1_6ck118 = 0 time = 595
.meas tran vdout1_6ck118 FIND v(dout1_6) AT=595.025n

* CHECK dout1_7 Vdout1_7ck118 = 0.9 time = 595
.meas tran vdout1_7ck118 FIND v(dout1_7) AT=595.025n

* CHECK dout1_8 Vdout1_8ck118 = 0 time = 595
.meas tran vdout1_8ck118 FIND v(dout1_8) AT=595.025n

* CHECK dout1_9 Vdout1_9ck118 = 0.9 time = 595
.meas tran vdout1_9ck118 FIND v(dout1_9) AT=595.025n

* CHECK dout1_10 Vdout1_10ck118 = 0 time = 595
.meas tran vdout1_10ck118 FIND v(dout1_10) AT=595.025n

* CHECK dout1_11 Vdout1_11ck118 = 0.9 time = 595
.meas tran vdout1_11ck118 FIND v(dout1_11) AT=595.025n

* CHECK dout1_12 Vdout1_12ck118 = 0 time = 595
.meas tran vdout1_12ck118 FIND v(dout1_12) AT=595.025n

* CHECK dout1_13 Vdout1_13ck118 = 0 time = 595
.meas tran vdout1_13ck118 FIND v(dout1_13) AT=595.025n

* CHECK dout1_14 Vdout1_14ck118 = 0.9 time = 595
.meas tran vdout1_14ck118 FIND v(dout1_14) AT=595.025n

* CHECK dout1_15 Vdout1_15ck118 = 0 time = 595
.meas tran vdout1_15ck118 FIND v(dout1_15) AT=595.025n

* CHECK dout1_16 Vdout1_16ck118 = 0 time = 595
.meas tran vdout1_16ck118 FIND v(dout1_16) AT=595.025n

* CHECK dout1_17 Vdout1_17ck118 = 0 time = 595
.meas tran vdout1_17ck118 FIND v(dout1_17) AT=595.025n

* CHECK dout1_18 Vdout1_18ck118 = 0 time = 595
.meas tran vdout1_18ck118 FIND v(dout1_18) AT=595.025n

* CHECK dout1_19 Vdout1_19ck118 = 0.9 time = 595
.meas tran vdout1_19ck118 FIND v(dout1_19) AT=595.025n

* CHECK dout1_20 Vdout1_20ck118 = 0.9 time = 595
.meas tran vdout1_20ck118 FIND v(dout1_20) AT=595.025n

* CHECK dout1_21 Vdout1_21ck118 = 0 time = 595
.meas tran vdout1_21ck118 FIND v(dout1_21) AT=595.025n

* CHECK dout1_22 Vdout1_22ck118 = 0.9 time = 595
.meas tran vdout1_22ck118 FIND v(dout1_22) AT=595.025n

* CHECK dout1_23 Vdout1_23ck118 = 0.9 time = 595
.meas tran vdout1_23ck118 FIND v(dout1_23) AT=595.025n

* CHECK dout1_24 Vdout1_24ck118 = 0.9 time = 595
.meas tran vdout1_24ck118 FIND v(dout1_24) AT=595.025n

* CHECK dout1_25 Vdout1_25ck118 = 0 time = 595
.meas tran vdout1_25ck118 FIND v(dout1_25) AT=595.025n

* CHECK dout1_26 Vdout1_26ck118 = 0 time = 595
.meas tran vdout1_26ck118 FIND v(dout1_26) AT=595.025n

* CHECK dout1_27 Vdout1_27ck118 = 0 time = 595
.meas tran vdout1_27ck118 FIND v(dout1_27) AT=595.025n

* CHECK dout1_28 Vdout1_28ck118 = 0 time = 595
.meas tran vdout1_28ck118 FIND v(dout1_28) AT=595.025n

* CHECK dout1_29 Vdout1_29ck118 = 0 time = 595
.meas tran vdout1_29ck118 FIND v(dout1_29) AT=595.025n

* CHECK dout1_30 Vdout1_30ck118 = 0.9 time = 595
.meas tran vdout1_30ck118 FIND v(dout1_30) AT=595.025n

* CHECK dout1_31 Vdout1_31ck118 = 0 time = 595
.meas tran vdout1_31ck118 FIND v(dout1_31) AT=595.025n

* CHECK dout1_32 Vdout1_32ck118 = 0.9 time = 595
.meas tran vdout1_32ck118 FIND v(dout1_32) AT=595.025n

* CHECK dout1_33 Vdout1_33ck118 = 0 time = 595
.meas tran vdout1_33ck118 FIND v(dout1_33) AT=595.025n

* CHECK dout1_34 Vdout1_34ck118 = 0 time = 595
.meas tran vdout1_34ck118 FIND v(dout1_34) AT=595.025n

* CHECK dout1_35 Vdout1_35ck118 = 0 time = 595
.meas tran vdout1_35ck118 FIND v(dout1_35) AT=595.025n

* CHECK dout1_36 Vdout1_36ck118 = 0 time = 595
.meas tran vdout1_36ck118 FIND v(dout1_36) AT=595.025n

* CHECK dout1_37 Vdout1_37ck118 = 0.9 time = 595
.meas tran vdout1_37ck118 FIND v(dout1_37) AT=595.025n

* CHECK dout1_38 Vdout1_38ck118 = 0.9 time = 595
.meas tran vdout1_38ck118 FIND v(dout1_38) AT=595.025n

* CHECK dout1_39 Vdout1_39ck118 = 0.9 time = 595
.meas tran vdout1_39ck118 FIND v(dout1_39) AT=595.025n

* CHECK dout1_40 Vdout1_40ck118 = 0 time = 595
.meas tran vdout1_40ck118 FIND v(dout1_40) AT=595.025n

* CHECK dout1_41 Vdout1_41ck118 = 0 time = 595
.meas tran vdout1_41ck118 FIND v(dout1_41) AT=595.025n

* CHECK dout1_42 Vdout1_42ck118 = 0 time = 595
.meas tran vdout1_42ck118 FIND v(dout1_42) AT=595.025n

* CHECK dout1_43 Vdout1_43ck118 = 0 time = 595
.meas tran vdout1_43ck118 FIND v(dout1_43) AT=595.025n

* CHECK dout1_44 Vdout1_44ck118 = 0 time = 595
.meas tran vdout1_44ck118 FIND v(dout1_44) AT=595.025n

* CHECK dout1_45 Vdout1_45ck118 = 0 time = 595
.meas tran vdout1_45ck118 FIND v(dout1_45) AT=595.025n

* CHECK dout1_46 Vdout1_46ck118 = 0.9 time = 595
.meas tran vdout1_46ck118 FIND v(dout1_46) AT=595.025n

* CHECK dout1_47 Vdout1_47ck118 = 0.9 time = 595
.meas tran vdout1_47ck118 FIND v(dout1_47) AT=595.025n

* CHECK dout1_48 Vdout1_48ck118 = 0.9 time = 595
.meas tran vdout1_48ck118 FIND v(dout1_48) AT=595.025n

* CHECK dout1_49 Vdout1_49ck118 = 0 time = 595
.meas tran vdout1_49ck118 FIND v(dout1_49) AT=595.025n

* CHECK dout1_50 Vdout1_50ck118 = 0 time = 595
.meas tran vdout1_50ck118 FIND v(dout1_50) AT=595.025n

* CHECK dout1_51 Vdout1_51ck118 = 0.9 time = 595
.meas tran vdout1_51ck118 FIND v(dout1_51) AT=595.025n

* CHECK dout1_52 Vdout1_52ck118 = 0.9 time = 595
.meas tran vdout1_52ck118 FIND v(dout1_52) AT=595.025n

* CHECK dout1_53 Vdout1_53ck118 = 0 time = 595
.meas tran vdout1_53ck118 FIND v(dout1_53) AT=595.025n

* CHECK dout1_54 Vdout1_54ck118 = 0 time = 595
.meas tran vdout1_54ck118 FIND v(dout1_54) AT=595.025n

* CHECK dout1_55 Vdout1_55ck118 = 0.9 time = 595
.meas tran vdout1_55ck118 FIND v(dout1_55) AT=595.025n

* CHECK dout1_56 Vdout1_56ck118 = 0.9 time = 595
.meas tran vdout1_56ck118 FIND v(dout1_56) AT=595.025n

* CHECK dout1_57 Vdout1_57ck118 = 0 time = 595
.meas tran vdout1_57ck118 FIND v(dout1_57) AT=595.025n

* CHECK dout1_58 Vdout1_58ck118 = 0.9 time = 595
.meas tran vdout1_58ck118 FIND v(dout1_58) AT=595.025n

* CHECK dout1_59 Vdout1_59ck118 = 0 time = 595
.meas tran vdout1_59ck118 FIND v(dout1_59) AT=595.025n

* CHECK dout1_60 Vdout1_60ck118 = 0.9 time = 595
.meas tran vdout1_60ck118 FIND v(dout1_60) AT=595.025n

* CHECK dout1_61 Vdout1_61ck118 = 0 time = 595
.meas tran vdout1_61ck118 FIND v(dout1_61) AT=595.025n

* CHECK dout1_62 Vdout1_62ck118 = 0.9 time = 595
.meas tran vdout1_62ck118 FIND v(dout1_62) AT=595.025n

* CHECK dout1_63 Vdout1_63ck118 = 0.9 time = 595
.meas tran vdout1_63ck118 FIND v(dout1_63) AT=595.025n

* CHECK dout1_0 Vdout1_0ck120 = 0 time = 605
.meas tran vdout1_0ck120 FIND v(dout1_0) AT=605.025n

* CHECK dout1_1 Vdout1_1ck120 = 0 time = 605
.meas tran vdout1_1ck120 FIND v(dout1_1) AT=605.025n

* CHECK dout1_2 Vdout1_2ck120 = 0 time = 605
.meas tran vdout1_2ck120 FIND v(dout1_2) AT=605.025n

* CHECK dout1_3 Vdout1_3ck120 = 0.9 time = 605
.meas tran vdout1_3ck120 FIND v(dout1_3) AT=605.025n

* CHECK dout1_4 Vdout1_4ck120 = 0 time = 605
.meas tran vdout1_4ck120 FIND v(dout1_4) AT=605.025n

* CHECK dout1_5 Vdout1_5ck120 = 0 time = 605
.meas tran vdout1_5ck120 FIND v(dout1_5) AT=605.025n

* CHECK dout1_6 Vdout1_6ck120 = 0.9 time = 605
.meas tran vdout1_6ck120 FIND v(dout1_6) AT=605.025n

* CHECK dout1_7 Vdout1_7ck120 = 0.9 time = 605
.meas tran vdout1_7ck120 FIND v(dout1_7) AT=605.025n

* CHECK dout1_8 Vdout1_8ck120 = 0 time = 605
.meas tran vdout1_8ck120 FIND v(dout1_8) AT=605.025n

* CHECK dout1_9 Vdout1_9ck120 = 0.9 time = 605
.meas tran vdout1_9ck120 FIND v(dout1_9) AT=605.025n

* CHECK dout1_10 Vdout1_10ck120 = 0 time = 605
.meas tran vdout1_10ck120 FIND v(dout1_10) AT=605.025n

* CHECK dout1_11 Vdout1_11ck120 = 0 time = 605
.meas tran vdout1_11ck120 FIND v(dout1_11) AT=605.025n

* CHECK dout1_12 Vdout1_12ck120 = 0 time = 605
.meas tran vdout1_12ck120 FIND v(dout1_12) AT=605.025n

* CHECK dout1_13 Vdout1_13ck120 = 0.9 time = 605
.meas tran vdout1_13ck120 FIND v(dout1_13) AT=605.025n

* CHECK dout1_14 Vdout1_14ck120 = 0 time = 605
.meas tran vdout1_14ck120 FIND v(dout1_14) AT=605.025n

* CHECK dout1_15 Vdout1_15ck120 = 0 time = 605
.meas tran vdout1_15ck120 FIND v(dout1_15) AT=605.025n

* CHECK dout1_16 Vdout1_16ck120 = 0 time = 605
.meas tran vdout1_16ck120 FIND v(dout1_16) AT=605.025n

* CHECK dout1_17 Vdout1_17ck120 = 0 time = 605
.meas tran vdout1_17ck120 FIND v(dout1_17) AT=605.025n

* CHECK dout1_18 Vdout1_18ck120 = 0 time = 605
.meas tran vdout1_18ck120 FIND v(dout1_18) AT=605.025n

* CHECK dout1_19 Vdout1_19ck120 = 0 time = 605
.meas tran vdout1_19ck120 FIND v(dout1_19) AT=605.025n

* CHECK dout1_20 Vdout1_20ck120 = 0.9 time = 605
.meas tran vdout1_20ck120 FIND v(dout1_20) AT=605.025n

* CHECK dout1_21 Vdout1_21ck120 = 0 time = 605
.meas tran vdout1_21ck120 FIND v(dout1_21) AT=605.025n

* CHECK dout1_22 Vdout1_22ck120 = 0 time = 605
.meas tran vdout1_22ck120 FIND v(dout1_22) AT=605.025n

* CHECK dout1_23 Vdout1_23ck120 = 0.9 time = 605
.meas tran vdout1_23ck120 FIND v(dout1_23) AT=605.025n

* CHECK dout1_24 Vdout1_24ck120 = 0.9 time = 605
.meas tran vdout1_24ck120 FIND v(dout1_24) AT=605.025n

* CHECK dout1_25 Vdout1_25ck120 = 0 time = 605
.meas tran vdout1_25ck120 FIND v(dout1_25) AT=605.025n

* CHECK dout1_26 Vdout1_26ck120 = 0.9 time = 605
.meas tran vdout1_26ck120 FIND v(dout1_26) AT=605.025n

* CHECK dout1_27 Vdout1_27ck120 = 0 time = 605
.meas tran vdout1_27ck120 FIND v(dout1_27) AT=605.025n

* CHECK dout1_28 Vdout1_28ck120 = 0 time = 605
.meas tran vdout1_28ck120 FIND v(dout1_28) AT=605.025n

* CHECK dout1_29 Vdout1_29ck120 = 0.9 time = 605
.meas tran vdout1_29ck120 FIND v(dout1_29) AT=605.025n

* CHECK dout1_30 Vdout1_30ck120 = 0 time = 605
.meas tran vdout1_30ck120 FIND v(dout1_30) AT=605.025n

* CHECK dout1_31 Vdout1_31ck120 = 0.9 time = 605
.meas tran vdout1_31ck120 FIND v(dout1_31) AT=605.025n

* CHECK dout1_32 Vdout1_32ck120 = 0 time = 605
.meas tran vdout1_32ck120 FIND v(dout1_32) AT=605.025n

* CHECK dout1_33 Vdout1_33ck120 = 0 time = 605
.meas tran vdout1_33ck120 FIND v(dout1_33) AT=605.025n

* CHECK dout1_34 Vdout1_34ck120 = 0.9 time = 605
.meas tran vdout1_34ck120 FIND v(dout1_34) AT=605.025n

* CHECK dout1_35 Vdout1_35ck120 = 0 time = 605
.meas tran vdout1_35ck120 FIND v(dout1_35) AT=605.025n

* CHECK dout1_36 Vdout1_36ck120 = 0 time = 605
.meas tran vdout1_36ck120 FIND v(dout1_36) AT=605.025n

* CHECK dout1_37 Vdout1_37ck120 = 0.9 time = 605
.meas tran vdout1_37ck120 FIND v(dout1_37) AT=605.025n

* CHECK dout1_38 Vdout1_38ck120 = 0.9 time = 605
.meas tran vdout1_38ck120 FIND v(dout1_38) AT=605.025n

* CHECK dout1_39 Vdout1_39ck120 = 0 time = 605
.meas tran vdout1_39ck120 FIND v(dout1_39) AT=605.025n

* CHECK dout1_40 Vdout1_40ck120 = 0.9 time = 605
.meas tran vdout1_40ck120 FIND v(dout1_40) AT=605.025n

* CHECK dout1_41 Vdout1_41ck120 = 0.9 time = 605
.meas tran vdout1_41ck120 FIND v(dout1_41) AT=605.025n

* CHECK dout1_42 Vdout1_42ck120 = 0.9 time = 605
.meas tran vdout1_42ck120 FIND v(dout1_42) AT=605.025n

* CHECK dout1_43 Vdout1_43ck120 = 0.9 time = 605
.meas tran vdout1_43ck120 FIND v(dout1_43) AT=605.025n

* CHECK dout1_44 Vdout1_44ck120 = 0 time = 605
.meas tran vdout1_44ck120 FIND v(dout1_44) AT=605.025n

* CHECK dout1_45 Vdout1_45ck120 = 0 time = 605
.meas tran vdout1_45ck120 FIND v(dout1_45) AT=605.025n

* CHECK dout1_46 Vdout1_46ck120 = 0 time = 605
.meas tran vdout1_46ck120 FIND v(dout1_46) AT=605.025n

* CHECK dout1_47 Vdout1_47ck120 = 0 time = 605
.meas tran vdout1_47ck120 FIND v(dout1_47) AT=605.025n

* CHECK dout1_48 Vdout1_48ck120 = 0 time = 605
.meas tran vdout1_48ck120 FIND v(dout1_48) AT=605.025n

* CHECK dout1_49 Vdout1_49ck120 = 0 time = 605
.meas tran vdout1_49ck120 FIND v(dout1_49) AT=605.025n

* CHECK dout1_50 Vdout1_50ck120 = 0.9 time = 605
.meas tran vdout1_50ck120 FIND v(dout1_50) AT=605.025n

* CHECK dout1_51 Vdout1_51ck120 = 0 time = 605
.meas tran vdout1_51ck120 FIND v(dout1_51) AT=605.025n

* CHECK dout1_52 Vdout1_52ck120 = 0 time = 605
.meas tran vdout1_52ck120 FIND v(dout1_52) AT=605.025n

* CHECK dout1_53 Vdout1_53ck120 = 0 time = 605
.meas tran vdout1_53ck120 FIND v(dout1_53) AT=605.025n

* CHECK dout1_54 Vdout1_54ck120 = 0.9 time = 605
.meas tran vdout1_54ck120 FIND v(dout1_54) AT=605.025n

* CHECK dout1_55 Vdout1_55ck120 = 0 time = 605
.meas tran vdout1_55ck120 FIND v(dout1_55) AT=605.025n

* CHECK dout1_56 Vdout1_56ck120 = 0 time = 605
.meas tran vdout1_56ck120 FIND v(dout1_56) AT=605.025n

* CHECK dout1_57 Vdout1_57ck120 = 0 time = 605
.meas tran vdout1_57ck120 FIND v(dout1_57) AT=605.025n

* CHECK dout1_58 Vdout1_58ck120 = 0 time = 605
.meas tran vdout1_58ck120 FIND v(dout1_58) AT=605.025n

* CHECK dout1_59 Vdout1_59ck120 = 0 time = 605
.meas tran vdout1_59ck120 FIND v(dout1_59) AT=605.025n

* CHECK dout1_60 Vdout1_60ck120 = 0.9 time = 605
.meas tran vdout1_60ck120 FIND v(dout1_60) AT=605.025n

* CHECK dout1_61 Vdout1_61ck120 = 0.9 time = 605
.meas tran vdout1_61ck120 FIND v(dout1_61) AT=605.025n

* CHECK dout1_62 Vdout1_62ck120 = 0.9 time = 605
.meas tran vdout1_62ck120 FIND v(dout1_62) AT=605.025n

* CHECK dout1_63 Vdout1_63ck120 = 0 time = 605
.meas tran vdout1_63ck120 FIND v(dout1_63) AT=605.025n

* CHECK dout1_0 Vdout1_0ck121 = 0 time = 610
.meas tran vdout1_0ck121 FIND v(dout1_0) AT=610.025n

* CHECK dout1_1 Vdout1_1ck121 = 0.9 time = 610
.meas tran vdout1_1ck121 FIND v(dout1_1) AT=610.025n

* CHECK dout1_2 Vdout1_2ck121 = 0 time = 610
.meas tran vdout1_2ck121 FIND v(dout1_2) AT=610.025n

* CHECK dout1_3 Vdout1_3ck121 = 0 time = 610
.meas tran vdout1_3ck121 FIND v(dout1_3) AT=610.025n

* CHECK dout1_4 Vdout1_4ck121 = 0 time = 610
.meas tran vdout1_4ck121 FIND v(dout1_4) AT=610.025n

* CHECK dout1_5 Vdout1_5ck121 = 0 time = 610
.meas tran vdout1_5ck121 FIND v(dout1_5) AT=610.025n

* CHECK dout1_6 Vdout1_6ck121 = 0 time = 610
.meas tran vdout1_6ck121 FIND v(dout1_6) AT=610.025n

* CHECK dout1_7 Vdout1_7ck121 = 0.9 time = 610
.meas tran vdout1_7ck121 FIND v(dout1_7) AT=610.025n

* CHECK dout1_8 Vdout1_8ck121 = 0 time = 610
.meas tran vdout1_8ck121 FIND v(dout1_8) AT=610.025n

* CHECK dout1_9 Vdout1_9ck121 = 0.9 time = 610
.meas tran vdout1_9ck121 FIND v(dout1_9) AT=610.025n

* CHECK dout1_10 Vdout1_10ck121 = 0 time = 610
.meas tran vdout1_10ck121 FIND v(dout1_10) AT=610.025n

* CHECK dout1_11 Vdout1_11ck121 = 0.9 time = 610
.meas tran vdout1_11ck121 FIND v(dout1_11) AT=610.025n

* CHECK dout1_12 Vdout1_12ck121 = 0 time = 610
.meas tran vdout1_12ck121 FIND v(dout1_12) AT=610.025n

* CHECK dout1_13 Vdout1_13ck121 = 0 time = 610
.meas tran vdout1_13ck121 FIND v(dout1_13) AT=610.025n

* CHECK dout1_14 Vdout1_14ck121 = 0.9 time = 610
.meas tran vdout1_14ck121 FIND v(dout1_14) AT=610.025n

* CHECK dout1_15 Vdout1_15ck121 = 0 time = 610
.meas tran vdout1_15ck121 FIND v(dout1_15) AT=610.025n

* CHECK dout1_16 Vdout1_16ck121 = 0 time = 610
.meas tran vdout1_16ck121 FIND v(dout1_16) AT=610.025n

* CHECK dout1_17 Vdout1_17ck121 = 0 time = 610
.meas tran vdout1_17ck121 FIND v(dout1_17) AT=610.025n

* CHECK dout1_18 Vdout1_18ck121 = 0 time = 610
.meas tran vdout1_18ck121 FIND v(dout1_18) AT=610.025n

* CHECK dout1_19 Vdout1_19ck121 = 0.9 time = 610
.meas tran vdout1_19ck121 FIND v(dout1_19) AT=610.025n

* CHECK dout1_20 Vdout1_20ck121 = 0.9 time = 610
.meas tran vdout1_20ck121 FIND v(dout1_20) AT=610.025n

* CHECK dout1_21 Vdout1_21ck121 = 0 time = 610
.meas tran vdout1_21ck121 FIND v(dout1_21) AT=610.025n

* CHECK dout1_22 Vdout1_22ck121 = 0.9 time = 610
.meas tran vdout1_22ck121 FIND v(dout1_22) AT=610.025n

* CHECK dout1_23 Vdout1_23ck121 = 0.9 time = 610
.meas tran vdout1_23ck121 FIND v(dout1_23) AT=610.025n

* CHECK dout1_24 Vdout1_24ck121 = 0.9 time = 610
.meas tran vdout1_24ck121 FIND v(dout1_24) AT=610.025n

* CHECK dout1_25 Vdout1_25ck121 = 0 time = 610
.meas tran vdout1_25ck121 FIND v(dout1_25) AT=610.025n

* CHECK dout1_26 Vdout1_26ck121 = 0 time = 610
.meas tran vdout1_26ck121 FIND v(dout1_26) AT=610.025n

* CHECK dout1_27 Vdout1_27ck121 = 0 time = 610
.meas tran vdout1_27ck121 FIND v(dout1_27) AT=610.025n

* CHECK dout1_28 Vdout1_28ck121 = 0 time = 610
.meas tran vdout1_28ck121 FIND v(dout1_28) AT=610.025n

* CHECK dout1_29 Vdout1_29ck121 = 0 time = 610
.meas tran vdout1_29ck121 FIND v(dout1_29) AT=610.025n

* CHECK dout1_30 Vdout1_30ck121 = 0.9 time = 610
.meas tran vdout1_30ck121 FIND v(dout1_30) AT=610.025n

* CHECK dout1_31 Vdout1_31ck121 = 0 time = 610
.meas tran vdout1_31ck121 FIND v(dout1_31) AT=610.025n

* CHECK dout1_32 Vdout1_32ck121 = 0.9 time = 610
.meas tran vdout1_32ck121 FIND v(dout1_32) AT=610.025n

* CHECK dout1_33 Vdout1_33ck121 = 0 time = 610
.meas tran vdout1_33ck121 FIND v(dout1_33) AT=610.025n

* CHECK dout1_34 Vdout1_34ck121 = 0 time = 610
.meas tran vdout1_34ck121 FIND v(dout1_34) AT=610.025n

* CHECK dout1_35 Vdout1_35ck121 = 0 time = 610
.meas tran vdout1_35ck121 FIND v(dout1_35) AT=610.025n

* CHECK dout1_36 Vdout1_36ck121 = 0 time = 610
.meas tran vdout1_36ck121 FIND v(dout1_36) AT=610.025n

* CHECK dout1_37 Vdout1_37ck121 = 0 time = 610
.meas tran vdout1_37ck121 FIND v(dout1_37) AT=610.025n

* CHECK dout1_38 Vdout1_38ck121 = 0.9 time = 610
.meas tran vdout1_38ck121 FIND v(dout1_38) AT=610.025n

* CHECK dout1_39 Vdout1_39ck121 = 0 time = 610
.meas tran vdout1_39ck121 FIND v(dout1_39) AT=610.025n

* CHECK dout1_40 Vdout1_40ck121 = 0.9 time = 610
.meas tran vdout1_40ck121 FIND v(dout1_40) AT=610.025n

* CHECK dout1_41 Vdout1_41ck121 = 0 time = 610
.meas tran vdout1_41ck121 FIND v(dout1_41) AT=610.025n

* CHECK dout1_42 Vdout1_42ck121 = 0 time = 610
.meas tran vdout1_42ck121 FIND v(dout1_42) AT=610.025n

* CHECK dout1_43 Vdout1_43ck121 = 0.9 time = 610
.meas tran vdout1_43ck121 FIND v(dout1_43) AT=610.025n

* CHECK dout1_44 Vdout1_44ck121 = 0.9 time = 610
.meas tran vdout1_44ck121 FIND v(dout1_44) AT=610.025n

* CHECK dout1_45 Vdout1_45ck121 = 0 time = 610
.meas tran vdout1_45ck121 FIND v(dout1_45) AT=610.025n

* CHECK dout1_46 Vdout1_46ck121 = 0.9 time = 610
.meas tran vdout1_46ck121 FIND v(dout1_46) AT=610.025n

* CHECK dout1_47 Vdout1_47ck121 = 0.9 time = 610
.meas tran vdout1_47ck121 FIND v(dout1_47) AT=610.025n

* CHECK dout1_48 Vdout1_48ck121 = 0 time = 610
.meas tran vdout1_48ck121 FIND v(dout1_48) AT=610.025n

* CHECK dout1_49 Vdout1_49ck121 = 0.9 time = 610
.meas tran vdout1_49ck121 FIND v(dout1_49) AT=610.025n

* CHECK dout1_50 Vdout1_50ck121 = 0.9 time = 610
.meas tran vdout1_50ck121 FIND v(dout1_50) AT=610.025n

* CHECK dout1_51 Vdout1_51ck121 = 0.9 time = 610
.meas tran vdout1_51ck121 FIND v(dout1_51) AT=610.025n

* CHECK dout1_52 Vdout1_52ck121 = 0 time = 610
.meas tran vdout1_52ck121 FIND v(dout1_52) AT=610.025n

* CHECK dout1_53 Vdout1_53ck121 = 0 time = 610
.meas tran vdout1_53ck121 FIND v(dout1_53) AT=610.025n

* CHECK dout1_54 Vdout1_54ck121 = 0.9 time = 610
.meas tran vdout1_54ck121 FIND v(dout1_54) AT=610.025n

* CHECK dout1_55 Vdout1_55ck121 = 0 time = 610
.meas tran vdout1_55ck121 FIND v(dout1_55) AT=610.025n

* CHECK dout1_56 Vdout1_56ck121 = 0.9 time = 610
.meas tran vdout1_56ck121 FIND v(dout1_56) AT=610.025n

* CHECK dout1_57 Vdout1_57ck121 = 0 time = 610
.meas tran vdout1_57ck121 FIND v(dout1_57) AT=610.025n

* CHECK dout1_58 Vdout1_58ck121 = 0.9 time = 610
.meas tran vdout1_58ck121 FIND v(dout1_58) AT=610.025n

* CHECK dout1_59 Vdout1_59ck121 = 0 time = 610
.meas tran vdout1_59ck121 FIND v(dout1_59) AT=610.025n

* CHECK dout1_60 Vdout1_60ck121 = 0 time = 610
.meas tran vdout1_60ck121 FIND v(dout1_60) AT=610.025n

* CHECK dout1_61 Vdout1_61ck121 = 0.9 time = 610
.meas tran vdout1_61ck121 FIND v(dout1_61) AT=610.025n

* CHECK dout1_62 Vdout1_62ck121 = 0.9 time = 610
.meas tran vdout1_62ck121 FIND v(dout1_62) AT=610.025n

* CHECK dout1_63 Vdout1_63ck121 = 0 time = 610
.meas tran vdout1_63ck121 FIND v(dout1_63) AT=610.025n

* CHECK dout1_0 Vdout1_0ck123 = 0 time = 620
.meas tran vdout1_0ck123 FIND v(dout1_0) AT=620.025n

* CHECK dout1_1 Vdout1_1ck123 = 0.9 time = 620
.meas tran vdout1_1ck123 FIND v(dout1_1) AT=620.025n

* CHECK dout1_2 Vdout1_2ck123 = 0 time = 620
.meas tran vdout1_2ck123 FIND v(dout1_2) AT=620.025n

* CHECK dout1_3 Vdout1_3ck123 = 0 time = 620
.meas tran vdout1_3ck123 FIND v(dout1_3) AT=620.025n

* CHECK dout1_4 Vdout1_4ck123 = 0 time = 620
.meas tran vdout1_4ck123 FIND v(dout1_4) AT=620.025n

* CHECK dout1_5 Vdout1_5ck123 = 0 time = 620
.meas tran vdout1_5ck123 FIND v(dout1_5) AT=620.025n

* CHECK dout1_6 Vdout1_6ck123 = 0 time = 620
.meas tran vdout1_6ck123 FIND v(dout1_6) AT=620.025n

* CHECK dout1_7 Vdout1_7ck123 = 0.9 time = 620
.meas tran vdout1_7ck123 FIND v(dout1_7) AT=620.025n

* CHECK dout1_8 Vdout1_8ck123 = 0 time = 620
.meas tran vdout1_8ck123 FIND v(dout1_8) AT=620.025n

* CHECK dout1_9 Vdout1_9ck123 = 0.9 time = 620
.meas tran vdout1_9ck123 FIND v(dout1_9) AT=620.025n

* CHECK dout1_10 Vdout1_10ck123 = 0 time = 620
.meas tran vdout1_10ck123 FIND v(dout1_10) AT=620.025n

* CHECK dout1_11 Vdout1_11ck123 = 0.9 time = 620
.meas tran vdout1_11ck123 FIND v(dout1_11) AT=620.025n

* CHECK dout1_12 Vdout1_12ck123 = 0 time = 620
.meas tran vdout1_12ck123 FIND v(dout1_12) AT=620.025n

* CHECK dout1_13 Vdout1_13ck123 = 0 time = 620
.meas tran vdout1_13ck123 FIND v(dout1_13) AT=620.025n

* CHECK dout1_14 Vdout1_14ck123 = 0.9 time = 620
.meas tran vdout1_14ck123 FIND v(dout1_14) AT=620.025n

* CHECK dout1_15 Vdout1_15ck123 = 0 time = 620
.meas tran vdout1_15ck123 FIND v(dout1_15) AT=620.025n

* CHECK dout1_16 Vdout1_16ck123 = 0 time = 620
.meas tran vdout1_16ck123 FIND v(dout1_16) AT=620.025n

* CHECK dout1_17 Vdout1_17ck123 = 0 time = 620
.meas tran vdout1_17ck123 FIND v(dout1_17) AT=620.025n

* CHECK dout1_18 Vdout1_18ck123 = 0 time = 620
.meas tran vdout1_18ck123 FIND v(dout1_18) AT=620.025n

* CHECK dout1_19 Vdout1_19ck123 = 0.9 time = 620
.meas tran vdout1_19ck123 FIND v(dout1_19) AT=620.025n

* CHECK dout1_20 Vdout1_20ck123 = 0.9 time = 620
.meas tran vdout1_20ck123 FIND v(dout1_20) AT=620.025n

* CHECK dout1_21 Vdout1_21ck123 = 0 time = 620
.meas tran vdout1_21ck123 FIND v(dout1_21) AT=620.025n

* CHECK dout1_22 Vdout1_22ck123 = 0.9 time = 620
.meas tran vdout1_22ck123 FIND v(dout1_22) AT=620.025n

* CHECK dout1_23 Vdout1_23ck123 = 0.9 time = 620
.meas tran vdout1_23ck123 FIND v(dout1_23) AT=620.025n

* CHECK dout1_24 Vdout1_24ck123 = 0.9 time = 620
.meas tran vdout1_24ck123 FIND v(dout1_24) AT=620.025n

* CHECK dout1_25 Vdout1_25ck123 = 0 time = 620
.meas tran vdout1_25ck123 FIND v(dout1_25) AT=620.025n

* CHECK dout1_26 Vdout1_26ck123 = 0 time = 620
.meas tran vdout1_26ck123 FIND v(dout1_26) AT=620.025n

* CHECK dout1_27 Vdout1_27ck123 = 0 time = 620
.meas tran vdout1_27ck123 FIND v(dout1_27) AT=620.025n

* CHECK dout1_28 Vdout1_28ck123 = 0 time = 620
.meas tran vdout1_28ck123 FIND v(dout1_28) AT=620.025n

* CHECK dout1_29 Vdout1_29ck123 = 0 time = 620
.meas tran vdout1_29ck123 FIND v(dout1_29) AT=620.025n

* CHECK dout1_30 Vdout1_30ck123 = 0.9 time = 620
.meas tran vdout1_30ck123 FIND v(dout1_30) AT=620.025n

* CHECK dout1_31 Vdout1_31ck123 = 0 time = 620
.meas tran vdout1_31ck123 FIND v(dout1_31) AT=620.025n

* CHECK dout1_32 Vdout1_32ck123 = 0.9 time = 620
.meas tran vdout1_32ck123 FIND v(dout1_32) AT=620.025n

* CHECK dout1_33 Vdout1_33ck123 = 0 time = 620
.meas tran vdout1_33ck123 FIND v(dout1_33) AT=620.025n

* CHECK dout1_34 Vdout1_34ck123 = 0 time = 620
.meas tran vdout1_34ck123 FIND v(dout1_34) AT=620.025n

* CHECK dout1_35 Vdout1_35ck123 = 0 time = 620
.meas tran vdout1_35ck123 FIND v(dout1_35) AT=620.025n

* CHECK dout1_36 Vdout1_36ck123 = 0 time = 620
.meas tran vdout1_36ck123 FIND v(dout1_36) AT=620.025n

* CHECK dout1_37 Vdout1_37ck123 = 0 time = 620
.meas tran vdout1_37ck123 FIND v(dout1_37) AT=620.025n

* CHECK dout1_38 Vdout1_38ck123 = 0.9 time = 620
.meas tran vdout1_38ck123 FIND v(dout1_38) AT=620.025n

* CHECK dout1_39 Vdout1_39ck123 = 0 time = 620
.meas tran vdout1_39ck123 FIND v(dout1_39) AT=620.025n

* CHECK dout1_40 Vdout1_40ck123 = 0.9 time = 620
.meas tran vdout1_40ck123 FIND v(dout1_40) AT=620.025n

* CHECK dout1_41 Vdout1_41ck123 = 0 time = 620
.meas tran vdout1_41ck123 FIND v(dout1_41) AT=620.025n

* CHECK dout1_42 Vdout1_42ck123 = 0 time = 620
.meas tran vdout1_42ck123 FIND v(dout1_42) AT=620.025n

* CHECK dout1_43 Vdout1_43ck123 = 0.9 time = 620
.meas tran vdout1_43ck123 FIND v(dout1_43) AT=620.025n

* CHECK dout1_44 Vdout1_44ck123 = 0.9 time = 620
.meas tran vdout1_44ck123 FIND v(dout1_44) AT=620.025n

* CHECK dout1_45 Vdout1_45ck123 = 0 time = 620
.meas tran vdout1_45ck123 FIND v(dout1_45) AT=620.025n

* CHECK dout1_46 Vdout1_46ck123 = 0.9 time = 620
.meas tran vdout1_46ck123 FIND v(dout1_46) AT=620.025n

* CHECK dout1_47 Vdout1_47ck123 = 0.9 time = 620
.meas tran vdout1_47ck123 FIND v(dout1_47) AT=620.025n

* CHECK dout1_48 Vdout1_48ck123 = 0 time = 620
.meas tran vdout1_48ck123 FIND v(dout1_48) AT=620.025n

* CHECK dout1_49 Vdout1_49ck123 = 0.9 time = 620
.meas tran vdout1_49ck123 FIND v(dout1_49) AT=620.025n

* CHECK dout1_50 Vdout1_50ck123 = 0.9 time = 620
.meas tran vdout1_50ck123 FIND v(dout1_50) AT=620.025n

* CHECK dout1_51 Vdout1_51ck123 = 0.9 time = 620
.meas tran vdout1_51ck123 FIND v(dout1_51) AT=620.025n

* CHECK dout1_52 Vdout1_52ck123 = 0 time = 620
.meas tran vdout1_52ck123 FIND v(dout1_52) AT=620.025n

* CHECK dout1_53 Vdout1_53ck123 = 0 time = 620
.meas tran vdout1_53ck123 FIND v(dout1_53) AT=620.025n

* CHECK dout1_54 Vdout1_54ck123 = 0.9 time = 620
.meas tran vdout1_54ck123 FIND v(dout1_54) AT=620.025n

* CHECK dout1_55 Vdout1_55ck123 = 0 time = 620
.meas tran vdout1_55ck123 FIND v(dout1_55) AT=620.025n

* CHECK dout1_56 Vdout1_56ck123 = 0.9 time = 620
.meas tran vdout1_56ck123 FIND v(dout1_56) AT=620.025n

* CHECK dout1_57 Vdout1_57ck123 = 0 time = 620
.meas tran vdout1_57ck123 FIND v(dout1_57) AT=620.025n

* CHECK dout1_58 Vdout1_58ck123 = 0.9 time = 620
.meas tran vdout1_58ck123 FIND v(dout1_58) AT=620.025n

* CHECK dout1_59 Vdout1_59ck123 = 0 time = 620
.meas tran vdout1_59ck123 FIND v(dout1_59) AT=620.025n

* CHECK dout1_60 Vdout1_60ck123 = 0 time = 620
.meas tran vdout1_60ck123 FIND v(dout1_60) AT=620.025n

* CHECK dout1_61 Vdout1_61ck123 = 0.9 time = 620
.meas tran vdout1_61ck123 FIND v(dout1_61) AT=620.025n

* CHECK dout1_62 Vdout1_62ck123 = 0.9 time = 620
.meas tran vdout1_62ck123 FIND v(dout1_62) AT=620.025n

* CHECK dout1_63 Vdout1_63ck123 = 0 time = 620
.meas tran vdout1_63ck123 FIND v(dout1_63) AT=620.025n

* CHECK dout1_0 Vdout1_0ck125 = 0.9 time = 630
.meas tran vdout1_0ck125 FIND v(dout1_0) AT=630.025n

* CHECK dout1_1 Vdout1_1ck125 = 0.9 time = 630
.meas tran vdout1_1ck125 FIND v(dout1_1) AT=630.025n

* CHECK dout1_2 Vdout1_2ck125 = 0.9 time = 630
.meas tran vdout1_2ck125 FIND v(dout1_2) AT=630.025n

* CHECK dout1_3 Vdout1_3ck125 = 0.9 time = 630
.meas tran vdout1_3ck125 FIND v(dout1_3) AT=630.025n

* CHECK dout1_4 Vdout1_4ck125 = 0 time = 630
.meas tran vdout1_4ck125 FIND v(dout1_4) AT=630.025n

* CHECK dout1_5 Vdout1_5ck125 = 0.9 time = 630
.meas tran vdout1_5ck125 FIND v(dout1_5) AT=630.025n

* CHECK dout1_6 Vdout1_6ck125 = 0.9 time = 630
.meas tran vdout1_6ck125 FIND v(dout1_6) AT=630.025n

* CHECK dout1_7 Vdout1_7ck125 = 0.9 time = 630
.meas tran vdout1_7ck125 FIND v(dout1_7) AT=630.025n

* CHECK dout1_8 Vdout1_8ck125 = 0 time = 630
.meas tran vdout1_8ck125 FIND v(dout1_8) AT=630.025n

* CHECK dout1_9 Vdout1_9ck125 = 0 time = 630
.meas tran vdout1_9ck125 FIND v(dout1_9) AT=630.025n

* CHECK dout1_10 Vdout1_10ck125 = 0.9 time = 630
.meas tran vdout1_10ck125 FIND v(dout1_10) AT=630.025n

* CHECK dout1_11 Vdout1_11ck125 = 0.9 time = 630
.meas tran vdout1_11ck125 FIND v(dout1_11) AT=630.025n

* CHECK dout1_12 Vdout1_12ck125 = 0.9 time = 630
.meas tran vdout1_12ck125 FIND v(dout1_12) AT=630.025n

* CHECK dout1_13 Vdout1_13ck125 = 0.9 time = 630
.meas tran vdout1_13ck125 FIND v(dout1_13) AT=630.025n

* CHECK dout1_14 Vdout1_14ck125 = 0 time = 630
.meas tran vdout1_14ck125 FIND v(dout1_14) AT=630.025n

* CHECK dout1_15 Vdout1_15ck125 = 0.9 time = 630
.meas tran vdout1_15ck125 FIND v(dout1_15) AT=630.025n

* CHECK dout1_16 Vdout1_16ck125 = 0 time = 630
.meas tran vdout1_16ck125 FIND v(dout1_16) AT=630.025n

* CHECK dout1_17 Vdout1_17ck125 = 0.9 time = 630
.meas tran vdout1_17ck125 FIND v(dout1_17) AT=630.025n

* CHECK dout1_18 Vdout1_18ck125 = 0 time = 630
.meas tran vdout1_18ck125 FIND v(dout1_18) AT=630.025n

* CHECK dout1_19 Vdout1_19ck125 = 0.9 time = 630
.meas tran vdout1_19ck125 FIND v(dout1_19) AT=630.025n

* CHECK dout1_20 Vdout1_20ck125 = 0.9 time = 630
.meas tran vdout1_20ck125 FIND v(dout1_20) AT=630.025n

* CHECK dout1_21 Vdout1_21ck125 = 0.9 time = 630
.meas tran vdout1_21ck125 FIND v(dout1_21) AT=630.025n

* CHECK dout1_22 Vdout1_22ck125 = 0 time = 630
.meas tran vdout1_22ck125 FIND v(dout1_22) AT=630.025n

* CHECK dout1_23 Vdout1_23ck125 = 0 time = 630
.meas tran vdout1_23ck125 FIND v(dout1_23) AT=630.025n

* CHECK dout1_24 Vdout1_24ck125 = 0 time = 630
.meas tran vdout1_24ck125 FIND v(dout1_24) AT=630.025n

* CHECK dout1_25 Vdout1_25ck125 = 0.9 time = 630
.meas tran vdout1_25ck125 FIND v(dout1_25) AT=630.025n

* CHECK dout1_26 Vdout1_26ck125 = 0 time = 630
.meas tran vdout1_26ck125 FIND v(dout1_26) AT=630.025n

* CHECK dout1_27 Vdout1_27ck125 = 0.9 time = 630
.meas tran vdout1_27ck125 FIND v(dout1_27) AT=630.025n

* CHECK dout1_28 Vdout1_28ck125 = 0.9 time = 630
.meas tran vdout1_28ck125 FIND v(dout1_28) AT=630.025n

* CHECK dout1_29 Vdout1_29ck125 = 0.9 time = 630
.meas tran vdout1_29ck125 FIND v(dout1_29) AT=630.025n

* CHECK dout1_30 Vdout1_30ck125 = 0 time = 630
.meas tran vdout1_30ck125 FIND v(dout1_30) AT=630.025n

* CHECK dout1_31 Vdout1_31ck125 = 0.9 time = 630
.meas tran vdout1_31ck125 FIND v(dout1_31) AT=630.025n

* CHECK dout1_32 Vdout1_32ck125 = 0.9 time = 630
.meas tran vdout1_32ck125 FIND v(dout1_32) AT=630.025n

* CHECK dout1_33 Vdout1_33ck125 = 0.9 time = 630
.meas tran vdout1_33ck125 FIND v(dout1_33) AT=630.025n

* CHECK dout1_34 Vdout1_34ck125 = 0 time = 630
.meas tran vdout1_34ck125 FIND v(dout1_34) AT=630.025n

* CHECK dout1_35 Vdout1_35ck125 = 0.9 time = 630
.meas tran vdout1_35ck125 FIND v(dout1_35) AT=630.025n

* CHECK dout1_36 Vdout1_36ck125 = 0.9 time = 630
.meas tran vdout1_36ck125 FIND v(dout1_36) AT=630.025n

* CHECK dout1_37 Vdout1_37ck125 = 0.9 time = 630
.meas tran vdout1_37ck125 FIND v(dout1_37) AT=630.025n

* CHECK dout1_38 Vdout1_38ck125 = 0 time = 630
.meas tran vdout1_38ck125 FIND v(dout1_38) AT=630.025n

* CHECK dout1_39 Vdout1_39ck125 = 0.9 time = 630
.meas tran vdout1_39ck125 FIND v(dout1_39) AT=630.025n

* CHECK dout1_40 Vdout1_40ck125 = 0.9 time = 630
.meas tran vdout1_40ck125 FIND v(dout1_40) AT=630.025n

* CHECK dout1_41 Vdout1_41ck125 = 0 time = 630
.meas tran vdout1_41ck125 FIND v(dout1_41) AT=630.025n

* CHECK dout1_42 Vdout1_42ck125 = 0.9 time = 630
.meas tran vdout1_42ck125 FIND v(dout1_42) AT=630.025n

* CHECK dout1_43 Vdout1_43ck125 = 0 time = 630
.meas tran vdout1_43ck125 FIND v(dout1_43) AT=630.025n

* CHECK dout1_44 Vdout1_44ck125 = 0 time = 630
.meas tran vdout1_44ck125 FIND v(dout1_44) AT=630.025n

* CHECK dout1_45 Vdout1_45ck125 = 0.9 time = 630
.meas tran vdout1_45ck125 FIND v(dout1_45) AT=630.025n

* CHECK dout1_46 Vdout1_46ck125 = 0.9 time = 630
.meas tran vdout1_46ck125 FIND v(dout1_46) AT=630.025n

* CHECK dout1_47 Vdout1_47ck125 = 0 time = 630
.meas tran vdout1_47ck125 FIND v(dout1_47) AT=630.025n

* CHECK dout1_48 Vdout1_48ck125 = 0.9 time = 630
.meas tran vdout1_48ck125 FIND v(dout1_48) AT=630.025n

* CHECK dout1_49 Vdout1_49ck125 = 0 time = 630
.meas tran vdout1_49ck125 FIND v(dout1_49) AT=630.025n

* CHECK dout1_50 Vdout1_50ck125 = 0 time = 630
.meas tran vdout1_50ck125 FIND v(dout1_50) AT=630.025n

* CHECK dout1_51 Vdout1_51ck125 = 0.9 time = 630
.meas tran vdout1_51ck125 FIND v(dout1_51) AT=630.025n

* CHECK dout1_52 Vdout1_52ck125 = 0.9 time = 630
.meas tran vdout1_52ck125 FIND v(dout1_52) AT=630.025n

* CHECK dout1_53 Vdout1_53ck125 = 0.9 time = 630
.meas tran vdout1_53ck125 FIND v(dout1_53) AT=630.025n

* CHECK dout1_54 Vdout1_54ck125 = 0.9 time = 630
.meas tran vdout1_54ck125 FIND v(dout1_54) AT=630.025n

* CHECK dout1_55 Vdout1_55ck125 = 0.9 time = 630
.meas tran vdout1_55ck125 FIND v(dout1_55) AT=630.025n

* CHECK dout1_56 Vdout1_56ck125 = 0 time = 630
.meas tran vdout1_56ck125 FIND v(dout1_56) AT=630.025n

* CHECK dout1_57 Vdout1_57ck125 = 0 time = 630
.meas tran vdout1_57ck125 FIND v(dout1_57) AT=630.025n

* CHECK dout1_58 Vdout1_58ck125 = 0 time = 630
.meas tran vdout1_58ck125 FIND v(dout1_58) AT=630.025n

* CHECK dout1_59 Vdout1_59ck125 = 0 time = 630
.meas tran vdout1_59ck125 FIND v(dout1_59) AT=630.025n

* CHECK dout1_60 Vdout1_60ck125 = 0.9 time = 630
.meas tran vdout1_60ck125 FIND v(dout1_60) AT=630.025n

* CHECK dout1_61 Vdout1_61ck125 = 0.9 time = 630
.meas tran vdout1_61ck125 FIND v(dout1_61) AT=630.025n

* CHECK dout1_62 Vdout1_62ck125 = 0.9 time = 630
.meas tran vdout1_62ck125 FIND v(dout1_62) AT=630.025n

* CHECK dout1_63 Vdout1_63ck125 = 0.9 time = 630
.meas tran vdout1_63ck125 FIND v(dout1_63) AT=630.025n

* CHECK dout1_0 Vdout1_0ck126 = 0 time = 635
.meas tran vdout1_0ck126 FIND v(dout1_0) AT=635.025n

* CHECK dout1_1 Vdout1_1ck126 = 0.9 time = 635
.meas tran vdout1_1ck126 FIND v(dout1_1) AT=635.025n

* CHECK dout1_2 Vdout1_2ck126 = 0 time = 635
.meas tran vdout1_2ck126 FIND v(dout1_2) AT=635.025n

* CHECK dout1_3 Vdout1_3ck126 = 0 time = 635
.meas tran vdout1_3ck126 FIND v(dout1_3) AT=635.025n

* CHECK dout1_4 Vdout1_4ck126 = 0 time = 635
.meas tran vdout1_4ck126 FIND v(dout1_4) AT=635.025n

* CHECK dout1_5 Vdout1_5ck126 = 0 time = 635
.meas tran vdout1_5ck126 FIND v(dout1_5) AT=635.025n

* CHECK dout1_6 Vdout1_6ck126 = 0 time = 635
.meas tran vdout1_6ck126 FIND v(dout1_6) AT=635.025n

* CHECK dout1_7 Vdout1_7ck126 = 0.9 time = 635
.meas tran vdout1_7ck126 FIND v(dout1_7) AT=635.025n

* CHECK dout1_8 Vdout1_8ck126 = 0 time = 635
.meas tran vdout1_8ck126 FIND v(dout1_8) AT=635.025n

* CHECK dout1_9 Vdout1_9ck126 = 0.9 time = 635
.meas tran vdout1_9ck126 FIND v(dout1_9) AT=635.025n

* CHECK dout1_10 Vdout1_10ck126 = 0 time = 635
.meas tran vdout1_10ck126 FIND v(dout1_10) AT=635.025n

* CHECK dout1_11 Vdout1_11ck126 = 0.9 time = 635
.meas tran vdout1_11ck126 FIND v(dout1_11) AT=635.025n

* CHECK dout1_12 Vdout1_12ck126 = 0 time = 635
.meas tran vdout1_12ck126 FIND v(dout1_12) AT=635.025n

* CHECK dout1_13 Vdout1_13ck126 = 0 time = 635
.meas tran vdout1_13ck126 FIND v(dout1_13) AT=635.025n

* CHECK dout1_14 Vdout1_14ck126 = 0.9 time = 635
.meas tran vdout1_14ck126 FIND v(dout1_14) AT=635.025n

* CHECK dout1_15 Vdout1_15ck126 = 0 time = 635
.meas tran vdout1_15ck126 FIND v(dout1_15) AT=635.025n

* CHECK dout1_16 Vdout1_16ck126 = 0 time = 635
.meas tran vdout1_16ck126 FIND v(dout1_16) AT=635.025n

* CHECK dout1_17 Vdout1_17ck126 = 0 time = 635
.meas tran vdout1_17ck126 FIND v(dout1_17) AT=635.025n

* CHECK dout1_18 Vdout1_18ck126 = 0 time = 635
.meas tran vdout1_18ck126 FIND v(dout1_18) AT=635.025n

* CHECK dout1_19 Vdout1_19ck126 = 0.9 time = 635
.meas tran vdout1_19ck126 FIND v(dout1_19) AT=635.025n

* CHECK dout1_20 Vdout1_20ck126 = 0.9 time = 635
.meas tran vdout1_20ck126 FIND v(dout1_20) AT=635.025n

* CHECK dout1_21 Vdout1_21ck126 = 0 time = 635
.meas tran vdout1_21ck126 FIND v(dout1_21) AT=635.025n

* CHECK dout1_22 Vdout1_22ck126 = 0.9 time = 635
.meas tran vdout1_22ck126 FIND v(dout1_22) AT=635.025n

* CHECK dout1_23 Vdout1_23ck126 = 0.9 time = 635
.meas tran vdout1_23ck126 FIND v(dout1_23) AT=635.025n

* CHECK dout1_24 Vdout1_24ck126 = 0.9 time = 635
.meas tran vdout1_24ck126 FIND v(dout1_24) AT=635.025n

* CHECK dout1_25 Vdout1_25ck126 = 0 time = 635
.meas tran vdout1_25ck126 FIND v(dout1_25) AT=635.025n

* CHECK dout1_26 Vdout1_26ck126 = 0 time = 635
.meas tran vdout1_26ck126 FIND v(dout1_26) AT=635.025n

* CHECK dout1_27 Vdout1_27ck126 = 0 time = 635
.meas tran vdout1_27ck126 FIND v(dout1_27) AT=635.025n

* CHECK dout1_28 Vdout1_28ck126 = 0 time = 635
.meas tran vdout1_28ck126 FIND v(dout1_28) AT=635.025n

* CHECK dout1_29 Vdout1_29ck126 = 0 time = 635
.meas tran vdout1_29ck126 FIND v(dout1_29) AT=635.025n

* CHECK dout1_30 Vdout1_30ck126 = 0.9 time = 635
.meas tran vdout1_30ck126 FIND v(dout1_30) AT=635.025n

* CHECK dout1_31 Vdout1_31ck126 = 0 time = 635
.meas tran vdout1_31ck126 FIND v(dout1_31) AT=635.025n

* CHECK dout1_32 Vdout1_32ck126 = 0.9 time = 635
.meas tran vdout1_32ck126 FIND v(dout1_32) AT=635.025n

* CHECK dout1_33 Vdout1_33ck126 = 0 time = 635
.meas tran vdout1_33ck126 FIND v(dout1_33) AT=635.025n

* CHECK dout1_34 Vdout1_34ck126 = 0 time = 635
.meas tran vdout1_34ck126 FIND v(dout1_34) AT=635.025n

* CHECK dout1_35 Vdout1_35ck126 = 0 time = 635
.meas tran vdout1_35ck126 FIND v(dout1_35) AT=635.025n

* CHECK dout1_36 Vdout1_36ck126 = 0 time = 635
.meas tran vdout1_36ck126 FIND v(dout1_36) AT=635.025n

* CHECK dout1_37 Vdout1_37ck126 = 0 time = 635
.meas tran vdout1_37ck126 FIND v(dout1_37) AT=635.025n

* CHECK dout1_38 Vdout1_38ck126 = 0.9 time = 635
.meas tran vdout1_38ck126 FIND v(dout1_38) AT=635.025n

* CHECK dout1_39 Vdout1_39ck126 = 0 time = 635
.meas tran vdout1_39ck126 FIND v(dout1_39) AT=635.025n

* CHECK dout1_40 Vdout1_40ck126 = 0.9 time = 635
.meas tran vdout1_40ck126 FIND v(dout1_40) AT=635.025n

* CHECK dout1_41 Vdout1_41ck126 = 0 time = 635
.meas tran vdout1_41ck126 FIND v(dout1_41) AT=635.025n

* CHECK dout1_42 Vdout1_42ck126 = 0 time = 635
.meas tran vdout1_42ck126 FIND v(dout1_42) AT=635.025n

* CHECK dout1_43 Vdout1_43ck126 = 0.9 time = 635
.meas tran vdout1_43ck126 FIND v(dout1_43) AT=635.025n

* CHECK dout1_44 Vdout1_44ck126 = 0.9 time = 635
.meas tran vdout1_44ck126 FIND v(dout1_44) AT=635.025n

* CHECK dout1_45 Vdout1_45ck126 = 0 time = 635
.meas tran vdout1_45ck126 FIND v(dout1_45) AT=635.025n

* CHECK dout1_46 Vdout1_46ck126 = 0.9 time = 635
.meas tran vdout1_46ck126 FIND v(dout1_46) AT=635.025n

* CHECK dout1_47 Vdout1_47ck126 = 0.9 time = 635
.meas tran vdout1_47ck126 FIND v(dout1_47) AT=635.025n

* CHECK dout1_48 Vdout1_48ck126 = 0 time = 635
.meas tran vdout1_48ck126 FIND v(dout1_48) AT=635.025n

* CHECK dout1_49 Vdout1_49ck126 = 0.9 time = 635
.meas tran vdout1_49ck126 FIND v(dout1_49) AT=635.025n

* CHECK dout1_50 Vdout1_50ck126 = 0.9 time = 635
.meas tran vdout1_50ck126 FIND v(dout1_50) AT=635.025n

* CHECK dout1_51 Vdout1_51ck126 = 0.9 time = 635
.meas tran vdout1_51ck126 FIND v(dout1_51) AT=635.025n

* CHECK dout1_52 Vdout1_52ck126 = 0 time = 635
.meas tran vdout1_52ck126 FIND v(dout1_52) AT=635.025n

* CHECK dout1_53 Vdout1_53ck126 = 0 time = 635
.meas tran vdout1_53ck126 FIND v(dout1_53) AT=635.025n

* CHECK dout1_54 Vdout1_54ck126 = 0.9 time = 635
.meas tran vdout1_54ck126 FIND v(dout1_54) AT=635.025n

* CHECK dout1_55 Vdout1_55ck126 = 0 time = 635
.meas tran vdout1_55ck126 FIND v(dout1_55) AT=635.025n

* CHECK dout1_56 Vdout1_56ck126 = 0.9 time = 635
.meas tran vdout1_56ck126 FIND v(dout1_56) AT=635.025n

* CHECK dout1_57 Vdout1_57ck126 = 0 time = 635
.meas tran vdout1_57ck126 FIND v(dout1_57) AT=635.025n

* CHECK dout1_58 Vdout1_58ck126 = 0.9 time = 635
.meas tran vdout1_58ck126 FIND v(dout1_58) AT=635.025n

* CHECK dout1_59 Vdout1_59ck126 = 0 time = 635
.meas tran vdout1_59ck126 FIND v(dout1_59) AT=635.025n

* CHECK dout1_60 Vdout1_60ck126 = 0 time = 635
.meas tran vdout1_60ck126 FIND v(dout1_60) AT=635.025n

* CHECK dout1_61 Vdout1_61ck126 = 0.9 time = 635
.meas tran vdout1_61ck126 FIND v(dout1_61) AT=635.025n

* CHECK dout1_62 Vdout1_62ck126 = 0.9 time = 635
.meas tran vdout1_62ck126 FIND v(dout1_62) AT=635.025n

* CHECK dout1_63 Vdout1_63ck126 = 0 time = 635
.meas tran vdout1_63ck126 FIND v(dout1_63) AT=635.025n

* CHECK dout1_0 Vdout1_0ck128 = 0.9 time = 645
.meas tran vdout1_0ck128 FIND v(dout1_0) AT=645.025n

* CHECK dout1_1 Vdout1_1ck128 = 0 time = 645
.meas tran vdout1_1ck128 FIND v(dout1_1) AT=645.025n

* CHECK dout1_2 Vdout1_2ck128 = 0 time = 645
.meas tran vdout1_2ck128 FIND v(dout1_2) AT=645.025n

* CHECK dout1_3 Vdout1_3ck128 = 0.9 time = 645
.meas tran vdout1_3ck128 FIND v(dout1_3) AT=645.025n

* CHECK dout1_4 Vdout1_4ck128 = 0 time = 645
.meas tran vdout1_4ck128 FIND v(dout1_4) AT=645.025n

* CHECK dout1_5 Vdout1_5ck128 = 0 time = 645
.meas tran vdout1_5ck128 FIND v(dout1_5) AT=645.025n

* CHECK dout1_6 Vdout1_6ck128 = 0.9 time = 645
.meas tran vdout1_6ck128 FIND v(dout1_6) AT=645.025n

* CHECK dout1_7 Vdout1_7ck128 = 0.9 time = 645
.meas tran vdout1_7ck128 FIND v(dout1_7) AT=645.025n

* CHECK dout1_8 Vdout1_8ck128 = 0.9 time = 645
.meas tran vdout1_8ck128 FIND v(dout1_8) AT=645.025n

* CHECK dout1_9 Vdout1_9ck128 = 0 time = 645
.meas tran vdout1_9ck128 FIND v(dout1_9) AT=645.025n

* CHECK dout1_10 Vdout1_10ck128 = 0.9 time = 645
.meas tran vdout1_10ck128 FIND v(dout1_10) AT=645.025n

* CHECK dout1_11 Vdout1_11ck128 = 0 time = 645
.meas tran vdout1_11ck128 FIND v(dout1_11) AT=645.025n

* CHECK dout1_12 Vdout1_12ck128 = 0.9 time = 645
.meas tran vdout1_12ck128 FIND v(dout1_12) AT=645.025n

* CHECK dout1_13 Vdout1_13ck128 = 0.9 time = 645
.meas tran vdout1_13ck128 FIND v(dout1_13) AT=645.025n

* CHECK dout1_14 Vdout1_14ck128 = 0.9 time = 645
.meas tran vdout1_14ck128 FIND v(dout1_14) AT=645.025n

* CHECK dout1_15 Vdout1_15ck128 = 0 time = 645
.meas tran vdout1_15ck128 FIND v(dout1_15) AT=645.025n

* CHECK dout1_16 Vdout1_16ck128 = 0 time = 645
.meas tran vdout1_16ck128 FIND v(dout1_16) AT=645.025n

* CHECK dout1_17 Vdout1_17ck128 = 0 time = 645
.meas tran vdout1_17ck128 FIND v(dout1_17) AT=645.025n

* CHECK dout1_18 Vdout1_18ck128 = 0 time = 645
.meas tran vdout1_18ck128 FIND v(dout1_18) AT=645.025n

* CHECK dout1_19 Vdout1_19ck128 = 0 time = 645
.meas tran vdout1_19ck128 FIND v(dout1_19) AT=645.025n

* CHECK dout1_20 Vdout1_20ck128 = 0.9 time = 645
.meas tran vdout1_20ck128 FIND v(dout1_20) AT=645.025n

* CHECK dout1_21 Vdout1_21ck128 = 0.9 time = 645
.meas tran vdout1_21ck128 FIND v(dout1_21) AT=645.025n

* CHECK dout1_22 Vdout1_22ck128 = 0.9 time = 645
.meas tran vdout1_22ck128 FIND v(dout1_22) AT=645.025n

* CHECK dout1_23 Vdout1_23ck128 = 0 time = 645
.meas tran vdout1_23ck128 FIND v(dout1_23) AT=645.025n

* CHECK dout1_24 Vdout1_24ck128 = 0 time = 645
.meas tran vdout1_24ck128 FIND v(dout1_24) AT=645.025n

* CHECK dout1_25 Vdout1_25ck128 = 0 time = 645
.meas tran vdout1_25ck128 FIND v(dout1_25) AT=645.025n

* CHECK dout1_26 Vdout1_26ck128 = 0.9 time = 645
.meas tran vdout1_26ck128 FIND v(dout1_26) AT=645.025n

* CHECK dout1_27 Vdout1_27ck128 = 0 time = 645
.meas tran vdout1_27ck128 FIND v(dout1_27) AT=645.025n

* CHECK dout1_28 Vdout1_28ck128 = 0 time = 645
.meas tran vdout1_28ck128 FIND v(dout1_28) AT=645.025n

* CHECK dout1_29 Vdout1_29ck128 = 0.9 time = 645
.meas tran vdout1_29ck128 FIND v(dout1_29) AT=645.025n

* CHECK dout1_30 Vdout1_30ck128 = 0.9 time = 645
.meas tran vdout1_30ck128 FIND v(dout1_30) AT=645.025n

* CHECK dout1_31 Vdout1_31ck128 = 0 time = 645
.meas tran vdout1_31ck128 FIND v(dout1_31) AT=645.025n

* CHECK dout1_32 Vdout1_32ck128 = 0.9 time = 645
.meas tran vdout1_32ck128 FIND v(dout1_32) AT=645.025n

* CHECK dout1_33 Vdout1_33ck128 = 0 time = 645
.meas tran vdout1_33ck128 FIND v(dout1_33) AT=645.025n

* CHECK dout1_34 Vdout1_34ck128 = 0 time = 645
.meas tran vdout1_34ck128 FIND v(dout1_34) AT=645.025n

* CHECK dout1_35 Vdout1_35ck128 = 0 time = 645
.meas tran vdout1_35ck128 FIND v(dout1_35) AT=645.025n

* CHECK dout1_36 Vdout1_36ck128 = 0 time = 645
.meas tran vdout1_36ck128 FIND v(dout1_36) AT=645.025n

* CHECK dout1_37 Vdout1_37ck128 = 0 time = 645
.meas tran vdout1_37ck128 FIND v(dout1_37) AT=645.025n

* CHECK dout1_38 Vdout1_38ck128 = 0.9 time = 645
.meas tran vdout1_38ck128 FIND v(dout1_38) AT=645.025n

* CHECK dout1_39 Vdout1_39ck128 = 0 time = 645
.meas tran vdout1_39ck128 FIND v(dout1_39) AT=645.025n

* CHECK dout1_40 Vdout1_40ck128 = 0.9 time = 645
.meas tran vdout1_40ck128 FIND v(dout1_40) AT=645.025n

* CHECK dout1_41 Vdout1_41ck128 = 0 time = 645
.meas tran vdout1_41ck128 FIND v(dout1_41) AT=645.025n

* CHECK dout1_42 Vdout1_42ck128 = 0 time = 645
.meas tran vdout1_42ck128 FIND v(dout1_42) AT=645.025n

* CHECK dout1_43 Vdout1_43ck128 = 0.9 time = 645
.meas tran vdout1_43ck128 FIND v(dout1_43) AT=645.025n

* CHECK dout1_44 Vdout1_44ck128 = 0.9 time = 645
.meas tran vdout1_44ck128 FIND v(dout1_44) AT=645.025n

* CHECK dout1_45 Vdout1_45ck128 = 0 time = 645
.meas tran vdout1_45ck128 FIND v(dout1_45) AT=645.025n

* CHECK dout1_46 Vdout1_46ck128 = 0.9 time = 645
.meas tran vdout1_46ck128 FIND v(dout1_46) AT=645.025n

* CHECK dout1_47 Vdout1_47ck128 = 0.9 time = 645
.meas tran vdout1_47ck128 FIND v(dout1_47) AT=645.025n

* CHECK dout1_48 Vdout1_48ck128 = 0 time = 645
.meas tran vdout1_48ck128 FIND v(dout1_48) AT=645.025n

* CHECK dout1_49 Vdout1_49ck128 = 0.9 time = 645
.meas tran vdout1_49ck128 FIND v(dout1_49) AT=645.025n

* CHECK dout1_50 Vdout1_50ck128 = 0.9 time = 645
.meas tran vdout1_50ck128 FIND v(dout1_50) AT=645.025n

* CHECK dout1_51 Vdout1_51ck128 = 0.9 time = 645
.meas tran vdout1_51ck128 FIND v(dout1_51) AT=645.025n

* CHECK dout1_52 Vdout1_52ck128 = 0 time = 645
.meas tran vdout1_52ck128 FIND v(dout1_52) AT=645.025n

* CHECK dout1_53 Vdout1_53ck128 = 0 time = 645
.meas tran vdout1_53ck128 FIND v(dout1_53) AT=645.025n

* CHECK dout1_54 Vdout1_54ck128 = 0.9 time = 645
.meas tran vdout1_54ck128 FIND v(dout1_54) AT=645.025n

* CHECK dout1_55 Vdout1_55ck128 = 0 time = 645
.meas tran vdout1_55ck128 FIND v(dout1_55) AT=645.025n

* CHECK dout1_56 Vdout1_56ck128 = 0.9 time = 645
.meas tran vdout1_56ck128 FIND v(dout1_56) AT=645.025n

* CHECK dout1_57 Vdout1_57ck128 = 0 time = 645
.meas tran vdout1_57ck128 FIND v(dout1_57) AT=645.025n

* CHECK dout1_58 Vdout1_58ck128 = 0.9 time = 645
.meas tran vdout1_58ck128 FIND v(dout1_58) AT=645.025n

* CHECK dout1_59 Vdout1_59ck128 = 0 time = 645
.meas tran vdout1_59ck128 FIND v(dout1_59) AT=645.025n

* CHECK dout1_60 Vdout1_60ck128 = 0 time = 645
.meas tran vdout1_60ck128 FIND v(dout1_60) AT=645.025n

* CHECK dout1_61 Vdout1_61ck128 = 0.9 time = 645
.meas tran vdout1_61ck128 FIND v(dout1_61) AT=645.025n

* CHECK dout1_62 Vdout1_62ck128 = 0.9 time = 645
.meas tran vdout1_62ck128 FIND v(dout1_62) AT=645.025n

* CHECK dout1_63 Vdout1_63ck128 = 0 time = 645
.meas tran vdout1_63ck128 FIND v(dout1_63) AT=645.025n

* CHECK dout1_0 Vdout1_0ck130 = 0 time = 655
.meas tran vdout1_0ck130 FIND v(dout1_0) AT=655.025n

* CHECK dout1_1 Vdout1_1ck130 = 0 time = 655
.meas tran vdout1_1ck130 FIND v(dout1_1) AT=655.025n

* CHECK dout1_2 Vdout1_2ck130 = 0.9 time = 655
.meas tran vdout1_2ck130 FIND v(dout1_2) AT=655.025n

* CHECK dout1_3 Vdout1_3ck130 = 0.9 time = 655
.meas tran vdout1_3ck130 FIND v(dout1_3) AT=655.025n

* CHECK dout1_4 Vdout1_4ck130 = 0 time = 655
.meas tran vdout1_4ck130 FIND v(dout1_4) AT=655.025n

* CHECK dout1_5 Vdout1_5ck130 = 0.9 time = 655
.meas tran vdout1_5ck130 FIND v(dout1_5) AT=655.025n

* CHECK dout1_6 Vdout1_6ck130 = 0 time = 655
.meas tran vdout1_6ck130 FIND v(dout1_6) AT=655.025n

* CHECK dout1_7 Vdout1_7ck130 = 0 time = 655
.meas tran vdout1_7ck130 FIND v(dout1_7) AT=655.025n

* CHECK dout1_8 Vdout1_8ck130 = 0 time = 655
.meas tran vdout1_8ck130 FIND v(dout1_8) AT=655.025n

* CHECK dout1_9 Vdout1_9ck130 = 0.9 time = 655
.meas tran vdout1_9ck130 FIND v(dout1_9) AT=655.025n

* CHECK dout1_10 Vdout1_10ck130 = 0 time = 655
.meas tran vdout1_10ck130 FIND v(dout1_10) AT=655.025n

* CHECK dout1_11 Vdout1_11ck130 = 0.9 time = 655
.meas tran vdout1_11ck130 FIND v(dout1_11) AT=655.025n

* CHECK dout1_12 Vdout1_12ck130 = 0 time = 655
.meas tran vdout1_12ck130 FIND v(dout1_12) AT=655.025n

* CHECK dout1_13 Vdout1_13ck130 = 0 time = 655
.meas tran vdout1_13ck130 FIND v(dout1_13) AT=655.025n

* CHECK dout1_14 Vdout1_14ck130 = 0 time = 655
.meas tran vdout1_14ck130 FIND v(dout1_14) AT=655.025n

* CHECK dout1_15 Vdout1_15ck130 = 0 time = 655
.meas tran vdout1_15ck130 FIND v(dout1_15) AT=655.025n

* CHECK dout1_16 Vdout1_16ck130 = 0.9 time = 655
.meas tran vdout1_16ck130 FIND v(dout1_16) AT=655.025n

* CHECK dout1_17 Vdout1_17ck130 = 0.9 time = 655
.meas tran vdout1_17ck130 FIND v(dout1_17) AT=655.025n

* CHECK dout1_18 Vdout1_18ck130 = 0 time = 655
.meas tran vdout1_18ck130 FIND v(dout1_18) AT=655.025n

* CHECK dout1_19 Vdout1_19ck130 = 0 time = 655
.meas tran vdout1_19ck130 FIND v(dout1_19) AT=655.025n

* CHECK dout1_20 Vdout1_20ck130 = 0.9 time = 655
.meas tran vdout1_20ck130 FIND v(dout1_20) AT=655.025n

* CHECK dout1_21 Vdout1_21ck130 = 0.9 time = 655
.meas tran vdout1_21ck130 FIND v(dout1_21) AT=655.025n

* CHECK dout1_22 Vdout1_22ck130 = 0.9 time = 655
.meas tran vdout1_22ck130 FIND v(dout1_22) AT=655.025n

* CHECK dout1_23 Vdout1_23ck130 = 0 time = 655
.meas tran vdout1_23ck130 FIND v(dout1_23) AT=655.025n

* CHECK dout1_24 Vdout1_24ck130 = 0 time = 655
.meas tran vdout1_24ck130 FIND v(dout1_24) AT=655.025n

* CHECK dout1_25 Vdout1_25ck130 = 0 time = 655
.meas tran vdout1_25ck130 FIND v(dout1_25) AT=655.025n

* CHECK dout1_26 Vdout1_26ck130 = 0 time = 655
.meas tran vdout1_26ck130 FIND v(dout1_26) AT=655.025n

* CHECK dout1_27 Vdout1_27ck130 = 0 time = 655
.meas tran vdout1_27ck130 FIND v(dout1_27) AT=655.025n

* CHECK dout1_28 Vdout1_28ck130 = 0 time = 655
.meas tran vdout1_28ck130 FIND v(dout1_28) AT=655.025n

* CHECK dout1_29 Vdout1_29ck130 = 0.9 time = 655
.meas tran vdout1_29ck130 FIND v(dout1_29) AT=655.025n

* CHECK dout1_30 Vdout1_30ck130 = 0 time = 655
.meas tran vdout1_30ck130 FIND v(dout1_30) AT=655.025n

* CHECK dout1_31 Vdout1_31ck130 = 0.9 time = 655
.meas tran vdout1_31ck130 FIND v(dout1_31) AT=655.025n

* CHECK dout1_32 Vdout1_32ck130 = 0 time = 655
.meas tran vdout1_32ck130 FIND v(dout1_32) AT=655.025n

* CHECK dout1_33 Vdout1_33ck130 = 0 time = 655
.meas tran vdout1_33ck130 FIND v(dout1_33) AT=655.025n

* CHECK dout1_34 Vdout1_34ck130 = 0 time = 655
.meas tran vdout1_34ck130 FIND v(dout1_34) AT=655.025n

* CHECK dout1_35 Vdout1_35ck130 = 0 time = 655
.meas tran vdout1_35ck130 FIND v(dout1_35) AT=655.025n

* CHECK dout1_36 Vdout1_36ck130 = 0 time = 655
.meas tran vdout1_36ck130 FIND v(dout1_36) AT=655.025n

* CHECK dout1_37 Vdout1_37ck130 = 0 time = 655
.meas tran vdout1_37ck130 FIND v(dout1_37) AT=655.025n

* CHECK dout1_38 Vdout1_38ck130 = 0 time = 655
.meas tran vdout1_38ck130 FIND v(dout1_38) AT=655.025n

* CHECK dout1_39 Vdout1_39ck130 = 0 time = 655
.meas tran vdout1_39ck130 FIND v(dout1_39) AT=655.025n

* CHECK dout1_40 Vdout1_40ck130 = 0 time = 655
.meas tran vdout1_40ck130 FIND v(dout1_40) AT=655.025n

* CHECK dout1_41 Vdout1_41ck130 = 0.9 time = 655
.meas tran vdout1_41ck130 FIND v(dout1_41) AT=655.025n

* CHECK dout1_42 Vdout1_42ck130 = 0 time = 655
.meas tran vdout1_42ck130 FIND v(dout1_42) AT=655.025n

* CHECK dout1_43 Vdout1_43ck130 = 0 time = 655
.meas tran vdout1_43ck130 FIND v(dout1_43) AT=655.025n

* CHECK dout1_44 Vdout1_44ck130 = 0.9 time = 655
.meas tran vdout1_44ck130 FIND v(dout1_44) AT=655.025n

* CHECK dout1_45 Vdout1_45ck130 = 0.9 time = 655
.meas tran vdout1_45ck130 FIND v(dout1_45) AT=655.025n

* CHECK dout1_46 Vdout1_46ck130 = 0 time = 655
.meas tran vdout1_46ck130 FIND v(dout1_46) AT=655.025n

* CHECK dout1_47 Vdout1_47ck130 = 0.9 time = 655
.meas tran vdout1_47ck130 FIND v(dout1_47) AT=655.025n

* CHECK dout1_48 Vdout1_48ck130 = 0 time = 655
.meas tran vdout1_48ck130 FIND v(dout1_48) AT=655.025n

* CHECK dout1_49 Vdout1_49ck130 = 0.9 time = 655
.meas tran vdout1_49ck130 FIND v(dout1_49) AT=655.025n

* CHECK dout1_50 Vdout1_50ck130 = 0 time = 655
.meas tran vdout1_50ck130 FIND v(dout1_50) AT=655.025n

* CHECK dout1_51 Vdout1_51ck130 = 0 time = 655
.meas tran vdout1_51ck130 FIND v(dout1_51) AT=655.025n

* CHECK dout1_52 Vdout1_52ck130 = 0.9 time = 655
.meas tran vdout1_52ck130 FIND v(dout1_52) AT=655.025n

* CHECK dout1_53 Vdout1_53ck130 = 0 time = 655
.meas tran vdout1_53ck130 FIND v(dout1_53) AT=655.025n

* CHECK dout1_54 Vdout1_54ck130 = 0 time = 655
.meas tran vdout1_54ck130 FIND v(dout1_54) AT=655.025n

* CHECK dout1_55 Vdout1_55ck130 = 0.9 time = 655
.meas tran vdout1_55ck130 FIND v(dout1_55) AT=655.025n

* CHECK dout1_56 Vdout1_56ck130 = 0 time = 655
.meas tran vdout1_56ck130 FIND v(dout1_56) AT=655.025n

* CHECK dout1_57 Vdout1_57ck130 = 0 time = 655
.meas tran vdout1_57ck130 FIND v(dout1_57) AT=655.025n

* CHECK dout1_58 Vdout1_58ck130 = 0 time = 655
.meas tran vdout1_58ck130 FIND v(dout1_58) AT=655.025n

* CHECK dout1_59 Vdout1_59ck130 = 0.9 time = 655
.meas tran vdout1_59ck130 FIND v(dout1_59) AT=655.025n

* CHECK dout1_60 Vdout1_60ck130 = 0 time = 655
.meas tran vdout1_60ck130 FIND v(dout1_60) AT=655.025n

* CHECK dout1_61 Vdout1_61ck130 = 0.9 time = 655
.meas tran vdout1_61ck130 FIND v(dout1_61) AT=655.025n

* CHECK dout1_62 Vdout1_62ck130 = 0 time = 655
.meas tran vdout1_62ck130 FIND v(dout1_62) AT=655.025n

* CHECK dout1_63 Vdout1_63ck130 = 0 time = 655
.meas tran vdout1_63ck130 FIND v(dout1_63) AT=655.025n

* CHECK dout1_0 Vdout1_0ck131 = 0.9 time = 660
.meas tran vdout1_0ck131 FIND v(dout1_0) AT=660.025n

* CHECK dout1_1 Vdout1_1ck131 = 0 time = 660
.meas tran vdout1_1ck131 FIND v(dout1_1) AT=660.025n

* CHECK dout1_2 Vdout1_2ck131 = 0 time = 660
.meas tran vdout1_2ck131 FIND v(dout1_2) AT=660.025n

* CHECK dout1_3 Vdout1_3ck131 = 0.9 time = 660
.meas tran vdout1_3ck131 FIND v(dout1_3) AT=660.025n

* CHECK dout1_4 Vdout1_4ck131 = 0 time = 660
.meas tran vdout1_4ck131 FIND v(dout1_4) AT=660.025n

* CHECK dout1_5 Vdout1_5ck131 = 0 time = 660
.meas tran vdout1_5ck131 FIND v(dout1_5) AT=660.025n

* CHECK dout1_6 Vdout1_6ck131 = 0.9 time = 660
.meas tran vdout1_6ck131 FIND v(dout1_6) AT=660.025n

* CHECK dout1_7 Vdout1_7ck131 = 0.9 time = 660
.meas tran vdout1_7ck131 FIND v(dout1_7) AT=660.025n

* CHECK dout1_8 Vdout1_8ck131 = 0.9 time = 660
.meas tran vdout1_8ck131 FIND v(dout1_8) AT=660.025n

* CHECK dout1_9 Vdout1_9ck131 = 0 time = 660
.meas tran vdout1_9ck131 FIND v(dout1_9) AT=660.025n

* CHECK dout1_10 Vdout1_10ck131 = 0.9 time = 660
.meas tran vdout1_10ck131 FIND v(dout1_10) AT=660.025n

* CHECK dout1_11 Vdout1_11ck131 = 0 time = 660
.meas tran vdout1_11ck131 FIND v(dout1_11) AT=660.025n

* CHECK dout1_12 Vdout1_12ck131 = 0.9 time = 660
.meas tran vdout1_12ck131 FIND v(dout1_12) AT=660.025n

* CHECK dout1_13 Vdout1_13ck131 = 0.9 time = 660
.meas tran vdout1_13ck131 FIND v(dout1_13) AT=660.025n

* CHECK dout1_14 Vdout1_14ck131 = 0.9 time = 660
.meas tran vdout1_14ck131 FIND v(dout1_14) AT=660.025n

* CHECK dout1_15 Vdout1_15ck131 = 0 time = 660
.meas tran vdout1_15ck131 FIND v(dout1_15) AT=660.025n

* CHECK dout1_16 Vdout1_16ck131 = 0 time = 660
.meas tran vdout1_16ck131 FIND v(dout1_16) AT=660.025n

* CHECK dout1_17 Vdout1_17ck131 = 0 time = 660
.meas tran vdout1_17ck131 FIND v(dout1_17) AT=660.025n

* CHECK dout1_18 Vdout1_18ck131 = 0 time = 660
.meas tran vdout1_18ck131 FIND v(dout1_18) AT=660.025n

* CHECK dout1_19 Vdout1_19ck131 = 0 time = 660
.meas tran vdout1_19ck131 FIND v(dout1_19) AT=660.025n

* CHECK dout1_20 Vdout1_20ck131 = 0.9 time = 660
.meas tran vdout1_20ck131 FIND v(dout1_20) AT=660.025n

* CHECK dout1_21 Vdout1_21ck131 = 0.9 time = 660
.meas tran vdout1_21ck131 FIND v(dout1_21) AT=660.025n

* CHECK dout1_22 Vdout1_22ck131 = 0.9 time = 660
.meas tran vdout1_22ck131 FIND v(dout1_22) AT=660.025n

* CHECK dout1_23 Vdout1_23ck131 = 0 time = 660
.meas tran vdout1_23ck131 FIND v(dout1_23) AT=660.025n

* CHECK dout1_24 Vdout1_24ck131 = 0 time = 660
.meas tran vdout1_24ck131 FIND v(dout1_24) AT=660.025n

* CHECK dout1_25 Vdout1_25ck131 = 0 time = 660
.meas tran vdout1_25ck131 FIND v(dout1_25) AT=660.025n

* CHECK dout1_26 Vdout1_26ck131 = 0.9 time = 660
.meas tran vdout1_26ck131 FIND v(dout1_26) AT=660.025n

* CHECK dout1_27 Vdout1_27ck131 = 0 time = 660
.meas tran vdout1_27ck131 FIND v(dout1_27) AT=660.025n

* CHECK dout1_28 Vdout1_28ck131 = 0 time = 660
.meas tran vdout1_28ck131 FIND v(dout1_28) AT=660.025n

* CHECK dout1_29 Vdout1_29ck131 = 0.9 time = 660
.meas tran vdout1_29ck131 FIND v(dout1_29) AT=660.025n

* CHECK dout1_30 Vdout1_30ck131 = 0.9 time = 660
.meas tran vdout1_30ck131 FIND v(dout1_30) AT=660.025n

* CHECK dout1_31 Vdout1_31ck131 = 0 time = 660
.meas tran vdout1_31ck131 FIND v(dout1_31) AT=660.025n

* CHECK dout1_32 Vdout1_32ck131 = 0.9 time = 660
.meas tran vdout1_32ck131 FIND v(dout1_32) AT=660.025n

* CHECK dout1_33 Vdout1_33ck131 = 0 time = 660
.meas tran vdout1_33ck131 FIND v(dout1_33) AT=660.025n

* CHECK dout1_34 Vdout1_34ck131 = 0 time = 660
.meas tran vdout1_34ck131 FIND v(dout1_34) AT=660.025n

* CHECK dout1_35 Vdout1_35ck131 = 0 time = 660
.meas tran vdout1_35ck131 FIND v(dout1_35) AT=660.025n

* CHECK dout1_36 Vdout1_36ck131 = 0 time = 660
.meas tran vdout1_36ck131 FIND v(dout1_36) AT=660.025n

* CHECK dout1_37 Vdout1_37ck131 = 0 time = 660
.meas tran vdout1_37ck131 FIND v(dout1_37) AT=660.025n

* CHECK dout1_38 Vdout1_38ck131 = 0.9 time = 660
.meas tran vdout1_38ck131 FIND v(dout1_38) AT=660.025n

* CHECK dout1_39 Vdout1_39ck131 = 0 time = 660
.meas tran vdout1_39ck131 FIND v(dout1_39) AT=660.025n

* CHECK dout1_40 Vdout1_40ck131 = 0.9 time = 660
.meas tran vdout1_40ck131 FIND v(dout1_40) AT=660.025n

* CHECK dout1_41 Vdout1_41ck131 = 0 time = 660
.meas tran vdout1_41ck131 FIND v(dout1_41) AT=660.025n

* CHECK dout1_42 Vdout1_42ck131 = 0 time = 660
.meas tran vdout1_42ck131 FIND v(dout1_42) AT=660.025n

* CHECK dout1_43 Vdout1_43ck131 = 0.9 time = 660
.meas tran vdout1_43ck131 FIND v(dout1_43) AT=660.025n

* CHECK dout1_44 Vdout1_44ck131 = 0.9 time = 660
.meas tran vdout1_44ck131 FIND v(dout1_44) AT=660.025n

* CHECK dout1_45 Vdout1_45ck131 = 0 time = 660
.meas tran vdout1_45ck131 FIND v(dout1_45) AT=660.025n

* CHECK dout1_46 Vdout1_46ck131 = 0.9 time = 660
.meas tran vdout1_46ck131 FIND v(dout1_46) AT=660.025n

* CHECK dout1_47 Vdout1_47ck131 = 0.9 time = 660
.meas tran vdout1_47ck131 FIND v(dout1_47) AT=660.025n

* CHECK dout1_48 Vdout1_48ck131 = 0 time = 660
.meas tran vdout1_48ck131 FIND v(dout1_48) AT=660.025n

* CHECK dout1_49 Vdout1_49ck131 = 0.9 time = 660
.meas tran vdout1_49ck131 FIND v(dout1_49) AT=660.025n

* CHECK dout1_50 Vdout1_50ck131 = 0.9 time = 660
.meas tran vdout1_50ck131 FIND v(dout1_50) AT=660.025n

* CHECK dout1_51 Vdout1_51ck131 = 0.9 time = 660
.meas tran vdout1_51ck131 FIND v(dout1_51) AT=660.025n

* CHECK dout1_52 Vdout1_52ck131 = 0 time = 660
.meas tran vdout1_52ck131 FIND v(dout1_52) AT=660.025n

* CHECK dout1_53 Vdout1_53ck131 = 0 time = 660
.meas tran vdout1_53ck131 FIND v(dout1_53) AT=660.025n

* CHECK dout1_54 Vdout1_54ck131 = 0.9 time = 660
.meas tran vdout1_54ck131 FIND v(dout1_54) AT=660.025n

* CHECK dout1_55 Vdout1_55ck131 = 0 time = 660
.meas tran vdout1_55ck131 FIND v(dout1_55) AT=660.025n

* CHECK dout1_56 Vdout1_56ck131 = 0.9 time = 660
.meas tran vdout1_56ck131 FIND v(dout1_56) AT=660.025n

* CHECK dout1_57 Vdout1_57ck131 = 0 time = 660
.meas tran vdout1_57ck131 FIND v(dout1_57) AT=660.025n

* CHECK dout1_58 Vdout1_58ck131 = 0.9 time = 660
.meas tran vdout1_58ck131 FIND v(dout1_58) AT=660.025n

* CHECK dout1_59 Vdout1_59ck131 = 0 time = 660
.meas tran vdout1_59ck131 FIND v(dout1_59) AT=660.025n

* CHECK dout1_60 Vdout1_60ck131 = 0 time = 660
.meas tran vdout1_60ck131 FIND v(dout1_60) AT=660.025n

* CHECK dout1_61 Vdout1_61ck131 = 0.9 time = 660
.meas tran vdout1_61ck131 FIND v(dout1_61) AT=660.025n

* CHECK dout1_62 Vdout1_62ck131 = 0.9 time = 660
.meas tran vdout1_62ck131 FIND v(dout1_62) AT=660.025n

* CHECK dout1_63 Vdout1_63ck131 = 0 time = 660
.meas tran vdout1_63ck131 FIND v(dout1_63) AT=660.025n

* CHECK dout1_0 Vdout1_0ck134 = 0.9 time = 675
.meas tran vdout1_0ck134 FIND v(dout1_0) AT=675.025n

* CHECK dout1_1 Vdout1_1ck134 = 0 time = 675
.meas tran vdout1_1ck134 FIND v(dout1_1) AT=675.025n

* CHECK dout1_2 Vdout1_2ck134 = 0 time = 675
.meas tran vdout1_2ck134 FIND v(dout1_2) AT=675.025n

* CHECK dout1_3 Vdout1_3ck134 = 0 time = 675
.meas tran vdout1_3ck134 FIND v(dout1_3) AT=675.025n

* CHECK dout1_4 Vdout1_4ck134 = 0.9 time = 675
.meas tran vdout1_4ck134 FIND v(dout1_4) AT=675.025n

* CHECK dout1_5 Vdout1_5ck134 = 0 time = 675
.meas tran vdout1_5ck134 FIND v(dout1_5) AT=675.025n

* CHECK dout1_6 Vdout1_6ck134 = 0 time = 675
.meas tran vdout1_6ck134 FIND v(dout1_6) AT=675.025n

* CHECK dout1_7 Vdout1_7ck134 = 0.9 time = 675
.meas tran vdout1_7ck134 FIND v(dout1_7) AT=675.025n

* CHECK dout1_8 Vdout1_8ck134 = 0.9 time = 675
.meas tran vdout1_8ck134 FIND v(dout1_8) AT=675.025n

* CHECK dout1_9 Vdout1_9ck134 = 0 time = 675
.meas tran vdout1_9ck134 FIND v(dout1_9) AT=675.025n

* CHECK dout1_10 Vdout1_10ck134 = 0 time = 675
.meas tran vdout1_10ck134 FIND v(dout1_10) AT=675.025n

* CHECK dout1_11 Vdout1_11ck134 = 0 time = 675
.meas tran vdout1_11ck134 FIND v(dout1_11) AT=675.025n

* CHECK dout1_12 Vdout1_12ck134 = 0 time = 675
.meas tran vdout1_12ck134 FIND v(dout1_12) AT=675.025n

* CHECK dout1_13 Vdout1_13ck134 = 0.9 time = 675
.meas tran vdout1_13ck134 FIND v(dout1_13) AT=675.025n

* CHECK dout1_14 Vdout1_14ck134 = 0.9 time = 675
.meas tran vdout1_14ck134 FIND v(dout1_14) AT=675.025n

* CHECK dout1_15 Vdout1_15ck134 = 0 time = 675
.meas tran vdout1_15ck134 FIND v(dout1_15) AT=675.025n

* CHECK dout1_16 Vdout1_16ck134 = 0 time = 675
.meas tran vdout1_16ck134 FIND v(dout1_16) AT=675.025n

* CHECK dout1_17 Vdout1_17ck134 = 0.9 time = 675
.meas tran vdout1_17ck134 FIND v(dout1_17) AT=675.025n

* CHECK dout1_18 Vdout1_18ck134 = 0 time = 675
.meas tran vdout1_18ck134 FIND v(dout1_18) AT=675.025n

* CHECK dout1_19 Vdout1_19ck134 = 0 time = 675
.meas tran vdout1_19ck134 FIND v(dout1_19) AT=675.025n

* CHECK dout1_20 Vdout1_20ck134 = 0 time = 675
.meas tran vdout1_20ck134 FIND v(dout1_20) AT=675.025n

* CHECK dout1_21 Vdout1_21ck134 = 0.9 time = 675
.meas tran vdout1_21ck134 FIND v(dout1_21) AT=675.025n

* CHECK dout1_22 Vdout1_22ck134 = 0.9 time = 675
.meas tran vdout1_22ck134 FIND v(dout1_22) AT=675.025n

* CHECK dout1_23 Vdout1_23ck134 = 0 time = 675
.meas tran vdout1_23ck134 FIND v(dout1_23) AT=675.025n

* CHECK dout1_24 Vdout1_24ck134 = 0 time = 675
.meas tran vdout1_24ck134 FIND v(dout1_24) AT=675.025n

* CHECK dout1_25 Vdout1_25ck134 = 0 time = 675
.meas tran vdout1_25ck134 FIND v(dout1_25) AT=675.025n

* CHECK dout1_26 Vdout1_26ck134 = 0 time = 675
.meas tran vdout1_26ck134 FIND v(dout1_26) AT=675.025n

* CHECK dout1_27 Vdout1_27ck134 = 0 time = 675
.meas tran vdout1_27ck134 FIND v(dout1_27) AT=675.025n

* CHECK dout1_28 Vdout1_28ck134 = 0 time = 675
.meas tran vdout1_28ck134 FIND v(dout1_28) AT=675.025n

* CHECK dout1_29 Vdout1_29ck134 = 0.9 time = 675
.meas tran vdout1_29ck134 FIND v(dout1_29) AT=675.025n

* CHECK dout1_30 Vdout1_30ck134 = 0 time = 675
.meas tran vdout1_30ck134 FIND v(dout1_30) AT=675.025n

* CHECK dout1_31 Vdout1_31ck134 = 0.9 time = 675
.meas tran vdout1_31ck134 FIND v(dout1_31) AT=675.025n

* CHECK dout1_32 Vdout1_32ck134 = 0.9 time = 675
.meas tran vdout1_32ck134 FIND v(dout1_32) AT=675.025n

* CHECK dout1_33 Vdout1_33ck134 = 0 time = 675
.meas tran vdout1_33ck134 FIND v(dout1_33) AT=675.025n

* CHECK dout1_34 Vdout1_34ck134 = 0.9 time = 675
.meas tran vdout1_34ck134 FIND v(dout1_34) AT=675.025n

* CHECK dout1_35 Vdout1_35ck134 = 0 time = 675
.meas tran vdout1_35ck134 FIND v(dout1_35) AT=675.025n

* CHECK dout1_36 Vdout1_36ck134 = 0.9 time = 675
.meas tran vdout1_36ck134 FIND v(dout1_36) AT=675.025n

* CHECK dout1_37 Vdout1_37ck134 = 0.9 time = 675
.meas tran vdout1_37ck134 FIND v(dout1_37) AT=675.025n

* CHECK dout1_38 Vdout1_38ck134 = 0.9 time = 675
.meas tran vdout1_38ck134 FIND v(dout1_38) AT=675.025n

* CHECK dout1_39 Vdout1_39ck134 = 0 time = 675
.meas tran vdout1_39ck134 FIND v(dout1_39) AT=675.025n

* CHECK dout1_40 Vdout1_40ck134 = 0 time = 675
.meas tran vdout1_40ck134 FIND v(dout1_40) AT=675.025n

* CHECK dout1_41 Vdout1_41ck134 = 0 time = 675
.meas tran vdout1_41ck134 FIND v(dout1_41) AT=675.025n

* CHECK dout1_42 Vdout1_42ck134 = 0 time = 675
.meas tran vdout1_42ck134 FIND v(dout1_42) AT=675.025n

* CHECK dout1_43 Vdout1_43ck134 = 0.9 time = 675
.meas tran vdout1_43ck134 FIND v(dout1_43) AT=675.025n

* CHECK dout1_44 Vdout1_44ck134 = 0 time = 675
.meas tran vdout1_44ck134 FIND v(dout1_44) AT=675.025n

* CHECK dout1_45 Vdout1_45ck134 = 0 time = 675
.meas tran vdout1_45ck134 FIND v(dout1_45) AT=675.025n

* CHECK dout1_46 Vdout1_46ck134 = 0 time = 675
.meas tran vdout1_46ck134 FIND v(dout1_46) AT=675.025n

* CHECK dout1_47 Vdout1_47ck134 = 0 time = 675
.meas tran vdout1_47ck134 FIND v(dout1_47) AT=675.025n

* CHECK dout1_48 Vdout1_48ck134 = 0 time = 675
.meas tran vdout1_48ck134 FIND v(dout1_48) AT=675.025n

* CHECK dout1_49 Vdout1_49ck134 = 0 time = 675
.meas tran vdout1_49ck134 FIND v(dout1_49) AT=675.025n

* CHECK dout1_50 Vdout1_50ck134 = 0 time = 675
.meas tran vdout1_50ck134 FIND v(dout1_50) AT=675.025n

* CHECK dout1_51 Vdout1_51ck134 = 0 time = 675
.meas tran vdout1_51ck134 FIND v(dout1_51) AT=675.025n

* CHECK dout1_52 Vdout1_52ck134 = 0 time = 675
.meas tran vdout1_52ck134 FIND v(dout1_52) AT=675.025n

* CHECK dout1_53 Vdout1_53ck134 = 0.9 time = 675
.meas tran vdout1_53ck134 FIND v(dout1_53) AT=675.025n

* CHECK dout1_54 Vdout1_54ck134 = 0 time = 675
.meas tran vdout1_54ck134 FIND v(dout1_54) AT=675.025n

* CHECK dout1_55 Vdout1_55ck134 = 0 time = 675
.meas tran vdout1_55ck134 FIND v(dout1_55) AT=675.025n

* CHECK dout1_56 Vdout1_56ck134 = 0 time = 675
.meas tran vdout1_56ck134 FIND v(dout1_56) AT=675.025n

* CHECK dout1_57 Vdout1_57ck134 = 0.9 time = 675
.meas tran vdout1_57ck134 FIND v(dout1_57) AT=675.025n

* CHECK dout1_58 Vdout1_58ck134 = 0.9 time = 675
.meas tran vdout1_58ck134 FIND v(dout1_58) AT=675.025n

* CHECK dout1_59 Vdout1_59ck134 = 0 time = 675
.meas tran vdout1_59ck134 FIND v(dout1_59) AT=675.025n

* CHECK dout1_60 Vdout1_60ck134 = 0 time = 675
.meas tran vdout1_60ck134 FIND v(dout1_60) AT=675.025n

* CHECK dout1_61 Vdout1_61ck134 = 0 time = 675
.meas tran vdout1_61ck134 FIND v(dout1_61) AT=675.025n

* CHECK dout1_62 Vdout1_62ck134 = 0.9 time = 675
.meas tran vdout1_62ck134 FIND v(dout1_62) AT=675.025n

* CHECK dout1_63 Vdout1_63ck134 = 0.9 time = 675
.meas tran vdout1_63ck134 FIND v(dout1_63) AT=675.025n

* CHECK dout1_0 Vdout1_0ck135 = 0.9 time = 680
.meas tran vdout1_0ck135 FIND v(dout1_0) AT=680.025n

* CHECK dout1_1 Vdout1_1ck135 = 0 time = 680
.meas tran vdout1_1ck135 FIND v(dout1_1) AT=680.025n

* CHECK dout1_2 Vdout1_2ck135 = 0 time = 680
.meas tran vdout1_2ck135 FIND v(dout1_2) AT=680.025n

* CHECK dout1_3 Vdout1_3ck135 = 0 time = 680
.meas tran vdout1_3ck135 FIND v(dout1_3) AT=680.025n

* CHECK dout1_4 Vdout1_4ck135 = 0.9 time = 680
.meas tran vdout1_4ck135 FIND v(dout1_4) AT=680.025n

* CHECK dout1_5 Vdout1_5ck135 = 0 time = 680
.meas tran vdout1_5ck135 FIND v(dout1_5) AT=680.025n

* CHECK dout1_6 Vdout1_6ck135 = 0 time = 680
.meas tran vdout1_6ck135 FIND v(dout1_6) AT=680.025n

* CHECK dout1_7 Vdout1_7ck135 = 0.9 time = 680
.meas tran vdout1_7ck135 FIND v(dout1_7) AT=680.025n

* CHECK dout1_8 Vdout1_8ck135 = 0.9 time = 680
.meas tran vdout1_8ck135 FIND v(dout1_8) AT=680.025n

* CHECK dout1_9 Vdout1_9ck135 = 0 time = 680
.meas tran vdout1_9ck135 FIND v(dout1_9) AT=680.025n

* CHECK dout1_10 Vdout1_10ck135 = 0 time = 680
.meas tran vdout1_10ck135 FIND v(dout1_10) AT=680.025n

* CHECK dout1_11 Vdout1_11ck135 = 0 time = 680
.meas tran vdout1_11ck135 FIND v(dout1_11) AT=680.025n

* CHECK dout1_12 Vdout1_12ck135 = 0 time = 680
.meas tran vdout1_12ck135 FIND v(dout1_12) AT=680.025n

* CHECK dout1_13 Vdout1_13ck135 = 0.9 time = 680
.meas tran vdout1_13ck135 FIND v(dout1_13) AT=680.025n

* CHECK dout1_14 Vdout1_14ck135 = 0.9 time = 680
.meas tran vdout1_14ck135 FIND v(dout1_14) AT=680.025n

* CHECK dout1_15 Vdout1_15ck135 = 0 time = 680
.meas tran vdout1_15ck135 FIND v(dout1_15) AT=680.025n

* CHECK dout1_16 Vdout1_16ck135 = 0 time = 680
.meas tran vdout1_16ck135 FIND v(dout1_16) AT=680.025n

* CHECK dout1_17 Vdout1_17ck135 = 0.9 time = 680
.meas tran vdout1_17ck135 FIND v(dout1_17) AT=680.025n

* CHECK dout1_18 Vdout1_18ck135 = 0 time = 680
.meas tran vdout1_18ck135 FIND v(dout1_18) AT=680.025n

* CHECK dout1_19 Vdout1_19ck135 = 0 time = 680
.meas tran vdout1_19ck135 FIND v(dout1_19) AT=680.025n

* CHECK dout1_20 Vdout1_20ck135 = 0 time = 680
.meas tran vdout1_20ck135 FIND v(dout1_20) AT=680.025n

* CHECK dout1_21 Vdout1_21ck135 = 0.9 time = 680
.meas tran vdout1_21ck135 FIND v(dout1_21) AT=680.025n

* CHECK dout1_22 Vdout1_22ck135 = 0.9 time = 680
.meas tran vdout1_22ck135 FIND v(dout1_22) AT=680.025n

* CHECK dout1_23 Vdout1_23ck135 = 0 time = 680
.meas tran vdout1_23ck135 FIND v(dout1_23) AT=680.025n

* CHECK dout1_24 Vdout1_24ck135 = 0 time = 680
.meas tran vdout1_24ck135 FIND v(dout1_24) AT=680.025n

* CHECK dout1_25 Vdout1_25ck135 = 0 time = 680
.meas tran vdout1_25ck135 FIND v(dout1_25) AT=680.025n

* CHECK dout1_26 Vdout1_26ck135 = 0 time = 680
.meas tran vdout1_26ck135 FIND v(dout1_26) AT=680.025n

* CHECK dout1_27 Vdout1_27ck135 = 0 time = 680
.meas tran vdout1_27ck135 FIND v(dout1_27) AT=680.025n

* CHECK dout1_28 Vdout1_28ck135 = 0 time = 680
.meas tran vdout1_28ck135 FIND v(dout1_28) AT=680.025n

* CHECK dout1_29 Vdout1_29ck135 = 0.9 time = 680
.meas tran vdout1_29ck135 FIND v(dout1_29) AT=680.025n

* CHECK dout1_30 Vdout1_30ck135 = 0 time = 680
.meas tran vdout1_30ck135 FIND v(dout1_30) AT=680.025n

* CHECK dout1_31 Vdout1_31ck135 = 0.9 time = 680
.meas tran vdout1_31ck135 FIND v(dout1_31) AT=680.025n

* CHECK dout1_32 Vdout1_32ck135 = 0.9 time = 680
.meas tran vdout1_32ck135 FIND v(dout1_32) AT=680.025n

* CHECK dout1_33 Vdout1_33ck135 = 0 time = 680
.meas tran vdout1_33ck135 FIND v(dout1_33) AT=680.025n

* CHECK dout1_34 Vdout1_34ck135 = 0.9 time = 680
.meas tran vdout1_34ck135 FIND v(dout1_34) AT=680.025n

* CHECK dout1_35 Vdout1_35ck135 = 0 time = 680
.meas tran vdout1_35ck135 FIND v(dout1_35) AT=680.025n

* CHECK dout1_36 Vdout1_36ck135 = 0.9 time = 680
.meas tran vdout1_36ck135 FIND v(dout1_36) AT=680.025n

* CHECK dout1_37 Vdout1_37ck135 = 0.9 time = 680
.meas tran vdout1_37ck135 FIND v(dout1_37) AT=680.025n

* CHECK dout1_38 Vdout1_38ck135 = 0.9 time = 680
.meas tran vdout1_38ck135 FIND v(dout1_38) AT=680.025n

* CHECK dout1_39 Vdout1_39ck135 = 0 time = 680
.meas tran vdout1_39ck135 FIND v(dout1_39) AT=680.025n

* CHECK dout1_40 Vdout1_40ck135 = 0 time = 680
.meas tran vdout1_40ck135 FIND v(dout1_40) AT=680.025n

* CHECK dout1_41 Vdout1_41ck135 = 0 time = 680
.meas tran vdout1_41ck135 FIND v(dout1_41) AT=680.025n

* CHECK dout1_42 Vdout1_42ck135 = 0 time = 680
.meas tran vdout1_42ck135 FIND v(dout1_42) AT=680.025n

* CHECK dout1_43 Vdout1_43ck135 = 0.9 time = 680
.meas tran vdout1_43ck135 FIND v(dout1_43) AT=680.025n

* CHECK dout1_44 Vdout1_44ck135 = 0 time = 680
.meas tran vdout1_44ck135 FIND v(dout1_44) AT=680.025n

* CHECK dout1_45 Vdout1_45ck135 = 0 time = 680
.meas tran vdout1_45ck135 FIND v(dout1_45) AT=680.025n

* CHECK dout1_46 Vdout1_46ck135 = 0 time = 680
.meas tran vdout1_46ck135 FIND v(dout1_46) AT=680.025n

* CHECK dout1_47 Vdout1_47ck135 = 0 time = 680
.meas tran vdout1_47ck135 FIND v(dout1_47) AT=680.025n

* CHECK dout1_48 Vdout1_48ck135 = 0 time = 680
.meas tran vdout1_48ck135 FIND v(dout1_48) AT=680.025n

* CHECK dout1_49 Vdout1_49ck135 = 0 time = 680
.meas tran vdout1_49ck135 FIND v(dout1_49) AT=680.025n

* CHECK dout1_50 Vdout1_50ck135 = 0 time = 680
.meas tran vdout1_50ck135 FIND v(dout1_50) AT=680.025n

* CHECK dout1_51 Vdout1_51ck135 = 0 time = 680
.meas tran vdout1_51ck135 FIND v(dout1_51) AT=680.025n

* CHECK dout1_52 Vdout1_52ck135 = 0 time = 680
.meas tran vdout1_52ck135 FIND v(dout1_52) AT=680.025n

* CHECK dout1_53 Vdout1_53ck135 = 0.9 time = 680
.meas tran vdout1_53ck135 FIND v(dout1_53) AT=680.025n

* CHECK dout1_54 Vdout1_54ck135 = 0 time = 680
.meas tran vdout1_54ck135 FIND v(dout1_54) AT=680.025n

* CHECK dout1_55 Vdout1_55ck135 = 0 time = 680
.meas tran vdout1_55ck135 FIND v(dout1_55) AT=680.025n

* CHECK dout1_56 Vdout1_56ck135 = 0 time = 680
.meas tran vdout1_56ck135 FIND v(dout1_56) AT=680.025n

* CHECK dout1_57 Vdout1_57ck135 = 0.9 time = 680
.meas tran vdout1_57ck135 FIND v(dout1_57) AT=680.025n

* CHECK dout1_58 Vdout1_58ck135 = 0.9 time = 680
.meas tran vdout1_58ck135 FIND v(dout1_58) AT=680.025n

* CHECK dout1_59 Vdout1_59ck135 = 0 time = 680
.meas tran vdout1_59ck135 FIND v(dout1_59) AT=680.025n

* CHECK dout1_60 Vdout1_60ck135 = 0 time = 680
.meas tran vdout1_60ck135 FIND v(dout1_60) AT=680.025n

* CHECK dout1_61 Vdout1_61ck135 = 0 time = 680
.meas tran vdout1_61ck135 FIND v(dout1_61) AT=680.025n

* CHECK dout1_62 Vdout1_62ck135 = 0.9 time = 680
.meas tran vdout1_62ck135 FIND v(dout1_62) AT=680.025n

* CHECK dout1_63 Vdout1_63ck135 = 0.9 time = 680
.meas tran vdout1_63ck135 FIND v(dout1_63) AT=680.025n

* CHECK dout1_0 Vdout1_0ck142 = 0.9 time = 715
.meas tran vdout1_0ck142 FIND v(dout1_0) AT=715.025n

* CHECK dout1_1 Vdout1_1ck142 = 0.9 time = 715
.meas tran vdout1_1ck142 FIND v(dout1_1) AT=715.025n

* CHECK dout1_2 Vdout1_2ck142 = 0 time = 715
.meas tran vdout1_2ck142 FIND v(dout1_2) AT=715.025n

* CHECK dout1_3 Vdout1_3ck142 = 0 time = 715
.meas tran vdout1_3ck142 FIND v(dout1_3) AT=715.025n

* CHECK dout1_4 Vdout1_4ck142 = 0 time = 715
.meas tran vdout1_4ck142 FIND v(dout1_4) AT=715.025n

* CHECK dout1_5 Vdout1_5ck142 = 0 time = 715
.meas tran vdout1_5ck142 FIND v(dout1_5) AT=715.025n

* CHECK dout1_6 Vdout1_6ck142 = 0.9 time = 715
.meas tran vdout1_6ck142 FIND v(dout1_6) AT=715.025n

* CHECK dout1_7 Vdout1_7ck142 = 0.9 time = 715
.meas tran vdout1_7ck142 FIND v(dout1_7) AT=715.025n

* CHECK dout1_8 Vdout1_8ck142 = 0 time = 715
.meas tran vdout1_8ck142 FIND v(dout1_8) AT=715.025n

* CHECK dout1_9 Vdout1_9ck142 = 0 time = 715
.meas tran vdout1_9ck142 FIND v(dout1_9) AT=715.025n

* CHECK dout1_10 Vdout1_10ck142 = 0.9 time = 715
.meas tran vdout1_10ck142 FIND v(dout1_10) AT=715.025n

* CHECK dout1_11 Vdout1_11ck142 = 0.9 time = 715
.meas tran vdout1_11ck142 FIND v(dout1_11) AT=715.025n

* CHECK dout1_12 Vdout1_12ck142 = 0.9 time = 715
.meas tran vdout1_12ck142 FIND v(dout1_12) AT=715.025n

* CHECK dout1_13 Vdout1_13ck142 = 0.9 time = 715
.meas tran vdout1_13ck142 FIND v(dout1_13) AT=715.025n

* CHECK dout1_14 Vdout1_14ck142 = 0 time = 715
.meas tran vdout1_14ck142 FIND v(dout1_14) AT=715.025n

* CHECK dout1_15 Vdout1_15ck142 = 0 time = 715
.meas tran vdout1_15ck142 FIND v(dout1_15) AT=715.025n

* CHECK dout1_16 Vdout1_16ck142 = 0 time = 715
.meas tran vdout1_16ck142 FIND v(dout1_16) AT=715.025n

* CHECK dout1_17 Vdout1_17ck142 = 0 time = 715
.meas tran vdout1_17ck142 FIND v(dout1_17) AT=715.025n

* CHECK dout1_18 Vdout1_18ck142 = 0.9 time = 715
.meas tran vdout1_18ck142 FIND v(dout1_18) AT=715.025n

* CHECK dout1_19 Vdout1_19ck142 = 0 time = 715
.meas tran vdout1_19ck142 FIND v(dout1_19) AT=715.025n

* CHECK dout1_20 Vdout1_20ck142 = 0.9 time = 715
.meas tran vdout1_20ck142 FIND v(dout1_20) AT=715.025n

* CHECK dout1_21 Vdout1_21ck142 = 0 time = 715
.meas tran vdout1_21ck142 FIND v(dout1_21) AT=715.025n

* CHECK dout1_22 Vdout1_22ck142 = 0 time = 715
.meas tran vdout1_22ck142 FIND v(dout1_22) AT=715.025n

* CHECK dout1_23 Vdout1_23ck142 = 0.9 time = 715
.meas tran vdout1_23ck142 FIND v(dout1_23) AT=715.025n

* CHECK dout1_24 Vdout1_24ck142 = 0 time = 715
.meas tran vdout1_24ck142 FIND v(dout1_24) AT=715.025n

* CHECK dout1_25 Vdout1_25ck142 = 0 time = 715
.meas tran vdout1_25ck142 FIND v(dout1_25) AT=715.025n

* CHECK dout1_26 Vdout1_26ck142 = 0.9 time = 715
.meas tran vdout1_26ck142 FIND v(dout1_26) AT=715.025n

* CHECK dout1_27 Vdout1_27ck142 = 0 time = 715
.meas tran vdout1_27ck142 FIND v(dout1_27) AT=715.025n

* CHECK dout1_28 Vdout1_28ck142 = 0 time = 715
.meas tran vdout1_28ck142 FIND v(dout1_28) AT=715.025n

* CHECK dout1_29 Vdout1_29ck142 = 0 time = 715
.meas tran vdout1_29ck142 FIND v(dout1_29) AT=715.025n

* CHECK dout1_30 Vdout1_30ck142 = 0 time = 715
.meas tran vdout1_30ck142 FIND v(dout1_30) AT=715.025n

* CHECK dout1_31 Vdout1_31ck142 = 0.9 time = 715
.meas tran vdout1_31ck142 FIND v(dout1_31) AT=715.025n

* CHECK dout1_32 Vdout1_32ck142 = 0 time = 715
.meas tran vdout1_32ck142 FIND v(dout1_32) AT=715.025n

* CHECK dout1_33 Vdout1_33ck142 = 0 time = 715
.meas tran vdout1_33ck142 FIND v(dout1_33) AT=715.025n

* CHECK dout1_34 Vdout1_34ck142 = 0.9 time = 715
.meas tran vdout1_34ck142 FIND v(dout1_34) AT=715.025n

* CHECK dout1_35 Vdout1_35ck142 = 0 time = 715
.meas tran vdout1_35ck142 FIND v(dout1_35) AT=715.025n

* CHECK dout1_36 Vdout1_36ck142 = 0 time = 715
.meas tran vdout1_36ck142 FIND v(dout1_36) AT=715.025n

* CHECK dout1_37 Vdout1_37ck142 = 0.9 time = 715
.meas tran vdout1_37ck142 FIND v(dout1_37) AT=715.025n

* CHECK dout1_38 Vdout1_38ck142 = 0 time = 715
.meas tran vdout1_38ck142 FIND v(dout1_38) AT=715.025n

* CHECK dout1_39 Vdout1_39ck142 = 0.9 time = 715
.meas tran vdout1_39ck142 FIND v(dout1_39) AT=715.025n

* CHECK dout1_40 Vdout1_40ck142 = 0 time = 715
.meas tran vdout1_40ck142 FIND v(dout1_40) AT=715.025n

* CHECK dout1_41 Vdout1_41ck142 = 0 time = 715
.meas tran vdout1_41ck142 FIND v(dout1_41) AT=715.025n

* CHECK dout1_42 Vdout1_42ck142 = 0 time = 715
.meas tran vdout1_42ck142 FIND v(dout1_42) AT=715.025n

* CHECK dout1_43 Vdout1_43ck142 = 0 time = 715
.meas tran vdout1_43ck142 FIND v(dout1_43) AT=715.025n

* CHECK dout1_44 Vdout1_44ck142 = 0 time = 715
.meas tran vdout1_44ck142 FIND v(dout1_44) AT=715.025n

* CHECK dout1_45 Vdout1_45ck142 = 0.9 time = 715
.meas tran vdout1_45ck142 FIND v(dout1_45) AT=715.025n

* CHECK dout1_46 Vdout1_46ck142 = 0.9 time = 715
.meas tran vdout1_46ck142 FIND v(dout1_46) AT=715.025n

* CHECK dout1_47 Vdout1_47ck142 = 0 time = 715
.meas tran vdout1_47ck142 FIND v(dout1_47) AT=715.025n

* CHECK dout1_48 Vdout1_48ck142 = 0.9 time = 715
.meas tran vdout1_48ck142 FIND v(dout1_48) AT=715.025n

* CHECK dout1_49 Vdout1_49ck142 = 0 time = 715
.meas tran vdout1_49ck142 FIND v(dout1_49) AT=715.025n

* CHECK dout1_50 Vdout1_50ck142 = 0 time = 715
.meas tran vdout1_50ck142 FIND v(dout1_50) AT=715.025n

* CHECK dout1_51 Vdout1_51ck142 = 0.9 time = 715
.meas tran vdout1_51ck142 FIND v(dout1_51) AT=715.025n

* CHECK dout1_52 Vdout1_52ck142 = 0 time = 715
.meas tran vdout1_52ck142 FIND v(dout1_52) AT=715.025n

* CHECK dout1_53 Vdout1_53ck142 = 0.9 time = 715
.meas tran vdout1_53ck142 FIND v(dout1_53) AT=715.025n

* CHECK dout1_54 Vdout1_54ck142 = 0.9 time = 715
.meas tran vdout1_54ck142 FIND v(dout1_54) AT=715.025n

* CHECK dout1_55 Vdout1_55ck142 = 0 time = 715
.meas tran vdout1_55ck142 FIND v(dout1_55) AT=715.025n

* CHECK dout1_56 Vdout1_56ck142 = 0.9 time = 715
.meas tran vdout1_56ck142 FIND v(dout1_56) AT=715.025n

* CHECK dout1_57 Vdout1_57ck142 = 0 time = 715
.meas tran vdout1_57ck142 FIND v(dout1_57) AT=715.025n

* CHECK dout1_58 Vdout1_58ck142 = 0.9 time = 715
.meas tran vdout1_58ck142 FIND v(dout1_58) AT=715.025n

* CHECK dout1_59 Vdout1_59ck142 = 0.9 time = 715
.meas tran vdout1_59ck142 FIND v(dout1_59) AT=715.025n

* CHECK dout1_60 Vdout1_60ck142 = 0 time = 715
.meas tran vdout1_60ck142 FIND v(dout1_60) AT=715.025n

* CHECK dout1_61 Vdout1_61ck142 = 0 time = 715
.meas tran vdout1_61ck142 FIND v(dout1_61) AT=715.025n

* CHECK dout1_62 Vdout1_62ck142 = 0 time = 715
.meas tran vdout1_62ck142 FIND v(dout1_62) AT=715.025n

* CHECK dout1_63 Vdout1_63ck142 = 0.9 time = 715
.meas tran vdout1_63ck142 FIND v(dout1_63) AT=715.025n

* CHECK dout1_0 Vdout1_0ck143 = 0.9 time = 720
.meas tran vdout1_0ck143 FIND v(dout1_0) AT=720.025n

* CHECK dout1_1 Vdout1_1ck143 = 0.9 time = 720
.meas tran vdout1_1ck143 FIND v(dout1_1) AT=720.025n

* CHECK dout1_2 Vdout1_2ck143 = 0 time = 720
.meas tran vdout1_2ck143 FIND v(dout1_2) AT=720.025n

* CHECK dout1_3 Vdout1_3ck143 = 0 time = 720
.meas tran vdout1_3ck143 FIND v(dout1_3) AT=720.025n

* CHECK dout1_4 Vdout1_4ck143 = 0 time = 720
.meas tran vdout1_4ck143 FIND v(dout1_4) AT=720.025n

* CHECK dout1_5 Vdout1_5ck143 = 0 time = 720
.meas tran vdout1_5ck143 FIND v(dout1_5) AT=720.025n

* CHECK dout1_6 Vdout1_6ck143 = 0.9 time = 720
.meas tran vdout1_6ck143 FIND v(dout1_6) AT=720.025n

* CHECK dout1_7 Vdout1_7ck143 = 0.9 time = 720
.meas tran vdout1_7ck143 FIND v(dout1_7) AT=720.025n

* CHECK dout1_8 Vdout1_8ck143 = 0 time = 720
.meas tran vdout1_8ck143 FIND v(dout1_8) AT=720.025n

* CHECK dout1_9 Vdout1_9ck143 = 0 time = 720
.meas tran vdout1_9ck143 FIND v(dout1_9) AT=720.025n

* CHECK dout1_10 Vdout1_10ck143 = 0.9 time = 720
.meas tran vdout1_10ck143 FIND v(dout1_10) AT=720.025n

* CHECK dout1_11 Vdout1_11ck143 = 0.9 time = 720
.meas tran vdout1_11ck143 FIND v(dout1_11) AT=720.025n

* CHECK dout1_12 Vdout1_12ck143 = 0.9 time = 720
.meas tran vdout1_12ck143 FIND v(dout1_12) AT=720.025n

* CHECK dout1_13 Vdout1_13ck143 = 0.9 time = 720
.meas tran vdout1_13ck143 FIND v(dout1_13) AT=720.025n

* CHECK dout1_14 Vdout1_14ck143 = 0 time = 720
.meas tran vdout1_14ck143 FIND v(dout1_14) AT=720.025n

* CHECK dout1_15 Vdout1_15ck143 = 0 time = 720
.meas tran vdout1_15ck143 FIND v(dout1_15) AT=720.025n

* CHECK dout1_16 Vdout1_16ck143 = 0 time = 720
.meas tran vdout1_16ck143 FIND v(dout1_16) AT=720.025n

* CHECK dout1_17 Vdout1_17ck143 = 0 time = 720
.meas tran vdout1_17ck143 FIND v(dout1_17) AT=720.025n

* CHECK dout1_18 Vdout1_18ck143 = 0.9 time = 720
.meas tran vdout1_18ck143 FIND v(dout1_18) AT=720.025n

* CHECK dout1_19 Vdout1_19ck143 = 0 time = 720
.meas tran vdout1_19ck143 FIND v(dout1_19) AT=720.025n

* CHECK dout1_20 Vdout1_20ck143 = 0.9 time = 720
.meas tran vdout1_20ck143 FIND v(dout1_20) AT=720.025n

* CHECK dout1_21 Vdout1_21ck143 = 0 time = 720
.meas tran vdout1_21ck143 FIND v(dout1_21) AT=720.025n

* CHECK dout1_22 Vdout1_22ck143 = 0 time = 720
.meas tran vdout1_22ck143 FIND v(dout1_22) AT=720.025n

* CHECK dout1_23 Vdout1_23ck143 = 0.9 time = 720
.meas tran vdout1_23ck143 FIND v(dout1_23) AT=720.025n

* CHECK dout1_24 Vdout1_24ck143 = 0 time = 720
.meas tran vdout1_24ck143 FIND v(dout1_24) AT=720.025n

* CHECK dout1_25 Vdout1_25ck143 = 0 time = 720
.meas tran vdout1_25ck143 FIND v(dout1_25) AT=720.025n

* CHECK dout1_26 Vdout1_26ck143 = 0.9 time = 720
.meas tran vdout1_26ck143 FIND v(dout1_26) AT=720.025n

* CHECK dout1_27 Vdout1_27ck143 = 0 time = 720
.meas tran vdout1_27ck143 FIND v(dout1_27) AT=720.025n

* CHECK dout1_28 Vdout1_28ck143 = 0 time = 720
.meas tran vdout1_28ck143 FIND v(dout1_28) AT=720.025n

* CHECK dout1_29 Vdout1_29ck143 = 0 time = 720
.meas tran vdout1_29ck143 FIND v(dout1_29) AT=720.025n

* CHECK dout1_30 Vdout1_30ck143 = 0 time = 720
.meas tran vdout1_30ck143 FIND v(dout1_30) AT=720.025n

* CHECK dout1_31 Vdout1_31ck143 = 0.9 time = 720
.meas tran vdout1_31ck143 FIND v(dout1_31) AT=720.025n

* CHECK dout1_32 Vdout1_32ck143 = 0 time = 720
.meas tran vdout1_32ck143 FIND v(dout1_32) AT=720.025n

* CHECK dout1_33 Vdout1_33ck143 = 0 time = 720
.meas tran vdout1_33ck143 FIND v(dout1_33) AT=720.025n

* CHECK dout1_34 Vdout1_34ck143 = 0.9 time = 720
.meas tran vdout1_34ck143 FIND v(dout1_34) AT=720.025n

* CHECK dout1_35 Vdout1_35ck143 = 0 time = 720
.meas tran vdout1_35ck143 FIND v(dout1_35) AT=720.025n

* CHECK dout1_36 Vdout1_36ck143 = 0 time = 720
.meas tran vdout1_36ck143 FIND v(dout1_36) AT=720.025n

* CHECK dout1_37 Vdout1_37ck143 = 0.9 time = 720
.meas tran vdout1_37ck143 FIND v(dout1_37) AT=720.025n

* CHECK dout1_38 Vdout1_38ck143 = 0 time = 720
.meas tran vdout1_38ck143 FIND v(dout1_38) AT=720.025n

* CHECK dout1_39 Vdout1_39ck143 = 0.9 time = 720
.meas tran vdout1_39ck143 FIND v(dout1_39) AT=720.025n

* CHECK dout1_40 Vdout1_40ck143 = 0 time = 720
.meas tran vdout1_40ck143 FIND v(dout1_40) AT=720.025n

* CHECK dout1_41 Vdout1_41ck143 = 0 time = 720
.meas tran vdout1_41ck143 FIND v(dout1_41) AT=720.025n

* CHECK dout1_42 Vdout1_42ck143 = 0 time = 720
.meas tran vdout1_42ck143 FIND v(dout1_42) AT=720.025n

* CHECK dout1_43 Vdout1_43ck143 = 0 time = 720
.meas tran vdout1_43ck143 FIND v(dout1_43) AT=720.025n

* CHECK dout1_44 Vdout1_44ck143 = 0 time = 720
.meas tran vdout1_44ck143 FIND v(dout1_44) AT=720.025n

* CHECK dout1_45 Vdout1_45ck143 = 0.9 time = 720
.meas tran vdout1_45ck143 FIND v(dout1_45) AT=720.025n

* CHECK dout1_46 Vdout1_46ck143 = 0.9 time = 720
.meas tran vdout1_46ck143 FIND v(dout1_46) AT=720.025n

* CHECK dout1_47 Vdout1_47ck143 = 0 time = 720
.meas tran vdout1_47ck143 FIND v(dout1_47) AT=720.025n

* CHECK dout1_48 Vdout1_48ck143 = 0.9 time = 720
.meas tran vdout1_48ck143 FIND v(dout1_48) AT=720.025n

* CHECK dout1_49 Vdout1_49ck143 = 0 time = 720
.meas tran vdout1_49ck143 FIND v(dout1_49) AT=720.025n

* CHECK dout1_50 Vdout1_50ck143 = 0 time = 720
.meas tran vdout1_50ck143 FIND v(dout1_50) AT=720.025n

* CHECK dout1_51 Vdout1_51ck143 = 0.9 time = 720
.meas tran vdout1_51ck143 FIND v(dout1_51) AT=720.025n

* CHECK dout1_52 Vdout1_52ck143 = 0 time = 720
.meas tran vdout1_52ck143 FIND v(dout1_52) AT=720.025n

* CHECK dout1_53 Vdout1_53ck143 = 0.9 time = 720
.meas tran vdout1_53ck143 FIND v(dout1_53) AT=720.025n

* CHECK dout1_54 Vdout1_54ck143 = 0.9 time = 720
.meas tran vdout1_54ck143 FIND v(dout1_54) AT=720.025n

* CHECK dout1_55 Vdout1_55ck143 = 0 time = 720
.meas tran vdout1_55ck143 FIND v(dout1_55) AT=720.025n

* CHECK dout1_56 Vdout1_56ck143 = 0.9 time = 720
.meas tran vdout1_56ck143 FIND v(dout1_56) AT=720.025n

* CHECK dout1_57 Vdout1_57ck143 = 0 time = 720
.meas tran vdout1_57ck143 FIND v(dout1_57) AT=720.025n

* CHECK dout1_58 Vdout1_58ck143 = 0.9 time = 720
.meas tran vdout1_58ck143 FIND v(dout1_58) AT=720.025n

* CHECK dout1_59 Vdout1_59ck143 = 0.9 time = 720
.meas tran vdout1_59ck143 FIND v(dout1_59) AT=720.025n

* CHECK dout1_60 Vdout1_60ck143 = 0 time = 720
.meas tran vdout1_60ck143 FIND v(dout1_60) AT=720.025n

* CHECK dout1_61 Vdout1_61ck143 = 0 time = 720
.meas tran vdout1_61ck143 FIND v(dout1_61) AT=720.025n

* CHECK dout1_62 Vdout1_62ck143 = 0 time = 720
.meas tran vdout1_62ck143 FIND v(dout1_62) AT=720.025n

* CHECK dout1_63 Vdout1_63ck143 = 0.9 time = 720
.meas tran vdout1_63ck143 FIND v(dout1_63) AT=720.025n

* CHECK dout1_0 Vdout1_0ck144 = 0.9 time = 725
.meas tran vdout1_0ck144 FIND v(dout1_0) AT=725.025n

* CHECK dout1_1 Vdout1_1ck144 = 0 time = 725
.meas tran vdout1_1ck144 FIND v(dout1_1) AT=725.025n

* CHECK dout1_2 Vdout1_2ck144 = 0.9 time = 725
.meas tran vdout1_2ck144 FIND v(dout1_2) AT=725.025n

* CHECK dout1_3 Vdout1_3ck144 = 0.9 time = 725
.meas tran vdout1_3ck144 FIND v(dout1_3) AT=725.025n

* CHECK dout1_4 Vdout1_4ck144 = 0.9 time = 725
.meas tran vdout1_4ck144 FIND v(dout1_4) AT=725.025n

* CHECK dout1_5 Vdout1_5ck144 = 0 time = 725
.meas tran vdout1_5ck144 FIND v(dout1_5) AT=725.025n

* CHECK dout1_6 Vdout1_6ck144 = 0.9 time = 725
.meas tran vdout1_6ck144 FIND v(dout1_6) AT=725.025n

* CHECK dout1_7 Vdout1_7ck144 = 0 time = 725
.meas tran vdout1_7ck144 FIND v(dout1_7) AT=725.025n

* CHECK dout1_8 Vdout1_8ck144 = 0.9 time = 725
.meas tran vdout1_8ck144 FIND v(dout1_8) AT=725.025n

* CHECK dout1_9 Vdout1_9ck144 = 0 time = 725
.meas tran vdout1_9ck144 FIND v(dout1_9) AT=725.025n

* CHECK dout1_10 Vdout1_10ck144 = 0 time = 725
.meas tran vdout1_10ck144 FIND v(dout1_10) AT=725.025n

* CHECK dout1_11 Vdout1_11ck144 = 0 time = 725
.meas tran vdout1_11ck144 FIND v(dout1_11) AT=725.025n

* CHECK dout1_12 Vdout1_12ck144 = 0 time = 725
.meas tran vdout1_12ck144 FIND v(dout1_12) AT=725.025n

* CHECK dout1_13 Vdout1_13ck144 = 0.9 time = 725
.meas tran vdout1_13ck144 FIND v(dout1_13) AT=725.025n

* CHECK dout1_14 Vdout1_14ck144 = 0.9 time = 725
.meas tran vdout1_14ck144 FIND v(dout1_14) AT=725.025n

* CHECK dout1_15 Vdout1_15ck144 = 0.9 time = 725
.meas tran vdout1_15ck144 FIND v(dout1_15) AT=725.025n

* CHECK dout1_16 Vdout1_16ck144 = 0.9 time = 725
.meas tran vdout1_16ck144 FIND v(dout1_16) AT=725.025n

* CHECK dout1_17 Vdout1_17ck144 = 0.9 time = 725
.meas tran vdout1_17ck144 FIND v(dout1_17) AT=725.025n

* CHECK dout1_18 Vdout1_18ck144 = 0 time = 725
.meas tran vdout1_18ck144 FIND v(dout1_18) AT=725.025n

* CHECK dout1_19 Vdout1_19ck144 = 0 time = 725
.meas tran vdout1_19ck144 FIND v(dout1_19) AT=725.025n

* CHECK dout1_20 Vdout1_20ck144 = 0 time = 725
.meas tran vdout1_20ck144 FIND v(dout1_20) AT=725.025n

* CHECK dout1_21 Vdout1_21ck144 = 0.9 time = 725
.meas tran vdout1_21ck144 FIND v(dout1_21) AT=725.025n

* CHECK dout1_22 Vdout1_22ck144 = 0 time = 725
.meas tran vdout1_22ck144 FIND v(dout1_22) AT=725.025n

* CHECK dout1_23 Vdout1_23ck144 = 0 time = 725
.meas tran vdout1_23ck144 FIND v(dout1_23) AT=725.025n

* CHECK dout1_24 Vdout1_24ck144 = 0 time = 725
.meas tran vdout1_24ck144 FIND v(dout1_24) AT=725.025n

* CHECK dout1_25 Vdout1_25ck144 = 0 time = 725
.meas tran vdout1_25ck144 FIND v(dout1_25) AT=725.025n

* CHECK dout1_26 Vdout1_26ck144 = 0.9 time = 725
.meas tran vdout1_26ck144 FIND v(dout1_26) AT=725.025n

* CHECK dout1_27 Vdout1_27ck144 = 0.9 time = 725
.meas tran vdout1_27ck144 FIND v(dout1_27) AT=725.025n

* CHECK dout1_28 Vdout1_28ck144 = 0.9 time = 725
.meas tran vdout1_28ck144 FIND v(dout1_28) AT=725.025n

* CHECK dout1_29 Vdout1_29ck144 = 0 time = 725
.meas tran vdout1_29ck144 FIND v(dout1_29) AT=725.025n

* CHECK dout1_30 Vdout1_30ck144 = 0 time = 725
.meas tran vdout1_30ck144 FIND v(dout1_30) AT=725.025n

* CHECK dout1_31 Vdout1_31ck144 = 0 time = 725
.meas tran vdout1_31ck144 FIND v(dout1_31) AT=725.025n

* CHECK dout1_32 Vdout1_32ck144 = 0.9 time = 725
.meas tran vdout1_32ck144 FIND v(dout1_32) AT=725.025n

* CHECK dout1_33 Vdout1_33ck144 = 0.9 time = 725
.meas tran vdout1_33ck144 FIND v(dout1_33) AT=725.025n

* CHECK dout1_34 Vdout1_34ck144 = 0 time = 725
.meas tran vdout1_34ck144 FIND v(dout1_34) AT=725.025n

* CHECK dout1_35 Vdout1_35ck144 = 0 time = 725
.meas tran vdout1_35ck144 FIND v(dout1_35) AT=725.025n

* CHECK dout1_36 Vdout1_36ck144 = 0.9 time = 725
.meas tran vdout1_36ck144 FIND v(dout1_36) AT=725.025n

* CHECK dout1_37 Vdout1_37ck144 = 0.9 time = 725
.meas tran vdout1_37ck144 FIND v(dout1_37) AT=725.025n

* CHECK dout1_38 Vdout1_38ck144 = 0 time = 725
.meas tran vdout1_38ck144 FIND v(dout1_38) AT=725.025n

* CHECK dout1_39 Vdout1_39ck144 = 0 time = 725
.meas tran vdout1_39ck144 FIND v(dout1_39) AT=725.025n

* CHECK dout1_40 Vdout1_40ck144 = 0 time = 725
.meas tran vdout1_40ck144 FIND v(dout1_40) AT=725.025n

* CHECK dout1_41 Vdout1_41ck144 = 0 time = 725
.meas tran vdout1_41ck144 FIND v(dout1_41) AT=725.025n

* CHECK dout1_42 Vdout1_42ck144 = 0 time = 725
.meas tran vdout1_42ck144 FIND v(dout1_42) AT=725.025n

* CHECK dout1_43 Vdout1_43ck144 = 0 time = 725
.meas tran vdout1_43ck144 FIND v(dout1_43) AT=725.025n

* CHECK dout1_44 Vdout1_44ck144 = 0.9 time = 725
.meas tran vdout1_44ck144 FIND v(dout1_44) AT=725.025n

* CHECK dout1_45 Vdout1_45ck144 = 0 time = 725
.meas tran vdout1_45ck144 FIND v(dout1_45) AT=725.025n

* CHECK dout1_46 Vdout1_46ck144 = 0 time = 725
.meas tran vdout1_46ck144 FIND v(dout1_46) AT=725.025n

* CHECK dout1_47 Vdout1_47ck144 = 0.9 time = 725
.meas tran vdout1_47ck144 FIND v(dout1_47) AT=725.025n

* CHECK dout1_48 Vdout1_48ck144 = 0.9 time = 725
.meas tran vdout1_48ck144 FIND v(dout1_48) AT=725.025n

* CHECK dout1_49 Vdout1_49ck144 = 0 time = 725
.meas tran vdout1_49ck144 FIND v(dout1_49) AT=725.025n

* CHECK dout1_50 Vdout1_50ck144 = 0.9 time = 725
.meas tran vdout1_50ck144 FIND v(dout1_50) AT=725.025n

* CHECK dout1_51 Vdout1_51ck144 = 0.9 time = 725
.meas tran vdout1_51ck144 FIND v(dout1_51) AT=725.025n

* CHECK dout1_52 Vdout1_52ck144 = 0 time = 725
.meas tran vdout1_52ck144 FIND v(dout1_52) AT=725.025n

* CHECK dout1_53 Vdout1_53ck144 = 0 time = 725
.meas tran vdout1_53ck144 FIND v(dout1_53) AT=725.025n

* CHECK dout1_54 Vdout1_54ck144 = 0 time = 725
.meas tran vdout1_54ck144 FIND v(dout1_54) AT=725.025n

* CHECK dout1_55 Vdout1_55ck144 = 0 time = 725
.meas tran vdout1_55ck144 FIND v(dout1_55) AT=725.025n

* CHECK dout1_56 Vdout1_56ck144 = 0 time = 725
.meas tran vdout1_56ck144 FIND v(dout1_56) AT=725.025n

* CHECK dout1_57 Vdout1_57ck144 = 0 time = 725
.meas tran vdout1_57ck144 FIND v(dout1_57) AT=725.025n

* CHECK dout1_58 Vdout1_58ck144 = 0.9 time = 725
.meas tran vdout1_58ck144 FIND v(dout1_58) AT=725.025n

* CHECK dout1_59 Vdout1_59ck144 = 0 time = 725
.meas tran vdout1_59ck144 FIND v(dout1_59) AT=725.025n

* CHECK dout1_60 Vdout1_60ck144 = 0 time = 725
.meas tran vdout1_60ck144 FIND v(dout1_60) AT=725.025n

* CHECK dout1_61 Vdout1_61ck144 = 0 time = 725
.meas tran vdout1_61ck144 FIND v(dout1_61) AT=725.025n

* CHECK dout1_62 Vdout1_62ck144 = 0 time = 725
.meas tran vdout1_62ck144 FIND v(dout1_62) AT=725.025n

* CHECK dout1_63 Vdout1_63ck144 = 0.9 time = 725
.meas tran vdout1_63ck144 FIND v(dout1_63) AT=725.025n

* CHECK dout1_0 Vdout1_0ck145 = 0.9 time = 730
.meas tran vdout1_0ck145 FIND v(dout1_0) AT=730.025n

* CHECK dout1_1 Vdout1_1ck145 = 0 time = 730
.meas tran vdout1_1ck145 FIND v(dout1_1) AT=730.025n

* CHECK dout1_2 Vdout1_2ck145 = 0.9 time = 730
.meas tran vdout1_2ck145 FIND v(dout1_2) AT=730.025n

* CHECK dout1_3 Vdout1_3ck145 = 0.9 time = 730
.meas tran vdout1_3ck145 FIND v(dout1_3) AT=730.025n

* CHECK dout1_4 Vdout1_4ck145 = 0.9 time = 730
.meas tran vdout1_4ck145 FIND v(dout1_4) AT=730.025n

* CHECK dout1_5 Vdout1_5ck145 = 0 time = 730
.meas tran vdout1_5ck145 FIND v(dout1_5) AT=730.025n

* CHECK dout1_6 Vdout1_6ck145 = 0.9 time = 730
.meas tran vdout1_6ck145 FIND v(dout1_6) AT=730.025n

* CHECK dout1_7 Vdout1_7ck145 = 0 time = 730
.meas tran vdout1_7ck145 FIND v(dout1_7) AT=730.025n

* CHECK dout1_8 Vdout1_8ck145 = 0.9 time = 730
.meas tran vdout1_8ck145 FIND v(dout1_8) AT=730.025n

* CHECK dout1_9 Vdout1_9ck145 = 0 time = 730
.meas tran vdout1_9ck145 FIND v(dout1_9) AT=730.025n

* CHECK dout1_10 Vdout1_10ck145 = 0 time = 730
.meas tran vdout1_10ck145 FIND v(dout1_10) AT=730.025n

* CHECK dout1_11 Vdout1_11ck145 = 0 time = 730
.meas tran vdout1_11ck145 FIND v(dout1_11) AT=730.025n

* CHECK dout1_12 Vdout1_12ck145 = 0 time = 730
.meas tran vdout1_12ck145 FIND v(dout1_12) AT=730.025n

* CHECK dout1_13 Vdout1_13ck145 = 0.9 time = 730
.meas tran vdout1_13ck145 FIND v(dout1_13) AT=730.025n

* CHECK dout1_14 Vdout1_14ck145 = 0.9 time = 730
.meas tran vdout1_14ck145 FIND v(dout1_14) AT=730.025n

* CHECK dout1_15 Vdout1_15ck145 = 0.9 time = 730
.meas tran vdout1_15ck145 FIND v(dout1_15) AT=730.025n

* CHECK dout1_16 Vdout1_16ck145 = 0.9 time = 730
.meas tran vdout1_16ck145 FIND v(dout1_16) AT=730.025n

* CHECK dout1_17 Vdout1_17ck145 = 0.9 time = 730
.meas tran vdout1_17ck145 FIND v(dout1_17) AT=730.025n

* CHECK dout1_18 Vdout1_18ck145 = 0 time = 730
.meas tran vdout1_18ck145 FIND v(dout1_18) AT=730.025n

* CHECK dout1_19 Vdout1_19ck145 = 0 time = 730
.meas tran vdout1_19ck145 FIND v(dout1_19) AT=730.025n

* CHECK dout1_20 Vdout1_20ck145 = 0 time = 730
.meas tran vdout1_20ck145 FIND v(dout1_20) AT=730.025n

* CHECK dout1_21 Vdout1_21ck145 = 0.9 time = 730
.meas tran vdout1_21ck145 FIND v(dout1_21) AT=730.025n

* CHECK dout1_22 Vdout1_22ck145 = 0 time = 730
.meas tran vdout1_22ck145 FIND v(dout1_22) AT=730.025n

* CHECK dout1_23 Vdout1_23ck145 = 0 time = 730
.meas tran vdout1_23ck145 FIND v(dout1_23) AT=730.025n

* CHECK dout1_24 Vdout1_24ck145 = 0 time = 730
.meas tran vdout1_24ck145 FIND v(dout1_24) AT=730.025n

* CHECK dout1_25 Vdout1_25ck145 = 0 time = 730
.meas tran vdout1_25ck145 FIND v(dout1_25) AT=730.025n

* CHECK dout1_26 Vdout1_26ck145 = 0.9 time = 730
.meas tran vdout1_26ck145 FIND v(dout1_26) AT=730.025n

* CHECK dout1_27 Vdout1_27ck145 = 0.9 time = 730
.meas tran vdout1_27ck145 FIND v(dout1_27) AT=730.025n

* CHECK dout1_28 Vdout1_28ck145 = 0.9 time = 730
.meas tran vdout1_28ck145 FIND v(dout1_28) AT=730.025n

* CHECK dout1_29 Vdout1_29ck145 = 0 time = 730
.meas tran vdout1_29ck145 FIND v(dout1_29) AT=730.025n

* CHECK dout1_30 Vdout1_30ck145 = 0 time = 730
.meas tran vdout1_30ck145 FIND v(dout1_30) AT=730.025n

* CHECK dout1_31 Vdout1_31ck145 = 0 time = 730
.meas tran vdout1_31ck145 FIND v(dout1_31) AT=730.025n

* CHECK dout1_32 Vdout1_32ck145 = 0.9 time = 730
.meas tran vdout1_32ck145 FIND v(dout1_32) AT=730.025n

* CHECK dout1_33 Vdout1_33ck145 = 0.9 time = 730
.meas tran vdout1_33ck145 FIND v(dout1_33) AT=730.025n

* CHECK dout1_34 Vdout1_34ck145 = 0 time = 730
.meas tran vdout1_34ck145 FIND v(dout1_34) AT=730.025n

* CHECK dout1_35 Vdout1_35ck145 = 0 time = 730
.meas tran vdout1_35ck145 FIND v(dout1_35) AT=730.025n

* CHECK dout1_36 Vdout1_36ck145 = 0.9 time = 730
.meas tran vdout1_36ck145 FIND v(dout1_36) AT=730.025n

* CHECK dout1_37 Vdout1_37ck145 = 0.9 time = 730
.meas tran vdout1_37ck145 FIND v(dout1_37) AT=730.025n

* CHECK dout1_38 Vdout1_38ck145 = 0 time = 730
.meas tran vdout1_38ck145 FIND v(dout1_38) AT=730.025n

* CHECK dout1_39 Vdout1_39ck145 = 0 time = 730
.meas tran vdout1_39ck145 FIND v(dout1_39) AT=730.025n

* CHECK dout1_40 Vdout1_40ck145 = 0 time = 730
.meas tran vdout1_40ck145 FIND v(dout1_40) AT=730.025n

* CHECK dout1_41 Vdout1_41ck145 = 0 time = 730
.meas tran vdout1_41ck145 FIND v(dout1_41) AT=730.025n

* CHECK dout1_42 Vdout1_42ck145 = 0 time = 730
.meas tran vdout1_42ck145 FIND v(dout1_42) AT=730.025n

* CHECK dout1_43 Vdout1_43ck145 = 0 time = 730
.meas tran vdout1_43ck145 FIND v(dout1_43) AT=730.025n

* CHECK dout1_44 Vdout1_44ck145 = 0.9 time = 730
.meas tran vdout1_44ck145 FIND v(dout1_44) AT=730.025n

* CHECK dout1_45 Vdout1_45ck145 = 0 time = 730
.meas tran vdout1_45ck145 FIND v(dout1_45) AT=730.025n

* CHECK dout1_46 Vdout1_46ck145 = 0 time = 730
.meas tran vdout1_46ck145 FIND v(dout1_46) AT=730.025n

* CHECK dout1_47 Vdout1_47ck145 = 0.9 time = 730
.meas tran vdout1_47ck145 FIND v(dout1_47) AT=730.025n

* CHECK dout1_48 Vdout1_48ck145 = 0.9 time = 730
.meas tran vdout1_48ck145 FIND v(dout1_48) AT=730.025n

* CHECK dout1_49 Vdout1_49ck145 = 0 time = 730
.meas tran vdout1_49ck145 FIND v(dout1_49) AT=730.025n

* CHECK dout1_50 Vdout1_50ck145 = 0.9 time = 730
.meas tran vdout1_50ck145 FIND v(dout1_50) AT=730.025n

* CHECK dout1_51 Vdout1_51ck145 = 0.9 time = 730
.meas tran vdout1_51ck145 FIND v(dout1_51) AT=730.025n

* CHECK dout1_52 Vdout1_52ck145 = 0 time = 730
.meas tran vdout1_52ck145 FIND v(dout1_52) AT=730.025n

* CHECK dout1_53 Vdout1_53ck145 = 0 time = 730
.meas tran vdout1_53ck145 FIND v(dout1_53) AT=730.025n

* CHECK dout1_54 Vdout1_54ck145 = 0 time = 730
.meas tran vdout1_54ck145 FIND v(dout1_54) AT=730.025n

* CHECK dout1_55 Vdout1_55ck145 = 0 time = 730
.meas tran vdout1_55ck145 FIND v(dout1_55) AT=730.025n

* CHECK dout1_56 Vdout1_56ck145 = 0 time = 730
.meas tran vdout1_56ck145 FIND v(dout1_56) AT=730.025n

* CHECK dout1_57 Vdout1_57ck145 = 0 time = 730
.meas tran vdout1_57ck145 FIND v(dout1_57) AT=730.025n

* CHECK dout1_58 Vdout1_58ck145 = 0.9 time = 730
.meas tran vdout1_58ck145 FIND v(dout1_58) AT=730.025n

* CHECK dout1_59 Vdout1_59ck145 = 0 time = 730
.meas tran vdout1_59ck145 FIND v(dout1_59) AT=730.025n

* CHECK dout1_60 Vdout1_60ck145 = 0 time = 730
.meas tran vdout1_60ck145 FIND v(dout1_60) AT=730.025n

* CHECK dout1_61 Vdout1_61ck145 = 0 time = 730
.meas tran vdout1_61ck145 FIND v(dout1_61) AT=730.025n

* CHECK dout1_62 Vdout1_62ck145 = 0 time = 730
.meas tran vdout1_62ck145 FIND v(dout1_62) AT=730.025n

* CHECK dout1_63 Vdout1_63ck145 = 0.9 time = 730
.meas tran vdout1_63ck145 FIND v(dout1_63) AT=730.025n

* CHECK dout1_0 Vdout1_0ck148 = 0.9 time = 745
.meas tran vdout1_0ck148 FIND v(dout1_0) AT=745.025n

* CHECK dout1_1 Vdout1_1ck148 = 0.9 time = 745
.meas tran vdout1_1ck148 FIND v(dout1_1) AT=745.025n

* CHECK dout1_2 Vdout1_2ck148 = 0 time = 745
.meas tran vdout1_2ck148 FIND v(dout1_2) AT=745.025n

* CHECK dout1_3 Vdout1_3ck148 = 0.9 time = 745
.meas tran vdout1_3ck148 FIND v(dout1_3) AT=745.025n

* CHECK dout1_4 Vdout1_4ck148 = 0 time = 745
.meas tran vdout1_4ck148 FIND v(dout1_4) AT=745.025n

* CHECK dout1_5 Vdout1_5ck148 = 0.9 time = 745
.meas tran vdout1_5ck148 FIND v(dout1_5) AT=745.025n

* CHECK dout1_6 Vdout1_6ck148 = 0 time = 745
.meas tran vdout1_6ck148 FIND v(dout1_6) AT=745.025n

* CHECK dout1_7 Vdout1_7ck148 = 0.9 time = 745
.meas tran vdout1_7ck148 FIND v(dout1_7) AT=745.025n

* CHECK dout1_8 Vdout1_8ck148 = 0 time = 745
.meas tran vdout1_8ck148 FIND v(dout1_8) AT=745.025n

* CHECK dout1_9 Vdout1_9ck148 = 0 time = 745
.meas tran vdout1_9ck148 FIND v(dout1_9) AT=745.025n

* CHECK dout1_10 Vdout1_10ck148 = 0.9 time = 745
.meas tran vdout1_10ck148 FIND v(dout1_10) AT=745.025n

* CHECK dout1_11 Vdout1_11ck148 = 0.9 time = 745
.meas tran vdout1_11ck148 FIND v(dout1_11) AT=745.025n

* CHECK dout1_12 Vdout1_12ck148 = 0 time = 745
.meas tran vdout1_12ck148 FIND v(dout1_12) AT=745.025n

* CHECK dout1_13 Vdout1_13ck148 = 0.9 time = 745
.meas tran vdout1_13ck148 FIND v(dout1_13) AT=745.025n

* CHECK dout1_14 Vdout1_14ck148 = 0.9 time = 745
.meas tran vdout1_14ck148 FIND v(dout1_14) AT=745.025n

* CHECK dout1_15 Vdout1_15ck148 = 0 time = 745
.meas tran vdout1_15ck148 FIND v(dout1_15) AT=745.025n

* CHECK dout1_16 Vdout1_16ck148 = 0 time = 745
.meas tran vdout1_16ck148 FIND v(dout1_16) AT=745.025n

* CHECK dout1_17 Vdout1_17ck148 = 0 time = 745
.meas tran vdout1_17ck148 FIND v(dout1_17) AT=745.025n

* CHECK dout1_18 Vdout1_18ck148 = 0.9 time = 745
.meas tran vdout1_18ck148 FIND v(dout1_18) AT=745.025n

* CHECK dout1_19 Vdout1_19ck148 = 0.9 time = 745
.meas tran vdout1_19ck148 FIND v(dout1_19) AT=745.025n

* CHECK dout1_20 Vdout1_20ck148 = 0 time = 745
.meas tran vdout1_20ck148 FIND v(dout1_20) AT=745.025n

* CHECK dout1_21 Vdout1_21ck148 = 0.9 time = 745
.meas tran vdout1_21ck148 FIND v(dout1_21) AT=745.025n

* CHECK dout1_22 Vdout1_22ck148 = 0.9 time = 745
.meas tran vdout1_22ck148 FIND v(dout1_22) AT=745.025n

* CHECK dout1_23 Vdout1_23ck148 = 0 time = 745
.meas tran vdout1_23ck148 FIND v(dout1_23) AT=745.025n

* CHECK dout1_24 Vdout1_24ck148 = 0.9 time = 745
.meas tran vdout1_24ck148 FIND v(dout1_24) AT=745.025n

* CHECK dout1_25 Vdout1_25ck148 = 0.9 time = 745
.meas tran vdout1_25ck148 FIND v(dout1_25) AT=745.025n

* CHECK dout1_26 Vdout1_26ck148 = 0 time = 745
.meas tran vdout1_26ck148 FIND v(dout1_26) AT=745.025n

* CHECK dout1_27 Vdout1_27ck148 = 0 time = 745
.meas tran vdout1_27ck148 FIND v(dout1_27) AT=745.025n

* CHECK dout1_28 Vdout1_28ck148 = 0 time = 745
.meas tran vdout1_28ck148 FIND v(dout1_28) AT=745.025n

* CHECK dout1_29 Vdout1_29ck148 = 0 time = 745
.meas tran vdout1_29ck148 FIND v(dout1_29) AT=745.025n

* CHECK dout1_30 Vdout1_30ck148 = 0 time = 745
.meas tran vdout1_30ck148 FIND v(dout1_30) AT=745.025n

* CHECK dout1_31 Vdout1_31ck148 = 0 time = 745
.meas tran vdout1_31ck148 FIND v(dout1_31) AT=745.025n

* CHECK dout1_32 Vdout1_32ck148 = 0.9 time = 745
.meas tran vdout1_32ck148 FIND v(dout1_32) AT=745.025n

* CHECK dout1_33 Vdout1_33ck148 = 0.9 time = 745
.meas tran vdout1_33ck148 FIND v(dout1_33) AT=745.025n

* CHECK dout1_34 Vdout1_34ck148 = 0 time = 745
.meas tran vdout1_34ck148 FIND v(dout1_34) AT=745.025n

* CHECK dout1_35 Vdout1_35ck148 = 0 time = 745
.meas tran vdout1_35ck148 FIND v(dout1_35) AT=745.025n

* CHECK dout1_36 Vdout1_36ck148 = 0 time = 745
.meas tran vdout1_36ck148 FIND v(dout1_36) AT=745.025n

* CHECK dout1_37 Vdout1_37ck148 = 0.9 time = 745
.meas tran vdout1_37ck148 FIND v(dout1_37) AT=745.025n

* CHECK dout1_38 Vdout1_38ck148 = 0 time = 745
.meas tran vdout1_38ck148 FIND v(dout1_38) AT=745.025n

* CHECK dout1_39 Vdout1_39ck148 = 0 time = 745
.meas tran vdout1_39ck148 FIND v(dout1_39) AT=745.025n

* CHECK dout1_40 Vdout1_40ck148 = 0.9 time = 745
.meas tran vdout1_40ck148 FIND v(dout1_40) AT=745.025n

* CHECK dout1_41 Vdout1_41ck148 = 0.9 time = 745
.meas tran vdout1_41ck148 FIND v(dout1_41) AT=745.025n

* CHECK dout1_42 Vdout1_42ck148 = 0 time = 745
.meas tran vdout1_42ck148 FIND v(dout1_42) AT=745.025n

* CHECK dout1_43 Vdout1_43ck148 = 0 time = 745
.meas tran vdout1_43ck148 FIND v(dout1_43) AT=745.025n

* CHECK dout1_44 Vdout1_44ck148 = 0.9 time = 745
.meas tran vdout1_44ck148 FIND v(dout1_44) AT=745.025n

* CHECK dout1_45 Vdout1_45ck148 = 0.9 time = 745
.meas tran vdout1_45ck148 FIND v(dout1_45) AT=745.025n

* CHECK dout1_46 Vdout1_46ck148 = 0.9 time = 745
.meas tran vdout1_46ck148 FIND v(dout1_46) AT=745.025n

* CHECK dout1_47 Vdout1_47ck148 = 0.9 time = 745
.meas tran vdout1_47ck148 FIND v(dout1_47) AT=745.025n

* CHECK dout1_48 Vdout1_48ck148 = 0.9 time = 745
.meas tran vdout1_48ck148 FIND v(dout1_48) AT=745.025n

* CHECK dout1_49 Vdout1_49ck148 = 0.9 time = 745
.meas tran vdout1_49ck148 FIND v(dout1_49) AT=745.025n

* CHECK dout1_50 Vdout1_50ck148 = 0.9 time = 745
.meas tran vdout1_50ck148 FIND v(dout1_50) AT=745.025n

* CHECK dout1_51 Vdout1_51ck148 = 0 time = 745
.meas tran vdout1_51ck148 FIND v(dout1_51) AT=745.025n

* CHECK dout1_52 Vdout1_52ck148 = 0 time = 745
.meas tran vdout1_52ck148 FIND v(dout1_52) AT=745.025n

* CHECK dout1_53 Vdout1_53ck148 = 0 time = 745
.meas tran vdout1_53ck148 FIND v(dout1_53) AT=745.025n

* CHECK dout1_54 Vdout1_54ck148 = 0 time = 745
.meas tran vdout1_54ck148 FIND v(dout1_54) AT=745.025n

* CHECK dout1_55 Vdout1_55ck148 = 0.9 time = 745
.meas tran vdout1_55ck148 FIND v(dout1_55) AT=745.025n

* CHECK dout1_56 Vdout1_56ck148 = 0.9 time = 745
.meas tran vdout1_56ck148 FIND v(dout1_56) AT=745.025n

* CHECK dout1_57 Vdout1_57ck148 = 0 time = 745
.meas tran vdout1_57ck148 FIND v(dout1_57) AT=745.025n

* CHECK dout1_58 Vdout1_58ck148 = 0.9 time = 745
.meas tran vdout1_58ck148 FIND v(dout1_58) AT=745.025n

* CHECK dout1_59 Vdout1_59ck148 = 0 time = 745
.meas tran vdout1_59ck148 FIND v(dout1_59) AT=745.025n

* CHECK dout1_60 Vdout1_60ck148 = 0 time = 745
.meas tran vdout1_60ck148 FIND v(dout1_60) AT=745.025n

* CHECK dout1_61 Vdout1_61ck148 = 0.9 time = 745
.meas tran vdout1_61ck148 FIND v(dout1_61) AT=745.025n

* CHECK dout1_62 Vdout1_62ck148 = 0.9 time = 745
.meas tran vdout1_62ck148 FIND v(dout1_62) AT=745.025n

* CHECK dout1_63 Vdout1_63ck148 = 0.9 time = 745
.meas tran vdout1_63ck148 FIND v(dout1_63) AT=745.025n

* CHECK dout1_0 Vdout1_0ck150 = 0.9 time = 755
.meas tran vdout1_0ck150 FIND v(dout1_0) AT=755.025n

* CHECK dout1_1 Vdout1_1ck150 = 0.9 time = 755
.meas tran vdout1_1ck150 FIND v(dout1_1) AT=755.025n

* CHECK dout1_2 Vdout1_2ck150 = 0 time = 755
.meas tran vdout1_2ck150 FIND v(dout1_2) AT=755.025n

* CHECK dout1_3 Vdout1_3ck150 = 0.9 time = 755
.meas tran vdout1_3ck150 FIND v(dout1_3) AT=755.025n

* CHECK dout1_4 Vdout1_4ck150 = 0.9 time = 755
.meas tran vdout1_4ck150 FIND v(dout1_4) AT=755.025n

* CHECK dout1_5 Vdout1_5ck150 = 0 time = 755
.meas tran vdout1_5ck150 FIND v(dout1_5) AT=755.025n

* CHECK dout1_6 Vdout1_6ck150 = 0 time = 755
.meas tran vdout1_6ck150 FIND v(dout1_6) AT=755.025n

* CHECK dout1_7 Vdout1_7ck150 = 0 time = 755
.meas tran vdout1_7ck150 FIND v(dout1_7) AT=755.025n

* CHECK dout1_8 Vdout1_8ck150 = 0.9 time = 755
.meas tran vdout1_8ck150 FIND v(dout1_8) AT=755.025n

* CHECK dout1_9 Vdout1_9ck150 = 0 time = 755
.meas tran vdout1_9ck150 FIND v(dout1_9) AT=755.025n

* CHECK dout1_10 Vdout1_10ck150 = 0.9 time = 755
.meas tran vdout1_10ck150 FIND v(dout1_10) AT=755.025n

* CHECK dout1_11 Vdout1_11ck150 = 0.9 time = 755
.meas tran vdout1_11ck150 FIND v(dout1_11) AT=755.025n

* CHECK dout1_12 Vdout1_12ck150 = 0.9 time = 755
.meas tran vdout1_12ck150 FIND v(dout1_12) AT=755.025n

* CHECK dout1_13 Vdout1_13ck150 = 0.9 time = 755
.meas tran vdout1_13ck150 FIND v(dout1_13) AT=755.025n

* CHECK dout1_14 Vdout1_14ck150 = 0.9 time = 755
.meas tran vdout1_14ck150 FIND v(dout1_14) AT=755.025n

* CHECK dout1_15 Vdout1_15ck150 = 0 time = 755
.meas tran vdout1_15ck150 FIND v(dout1_15) AT=755.025n

* CHECK dout1_16 Vdout1_16ck150 = 0.9 time = 755
.meas tran vdout1_16ck150 FIND v(dout1_16) AT=755.025n

* CHECK dout1_17 Vdout1_17ck150 = 0.9 time = 755
.meas tran vdout1_17ck150 FIND v(dout1_17) AT=755.025n

* CHECK dout1_18 Vdout1_18ck150 = 0 time = 755
.meas tran vdout1_18ck150 FIND v(dout1_18) AT=755.025n

* CHECK dout1_19 Vdout1_19ck150 = 0.9 time = 755
.meas tran vdout1_19ck150 FIND v(dout1_19) AT=755.025n

* CHECK dout1_20 Vdout1_20ck150 = 0 time = 755
.meas tran vdout1_20ck150 FIND v(dout1_20) AT=755.025n

* CHECK dout1_21 Vdout1_21ck150 = 0 time = 755
.meas tran vdout1_21ck150 FIND v(dout1_21) AT=755.025n

* CHECK dout1_22 Vdout1_22ck150 = 0 time = 755
.meas tran vdout1_22ck150 FIND v(dout1_22) AT=755.025n

* CHECK dout1_23 Vdout1_23ck150 = 0.9 time = 755
.meas tran vdout1_23ck150 FIND v(dout1_23) AT=755.025n

* CHECK dout1_24 Vdout1_24ck150 = 0 time = 755
.meas tran vdout1_24ck150 FIND v(dout1_24) AT=755.025n

* CHECK dout1_25 Vdout1_25ck150 = 0.9 time = 755
.meas tran vdout1_25ck150 FIND v(dout1_25) AT=755.025n

* CHECK dout1_26 Vdout1_26ck150 = 0.9 time = 755
.meas tran vdout1_26ck150 FIND v(dout1_26) AT=755.025n

* CHECK dout1_27 Vdout1_27ck150 = 0 time = 755
.meas tran vdout1_27ck150 FIND v(dout1_27) AT=755.025n

* CHECK dout1_28 Vdout1_28ck150 = 0 time = 755
.meas tran vdout1_28ck150 FIND v(dout1_28) AT=755.025n

* CHECK dout1_29 Vdout1_29ck150 = 0 time = 755
.meas tran vdout1_29ck150 FIND v(dout1_29) AT=755.025n

* CHECK dout1_30 Vdout1_30ck150 = 0.9 time = 755
.meas tran vdout1_30ck150 FIND v(dout1_30) AT=755.025n

* CHECK dout1_31 Vdout1_31ck150 = 0.9 time = 755
.meas tran vdout1_31ck150 FIND v(dout1_31) AT=755.025n

* CHECK dout1_32 Vdout1_32ck150 = 0 time = 755
.meas tran vdout1_32ck150 FIND v(dout1_32) AT=755.025n

* CHECK dout1_33 Vdout1_33ck150 = 0.9 time = 755
.meas tran vdout1_33ck150 FIND v(dout1_33) AT=755.025n

* CHECK dout1_34 Vdout1_34ck150 = 0.9 time = 755
.meas tran vdout1_34ck150 FIND v(dout1_34) AT=755.025n

* CHECK dout1_35 Vdout1_35ck150 = 0 time = 755
.meas tran vdout1_35ck150 FIND v(dout1_35) AT=755.025n

* CHECK dout1_36 Vdout1_36ck150 = 0.9 time = 755
.meas tran vdout1_36ck150 FIND v(dout1_36) AT=755.025n

* CHECK dout1_37 Vdout1_37ck150 = 0.9 time = 755
.meas tran vdout1_37ck150 FIND v(dout1_37) AT=755.025n

* CHECK dout1_38 Vdout1_38ck150 = 0 time = 755
.meas tran vdout1_38ck150 FIND v(dout1_38) AT=755.025n

* CHECK dout1_39 Vdout1_39ck150 = 0 time = 755
.meas tran vdout1_39ck150 FIND v(dout1_39) AT=755.025n

* CHECK dout1_40 Vdout1_40ck150 = 0.9 time = 755
.meas tran vdout1_40ck150 FIND v(dout1_40) AT=755.025n

* CHECK dout1_41 Vdout1_41ck150 = 0 time = 755
.meas tran vdout1_41ck150 FIND v(dout1_41) AT=755.025n

* CHECK dout1_42 Vdout1_42ck150 = 0 time = 755
.meas tran vdout1_42ck150 FIND v(dout1_42) AT=755.025n

* CHECK dout1_43 Vdout1_43ck150 = 0.9 time = 755
.meas tran vdout1_43ck150 FIND v(dout1_43) AT=755.025n

* CHECK dout1_44 Vdout1_44ck150 = 0.9 time = 755
.meas tran vdout1_44ck150 FIND v(dout1_44) AT=755.025n

* CHECK dout1_45 Vdout1_45ck150 = 0 time = 755
.meas tran vdout1_45ck150 FIND v(dout1_45) AT=755.025n

* CHECK dout1_46 Vdout1_46ck150 = 0 time = 755
.meas tran vdout1_46ck150 FIND v(dout1_46) AT=755.025n

* CHECK dout1_47 Vdout1_47ck150 = 0.9 time = 755
.meas tran vdout1_47ck150 FIND v(dout1_47) AT=755.025n

* CHECK dout1_48 Vdout1_48ck150 = 0.9 time = 755
.meas tran vdout1_48ck150 FIND v(dout1_48) AT=755.025n

* CHECK dout1_49 Vdout1_49ck150 = 0 time = 755
.meas tran vdout1_49ck150 FIND v(dout1_49) AT=755.025n

* CHECK dout1_50 Vdout1_50ck150 = 0 time = 755
.meas tran vdout1_50ck150 FIND v(dout1_50) AT=755.025n

* CHECK dout1_51 Vdout1_51ck150 = 0.9 time = 755
.meas tran vdout1_51ck150 FIND v(dout1_51) AT=755.025n

* CHECK dout1_52 Vdout1_52ck150 = 0 time = 755
.meas tran vdout1_52ck150 FIND v(dout1_52) AT=755.025n

* CHECK dout1_53 Vdout1_53ck150 = 0 time = 755
.meas tran vdout1_53ck150 FIND v(dout1_53) AT=755.025n

* CHECK dout1_54 Vdout1_54ck150 = 0 time = 755
.meas tran vdout1_54ck150 FIND v(dout1_54) AT=755.025n

* CHECK dout1_55 Vdout1_55ck150 = 0 time = 755
.meas tran vdout1_55ck150 FIND v(dout1_55) AT=755.025n

* CHECK dout1_56 Vdout1_56ck150 = 0.9 time = 755
.meas tran vdout1_56ck150 FIND v(dout1_56) AT=755.025n

* CHECK dout1_57 Vdout1_57ck150 = 0 time = 755
.meas tran vdout1_57ck150 FIND v(dout1_57) AT=755.025n

* CHECK dout1_58 Vdout1_58ck150 = 0.9 time = 755
.meas tran vdout1_58ck150 FIND v(dout1_58) AT=755.025n

* CHECK dout1_59 Vdout1_59ck150 = 0 time = 755
.meas tran vdout1_59ck150 FIND v(dout1_59) AT=755.025n

* CHECK dout1_60 Vdout1_60ck150 = 0 time = 755
.meas tran vdout1_60ck150 FIND v(dout1_60) AT=755.025n

* CHECK dout1_61 Vdout1_61ck150 = 0 time = 755
.meas tran vdout1_61ck150 FIND v(dout1_61) AT=755.025n

* CHECK dout1_62 Vdout1_62ck150 = 0.9 time = 755
.meas tran vdout1_62ck150 FIND v(dout1_62) AT=755.025n

* CHECK dout1_63 Vdout1_63ck150 = 0.9 time = 755
.meas tran vdout1_63ck150 FIND v(dout1_63) AT=755.025n

* CHECK dout1_0 Vdout1_0ck151 = 0.9 time = 760
.meas tran vdout1_0ck151 FIND v(dout1_0) AT=760.025n

* CHECK dout1_1 Vdout1_1ck151 = 0.9 time = 760
.meas tran vdout1_1ck151 FIND v(dout1_1) AT=760.025n

* CHECK dout1_2 Vdout1_2ck151 = 0 time = 760
.meas tran vdout1_2ck151 FIND v(dout1_2) AT=760.025n

* CHECK dout1_3 Vdout1_3ck151 = 0.9 time = 760
.meas tran vdout1_3ck151 FIND v(dout1_3) AT=760.025n

* CHECK dout1_4 Vdout1_4ck151 = 0 time = 760
.meas tran vdout1_4ck151 FIND v(dout1_4) AT=760.025n

* CHECK dout1_5 Vdout1_5ck151 = 0.9 time = 760
.meas tran vdout1_5ck151 FIND v(dout1_5) AT=760.025n

* CHECK dout1_6 Vdout1_6ck151 = 0 time = 760
.meas tran vdout1_6ck151 FIND v(dout1_6) AT=760.025n

* CHECK dout1_7 Vdout1_7ck151 = 0.9 time = 760
.meas tran vdout1_7ck151 FIND v(dout1_7) AT=760.025n

* CHECK dout1_8 Vdout1_8ck151 = 0 time = 760
.meas tran vdout1_8ck151 FIND v(dout1_8) AT=760.025n

* CHECK dout1_9 Vdout1_9ck151 = 0 time = 760
.meas tran vdout1_9ck151 FIND v(dout1_9) AT=760.025n

* CHECK dout1_10 Vdout1_10ck151 = 0.9 time = 760
.meas tran vdout1_10ck151 FIND v(dout1_10) AT=760.025n

* CHECK dout1_11 Vdout1_11ck151 = 0.9 time = 760
.meas tran vdout1_11ck151 FIND v(dout1_11) AT=760.025n

* CHECK dout1_12 Vdout1_12ck151 = 0 time = 760
.meas tran vdout1_12ck151 FIND v(dout1_12) AT=760.025n

* CHECK dout1_13 Vdout1_13ck151 = 0.9 time = 760
.meas tran vdout1_13ck151 FIND v(dout1_13) AT=760.025n

* CHECK dout1_14 Vdout1_14ck151 = 0.9 time = 760
.meas tran vdout1_14ck151 FIND v(dout1_14) AT=760.025n

* CHECK dout1_15 Vdout1_15ck151 = 0 time = 760
.meas tran vdout1_15ck151 FIND v(dout1_15) AT=760.025n

* CHECK dout1_16 Vdout1_16ck151 = 0 time = 760
.meas tran vdout1_16ck151 FIND v(dout1_16) AT=760.025n

* CHECK dout1_17 Vdout1_17ck151 = 0 time = 760
.meas tran vdout1_17ck151 FIND v(dout1_17) AT=760.025n

* CHECK dout1_18 Vdout1_18ck151 = 0.9 time = 760
.meas tran vdout1_18ck151 FIND v(dout1_18) AT=760.025n

* CHECK dout1_19 Vdout1_19ck151 = 0.9 time = 760
.meas tran vdout1_19ck151 FIND v(dout1_19) AT=760.025n

* CHECK dout1_20 Vdout1_20ck151 = 0 time = 760
.meas tran vdout1_20ck151 FIND v(dout1_20) AT=760.025n

* CHECK dout1_21 Vdout1_21ck151 = 0.9 time = 760
.meas tran vdout1_21ck151 FIND v(dout1_21) AT=760.025n

* CHECK dout1_22 Vdout1_22ck151 = 0.9 time = 760
.meas tran vdout1_22ck151 FIND v(dout1_22) AT=760.025n

* CHECK dout1_23 Vdout1_23ck151 = 0 time = 760
.meas tran vdout1_23ck151 FIND v(dout1_23) AT=760.025n

* CHECK dout1_24 Vdout1_24ck151 = 0.9 time = 760
.meas tran vdout1_24ck151 FIND v(dout1_24) AT=760.025n

* CHECK dout1_25 Vdout1_25ck151 = 0.9 time = 760
.meas tran vdout1_25ck151 FIND v(dout1_25) AT=760.025n

* CHECK dout1_26 Vdout1_26ck151 = 0 time = 760
.meas tran vdout1_26ck151 FIND v(dout1_26) AT=760.025n

* CHECK dout1_27 Vdout1_27ck151 = 0 time = 760
.meas tran vdout1_27ck151 FIND v(dout1_27) AT=760.025n

* CHECK dout1_28 Vdout1_28ck151 = 0 time = 760
.meas tran vdout1_28ck151 FIND v(dout1_28) AT=760.025n

* CHECK dout1_29 Vdout1_29ck151 = 0 time = 760
.meas tran vdout1_29ck151 FIND v(dout1_29) AT=760.025n

* CHECK dout1_30 Vdout1_30ck151 = 0 time = 760
.meas tran vdout1_30ck151 FIND v(dout1_30) AT=760.025n

* CHECK dout1_31 Vdout1_31ck151 = 0 time = 760
.meas tran vdout1_31ck151 FIND v(dout1_31) AT=760.025n

* CHECK dout1_32 Vdout1_32ck151 = 0.9 time = 760
.meas tran vdout1_32ck151 FIND v(dout1_32) AT=760.025n

* CHECK dout1_33 Vdout1_33ck151 = 0.9 time = 760
.meas tran vdout1_33ck151 FIND v(dout1_33) AT=760.025n

* CHECK dout1_34 Vdout1_34ck151 = 0 time = 760
.meas tran vdout1_34ck151 FIND v(dout1_34) AT=760.025n

* CHECK dout1_35 Vdout1_35ck151 = 0 time = 760
.meas tran vdout1_35ck151 FIND v(dout1_35) AT=760.025n

* CHECK dout1_36 Vdout1_36ck151 = 0 time = 760
.meas tran vdout1_36ck151 FIND v(dout1_36) AT=760.025n

* CHECK dout1_37 Vdout1_37ck151 = 0.9 time = 760
.meas tran vdout1_37ck151 FIND v(dout1_37) AT=760.025n

* CHECK dout1_38 Vdout1_38ck151 = 0 time = 760
.meas tran vdout1_38ck151 FIND v(dout1_38) AT=760.025n

* CHECK dout1_39 Vdout1_39ck151 = 0 time = 760
.meas tran vdout1_39ck151 FIND v(dout1_39) AT=760.025n

* CHECK dout1_40 Vdout1_40ck151 = 0.9 time = 760
.meas tran vdout1_40ck151 FIND v(dout1_40) AT=760.025n

* CHECK dout1_41 Vdout1_41ck151 = 0.9 time = 760
.meas tran vdout1_41ck151 FIND v(dout1_41) AT=760.025n

* CHECK dout1_42 Vdout1_42ck151 = 0 time = 760
.meas tran vdout1_42ck151 FIND v(dout1_42) AT=760.025n

* CHECK dout1_43 Vdout1_43ck151 = 0 time = 760
.meas tran vdout1_43ck151 FIND v(dout1_43) AT=760.025n

* CHECK dout1_44 Vdout1_44ck151 = 0.9 time = 760
.meas tran vdout1_44ck151 FIND v(dout1_44) AT=760.025n

* CHECK dout1_45 Vdout1_45ck151 = 0.9 time = 760
.meas tran vdout1_45ck151 FIND v(dout1_45) AT=760.025n

* CHECK dout1_46 Vdout1_46ck151 = 0.9 time = 760
.meas tran vdout1_46ck151 FIND v(dout1_46) AT=760.025n

* CHECK dout1_47 Vdout1_47ck151 = 0.9 time = 760
.meas tran vdout1_47ck151 FIND v(dout1_47) AT=760.025n

* CHECK dout1_48 Vdout1_48ck151 = 0.9 time = 760
.meas tran vdout1_48ck151 FIND v(dout1_48) AT=760.025n

* CHECK dout1_49 Vdout1_49ck151 = 0.9 time = 760
.meas tran vdout1_49ck151 FIND v(dout1_49) AT=760.025n

* CHECK dout1_50 Vdout1_50ck151 = 0.9 time = 760
.meas tran vdout1_50ck151 FIND v(dout1_50) AT=760.025n

* CHECK dout1_51 Vdout1_51ck151 = 0 time = 760
.meas tran vdout1_51ck151 FIND v(dout1_51) AT=760.025n

* CHECK dout1_52 Vdout1_52ck151 = 0 time = 760
.meas tran vdout1_52ck151 FIND v(dout1_52) AT=760.025n

* CHECK dout1_53 Vdout1_53ck151 = 0 time = 760
.meas tran vdout1_53ck151 FIND v(dout1_53) AT=760.025n

* CHECK dout1_54 Vdout1_54ck151 = 0 time = 760
.meas tran vdout1_54ck151 FIND v(dout1_54) AT=760.025n

* CHECK dout1_55 Vdout1_55ck151 = 0.9 time = 760
.meas tran vdout1_55ck151 FIND v(dout1_55) AT=760.025n

* CHECK dout1_56 Vdout1_56ck151 = 0.9 time = 760
.meas tran vdout1_56ck151 FIND v(dout1_56) AT=760.025n

* CHECK dout1_57 Vdout1_57ck151 = 0 time = 760
.meas tran vdout1_57ck151 FIND v(dout1_57) AT=760.025n

* CHECK dout1_58 Vdout1_58ck151 = 0.9 time = 760
.meas tran vdout1_58ck151 FIND v(dout1_58) AT=760.025n

* CHECK dout1_59 Vdout1_59ck151 = 0 time = 760
.meas tran vdout1_59ck151 FIND v(dout1_59) AT=760.025n

* CHECK dout1_60 Vdout1_60ck151 = 0 time = 760
.meas tran vdout1_60ck151 FIND v(dout1_60) AT=760.025n

* CHECK dout1_61 Vdout1_61ck151 = 0.9 time = 760
.meas tran vdout1_61ck151 FIND v(dout1_61) AT=760.025n

* CHECK dout1_62 Vdout1_62ck151 = 0.9 time = 760
.meas tran vdout1_62ck151 FIND v(dout1_62) AT=760.025n

* CHECK dout1_63 Vdout1_63ck151 = 0.9 time = 760
.meas tran vdout1_63ck151 FIND v(dout1_63) AT=760.025n

* CHECK dout1_0 Vdout1_0ck153 = 0.9 time = 770
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=770.025n

* CHECK dout1_1 Vdout1_1ck153 = 0 time = 770
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=770.025n

* CHECK dout1_2 Vdout1_2ck153 = 0 time = 770
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=770.025n

* CHECK dout1_3 Vdout1_3ck153 = 0.9 time = 770
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=770.025n

* CHECK dout1_4 Vdout1_4ck153 = 0 time = 770
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=770.025n

* CHECK dout1_5 Vdout1_5ck153 = 0 time = 770
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=770.025n

* CHECK dout1_6 Vdout1_6ck153 = 0.9 time = 770
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=770.025n

* CHECK dout1_7 Vdout1_7ck153 = 0.9 time = 770
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=770.025n

* CHECK dout1_8 Vdout1_8ck153 = 0 time = 770
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=770.025n

* CHECK dout1_9 Vdout1_9ck153 = 0 time = 770
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=770.025n

* CHECK dout1_10 Vdout1_10ck153 = 0.9 time = 770
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=770.025n

* CHECK dout1_11 Vdout1_11ck153 = 0.9 time = 770
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=770.025n

* CHECK dout1_12 Vdout1_12ck153 = 0.9 time = 770
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=770.025n

* CHECK dout1_13 Vdout1_13ck153 = 0 time = 770
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=770.025n

* CHECK dout1_14 Vdout1_14ck153 = 0.9 time = 770
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=770.025n

* CHECK dout1_15 Vdout1_15ck153 = 0.9 time = 770
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=770.025n

* CHECK dout1_16 Vdout1_16ck153 = 0.9 time = 770
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=770.025n

* CHECK dout1_17 Vdout1_17ck153 = 0.9 time = 770
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=770.025n

* CHECK dout1_18 Vdout1_18ck153 = 0.9 time = 770
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=770.025n

* CHECK dout1_19 Vdout1_19ck153 = 0 time = 770
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=770.025n

* CHECK dout1_20 Vdout1_20ck153 = 0.9 time = 770
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=770.025n

* CHECK dout1_21 Vdout1_21ck153 = 0 time = 770
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=770.025n

* CHECK dout1_22 Vdout1_22ck153 = 0.9 time = 770
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=770.025n

* CHECK dout1_23 Vdout1_23ck153 = 0 time = 770
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=770.025n

* CHECK dout1_24 Vdout1_24ck153 = 0.9 time = 770
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=770.025n

* CHECK dout1_25 Vdout1_25ck153 = 0 time = 770
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=770.025n

* CHECK dout1_26 Vdout1_26ck153 = 0.9 time = 770
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=770.025n

* CHECK dout1_27 Vdout1_27ck153 = 0 time = 770
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=770.025n

* CHECK dout1_28 Vdout1_28ck153 = 0.9 time = 770
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=770.025n

* CHECK dout1_29 Vdout1_29ck153 = 0.9 time = 770
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=770.025n

* CHECK dout1_30 Vdout1_30ck153 = 0.9 time = 770
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=770.025n

* CHECK dout1_31 Vdout1_31ck153 = 0 time = 770
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=770.025n

* CHECK dout1_32 Vdout1_32ck153 = 0 time = 770
.meas tran vdout1_32ck153 FIND v(dout1_32) AT=770.025n

* CHECK dout1_33 Vdout1_33ck153 = 0 time = 770
.meas tran vdout1_33ck153 FIND v(dout1_33) AT=770.025n

* CHECK dout1_34 Vdout1_34ck153 = 0 time = 770
.meas tran vdout1_34ck153 FIND v(dout1_34) AT=770.025n

* CHECK dout1_35 Vdout1_35ck153 = 0 time = 770
.meas tran vdout1_35ck153 FIND v(dout1_35) AT=770.025n

* CHECK dout1_36 Vdout1_36ck153 = 0 time = 770
.meas tran vdout1_36ck153 FIND v(dout1_36) AT=770.025n

* CHECK dout1_37 Vdout1_37ck153 = 0.9 time = 770
.meas tran vdout1_37ck153 FIND v(dout1_37) AT=770.025n

* CHECK dout1_38 Vdout1_38ck153 = 0 time = 770
.meas tran vdout1_38ck153 FIND v(dout1_38) AT=770.025n

* CHECK dout1_39 Vdout1_39ck153 = 0.9 time = 770
.meas tran vdout1_39ck153 FIND v(dout1_39) AT=770.025n

* CHECK dout1_40 Vdout1_40ck153 = 0 time = 770
.meas tran vdout1_40ck153 FIND v(dout1_40) AT=770.025n

* CHECK dout1_41 Vdout1_41ck153 = 0.9 time = 770
.meas tran vdout1_41ck153 FIND v(dout1_41) AT=770.025n

* CHECK dout1_42 Vdout1_42ck153 = 0.9 time = 770
.meas tran vdout1_42ck153 FIND v(dout1_42) AT=770.025n

* CHECK dout1_43 Vdout1_43ck153 = 0 time = 770
.meas tran vdout1_43ck153 FIND v(dout1_43) AT=770.025n

* CHECK dout1_44 Vdout1_44ck153 = 0.9 time = 770
.meas tran vdout1_44ck153 FIND v(dout1_44) AT=770.025n

* CHECK dout1_45 Vdout1_45ck153 = 0 time = 770
.meas tran vdout1_45ck153 FIND v(dout1_45) AT=770.025n

* CHECK dout1_46 Vdout1_46ck153 = 0.9 time = 770
.meas tran vdout1_46ck153 FIND v(dout1_46) AT=770.025n

* CHECK dout1_47 Vdout1_47ck153 = 0 time = 770
.meas tran vdout1_47ck153 FIND v(dout1_47) AT=770.025n

* CHECK dout1_48 Vdout1_48ck153 = 0 time = 770
.meas tran vdout1_48ck153 FIND v(dout1_48) AT=770.025n

* CHECK dout1_49 Vdout1_49ck153 = 0.9 time = 770
.meas tran vdout1_49ck153 FIND v(dout1_49) AT=770.025n

* CHECK dout1_50 Vdout1_50ck153 = 0 time = 770
.meas tran vdout1_50ck153 FIND v(dout1_50) AT=770.025n

* CHECK dout1_51 Vdout1_51ck153 = 0.9 time = 770
.meas tran vdout1_51ck153 FIND v(dout1_51) AT=770.025n

* CHECK dout1_52 Vdout1_52ck153 = 0 time = 770
.meas tran vdout1_52ck153 FIND v(dout1_52) AT=770.025n

* CHECK dout1_53 Vdout1_53ck153 = 0 time = 770
.meas tran vdout1_53ck153 FIND v(dout1_53) AT=770.025n

* CHECK dout1_54 Vdout1_54ck153 = 0.9 time = 770
.meas tran vdout1_54ck153 FIND v(dout1_54) AT=770.025n

* CHECK dout1_55 Vdout1_55ck153 = 0.9 time = 770
.meas tran vdout1_55ck153 FIND v(dout1_55) AT=770.025n

* CHECK dout1_56 Vdout1_56ck153 = 0 time = 770
.meas tran vdout1_56ck153 FIND v(dout1_56) AT=770.025n

* CHECK dout1_57 Vdout1_57ck153 = 0 time = 770
.meas tran vdout1_57ck153 FIND v(dout1_57) AT=770.025n

* CHECK dout1_58 Vdout1_58ck153 = 0 time = 770
.meas tran vdout1_58ck153 FIND v(dout1_58) AT=770.025n

* CHECK dout1_59 Vdout1_59ck153 = 0.9 time = 770
.meas tran vdout1_59ck153 FIND v(dout1_59) AT=770.025n

* CHECK dout1_60 Vdout1_60ck153 = 0 time = 770
.meas tran vdout1_60ck153 FIND v(dout1_60) AT=770.025n

* CHECK dout1_61 Vdout1_61ck153 = 0 time = 770
.meas tran vdout1_61ck153 FIND v(dout1_61) AT=770.025n

* CHECK dout1_62 Vdout1_62ck153 = 0 time = 770
.meas tran vdout1_62ck153 FIND v(dout1_62) AT=770.025n

* CHECK dout1_63 Vdout1_63ck153 = 0 time = 770
.meas tran vdout1_63ck153 FIND v(dout1_63) AT=770.025n

* CHECK dout1_0 Vdout1_0ck154 = 0.9 time = 775
.meas tran vdout1_0ck154 FIND v(dout1_0) AT=775.025n

* CHECK dout1_1 Vdout1_1ck154 = 0 time = 775
.meas tran vdout1_1ck154 FIND v(dout1_1) AT=775.025n

* CHECK dout1_2 Vdout1_2ck154 = 0 time = 775
.meas tran vdout1_2ck154 FIND v(dout1_2) AT=775.025n

* CHECK dout1_3 Vdout1_3ck154 = 0.9 time = 775
.meas tran vdout1_3ck154 FIND v(dout1_3) AT=775.025n

* CHECK dout1_4 Vdout1_4ck154 = 0 time = 775
.meas tran vdout1_4ck154 FIND v(dout1_4) AT=775.025n

* CHECK dout1_5 Vdout1_5ck154 = 0 time = 775
.meas tran vdout1_5ck154 FIND v(dout1_5) AT=775.025n

* CHECK dout1_6 Vdout1_6ck154 = 0.9 time = 775
.meas tran vdout1_6ck154 FIND v(dout1_6) AT=775.025n

* CHECK dout1_7 Vdout1_7ck154 = 0.9 time = 775
.meas tran vdout1_7ck154 FIND v(dout1_7) AT=775.025n

* CHECK dout1_8 Vdout1_8ck154 = 0 time = 775
.meas tran vdout1_8ck154 FIND v(dout1_8) AT=775.025n

* CHECK dout1_9 Vdout1_9ck154 = 0 time = 775
.meas tran vdout1_9ck154 FIND v(dout1_9) AT=775.025n

* CHECK dout1_10 Vdout1_10ck154 = 0.9 time = 775
.meas tran vdout1_10ck154 FIND v(dout1_10) AT=775.025n

* CHECK dout1_11 Vdout1_11ck154 = 0.9 time = 775
.meas tran vdout1_11ck154 FIND v(dout1_11) AT=775.025n

* CHECK dout1_12 Vdout1_12ck154 = 0.9 time = 775
.meas tran vdout1_12ck154 FIND v(dout1_12) AT=775.025n

* CHECK dout1_13 Vdout1_13ck154 = 0 time = 775
.meas tran vdout1_13ck154 FIND v(dout1_13) AT=775.025n

* CHECK dout1_14 Vdout1_14ck154 = 0.9 time = 775
.meas tran vdout1_14ck154 FIND v(dout1_14) AT=775.025n

* CHECK dout1_15 Vdout1_15ck154 = 0.9 time = 775
.meas tran vdout1_15ck154 FIND v(dout1_15) AT=775.025n

* CHECK dout1_16 Vdout1_16ck154 = 0.9 time = 775
.meas tran vdout1_16ck154 FIND v(dout1_16) AT=775.025n

* CHECK dout1_17 Vdout1_17ck154 = 0.9 time = 775
.meas tran vdout1_17ck154 FIND v(dout1_17) AT=775.025n

* CHECK dout1_18 Vdout1_18ck154 = 0.9 time = 775
.meas tran vdout1_18ck154 FIND v(dout1_18) AT=775.025n

* CHECK dout1_19 Vdout1_19ck154 = 0 time = 775
.meas tran vdout1_19ck154 FIND v(dout1_19) AT=775.025n

* CHECK dout1_20 Vdout1_20ck154 = 0.9 time = 775
.meas tran vdout1_20ck154 FIND v(dout1_20) AT=775.025n

* CHECK dout1_21 Vdout1_21ck154 = 0 time = 775
.meas tran vdout1_21ck154 FIND v(dout1_21) AT=775.025n

* CHECK dout1_22 Vdout1_22ck154 = 0.9 time = 775
.meas tran vdout1_22ck154 FIND v(dout1_22) AT=775.025n

* CHECK dout1_23 Vdout1_23ck154 = 0 time = 775
.meas tran vdout1_23ck154 FIND v(dout1_23) AT=775.025n

* CHECK dout1_24 Vdout1_24ck154 = 0.9 time = 775
.meas tran vdout1_24ck154 FIND v(dout1_24) AT=775.025n

* CHECK dout1_25 Vdout1_25ck154 = 0 time = 775
.meas tran vdout1_25ck154 FIND v(dout1_25) AT=775.025n

* CHECK dout1_26 Vdout1_26ck154 = 0.9 time = 775
.meas tran vdout1_26ck154 FIND v(dout1_26) AT=775.025n

* CHECK dout1_27 Vdout1_27ck154 = 0 time = 775
.meas tran vdout1_27ck154 FIND v(dout1_27) AT=775.025n

* CHECK dout1_28 Vdout1_28ck154 = 0.9 time = 775
.meas tran vdout1_28ck154 FIND v(dout1_28) AT=775.025n

* CHECK dout1_29 Vdout1_29ck154 = 0.9 time = 775
.meas tran vdout1_29ck154 FIND v(dout1_29) AT=775.025n

* CHECK dout1_30 Vdout1_30ck154 = 0.9 time = 775
.meas tran vdout1_30ck154 FIND v(dout1_30) AT=775.025n

* CHECK dout1_31 Vdout1_31ck154 = 0 time = 775
.meas tran vdout1_31ck154 FIND v(dout1_31) AT=775.025n

* CHECK dout1_32 Vdout1_32ck154 = 0 time = 775
.meas tran vdout1_32ck154 FIND v(dout1_32) AT=775.025n

* CHECK dout1_33 Vdout1_33ck154 = 0 time = 775
.meas tran vdout1_33ck154 FIND v(dout1_33) AT=775.025n

* CHECK dout1_34 Vdout1_34ck154 = 0 time = 775
.meas tran vdout1_34ck154 FIND v(dout1_34) AT=775.025n

* CHECK dout1_35 Vdout1_35ck154 = 0 time = 775
.meas tran vdout1_35ck154 FIND v(dout1_35) AT=775.025n

* CHECK dout1_36 Vdout1_36ck154 = 0 time = 775
.meas tran vdout1_36ck154 FIND v(dout1_36) AT=775.025n

* CHECK dout1_37 Vdout1_37ck154 = 0.9 time = 775
.meas tran vdout1_37ck154 FIND v(dout1_37) AT=775.025n

* CHECK dout1_38 Vdout1_38ck154 = 0 time = 775
.meas tran vdout1_38ck154 FIND v(dout1_38) AT=775.025n

* CHECK dout1_39 Vdout1_39ck154 = 0.9 time = 775
.meas tran vdout1_39ck154 FIND v(dout1_39) AT=775.025n

* CHECK dout1_40 Vdout1_40ck154 = 0 time = 775
.meas tran vdout1_40ck154 FIND v(dout1_40) AT=775.025n

* CHECK dout1_41 Vdout1_41ck154 = 0.9 time = 775
.meas tran vdout1_41ck154 FIND v(dout1_41) AT=775.025n

* CHECK dout1_42 Vdout1_42ck154 = 0.9 time = 775
.meas tran vdout1_42ck154 FIND v(dout1_42) AT=775.025n

* CHECK dout1_43 Vdout1_43ck154 = 0 time = 775
.meas tran vdout1_43ck154 FIND v(dout1_43) AT=775.025n

* CHECK dout1_44 Vdout1_44ck154 = 0.9 time = 775
.meas tran vdout1_44ck154 FIND v(dout1_44) AT=775.025n

* CHECK dout1_45 Vdout1_45ck154 = 0 time = 775
.meas tran vdout1_45ck154 FIND v(dout1_45) AT=775.025n

* CHECK dout1_46 Vdout1_46ck154 = 0.9 time = 775
.meas tran vdout1_46ck154 FIND v(dout1_46) AT=775.025n

* CHECK dout1_47 Vdout1_47ck154 = 0 time = 775
.meas tran vdout1_47ck154 FIND v(dout1_47) AT=775.025n

* CHECK dout1_48 Vdout1_48ck154 = 0 time = 775
.meas tran vdout1_48ck154 FIND v(dout1_48) AT=775.025n

* CHECK dout1_49 Vdout1_49ck154 = 0.9 time = 775
.meas tran vdout1_49ck154 FIND v(dout1_49) AT=775.025n

* CHECK dout1_50 Vdout1_50ck154 = 0 time = 775
.meas tran vdout1_50ck154 FIND v(dout1_50) AT=775.025n

* CHECK dout1_51 Vdout1_51ck154 = 0.9 time = 775
.meas tran vdout1_51ck154 FIND v(dout1_51) AT=775.025n

* CHECK dout1_52 Vdout1_52ck154 = 0 time = 775
.meas tran vdout1_52ck154 FIND v(dout1_52) AT=775.025n

* CHECK dout1_53 Vdout1_53ck154 = 0 time = 775
.meas tran vdout1_53ck154 FIND v(dout1_53) AT=775.025n

* CHECK dout1_54 Vdout1_54ck154 = 0.9 time = 775
.meas tran vdout1_54ck154 FIND v(dout1_54) AT=775.025n

* CHECK dout1_55 Vdout1_55ck154 = 0.9 time = 775
.meas tran vdout1_55ck154 FIND v(dout1_55) AT=775.025n

* CHECK dout1_56 Vdout1_56ck154 = 0 time = 775
.meas tran vdout1_56ck154 FIND v(dout1_56) AT=775.025n

* CHECK dout1_57 Vdout1_57ck154 = 0 time = 775
.meas tran vdout1_57ck154 FIND v(dout1_57) AT=775.025n

* CHECK dout1_58 Vdout1_58ck154 = 0 time = 775
.meas tran vdout1_58ck154 FIND v(dout1_58) AT=775.025n

* CHECK dout1_59 Vdout1_59ck154 = 0.9 time = 775
.meas tran vdout1_59ck154 FIND v(dout1_59) AT=775.025n

* CHECK dout1_60 Vdout1_60ck154 = 0 time = 775
.meas tran vdout1_60ck154 FIND v(dout1_60) AT=775.025n

* CHECK dout1_61 Vdout1_61ck154 = 0 time = 775
.meas tran vdout1_61ck154 FIND v(dout1_61) AT=775.025n

* CHECK dout1_62 Vdout1_62ck154 = 0 time = 775
.meas tran vdout1_62ck154 FIND v(dout1_62) AT=775.025n

* CHECK dout1_63 Vdout1_63ck154 = 0 time = 775
.meas tran vdout1_63ck154 FIND v(dout1_63) AT=775.025n

* CHECK dout1_0 Vdout1_0ck158 = 0 time = 795
.meas tran vdout1_0ck158 FIND v(dout1_0) AT=795.025n

* CHECK dout1_1 Vdout1_1ck158 = 0.9 time = 795
.meas tran vdout1_1ck158 FIND v(dout1_1) AT=795.025n

* CHECK dout1_2 Vdout1_2ck158 = 0.9 time = 795
.meas tran vdout1_2ck158 FIND v(dout1_2) AT=795.025n

* CHECK dout1_3 Vdout1_3ck158 = 0.9 time = 795
.meas tran vdout1_3ck158 FIND v(dout1_3) AT=795.025n

* CHECK dout1_4 Vdout1_4ck158 = 0.9 time = 795
.meas tran vdout1_4ck158 FIND v(dout1_4) AT=795.025n

* CHECK dout1_5 Vdout1_5ck158 = 0.9 time = 795
.meas tran vdout1_5ck158 FIND v(dout1_5) AT=795.025n

* CHECK dout1_6 Vdout1_6ck158 = 0.9 time = 795
.meas tran vdout1_6ck158 FIND v(dout1_6) AT=795.025n

* CHECK dout1_7 Vdout1_7ck158 = 0 time = 795
.meas tran vdout1_7ck158 FIND v(dout1_7) AT=795.025n

* CHECK dout1_8 Vdout1_8ck158 = 0 time = 795
.meas tran vdout1_8ck158 FIND v(dout1_8) AT=795.025n

* CHECK dout1_9 Vdout1_9ck158 = 0 time = 795
.meas tran vdout1_9ck158 FIND v(dout1_9) AT=795.025n

* CHECK dout1_10 Vdout1_10ck158 = 0 time = 795
.meas tran vdout1_10ck158 FIND v(dout1_10) AT=795.025n

* CHECK dout1_11 Vdout1_11ck158 = 0.9 time = 795
.meas tran vdout1_11ck158 FIND v(dout1_11) AT=795.025n

* CHECK dout1_12 Vdout1_12ck158 = 0.9 time = 795
.meas tran vdout1_12ck158 FIND v(dout1_12) AT=795.025n

* CHECK dout1_13 Vdout1_13ck158 = 0.9 time = 795
.meas tran vdout1_13ck158 FIND v(dout1_13) AT=795.025n

* CHECK dout1_14 Vdout1_14ck158 = 0 time = 795
.meas tran vdout1_14ck158 FIND v(dout1_14) AT=795.025n

* CHECK dout1_15 Vdout1_15ck158 = 0.9 time = 795
.meas tran vdout1_15ck158 FIND v(dout1_15) AT=795.025n

* CHECK dout1_16 Vdout1_16ck158 = 0 time = 795
.meas tran vdout1_16ck158 FIND v(dout1_16) AT=795.025n

* CHECK dout1_17 Vdout1_17ck158 = 0 time = 795
.meas tran vdout1_17ck158 FIND v(dout1_17) AT=795.025n

* CHECK dout1_18 Vdout1_18ck158 = 0.9 time = 795
.meas tran vdout1_18ck158 FIND v(dout1_18) AT=795.025n

* CHECK dout1_19 Vdout1_19ck158 = 0 time = 795
.meas tran vdout1_19ck158 FIND v(dout1_19) AT=795.025n

* CHECK dout1_20 Vdout1_20ck158 = 0.9 time = 795
.meas tran vdout1_20ck158 FIND v(dout1_20) AT=795.025n

* CHECK dout1_21 Vdout1_21ck158 = 0 time = 795
.meas tran vdout1_21ck158 FIND v(dout1_21) AT=795.025n

* CHECK dout1_22 Vdout1_22ck158 = 0.9 time = 795
.meas tran vdout1_22ck158 FIND v(dout1_22) AT=795.025n

* CHECK dout1_23 Vdout1_23ck158 = 0 time = 795
.meas tran vdout1_23ck158 FIND v(dout1_23) AT=795.025n

* CHECK dout1_24 Vdout1_24ck158 = 0 time = 795
.meas tran vdout1_24ck158 FIND v(dout1_24) AT=795.025n

* CHECK dout1_25 Vdout1_25ck158 = 0 time = 795
.meas tran vdout1_25ck158 FIND v(dout1_25) AT=795.025n

* CHECK dout1_26 Vdout1_26ck158 = 0 time = 795
.meas tran vdout1_26ck158 FIND v(dout1_26) AT=795.025n

* CHECK dout1_27 Vdout1_27ck158 = 0 time = 795
.meas tran vdout1_27ck158 FIND v(dout1_27) AT=795.025n

* CHECK dout1_28 Vdout1_28ck158 = 0 time = 795
.meas tran vdout1_28ck158 FIND v(dout1_28) AT=795.025n

* CHECK dout1_29 Vdout1_29ck158 = 0 time = 795
.meas tran vdout1_29ck158 FIND v(dout1_29) AT=795.025n

* CHECK dout1_30 Vdout1_30ck158 = 0.9 time = 795
.meas tran vdout1_30ck158 FIND v(dout1_30) AT=795.025n

* CHECK dout1_31 Vdout1_31ck158 = 0 time = 795
.meas tran vdout1_31ck158 FIND v(dout1_31) AT=795.025n

* CHECK dout1_32 Vdout1_32ck158 = 0.9 time = 795
.meas tran vdout1_32ck158 FIND v(dout1_32) AT=795.025n

* CHECK dout1_33 Vdout1_33ck158 = 0.9 time = 795
.meas tran vdout1_33ck158 FIND v(dout1_33) AT=795.025n

* CHECK dout1_34 Vdout1_34ck158 = 0 time = 795
.meas tran vdout1_34ck158 FIND v(dout1_34) AT=795.025n

* CHECK dout1_35 Vdout1_35ck158 = 0.9 time = 795
.meas tran vdout1_35ck158 FIND v(dout1_35) AT=795.025n

* CHECK dout1_36 Vdout1_36ck158 = 0 time = 795
.meas tran vdout1_36ck158 FIND v(dout1_36) AT=795.025n

* CHECK dout1_37 Vdout1_37ck158 = 0 time = 795
.meas tran vdout1_37ck158 FIND v(dout1_37) AT=795.025n

* CHECK dout1_38 Vdout1_38ck158 = 0 time = 795
.meas tran vdout1_38ck158 FIND v(dout1_38) AT=795.025n

* CHECK dout1_39 Vdout1_39ck158 = 0.9 time = 795
.meas tran vdout1_39ck158 FIND v(dout1_39) AT=795.025n

* CHECK dout1_40 Vdout1_40ck158 = 0 time = 795
.meas tran vdout1_40ck158 FIND v(dout1_40) AT=795.025n

* CHECK dout1_41 Vdout1_41ck158 = 0.9 time = 795
.meas tran vdout1_41ck158 FIND v(dout1_41) AT=795.025n

* CHECK dout1_42 Vdout1_42ck158 = 0 time = 795
.meas tran vdout1_42ck158 FIND v(dout1_42) AT=795.025n

* CHECK dout1_43 Vdout1_43ck158 = 0.9 time = 795
.meas tran vdout1_43ck158 FIND v(dout1_43) AT=795.025n

* CHECK dout1_44 Vdout1_44ck158 = 0.9 time = 795
.meas tran vdout1_44ck158 FIND v(dout1_44) AT=795.025n

* CHECK dout1_45 Vdout1_45ck158 = 0 time = 795
.meas tran vdout1_45ck158 FIND v(dout1_45) AT=795.025n

* CHECK dout1_46 Vdout1_46ck158 = 0.9 time = 795
.meas tran vdout1_46ck158 FIND v(dout1_46) AT=795.025n

* CHECK dout1_47 Vdout1_47ck158 = 0 time = 795
.meas tran vdout1_47ck158 FIND v(dout1_47) AT=795.025n

* CHECK dout1_48 Vdout1_48ck158 = 0.9 time = 795
.meas tran vdout1_48ck158 FIND v(dout1_48) AT=795.025n

* CHECK dout1_49 Vdout1_49ck158 = 0.9 time = 795
.meas tran vdout1_49ck158 FIND v(dout1_49) AT=795.025n

* CHECK dout1_50 Vdout1_50ck158 = 0 time = 795
.meas tran vdout1_50ck158 FIND v(dout1_50) AT=795.025n

* CHECK dout1_51 Vdout1_51ck158 = 0.9 time = 795
.meas tran vdout1_51ck158 FIND v(dout1_51) AT=795.025n

* CHECK dout1_52 Vdout1_52ck158 = 0.9 time = 795
.meas tran vdout1_52ck158 FIND v(dout1_52) AT=795.025n

* CHECK dout1_53 Vdout1_53ck158 = 0 time = 795
.meas tran vdout1_53ck158 FIND v(dout1_53) AT=795.025n

* CHECK dout1_54 Vdout1_54ck158 = 0 time = 795
.meas tran vdout1_54ck158 FIND v(dout1_54) AT=795.025n

* CHECK dout1_55 Vdout1_55ck158 = 0.9 time = 795
.meas tran vdout1_55ck158 FIND v(dout1_55) AT=795.025n

* CHECK dout1_56 Vdout1_56ck158 = 0 time = 795
.meas tran vdout1_56ck158 FIND v(dout1_56) AT=795.025n

* CHECK dout1_57 Vdout1_57ck158 = 0.9 time = 795
.meas tran vdout1_57ck158 FIND v(dout1_57) AT=795.025n

* CHECK dout1_58 Vdout1_58ck158 = 0 time = 795
.meas tran vdout1_58ck158 FIND v(dout1_58) AT=795.025n

* CHECK dout1_59 Vdout1_59ck158 = 0.9 time = 795
.meas tran vdout1_59ck158 FIND v(dout1_59) AT=795.025n

* CHECK dout1_60 Vdout1_60ck158 = 0 time = 795
.meas tran vdout1_60ck158 FIND v(dout1_60) AT=795.025n

* CHECK dout1_61 Vdout1_61ck158 = 0.9 time = 795
.meas tran vdout1_61ck158 FIND v(dout1_61) AT=795.025n

* CHECK dout1_62 Vdout1_62ck158 = 0 time = 795
.meas tran vdout1_62ck158 FIND v(dout1_62) AT=795.025n

* CHECK dout1_63 Vdout1_63ck158 = 0.9 time = 795
.meas tran vdout1_63ck158 FIND v(dout1_63) AT=795.025n

* CHECK dout1_0 Vdout1_0ck159 = 0.9 time = 800
.meas tran vdout1_0ck159 FIND v(dout1_0) AT=800.025n

* CHECK dout1_1 Vdout1_1ck159 = 0 time = 800
.meas tran vdout1_1ck159 FIND v(dout1_1) AT=800.025n

* CHECK dout1_2 Vdout1_2ck159 = 0 time = 800
.meas tran vdout1_2ck159 FIND v(dout1_2) AT=800.025n

* CHECK dout1_3 Vdout1_3ck159 = 0.9 time = 800
.meas tran vdout1_3ck159 FIND v(dout1_3) AT=800.025n

* CHECK dout1_4 Vdout1_4ck159 = 0.9 time = 800
.meas tran vdout1_4ck159 FIND v(dout1_4) AT=800.025n

* CHECK dout1_5 Vdout1_5ck159 = 0 time = 800
.meas tran vdout1_5ck159 FIND v(dout1_5) AT=800.025n

* CHECK dout1_6 Vdout1_6ck159 = 0 time = 800
.meas tran vdout1_6ck159 FIND v(dout1_6) AT=800.025n

* CHECK dout1_7 Vdout1_7ck159 = 0 time = 800
.meas tran vdout1_7ck159 FIND v(dout1_7) AT=800.025n

* CHECK dout1_8 Vdout1_8ck159 = 0 time = 800
.meas tran vdout1_8ck159 FIND v(dout1_8) AT=800.025n

* CHECK dout1_9 Vdout1_9ck159 = 0 time = 800
.meas tran vdout1_9ck159 FIND v(dout1_9) AT=800.025n

* CHECK dout1_10 Vdout1_10ck159 = 0.9 time = 800
.meas tran vdout1_10ck159 FIND v(dout1_10) AT=800.025n

* CHECK dout1_11 Vdout1_11ck159 = 0 time = 800
.meas tran vdout1_11ck159 FIND v(dout1_11) AT=800.025n

* CHECK dout1_12 Vdout1_12ck159 = 0.9 time = 800
.meas tran vdout1_12ck159 FIND v(dout1_12) AT=800.025n

* CHECK dout1_13 Vdout1_13ck159 = 0 time = 800
.meas tran vdout1_13ck159 FIND v(dout1_13) AT=800.025n

* CHECK dout1_14 Vdout1_14ck159 = 0 time = 800
.meas tran vdout1_14ck159 FIND v(dout1_14) AT=800.025n

* CHECK dout1_15 Vdout1_15ck159 = 0.9 time = 800
.meas tran vdout1_15ck159 FIND v(dout1_15) AT=800.025n

* CHECK dout1_16 Vdout1_16ck159 = 0 time = 800
.meas tran vdout1_16ck159 FIND v(dout1_16) AT=800.025n

* CHECK dout1_17 Vdout1_17ck159 = 0.9 time = 800
.meas tran vdout1_17ck159 FIND v(dout1_17) AT=800.025n

* CHECK dout1_18 Vdout1_18ck159 = 0.9 time = 800
.meas tran vdout1_18ck159 FIND v(dout1_18) AT=800.025n

* CHECK dout1_19 Vdout1_19ck159 = 0 time = 800
.meas tran vdout1_19ck159 FIND v(dout1_19) AT=800.025n

* CHECK dout1_20 Vdout1_20ck159 = 0 time = 800
.meas tran vdout1_20ck159 FIND v(dout1_20) AT=800.025n

* CHECK dout1_21 Vdout1_21ck159 = 0 time = 800
.meas tran vdout1_21ck159 FIND v(dout1_21) AT=800.025n

* CHECK dout1_22 Vdout1_22ck159 = 0 time = 800
.meas tran vdout1_22ck159 FIND v(dout1_22) AT=800.025n

* CHECK dout1_23 Vdout1_23ck159 = 0 time = 800
.meas tran vdout1_23ck159 FIND v(dout1_23) AT=800.025n

* CHECK dout1_24 Vdout1_24ck159 = 0 time = 800
.meas tran vdout1_24ck159 FIND v(dout1_24) AT=800.025n

* CHECK dout1_25 Vdout1_25ck159 = 0 time = 800
.meas tran vdout1_25ck159 FIND v(dout1_25) AT=800.025n

* CHECK dout1_26 Vdout1_26ck159 = 0 time = 800
.meas tran vdout1_26ck159 FIND v(dout1_26) AT=800.025n

* CHECK dout1_27 Vdout1_27ck159 = 0 time = 800
.meas tran vdout1_27ck159 FIND v(dout1_27) AT=800.025n

* CHECK dout1_28 Vdout1_28ck159 = 0 time = 800
.meas tran vdout1_28ck159 FIND v(dout1_28) AT=800.025n

* CHECK dout1_29 Vdout1_29ck159 = 0.9 time = 800
.meas tran vdout1_29ck159 FIND v(dout1_29) AT=800.025n

* CHECK dout1_30 Vdout1_30ck159 = 0.9 time = 800
.meas tran vdout1_30ck159 FIND v(dout1_30) AT=800.025n

* CHECK dout1_31 Vdout1_31ck159 = 0.9 time = 800
.meas tran vdout1_31ck159 FIND v(dout1_31) AT=800.025n

* CHECK dout1_32 Vdout1_32ck159 = 0 time = 800
.meas tran vdout1_32ck159 FIND v(dout1_32) AT=800.025n

* CHECK dout1_33 Vdout1_33ck159 = 0 time = 800
.meas tran vdout1_33ck159 FIND v(dout1_33) AT=800.025n

* CHECK dout1_34 Vdout1_34ck159 = 0 time = 800
.meas tran vdout1_34ck159 FIND v(dout1_34) AT=800.025n

* CHECK dout1_35 Vdout1_35ck159 = 0.9 time = 800
.meas tran vdout1_35ck159 FIND v(dout1_35) AT=800.025n

* CHECK dout1_36 Vdout1_36ck159 = 0 time = 800
.meas tran vdout1_36ck159 FIND v(dout1_36) AT=800.025n

* CHECK dout1_37 Vdout1_37ck159 = 0.9 time = 800
.meas tran vdout1_37ck159 FIND v(dout1_37) AT=800.025n

* CHECK dout1_38 Vdout1_38ck159 = 0.9 time = 800
.meas tran vdout1_38ck159 FIND v(dout1_38) AT=800.025n

* CHECK dout1_39 Vdout1_39ck159 = 0.9 time = 800
.meas tran vdout1_39ck159 FIND v(dout1_39) AT=800.025n

* CHECK dout1_40 Vdout1_40ck159 = 0.9 time = 800
.meas tran vdout1_40ck159 FIND v(dout1_40) AT=800.025n

* CHECK dout1_41 Vdout1_41ck159 = 0.9 time = 800
.meas tran vdout1_41ck159 FIND v(dout1_41) AT=800.025n

* CHECK dout1_42 Vdout1_42ck159 = 0.9 time = 800
.meas tran vdout1_42ck159 FIND v(dout1_42) AT=800.025n

* CHECK dout1_43 Vdout1_43ck159 = 0 time = 800
.meas tran vdout1_43ck159 FIND v(dout1_43) AT=800.025n

* CHECK dout1_44 Vdout1_44ck159 = 0 time = 800
.meas tran vdout1_44ck159 FIND v(dout1_44) AT=800.025n

* CHECK dout1_45 Vdout1_45ck159 = 0 time = 800
.meas tran vdout1_45ck159 FIND v(dout1_45) AT=800.025n

* CHECK dout1_46 Vdout1_46ck159 = 0.9 time = 800
.meas tran vdout1_46ck159 FIND v(dout1_46) AT=800.025n

* CHECK dout1_47 Vdout1_47ck159 = 0.9 time = 800
.meas tran vdout1_47ck159 FIND v(dout1_47) AT=800.025n

* CHECK dout1_48 Vdout1_48ck159 = 0 time = 800
.meas tran vdout1_48ck159 FIND v(dout1_48) AT=800.025n

* CHECK dout1_49 Vdout1_49ck159 = 0 time = 800
.meas tran vdout1_49ck159 FIND v(dout1_49) AT=800.025n

* CHECK dout1_50 Vdout1_50ck159 = 0 time = 800
.meas tran vdout1_50ck159 FIND v(dout1_50) AT=800.025n

* CHECK dout1_51 Vdout1_51ck159 = 0.9 time = 800
.meas tran vdout1_51ck159 FIND v(dout1_51) AT=800.025n

* CHECK dout1_52 Vdout1_52ck159 = 0 time = 800
.meas tran vdout1_52ck159 FIND v(dout1_52) AT=800.025n

* CHECK dout1_53 Vdout1_53ck159 = 0.9 time = 800
.meas tran vdout1_53ck159 FIND v(dout1_53) AT=800.025n

* CHECK dout1_54 Vdout1_54ck159 = 0.9 time = 800
.meas tran vdout1_54ck159 FIND v(dout1_54) AT=800.025n

* CHECK dout1_55 Vdout1_55ck159 = 0.9 time = 800
.meas tran vdout1_55ck159 FIND v(dout1_55) AT=800.025n

* CHECK dout1_56 Vdout1_56ck159 = 0.9 time = 800
.meas tran vdout1_56ck159 FIND v(dout1_56) AT=800.025n

* CHECK dout1_57 Vdout1_57ck159 = 0 time = 800
.meas tran vdout1_57ck159 FIND v(dout1_57) AT=800.025n

* CHECK dout1_58 Vdout1_58ck159 = 0.9 time = 800
.meas tran vdout1_58ck159 FIND v(dout1_58) AT=800.025n

* CHECK dout1_59 Vdout1_59ck159 = 0 time = 800
.meas tran vdout1_59ck159 FIND v(dout1_59) AT=800.025n

* CHECK dout1_60 Vdout1_60ck159 = 0.9 time = 800
.meas tran vdout1_60ck159 FIND v(dout1_60) AT=800.025n

* CHECK dout1_61 Vdout1_61ck159 = 0.9 time = 800
.meas tran vdout1_61ck159 FIND v(dout1_61) AT=800.025n

* CHECK dout1_62 Vdout1_62ck159 = 0.9 time = 800
.meas tran vdout1_62ck159 FIND v(dout1_62) AT=800.025n

* CHECK dout1_63 Vdout1_63ck159 = 0.9 time = 800
.meas tran vdout1_63ck159 FIND v(dout1_63) AT=800.025n

* CHECK dout1_0 Vdout1_0ck160 = 0.9 time = 805
.meas tran vdout1_0ck160 FIND v(dout1_0) AT=805.025n

* CHECK dout1_1 Vdout1_1ck160 = 0 time = 805
.meas tran vdout1_1ck160 FIND v(dout1_1) AT=805.025n

* CHECK dout1_2 Vdout1_2ck160 = 0 time = 805
.meas tran vdout1_2ck160 FIND v(dout1_2) AT=805.025n

* CHECK dout1_3 Vdout1_3ck160 = 0.9 time = 805
.meas tran vdout1_3ck160 FIND v(dout1_3) AT=805.025n

* CHECK dout1_4 Vdout1_4ck160 = 0.9 time = 805
.meas tran vdout1_4ck160 FIND v(dout1_4) AT=805.025n

* CHECK dout1_5 Vdout1_5ck160 = 0 time = 805
.meas tran vdout1_5ck160 FIND v(dout1_5) AT=805.025n

* CHECK dout1_6 Vdout1_6ck160 = 0 time = 805
.meas tran vdout1_6ck160 FIND v(dout1_6) AT=805.025n

* CHECK dout1_7 Vdout1_7ck160 = 0 time = 805
.meas tran vdout1_7ck160 FIND v(dout1_7) AT=805.025n

* CHECK dout1_8 Vdout1_8ck160 = 0 time = 805
.meas tran vdout1_8ck160 FIND v(dout1_8) AT=805.025n

* CHECK dout1_9 Vdout1_9ck160 = 0 time = 805
.meas tran vdout1_9ck160 FIND v(dout1_9) AT=805.025n

* CHECK dout1_10 Vdout1_10ck160 = 0.9 time = 805
.meas tran vdout1_10ck160 FIND v(dout1_10) AT=805.025n

* CHECK dout1_11 Vdout1_11ck160 = 0 time = 805
.meas tran vdout1_11ck160 FIND v(dout1_11) AT=805.025n

* CHECK dout1_12 Vdout1_12ck160 = 0.9 time = 805
.meas tran vdout1_12ck160 FIND v(dout1_12) AT=805.025n

* CHECK dout1_13 Vdout1_13ck160 = 0 time = 805
.meas tran vdout1_13ck160 FIND v(dout1_13) AT=805.025n

* CHECK dout1_14 Vdout1_14ck160 = 0 time = 805
.meas tran vdout1_14ck160 FIND v(dout1_14) AT=805.025n

* CHECK dout1_15 Vdout1_15ck160 = 0.9 time = 805
.meas tran vdout1_15ck160 FIND v(dout1_15) AT=805.025n

* CHECK dout1_16 Vdout1_16ck160 = 0 time = 805
.meas tran vdout1_16ck160 FIND v(dout1_16) AT=805.025n

* CHECK dout1_17 Vdout1_17ck160 = 0.9 time = 805
.meas tran vdout1_17ck160 FIND v(dout1_17) AT=805.025n

* CHECK dout1_18 Vdout1_18ck160 = 0.9 time = 805
.meas tran vdout1_18ck160 FIND v(dout1_18) AT=805.025n

* CHECK dout1_19 Vdout1_19ck160 = 0 time = 805
.meas tran vdout1_19ck160 FIND v(dout1_19) AT=805.025n

* CHECK dout1_20 Vdout1_20ck160 = 0 time = 805
.meas tran vdout1_20ck160 FIND v(dout1_20) AT=805.025n

* CHECK dout1_21 Vdout1_21ck160 = 0 time = 805
.meas tran vdout1_21ck160 FIND v(dout1_21) AT=805.025n

* CHECK dout1_22 Vdout1_22ck160 = 0 time = 805
.meas tran vdout1_22ck160 FIND v(dout1_22) AT=805.025n

* CHECK dout1_23 Vdout1_23ck160 = 0 time = 805
.meas tran vdout1_23ck160 FIND v(dout1_23) AT=805.025n

* CHECK dout1_24 Vdout1_24ck160 = 0 time = 805
.meas tran vdout1_24ck160 FIND v(dout1_24) AT=805.025n

* CHECK dout1_25 Vdout1_25ck160 = 0 time = 805
.meas tran vdout1_25ck160 FIND v(dout1_25) AT=805.025n

* CHECK dout1_26 Vdout1_26ck160 = 0 time = 805
.meas tran vdout1_26ck160 FIND v(dout1_26) AT=805.025n

* CHECK dout1_27 Vdout1_27ck160 = 0 time = 805
.meas tran vdout1_27ck160 FIND v(dout1_27) AT=805.025n

* CHECK dout1_28 Vdout1_28ck160 = 0 time = 805
.meas tran vdout1_28ck160 FIND v(dout1_28) AT=805.025n

* CHECK dout1_29 Vdout1_29ck160 = 0.9 time = 805
.meas tran vdout1_29ck160 FIND v(dout1_29) AT=805.025n

* CHECK dout1_30 Vdout1_30ck160 = 0.9 time = 805
.meas tran vdout1_30ck160 FIND v(dout1_30) AT=805.025n

* CHECK dout1_31 Vdout1_31ck160 = 0.9 time = 805
.meas tran vdout1_31ck160 FIND v(dout1_31) AT=805.025n

* CHECK dout1_32 Vdout1_32ck160 = 0 time = 805
.meas tran vdout1_32ck160 FIND v(dout1_32) AT=805.025n

* CHECK dout1_33 Vdout1_33ck160 = 0 time = 805
.meas tran vdout1_33ck160 FIND v(dout1_33) AT=805.025n

* CHECK dout1_34 Vdout1_34ck160 = 0 time = 805
.meas tran vdout1_34ck160 FIND v(dout1_34) AT=805.025n

* CHECK dout1_35 Vdout1_35ck160 = 0.9 time = 805
.meas tran vdout1_35ck160 FIND v(dout1_35) AT=805.025n

* CHECK dout1_36 Vdout1_36ck160 = 0 time = 805
.meas tran vdout1_36ck160 FIND v(dout1_36) AT=805.025n

* CHECK dout1_37 Vdout1_37ck160 = 0.9 time = 805
.meas tran vdout1_37ck160 FIND v(dout1_37) AT=805.025n

* CHECK dout1_38 Vdout1_38ck160 = 0.9 time = 805
.meas tran vdout1_38ck160 FIND v(dout1_38) AT=805.025n

* CHECK dout1_39 Vdout1_39ck160 = 0.9 time = 805
.meas tran vdout1_39ck160 FIND v(dout1_39) AT=805.025n

* CHECK dout1_40 Vdout1_40ck160 = 0.9 time = 805
.meas tran vdout1_40ck160 FIND v(dout1_40) AT=805.025n

* CHECK dout1_41 Vdout1_41ck160 = 0.9 time = 805
.meas tran vdout1_41ck160 FIND v(dout1_41) AT=805.025n

* CHECK dout1_42 Vdout1_42ck160 = 0.9 time = 805
.meas tran vdout1_42ck160 FIND v(dout1_42) AT=805.025n

* CHECK dout1_43 Vdout1_43ck160 = 0 time = 805
.meas tran vdout1_43ck160 FIND v(dout1_43) AT=805.025n

* CHECK dout1_44 Vdout1_44ck160 = 0 time = 805
.meas tran vdout1_44ck160 FIND v(dout1_44) AT=805.025n

* CHECK dout1_45 Vdout1_45ck160 = 0 time = 805
.meas tran vdout1_45ck160 FIND v(dout1_45) AT=805.025n

* CHECK dout1_46 Vdout1_46ck160 = 0.9 time = 805
.meas tran vdout1_46ck160 FIND v(dout1_46) AT=805.025n

* CHECK dout1_47 Vdout1_47ck160 = 0.9 time = 805
.meas tran vdout1_47ck160 FIND v(dout1_47) AT=805.025n

* CHECK dout1_48 Vdout1_48ck160 = 0 time = 805
.meas tran vdout1_48ck160 FIND v(dout1_48) AT=805.025n

* CHECK dout1_49 Vdout1_49ck160 = 0 time = 805
.meas tran vdout1_49ck160 FIND v(dout1_49) AT=805.025n

* CHECK dout1_50 Vdout1_50ck160 = 0 time = 805
.meas tran vdout1_50ck160 FIND v(dout1_50) AT=805.025n

* CHECK dout1_51 Vdout1_51ck160 = 0.9 time = 805
.meas tran vdout1_51ck160 FIND v(dout1_51) AT=805.025n

* CHECK dout1_52 Vdout1_52ck160 = 0 time = 805
.meas tran vdout1_52ck160 FIND v(dout1_52) AT=805.025n

* CHECK dout1_53 Vdout1_53ck160 = 0.9 time = 805
.meas tran vdout1_53ck160 FIND v(dout1_53) AT=805.025n

* CHECK dout1_54 Vdout1_54ck160 = 0.9 time = 805
.meas tran vdout1_54ck160 FIND v(dout1_54) AT=805.025n

* CHECK dout1_55 Vdout1_55ck160 = 0.9 time = 805
.meas tran vdout1_55ck160 FIND v(dout1_55) AT=805.025n

* CHECK dout1_56 Vdout1_56ck160 = 0.9 time = 805
.meas tran vdout1_56ck160 FIND v(dout1_56) AT=805.025n

* CHECK dout1_57 Vdout1_57ck160 = 0 time = 805
.meas tran vdout1_57ck160 FIND v(dout1_57) AT=805.025n

* CHECK dout1_58 Vdout1_58ck160 = 0.9 time = 805
.meas tran vdout1_58ck160 FIND v(dout1_58) AT=805.025n

* CHECK dout1_59 Vdout1_59ck160 = 0 time = 805
.meas tran vdout1_59ck160 FIND v(dout1_59) AT=805.025n

* CHECK dout1_60 Vdout1_60ck160 = 0.9 time = 805
.meas tran vdout1_60ck160 FIND v(dout1_60) AT=805.025n

* CHECK dout1_61 Vdout1_61ck160 = 0.9 time = 805
.meas tran vdout1_61ck160 FIND v(dout1_61) AT=805.025n

* CHECK dout1_62 Vdout1_62ck160 = 0.9 time = 805
.meas tran vdout1_62ck160 FIND v(dout1_62) AT=805.025n

* CHECK dout1_63 Vdout1_63ck160 = 0.9 time = 805
.meas tran vdout1_63ck160 FIND v(dout1_63) AT=805.025n

* CHECK dout1_0 Vdout1_0ck165 = 0 time = 830
.meas tran vdout1_0ck165 FIND v(dout1_0) AT=830.025n

* CHECK dout1_1 Vdout1_1ck165 = 0 time = 830
.meas tran vdout1_1ck165 FIND v(dout1_1) AT=830.025n

* CHECK dout1_2 Vdout1_2ck165 = 0 time = 830
.meas tran vdout1_2ck165 FIND v(dout1_2) AT=830.025n

* CHECK dout1_3 Vdout1_3ck165 = 0.9 time = 830
.meas tran vdout1_3ck165 FIND v(dout1_3) AT=830.025n

* CHECK dout1_4 Vdout1_4ck165 = 0 time = 830
.meas tran vdout1_4ck165 FIND v(dout1_4) AT=830.025n

* CHECK dout1_5 Vdout1_5ck165 = 0 time = 830
.meas tran vdout1_5ck165 FIND v(dout1_5) AT=830.025n

* CHECK dout1_6 Vdout1_6ck165 = 0.9 time = 830
.meas tran vdout1_6ck165 FIND v(dout1_6) AT=830.025n

* CHECK dout1_7 Vdout1_7ck165 = 0.9 time = 830
.meas tran vdout1_7ck165 FIND v(dout1_7) AT=830.025n

* CHECK dout1_8 Vdout1_8ck165 = 0 time = 830
.meas tran vdout1_8ck165 FIND v(dout1_8) AT=830.025n

* CHECK dout1_9 Vdout1_9ck165 = 0 time = 830
.meas tran vdout1_9ck165 FIND v(dout1_9) AT=830.025n

* CHECK dout1_10 Vdout1_10ck165 = 0.9 time = 830
.meas tran vdout1_10ck165 FIND v(dout1_10) AT=830.025n

* CHECK dout1_11 Vdout1_11ck165 = 0 time = 830
.meas tran vdout1_11ck165 FIND v(dout1_11) AT=830.025n

* CHECK dout1_12 Vdout1_12ck165 = 0.9 time = 830
.meas tran vdout1_12ck165 FIND v(dout1_12) AT=830.025n

* CHECK dout1_13 Vdout1_13ck165 = 0.9 time = 830
.meas tran vdout1_13ck165 FIND v(dout1_13) AT=830.025n

* CHECK dout1_14 Vdout1_14ck165 = 0.9 time = 830
.meas tran vdout1_14ck165 FIND v(dout1_14) AT=830.025n

* CHECK dout1_15 Vdout1_15ck165 = 0 time = 830
.meas tran vdout1_15ck165 FIND v(dout1_15) AT=830.025n

* CHECK dout1_16 Vdout1_16ck165 = 0 time = 830
.meas tran vdout1_16ck165 FIND v(dout1_16) AT=830.025n

* CHECK dout1_17 Vdout1_17ck165 = 0 time = 830
.meas tran vdout1_17ck165 FIND v(dout1_17) AT=830.025n

* CHECK dout1_18 Vdout1_18ck165 = 0.9 time = 830
.meas tran vdout1_18ck165 FIND v(dout1_18) AT=830.025n

* CHECK dout1_19 Vdout1_19ck165 = 0 time = 830
.meas tran vdout1_19ck165 FIND v(dout1_19) AT=830.025n

* CHECK dout1_20 Vdout1_20ck165 = 0.9 time = 830
.meas tran vdout1_20ck165 FIND v(dout1_20) AT=830.025n

* CHECK dout1_21 Vdout1_21ck165 = 0.9 time = 830
.meas tran vdout1_21ck165 FIND v(dout1_21) AT=830.025n

* CHECK dout1_22 Vdout1_22ck165 = 0 time = 830
.meas tran vdout1_22ck165 FIND v(dout1_22) AT=830.025n

* CHECK dout1_23 Vdout1_23ck165 = 0.9 time = 830
.meas tran vdout1_23ck165 FIND v(dout1_23) AT=830.025n

* CHECK dout1_24 Vdout1_24ck165 = 0.9 time = 830
.meas tran vdout1_24ck165 FIND v(dout1_24) AT=830.025n

* CHECK dout1_25 Vdout1_25ck165 = 0.9 time = 830
.meas tran vdout1_25ck165 FIND v(dout1_25) AT=830.025n

* CHECK dout1_26 Vdout1_26ck165 = 0.9 time = 830
.meas tran vdout1_26ck165 FIND v(dout1_26) AT=830.025n

* CHECK dout1_27 Vdout1_27ck165 = 0.9 time = 830
.meas tran vdout1_27ck165 FIND v(dout1_27) AT=830.025n

* CHECK dout1_28 Vdout1_28ck165 = 0.9 time = 830
.meas tran vdout1_28ck165 FIND v(dout1_28) AT=830.025n

* CHECK dout1_29 Vdout1_29ck165 = 0.9 time = 830
.meas tran vdout1_29ck165 FIND v(dout1_29) AT=830.025n

* CHECK dout1_30 Vdout1_30ck165 = 0.9 time = 830
.meas tran vdout1_30ck165 FIND v(dout1_30) AT=830.025n

* CHECK dout1_31 Vdout1_31ck165 = 0 time = 830
.meas tran vdout1_31ck165 FIND v(dout1_31) AT=830.025n

* CHECK dout1_32 Vdout1_32ck165 = 0.9 time = 830
.meas tran vdout1_32ck165 FIND v(dout1_32) AT=830.025n

* CHECK dout1_33 Vdout1_33ck165 = 0 time = 830
.meas tran vdout1_33ck165 FIND v(dout1_33) AT=830.025n

* CHECK dout1_34 Vdout1_34ck165 = 0 time = 830
.meas tran vdout1_34ck165 FIND v(dout1_34) AT=830.025n

* CHECK dout1_35 Vdout1_35ck165 = 0.9 time = 830
.meas tran vdout1_35ck165 FIND v(dout1_35) AT=830.025n

* CHECK dout1_36 Vdout1_36ck165 = 0 time = 830
.meas tran vdout1_36ck165 FIND v(dout1_36) AT=830.025n

* CHECK dout1_37 Vdout1_37ck165 = 0 time = 830
.meas tran vdout1_37ck165 FIND v(dout1_37) AT=830.025n

* CHECK dout1_38 Vdout1_38ck165 = 0.9 time = 830
.meas tran vdout1_38ck165 FIND v(dout1_38) AT=830.025n

* CHECK dout1_39 Vdout1_39ck165 = 0.9 time = 830
.meas tran vdout1_39ck165 FIND v(dout1_39) AT=830.025n

* CHECK dout1_40 Vdout1_40ck165 = 0.9 time = 830
.meas tran vdout1_40ck165 FIND v(dout1_40) AT=830.025n

* CHECK dout1_41 Vdout1_41ck165 = 0 time = 830
.meas tran vdout1_41ck165 FIND v(dout1_41) AT=830.025n

* CHECK dout1_42 Vdout1_42ck165 = 0.9 time = 830
.meas tran vdout1_42ck165 FIND v(dout1_42) AT=830.025n

* CHECK dout1_43 Vdout1_43ck165 = 0 time = 830
.meas tran vdout1_43ck165 FIND v(dout1_43) AT=830.025n

* CHECK dout1_44 Vdout1_44ck165 = 0.9 time = 830
.meas tran vdout1_44ck165 FIND v(dout1_44) AT=830.025n

* CHECK dout1_45 Vdout1_45ck165 = 0.9 time = 830
.meas tran vdout1_45ck165 FIND v(dout1_45) AT=830.025n

* CHECK dout1_46 Vdout1_46ck165 = 0 time = 830
.meas tran vdout1_46ck165 FIND v(dout1_46) AT=830.025n

* CHECK dout1_47 Vdout1_47ck165 = 0.9 time = 830
.meas tran vdout1_47ck165 FIND v(dout1_47) AT=830.025n

* CHECK dout1_48 Vdout1_48ck165 = 0 time = 830
.meas tran vdout1_48ck165 FIND v(dout1_48) AT=830.025n

* CHECK dout1_49 Vdout1_49ck165 = 0.9 time = 830
.meas tran vdout1_49ck165 FIND v(dout1_49) AT=830.025n

* CHECK dout1_50 Vdout1_50ck165 = 0 time = 830
.meas tran vdout1_50ck165 FIND v(dout1_50) AT=830.025n

* CHECK dout1_51 Vdout1_51ck165 = 0.9 time = 830
.meas tran vdout1_51ck165 FIND v(dout1_51) AT=830.025n

* CHECK dout1_52 Vdout1_52ck165 = 0.9 time = 830
.meas tran vdout1_52ck165 FIND v(dout1_52) AT=830.025n

* CHECK dout1_53 Vdout1_53ck165 = 0.9 time = 830
.meas tran vdout1_53ck165 FIND v(dout1_53) AT=830.025n

* CHECK dout1_54 Vdout1_54ck165 = 0.9 time = 830
.meas tran vdout1_54ck165 FIND v(dout1_54) AT=830.025n

* CHECK dout1_55 Vdout1_55ck165 = 0.9 time = 830
.meas tran vdout1_55ck165 FIND v(dout1_55) AT=830.025n

* CHECK dout1_56 Vdout1_56ck165 = 0.9 time = 830
.meas tran vdout1_56ck165 FIND v(dout1_56) AT=830.025n

* CHECK dout1_57 Vdout1_57ck165 = 0.9 time = 830
.meas tran vdout1_57ck165 FIND v(dout1_57) AT=830.025n

* CHECK dout1_58 Vdout1_58ck165 = 0.9 time = 830
.meas tran vdout1_58ck165 FIND v(dout1_58) AT=830.025n

* CHECK dout1_59 Vdout1_59ck165 = 0.9 time = 830
.meas tran vdout1_59ck165 FIND v(dout1_59) AT=830.025n

* CHECK dout1_60 Vdout1_60ck165 = 0 time = 830
.meas tran vdout1_60ck165 FIND v(dout1_60) AT=830.025n

* CHECK dout1_61 Vdout1_61ck165 = 0 time = 830
.meas tran vdout1_61ck165 FIND v(dout1_61) AT=830.025n

* CHECK dout1_62 Vdout1_62ck165 = 0 time = 830
.meas tran vdout1_62ck165 FIND v(dout1_62) AT=830.025n

* CHECK dout1_63 Vdout1_63ck165 = 0 time = 830
.meas tran vdout1_63ck165 FIND v(dout1_63) AT=830.025n

* CHECK dout1_0 Vdout1_0ck166 = 0 time = 835
.meas tran vdout1_0ck166 FIND v(dout1_0) AT=835.025n

* CHECK dout1_1 Vdout1_1ck166 = 0 time = 835
.meas tran vdout1_1ck166 FIND v(dout1_1) AT=835.025n

* CHECK dout1_2 Vdout1_2ck166 = 0 time = 835
.meas tran vdout1_2ck166 FIND v(dout1_2) AT=835.025n

* CHECK dout1_3 Vdout1_3ck166 = 0.9 time = 835
.meas tran vdout1_3ck166 FIND v(dout1_3) AT=835.025n

* CHECK dout1_4 Vdout1_4ck166 = 0 time = 835
.meas tran vdout1_4ck166 FIND v(dout1_4) AT=835.025n

* CHECK dout1_5 Vdout1_5ck166 = 0 time = 835
.meas tran vdout1_5ck166 FIND v(dout1_5) AT=835.025n

* CHECK dout1_6 Vdout1_6ck166 = 0 time = 835
.meas tran vdout1_6ck166 FIND v(dout1_6) AT=835.025n

* CHECK dout1_7 Vdout1_7ck166 = 0.9 time = 835
.meas tran vdout1_7ck166 FIND v(dout1_7) AT=835.025n

* CHECK dout1_8 Vdout1_8ck166 = 0.9 time = 835
.meas tran vdout1_8ck166 FIND v(dout1_8) AT=835.025n

* CHECK dout1_9 Vdout1_9ck166 = 0 time = 835
.meas tran vdout1_9ck166 FIND v(dout1_9) AT=835.025n

* CHECK dout1_10 Vdout1_10ck166 = 0 time = 835
.meas tran vdout1_10ck166 FIND v(dout1_10) AT=835.025n

* CHECK dout1_11 Vdout1_11ck166 = 0.9 time = 835
.meas tran vdout1_11ck166 FIND v(dout1_11) AT=835.025n

* CHECK dout1_12 Vdout1_12ck166 = 0 time = 835
.meas tran vdout1_12ck166 FIND v(dout1_12) AT=835.025n

* CHECK dout1_13 Vdout1_13ck166 = 0 time = 835
.meas tran vdout1_13ck166 FIND v(dout1_13) AT=835.025n

* CHECK dout1_14 Vdout1_14ck166 = 0 time = 835
.meas tran vdout1_14ck166 FIND v(dout1_14) AT=835.025n

* CHECK dout1_15 Vdout1_15ck166 = 0 time = 835
.meas tran vdout1_15ck166 FIND v(dout1_15) AT=835.025n

* CHECK dout1_16 Vdout1_16ck166 = 0 time = 835
.meas tran vdout1_16ck166 FIND v(dout1_16) AT=835.025n

* CHECK dout1_17 Vdout1_17ck166 = 0.9 time = 835
.meas tran vdout1_17ck166 FIND v(dout1_17) AT=835.025n

* CHECK dout1_18 Vdout1_18ck166 = 0.9 time = 835
.meas tran vdout1_18ck166 FIND v(dout1_18) AT=835.025n

* CHECK dout1_19 Vdout1_19ck166 = 0 time = 835
.meas tran vdout1_19ck166 FIND v(dout1_19) AT=835.025n

* CHECK dout1_20 Vdout1_20ck166 = 0.9 time = 835
.meas tran vdout1_20ck166 FIND v(dout1_20) AT=835.025n

* CHECK dout1_21 Vdout1_21ck166 = 0.9 time = 835
.meas tran vdout1_21ck166 FIND v(dout1_21) AT=835.025n

* CHECK dout1_22 Vdout1_22ck166 = 0 time = 835
.meas tran vdout1_22ck166 FIND v(dout1_22) AT=835.025n

* CHECK dout1_23 Vdout1_23ck166 = 0 time = 835
.meas tran vdout1_23ck166 FIND v(dout1_23) AT=835.025n

* CHECK dout1_24 Vdout1_24ck166 = 0 time = 835
.meas tran vdout1_24ck166 FIND v(dout1_24) AT=835.025n

* CHECK dout1_25 Vdout1_25ck166 = 0.9 time = 835
.meas tran vdout1_25ck166 FIND v(dout1_25) AT=835.025n

* CHECK dout1_26 Vdout1_26ck166 = 0 time = 835
.meas tran vdout1_26ck166 FIND v(dout1_26) AT=835.025n

* CHECK dout1_27 Vdout1_27ck166 = 0 time = 835
.meas tran vdout1_27ck166 FIND v(dout1_27) AT=835.025n

* CHECK dout1_28 Vdout1_28ck166 = 0.9 time = 835
.meas tran vdout1_28ck166 FIND v(dout1_28) AT=835.025n

* CHECK dout1_29 Vdout1_29ck166 = 0 time = 835
.meas tran vdout1_29ck166 FIND v(dout1_29) AT=835.025n

* CHECK dout1_30 Vdout1_30ck166 = 0 time = 835
.meas tran vdout1_30ck166 FIND v(dout1_30) AT=835.025n

* CHECK dout1_31 Vdout1_31ck166 = 0 time = 835
.meas tran vdout1_31ck166 FIND v(dout1_31) AT=835.025n

* CHECK dout1_32 Vdout1_32ck166 = 0.9 time = 835
.meas tran vdout1_32ck166 FIND v(dout1_32) AT=835.025n

* CHECK dout1_33 Vdout1_33ck166 = 0 time = 835
.meas tran vdout1_33ck166 FIND v(dout1_33) AT=835.025n

* CHECK dout1_34 Vdout1_34ck166 = 0.9 time = 835
.meas tran vdout1_34ck166 FIND v(dout1_34) AT=835.025n

* CHECK dout1_35 Vdout1_35ck166 = 0 time = 835
.meas tran vdout1_35ck166 FIND v(dout1_35) AT=835.025n

* CHECK dout1_36 Vdout1_36ck166 = 0.9 time = 835
.meas tran vdout1_36ck166 FIND v(dout1_36) AT=835.025n

* CHECK dout1_37 Vdout1_37ck166 = 0 time = 835
.meas tran vdout1_37ck166 FIND v(dout1_37) AT=835.025n

* CHECK dout1_38 Vdout1_38ck166 = 0 time = 835
.meas tran vdout1_38ck166 FIND v(dout1_38) AT=835.025n

* CHECK dout1_39 Vdout1_39ck166 = 0 time = 835
.meas tran vdout1_39ck166 FIND v(dout1_39) AT=835.025n

* CHECK dout1_40 Vdout1_40ck166 = 0.9 time = 835
.meas tran vdout1_40ck166 FIND v(dout1_40) AT=835.025n

* CHECK dout1_41 Vdout1_41ck166 = 0.9 time = 835
.meas tran vdout1_41ck166 FIND v(dout1_41) AT=835.025n

* CHECK dout1_42 Vdout1_42ck166 = 0 time = 835
.meas tran vdout1_42ck166 FIND v(dout1_42) AT=835.025n

* CHECK dout1_43 Vdout1_43ck166 = 0 time = 835
.meas tran vdout1_43ck166 FIND v(dout1_43) AT=835.025n

* CHECK dout1_44 Vdout1_44ck166 = 0 time = 835
.meas tran vdout1_44ck166 FIND v(dout1_44) AT=835.025n

* CHECK dout1_45 Vdout1_45ck166 = 0.9 time = 835
.meas tran vdout1_45ck166 FIND v(dout1_45) AT=835.025n

* CHECK dout1_46 Vdout1_46ck166 = 0.9 time = 835
.meas tran vdout1_46ck166 FIND v(dout1_46) AT=835.025n

* CHECK dout1_47 Vdout1_47ck166 = 0.9 time = 835
.meas tran vdout1_47ck166 FIND v(dout1_47) AT=835.025n

* CHECK dout1_48 Vdout1_48ck166 = 0.9 time = 835
.meas tran vdout1_48ck166 FIND v(dout1_48) AT=835.025n

* CHECK dout1_49 Vdout1_49ck166 = 0 time = 835
.meas tran vdout1_49ck166 FIND v(dout1_49) AT=835.025n

* CHECK dout1_50 Vdout1_50ck166 = 0.9 time = 835
.meas tran vdout1_50ck166 FIND v(dout1_50) AT=835.025n

* CHECK dout1_51 Vdout1_51ck166 = 0.9 time = 835
.meas tran vdout1_51ck166 FIND v(dout1_51) AT=835.025n

* CHECK dout1_52 Vdout1_52ck166 = 0 time = 835
.meas tran vdout1_52ck166 FIND v(dout1_52) AT=835.025n

* CHECK dout1_53 Vdout1_53ck166 = 0 time = 835
.meas tran vdout1_53ck166 FIND v(dout1_53) AT=835.025n

* CHECK dout1_54 Vdout1_54ck166 = 0.9 time = 835
.meas tran vdout1_54ck166 FIND v(dout1_54) AT=835.025n

* CHECK dout1_55 Vdout1_55ck166 = 0 time = 835
.meas tran vdout1_55ck166 FIND v(dout1_55) AT=835.025n

* CHECK dout1_56 Vdout1_56ck166 = 0 time = 835
.meas tran vdout1_56ck166 FIND v(dout1_56) AT=835.025n

* CHECK dout1_57 Vdout1_57ck166 = 0.9 time = 835
.meas tran vdout1_57ck166 FIND v(dout1_57) AT=835.025n

* CHECK dout1_58 Vdout1_58ck166 = 0 time = 835
.meas tran vdout1_58ck166 FIND v(dout1_58) AT=835.025n

* CHECK dout1_59 Vdout1_59ck166 = 0.9 time = 835
.meas tran vdout1_59ck166 FIND v(dout1_59) AT=835.025n

* CHECK dout1_60 Vdout1_60ck166 = 0 time = 835
.meas tran vdout1_60ck166 FIND v(dout1_60) AT=835.025n

* CHECK dout1_61 Vdout1_61ck166 = 0.9 time = 835
.meas tran vdout1_61ck166 FIND v(dout1_61) AT=835.025n

* CHECK dout1_62 Vdout1_62ck166 = 0 time = 835
.meas tran vdout1_62ck166 FIND v(dout1_62) AT=835.025n

* CHECK dout1_63 Vdout1_63ck166 = 0 time = 835
.meas tran vdout1_63ck166 FIND v(dout1_63) AT=835.025n

* CHECK dout1_0 Vdout1_0ck169 = 0 time = 850
.meas tran vdout1_0ck169 FIND v(dout1_0) AT=850.025n

* CHECK dout1_1 Vdout1_1ck169 = 0 time = 850
.meas tran vdout1_1ck169 FIND v(dout1_1) AT=850.025n

* CHECK dout1_2 Vdout1_2ck169 = 0 time = 850
.meas tran vdout1_2ck169 FIND v(dout1_2) AT=850.025n

* CHECK dout1_3 Vdout1_3ck169 = 0.9 time = 850
.meas tran vdout1_3ck169 FIND v(dout1_3) AT=850.025n

* CHECK dout1_4 Vdout1_4ck169 = 0 time = 850
.meas tran vdout1_4ck169 FIND v(dout1_4) AT=850.025n

* CHECK dout1_5 Vdout1_5ck169 = 0 time = 850
.meas tran vdout1_5ck169 FIND v(dout1_5) AT=850.025n

* CHECK dout1_6 Vdout1_6ck169 = 0.9 time = 850
.meas tran vdout1_6ck169 FIND v(dout1_6) AT=850.025n

* CHECK dout1_7 Vdout1_7ck169 = 0.9 time = 850
.meas tran vdout1_7ck169 FIND v(dout1_7) AT=850.025n

* CHECK dout1_8 Vdout1_8ck169 = 0 time = 850
.meas tran vdout1_8ck169 FIND v(dout1_8) AT=850.025n

* CHECK dout1_9 Vdout1_9ck169 = 0 time = 850
.meas tran vdout1_9ck169 FIND v(dout1_9) AT=850.025n

* CHECK dout1_10 Vdout1_10ck169 = 0.9 time = 850
.meas tran vdout1_10ck169 FIND v(dout1_10) AT=850.025n

* CHECK dout1_11 Vdout1_11ck169 = 0 time = 850
.meas tran vdout1_11ck169 FIND v(dout1_11) AT=850.025n

* CHECK dout1_12 Vdout1_12ck169 = 0.9 time = 850
.meas tran vdout1_12ck169 FIND v(dout1_12) AT=850.025n

* CHECK dout1_13 Vdout1_13ck169 = 0.9 time = 850
.meas tran vdout1_13ck169 FIND v(dout1_13) AT=850.025n

* CHECK dout1_14 Vdout1_14ck169 = 0.9 time = 850
.meas tran vdout1_14ck169 FIND v(dout1_14) AT=850.025n

* CHECK dout1_15 Vdout1_15ck169 = 0 time = 850
.meas tran vdout1_15ck169 FIND v(dout1_15) AT=850.025n

* CHECK dout1_16 Vdout1_16ck169 = 0 time = 850
.meas tran vdout1_16ck169 FIND v(dout1_16) AT=850.025n

* CHECK dout1_17 Vdout1_17ck169 = 0 time = 850
.meas tran vdout1_17ck169 FIND v(dout1_17) AT=850.025n

* CHECK dout1_18 Vdout1_18ck169 = 0.9 time = 850
.meas tran vdout1_18ck169 FIND v(dout1_18) AT=850.025n

* CHECK dout1_19 Vdout1_19ck169 = 0 time = 850
.meas tran vdout1_19ck169 FIND v(dout1_19) AT=850.025n

* CHECK dout1_20 Vdout1_20ck169 = 0.9 time = 850
.meas tran vdout1_20ck169 FIND v(dout1_20) AT=850.025n

* CHECK dout1_21 Vdout1_21ck169 = 0.9 time = 850
.meas tran vdout1_21ck169 FIND v(dout1_21) AT=850.025n

* CHECK dout1_22 Vdout1_22ck169 = 0 time = 850
.meas tran vdout1_22ck169 FIND v(dout1_22) AT=850.025n

* CHECK dout1_23 Vdout1_23ck169 = 0.9 time = 850
.meas tran vdout1_23ck169 FIND v(dout1_23) AT=850.025n

* CHECK dout1_24 Vdout1_24ck169 = 0.9 time = 850
.meas tran vdout1_24ck169 FIND v(dout1_24) AT=850.025n

* CHECK dout1_25 Vdout1_25ck169 = 0.9 time = 850
.meas tran vdout1_25ck169 FIND v(dout1_25) AT=850.025n

* CHECK dout1_26 Vdout1_26ck169 = 0.9 time = 850
.meas tran vdout1_26ck169 FIND v(dout1_26) AT=850.025n

* CHECK dout1_27 Vdout1_27ck169 = 0.9 time = 850
.meas tran vdout1_27ck169 FIND v(dout1_27) AT=850.025n

* CHECK dout1_28 Vdout1_28ck169 = 0.9 time = 850
.meas tran vdout1_28ck169 FIND v(dout1_28) AT=850.025n

* CHECK dout1_29 Vdout1_29ck169 = 0.9 time = 850
.meas tran vdout1_29ck169 FIND v(dout1_29) AT=850.025n

* CHECK dout1_30 Vdout1_30ck169 = 0.9 time = 850
.meas tran vdout1_30ck169 FIND v(dout1_30) AT=850.025n

* CHECK dout1_31 Vdout1_31ck169 = 0 time = 850
.meas tran vdout1_31ck169 FIND v(dout1_31) AT=850.025n

* CHECK dout1_32 Vdout1_32ck169 = 0.9 time = 850
.meas tran vdout1_32ck169 FIND v(dout1_32) AT=850.025n

* CHECK dout1_33 Vdout1_33ck169 = 0 time = 850
.meas tran vdout1_33ck169 FIND v(dout1_33) AT=850.025n

* CHECK dout1_34 Vdout1_34ck169 = 0 time = 850
.meas tran vdout1_34ck169 FIND v(dout1_34) AT=850.025n

* CHECK dout1_35 Vdout1_35ck169 = 0.9 time = 850
.meas tran vdout1_35ck169 FIND v(dout1_35) AT=850.025n

* CHECK dout1_36 Vdout1_36ck169 = 0 time = 850
.meas tran vdout1_36ck169 FIND v(dout1_36) AT=850.025n

* CHECK dout1_37 Vdout1_37ck169 = 0 time = 850
.meas tran vdout1_37ck169 FIND v(dout1_37) AT=850.025n

* CHECK dout1_38 Vdout1_38ck169 = 0.9 time = 850
.meas tran vdout1_38ck169 FIND v(dout1_38) AT=850.025n

* CHECK dout1_39 Vdout1_39ck169 = 0.9 time = 850
.meas tran vdout1_39ck169 FIND v(dout1_39) AT=850.025n

* CHECK dout1_40 Vdout1_40ck169 = 0.9 time = 850
.meas tran vdout1_40ck169 FIND v(dout1_40) AT=850.025n

* CHECK dout1_41 Vdout1_41ck169 = 0 time = 850
.meas tran vdout1_41ck169 FIND v(dout1_41) AT=850.025n

* CHECK dout1_42 Vdout1_42ck169 = 0.9 time = 850
.meas tran vdout1_42ck169 FIND v(dout1_42) AT=850.025n

* CHECK dout1_43 Vdout1_43ck169 = 0 time = 850
.meas tran vdout1_43ck169 FIND v(dout1_43) AT=850.025n

* CHECK dout1_44 Vdout1_44ck169 = 0.9 time = 850
.meas tran vdout1_44ck169 FIND v(dout1_44) AT=850.025n

* CHECK dout1_45 Vdout1_45ck169 = 0.9 time = 850
.meas tran vdout1_45ck169 FIND v(dout1_45) AT=850.025n

* CHECK dout1_46 Vdout1_46ck169 = 0 time = 850
.meas tran vdout1_46ck169 FIND v(dout1_46) AT=850.025n

* CHECK dout1_47 Vdout1_47ck169 = 0.9 time = 850
.meas tran vdout1_47ck169 FIND v(dout1_47) AT=850.025n

* CHECK dout1_48 Vdout1_48ck169 = 0 time = 850
.meas tran vdout1_48ck169 FIND v(dout1_48) AT=850.025n

* CHECK dout1_49 Vdout1_49ck169 = 0.9 time = 850
.meas tran vdout1_49ck169 FIND v(dout1_49) AT=850.025n

* CHECK dout1_50 Vdout1_50ck169 = 0 time = 850
.meas tran vdout1_50ck169 FIND v(dout1_50) AT=850.025n

* CHECK dout1_51 Vdout1_51ck169 = 0.9 time = 850
.meas tran vdout1_51ck169 FIND v(dout1_51) AT=850.025n

* CHECK dout1_52 Vdout1_52ck169 = 0.9 time = 850
.meas tran vdout1_52ck169 FIND v(dout1_52) AT=850.025n

* CHECK dout1_53 Vdout1_53ck169 = 0.9 time = 850
.meas tran vdout1_53ck169 FIND v(dout1_53) AT=850.025n

* CHECK dout1_54 Vdout1_54ck169 = 0.9 time = 850
.meas tran vdout1_54ck169 FIND v(dout1_54) AT=850.025n

* CHECK dout1_55 Vdout1_55ck169 = 0.9 time = 850
.meas tran vdout1_55ck169 FIND v(dout1_55) AT=850.025n

* CHECK dout1_56 Vdout1_56ck169 = 0.9 time = 850
.meas tran vdout1_56ck169 FIND v(dout1_56) AT=850.025n

* CHECK dout1_57 Vdout1_57ck169 = 0.9 time = 850
.meas tran vdout1_57ck169 FIND v(dout1_57) AT=850.025n

* CHECK dout1_58 Vdout1_58ck169 = 0.9 time = 850
.meas tran vdout1_58ck169 FIND v(dout1_58) AT=850.025n

* CHECK dout1_59 Vdout1_59ck169 = 0.9 time = 850
.meas tran vdout1_59ck169 FIND v(dout1_59) AT=850.025n

* CHECK dout1_60 Vdout1_60ck169 = 0 time = 850
.meas tran vdout1_60ck169 FIND v(dout1_60) AT=850.025n

* CHECK dout1_61 Vdout1_61ck169 = 0 time = 850
.meas tran vdout1_61ck169 FIND v(dout1_61) AT=850.025n

* CHECK dout1_62 Vdout1_62ck169 = 0 time = 850
.meas tran vdout1_62ck169 FIND v(dout1_62) AT=850.025n

* CHECK dout1_63 Vdout1_63ck169 = 0 time = 850
.meas tran vdout1_63ck169 FIND v(dout1_63) AT=850.025n

* CHECK dout1_0 Vdout1_0ck170 = 0 time = 855
.meas tran vdout1_0ck170 FIND v(dout1_0) AT=855.025n

* CHECK dout1_1 Vdout1_1ck170 = 0 time = 855
.meas tran vdout1_1ck170 FIND v(dout1_1) AT=855.025n

* CHECK dout1_2 Vdout1_2ck170 = 0.9 time = 855
.meas tran vdout1_2ck170 FIND v(dout1_2) AT=855.025n

* CHECK dout1_3 Vdout1_3ck170 = 0.9 time = 855
.meas tran vdout1_3ck170 FIND v(dout1_3) AT=855.025n

* CHECK dout1_4 Vdout1_4ck170 = 0.9 time = 855
.meas tran vdout1_4ck170 FIND v(dout1_4) AT=855.025n

* CHECK dout1_5 Vdout1_5ck170 = 0 time = 855
.meas tran vdout1_5ck170 FIND v(dout1_5) AT=855.025n

* CHECK dout1_6 Vdout1_6ck170 = 0.9 time = 855
.meas tran vdout1_6ck170 FIND v(dout1_6) AT=855.025n

* CHECK dout1_7 Vdout1_7ck170 = 0 time = 855
.meas tran vdout1_7ck170 FIND v(dout1_7) AT=855.025n

* CHECK dout1_8 Vdout1_8ck170 = 0.9 time = 855
.meas tran vdout1_8ck170 FIND v(dout1_8) AT=855.025n

* CHECK dout1_9 Vdout1_9ck170 = 0.9 time = 855
.meas tran vdout1_9ck170 FIND v(dout1_9) AT=855.025n

* CHECK dout1_10 Vdout1_10ck170 = 0.9 time = 855
.meas tran vdout1_10ck170 FIND v(dout1_10) AT=855.025n

* CHECK dout1_11 Vdout1_11ck170 = 0 time = 855
.meas tran vdout1_11ck170 FIND v(dout1_11) AT=855.025n

* CHECK dout1_12 Vdout1_12ck170 = 0 time = 855
.meas tran vdout1_12ck170 FIND v(dout1_12) AT=855.025n

* CHECK dout1_13 Vdout1_13ck170 = 0 time = 855
.meas tran vdout1_13ck170 FIND v(dout1_13) AT=855.025n

* CHECK dout1_14 Vdout1_14ck170 = 0.9 time = 855
.meas tran vdout1_14ck170 FIND v(dout1_14) AT=855.025n

* CHECK dout1_15 Vdout1_15ck170 = 0 time = 855
.meas tran vdout1_15ck170 FIND v(dout1_15) AT=855.025n

* CHECK dout1_16 Vdout1_16ck170 = 0.9 time = 855
.meas tran vdout1_16ck170 FIND v(dout1_16) AT=855.025n

* CHECK dout1_17 Vdout1_17ck170 = 0.9 time = 855
.meas tran vdout1_17ck170 FIND v(dout1_17) AT=855.025n

* CHECK dout1_18 Vdout1_18ck170 = 0 time = 855
.meas tran vdout1_18ck170 FIND v(dout1_18) AT=855.025n

* CHECK dout1_19 Vdout1_19ck170 = 0.9 time = 855
.meas tran vdout1_19ck170 FIND v(dout1_19) AT=855.025n

* CHECK dout1_20 Vdout1_20ck170 = 0.9 time = 855
.meas tran vdout1_20ck170 FIND v(dout1_20) AT=855.025n

* CHECK dout1_21 Vdout1_21ck170 = 0.9 time = 855
.meas tran vdout1_21ck170 FIND v(dout1_21) AT=855.025n

* CHECK dout1_22 Vdout1_22ck170 = 0.9 time = 855
.meas tran vdout1_22ck170 FIND v(dout1_22) AT=855.025n

* CHECK dout1_23 Vdout1_23ck170 = 0.9 time = 855
.meas tran vdout1_23ck170 FIND v(dout1_23) AT=855.025n

* CHECK dout1_24 Vdout1_24ck170 = 0.9 time = 855
.meas tran vdout1_24ck170 FIND v(dout1_24) AT=855.025n

* CHECK dout1_25 Vdout1_25ck170 = 0.9 time = 855
.meas tran vdout1_25ck170 FIND v(dout1_25) AT=855.025n

* CHECK dout1_26 Vdout1_26ck170 = 0 time = 855
.meas tran vdout1_26ck170 FIND v(dout1_26) AT=855.025n

* CHECK dout1_27 Vdout1_27ck170 = 0 time = 855
.meas tran vdout1_27ck170 FIND v(dout1_27) AT=855.025n

* CHECK dout1_28 Vdout1_28ck170 = 0.9 time = 855
.meas tran vdout1_28ck170 FIND v(dout1_28) AT=855.025n

* CHECK dout1_29 Vdout1_29ck170 = 0 time = 855
.meas tran vdout1_29ck170 FIND v(dout1_29) AT=855.025n

* CHECK dout1_30 Vdout1_30ck170 = 0.9 time = 855
.meas tran vdout1_30ck170 FIND v(dout1_30) AT=855.025n

* CHECK dout1_31 Vdout1_31ck170 = 0 time = 855
.meas tran vdout1_31ck170 FIND v(dout1_31) AT=855.025n

* CHECK dout1_32 Vdout1_32ck170 = 0.9 time = 855
.meas tran vdout1_32ck170 FIND v(dout1_32) AT=855.025n

* CHECK dout1_33 Vdout1_33ck170 = 0 time = 855
.meas tran vdout1_33ck170 FIND v(dout1_33) AT=855.025n

* CHECK dout1_34 Vdout1_34ck170 = 0.9 time = 855
.meas tran vdout1_34ck170 FIND v(dout1_34) AT=855.025n

* CHECK dout1_35 Vdout1_35ck170 = 0.9 time = 855
.meas tran vdout1_35ck170 FIND v(dout1_35) AT=855.025n

* CHECK dout1_36 Vdout1_36ck170 = 0 time = 855
.meas tran vdout1_36ck170 FIND v(dout1_36) AT=855.025n

* CHECK dout1_37 Vdout1_37ck170 = 0.9 time = 855
.meas tran vdout1_37ck170 FIND v(dout1_37) AT=855.025n

* CHECK dout1_38 Vdout1_38ck170 = 0.9 time = 855
.meas tran vdout1_38ck170 FIND v(dout1_38) AT=855.025n

* CHECK dout1_39 Vdout1_39ck170 = 0 time = 855
.meas tran vdout1_39ck170 FIND v(dout1_39) AT=855.025n

* CHECK dout1_40 Vdout1_40ck170 = 0 time = 855
.meas tran vdout1_40ck170 FIND v(dout1_40) AT=855.025n

* CHECK dout1_41 Vdout1_41ck170 = 0.9 time = 855
.meas tran vdout1_41ck170 FIND v(dout1_41) AT=855.025n

* CHECK dout1_42 Vdout1_42ck170 = 0 time = 855
.meas tran vdout1_42ck170 FIND v(dout1_42) AT=855.025n

* CHECK dout1_43 Vdout1_43ck170 = 0 time = 855
.meas tran vdout1_43ck170 FIND v(dout1_43) AT=855.025n

* CHECK dout1_44 Vdout1_44ck170 = 0.9 time = 855
.meas tran vdout1_44ck170 FIND v(dout1_44) AT=855.025n

* CHECK dout1_45 Vdout1_45ck170 = 0.9 time = 855
.meas tran vdout1_45ck170 FIND v(dout1_45) AT=855.025n

* CHECK dout1_46 Vdout1_46ck170 = 0 time = 855
.meas tran vdout1_46ck170 FIND v(dout1_46) AT=855.025n

* CHECK dout1_47 Vdout1_47ck170 = 0.9 time = 855
.meas tran vdout1_47ck170 FIND v(dout1_47) AT=855.025n

* CHECK dout1_48 Vdout1_48ck170 = 0 time = 855
.meas tran vdout1_48ck170 FIND v(dout1_48) AT=855.025n

* CHECK dout1_49 Vdout1_49ck170 = 0.9 time = 855
.meas tran vdout1_49ck170 FIND v(dout1_49) AT=855.025n

* CHECK dout1_50 Vdout1_50ck170 = 0.9 time = 855
.meas tran vdout1_50ck170 FIND v(dout1_50) AT=855.025n

* CHECK dout1_51 Vdout1_51ck170 = 0.9 time = 855
.meas tran vdout1_51ck170 FIND v(dout1_51) AT=855.025n

* CHECK dout1_52 Vdout1_52ck170 = 0 time = 855
.meas tran vdout1_52ck170 FIND v(dout1_52) AT=855.025n

* CHECK dout1_53 Vdout1_53ck170 = 0.9 time = 855
.meas tran vdout1_53ck170 FIND v(dout1_53) AT=855.025n

* CHECK dout1_54 Vdout1_54ck170 = 0 time = 855
.meas tran vdout1_54ck170 FIND v(dout1_54) AT=855.025n

* CHECK dout1_55 Vdout1_55ck170 = 0 time = 855
.meas tran vdout1_55ck170 FIND v(dout1_55) AT=855.025n

* CHECK dout1_56 Vdout1_56ck170 = 0.9 time = 855
.meas tran vdout1_56ck170 FIND v(dout1_56) AT=855.025n

* CHECK dout1_57 Vdout1_57ck170 = 0 time = 855
.meas tran vdout1_57ck170 FIND v(dout1_57) AT=855.025n

* CHECK dout1_58 Vdout1_58ck170 = 0 time = 855
.meas tran vdout1_58ck170 FIND v(dout1_58) AT=855.025n

* CHECK dout1_59 Vdout1_59ck170 = 0.9 time = 855
.meas tran vdout1_59ck170 FIND v(dout1_59) AT=855.025n

* CHECK dout1_60 Vdout1_60ck170 = 0.9 time = 855
.meas tran vdout1_60ck170 FIND v(dout1_60) AT=855.025n

* CHECK dout1_61 Vdout1_61ck170 = 0.9 time = 855
.meas tran vdout1_61ck170 FIND v(dout1_61) AT=855.025n

* CHECK dout1_62 Vdout1_62ck170 = 0 time = 855
.meas tran vdout1_62ck170 FIND v(dout1_62) AT=855.025n

* CHECK dout1_63 Vdout1_63ck170 = 0 time = 855
.meas tran vdout1_63ck170 FIND v(dout1_63) AT=855.025n

* CHECK dout1_0 Vdout1_0ck172 = 0 time = 865
.meas tran vdout1_0ck172 FIND v(dout1_0) AT=865.025n

* CHECK dout1_1 Vdout1_1ck172 = 0 time = 865
.meas tran vdout1_1ck172 FIND v(dout1_1) AT=865.025n

* CHECK dout1_2 Vdout1_2ck172 = 0.9 time = 865
.meas tran vdout1_2ck172 FIND v(dout1_2) AT=865.025n

* CHECK dout1_3 Vdout1_3ck172 = 0 time = 865
.meas tran vdout1_3ck172 FIND v(dout1_3) AT=865.025n

* CHECK dout1_4 Vdout1_4ck172 = 0.9 time = 865
.meas tran vdout1_4ck172 FIND v(dout1_4) AT=865.025n

* CHECK dout1_5 Vdout1_5ck172 = 0 time = 865
.meas tran vdout1_5ck172 FIND v(dout1_5) AT=865.025n

* CHECK dout1_6 Vdout1_6ck172 = 0 time = 865
.meas tran vdout1_6ck172 FIND v(dout1_6) AT=865.025n

* CHECK dout1_7 Vdout1_7ck172 = 0.9 time = 865
.meas tran vdout1_7ck172 FIND v(dout1_7) AT=865.025n

* CHECK dout1_8 Vdout1_8ck172 = 0.9 time = 865
.meas tran vdout1_8ck172 FIND v(dout1_8) AT=865.025n

* CHECK dout1_9 Vdout1_9ck172 = 0 time = 865
.meas tran vdout1_9ck172 FIND v(dout1_9) AT=865.025n

* CHECK dout1_10 Vdout1_10ck172 = 0 time = 865
.meas tran vdout1_10ck172 FIND v(dout1_10) AT=865.025n

* CHECK dout1_11 Vdout1_11ck172 = 0.9 time = 865
.meas tran vdout1_11ck172 FIND v(dout1_11) AT=865.025n

* CHECK dout1_12 Vdout1_12ck172 = 0 time = 865
.meas tran vdout1_12ck172 FIND v(dout1_12) AT=865.025n

* CHECK dout1_13 Vdout1_13ck172 = 0 time = 865
.meas tran vdout1_13ck172 FIND v(dout1_13) AT=865.025n

* CHECK dout1_14 Vdout1_14ck172 = 0 time = 865
.meas tran vdout1_14ck172 FIND v(dout1_14) AT=865.025n

* CHECK dout1_15 Vdout1_15ck172 = 0 time = 865
.meas tran vdout1_15ck172 FIND v(dout1_15) AT=865.025n

* CHECK dout1_16 Vdout1_16ck172 = 0.9 time = 865
.meas tran vdout1_16ck172 FIND v(dout1_16) AT=865.025n

* CHECK dout1_17 Vdout1_17ck172 = 0.9 time = 865
.meas tran vdout1_17ck172 FIND v(dout1_17) AT=865.025n

* CHECK dout1_18 Vdout1_18ck172 = 0.9 time = 865
.meas tran vdout1_18ck172 FIND v(dout1_18) AT=865.025n

* CHECK dout1_19 Vdout1_19ck172 = 0.9 time = 865
.meas tran vdout1_19ck172 FIND v(dout1_19) AT=865.025n

* CHECK dout1_20 Vdout1_20ck172 = 0.9 time = 865
.meas tran vdout1_20ck172 FIND v(dout1_20) AT=865.025n

* CHECK dout1_21 Vdout1_21ck172 = 0.9 time = 865
.meas tran vdout1_21ck172 FIND v(dout1_21) AT=865.025n

* CHECK dout1_22 Vdout1_22ck172 = 0.9 time = 865
.meas tran vdout1_22ck172 FIND v(dout1_22) AT=865.025n

* CHECK dout1_23 Vdout1_23ck172 = 0 time = 865
.meas tran vdout1_23ck172 FIND v(dout1_23) AT=865.025n

* CHECK dout1_24 Vdout1_24ck172 = 0 time = 865
.meas tran vdout1_24ck172 FIND v(dout1_24) AT=865.025n

* CHECK dout1_25 Vdout1_25ck172 = 0 time = 865
.meas tran vdout1_25ck172 FIND v(dout1_25) AT=865.025n

* CHECK dout1_26 Vdout1_26ck172 = 0.9 time = 865
.meas tran vdout1_26ck172 FIND v(dout1_26) AT=865.025n

* CHECK dout1_27 Vdout1_27ck172 = 0 time = 865
.meas tran vdout1_27ck172 FIND v(dout1_27) AT=865.025n

* CHECK dout1_28 Vdout1_28ck172 = 0.9 time = 865
.meas tran vdout1_28ck172 FIND v(dout1_28) AT=865.025n

* CHECK dout1_29 Vdout1_29ck172 = 0.9 time = 865
.meas tran vdout1_29ck172 FIND v(dout1_29) AT=865.025n

* CHECK dout1_30 Vdout1_30ck172 = 0 time = 865
.meas tran vdout1_30ck172 FIND v(dout1_30) AT=865.025n

* CHECK dout1_31 Vdout1_31ck172 = 0 time = 865
.meas tran vdout1_31ck172 FIND v(dout1_31) AT=865.025n

* CHECK dout1_32 Vdout1_32ck172 = 0 time = 865
.meas tran vdout1_32ck172 FIND v(dout1_32) AT=865.025n

* CHECK dout1_33 Vdout1_33ck172 = 0.9 time = 865
.meas tran vdout1_33ck172 FIND v(dout1_33) AT=865.025n

* CHECK dout1_34 Vdout1_34ck172 = 0 time = 865
.meas tran vdout1_34ck172 FIND v(dout1_34) AT=865.025n

* CHECK dout1_35 Vdout1_35ck172 = 0 time = 865
.meas tran vdout1_35ck172 FIND v(dout1_35) AT=865.025n

* CHECK dout1_36 Vdout1_36ck172 = 0 time = 865
.meas tran vdout1_36ck172 FIND v(dout1_36) AT=865.025n

* CHECK dout1_37 Vdout1_37ck172 = 0 time = 865
.meas tran vdout1_37ck172 FIND v(dout1_37) AT=865.025n

* CHECK dout1_38 Vdout1_38ck172 = 0 time = 865
.meas tran vdout1_38ck172 FIND v(dout1_38) AT=865.025n

* CHECK dout1_39 Vdout1_39ck172 = 0 time = 865
.meas tran vdout1_39ck172 FIND v(dout1_39) AT=865.025n

* CHECK dout1_40 Vdout1_40ck172 = 0.9 time = 865
.meas tran vdout1_40ck172 FIND v(dout1_40) AT=865.025n

* CHECK dout1_41 Vdout1_41ck172 = 0 time = 865
.meas tran vdout1_41ck172 FIND v(dout1_41) AT=865.025n

* CHECK dout1_42 Vdout1_42ck172 = 0 time = 865
.meas tran vdout1_42ck172 FIND v(dout1_42) AT=865.025n

* CHECK dout1_43 Vdout1_43ck172 = 0.9 time = 865
.meas tran vdout1_43ck172 FIND v(dout1_43) AT=865.025n

* CHECK dout1_44 Vdout1_44ck172 = 0.9 time = 865
.meas tran vdout1_44ck172 FIND v(dout1_44) AT=865.025n

* CHECK dout1_45 Vdout1_45ck172 = 0 time = 865
.meas tran vdout1_45ck172 FIND v(dout1_45) AT=865.025n

* CHECK dout1_46 Vdout1_46ck172 = 0 time = 865
.meas tran vdout1_46ck172 FIND v(dout1_46) AT=865.025n

* CHECK dout1_47 Vdout1_47ck172 = 0 time = 865
.meas tran vdout1_47ck172 FIND v(dout1_47) AT=865.025n

* CHECK dout1_48 Vdout1_48ck172 = 0 time = 865
.meas tran vdout1_48ck172 FIND v(dout1_48) AT=865.025n

* CHECK dout1_49 Vdout1_49ck172 = 0.9 time = 865
.meas tran vdout1_49ck172 FIND v(dout1_49) AT=865.025n

* CHECK dout1_50 Vdout1_50ck172 = 0 time = 865
.meas tran vdout1_50ck172 FIND v(dout1_50) AT=865.025n

* CHECK dout1_51 Vdout1_51ck172 = 0 time = 865
.meas tran vdout1_51ck172 FIND v(dout1_51) AT=865.025n

* CHECK dout1_52 Vdout1_52ck172 = 0 time = 865
.meas tran vdout1_52ck172 FIND v(dout1_52) AT=865.025n

* CHECK dout1_53 Vdout1_53ck172 = 0 time = 865
.meas tran vdout1_53ck172 FIND v(dout1_53) AT=865.025n

* CHECK dout1_54 Vdout1_54ck172 = 0.9 time = 865
.meas tran vdout1_54ck172 FIND v(dout1_54) AT=865.025n

* CHECK dout1_55 Vdout1_55ck172 = 0.9 time = 865
.meas tran vdout1_55ck172 FIND v(dout1_55) AT=865.025n

* CHECK dout1_56 Vdout1_56ck172 = 0.9 time = 865
.meas tran vdout1_56ck172 FIND v(dout1_56) AT=865.025n

* CHECK dout1_57 Vdout1_57ck172 = 0 time = 865
.meas tran vdout1_57ck172 FIND v(dout1_57) AT=865.025n

* CHECK dout1_58 Vdout1_58ck172 = 0.9 time = 865
.meas tran vdout1_58ck172 FIND v(dout1_58) AT=865.025n

* CHECK dout1_59 Vdout1_59ck172 = 0 time = 865
.meas tran vdout1_59ck172 FIND v(dout1_59) AT=865.025n

* CHECK dout1_60 Vdout1_60ck172 = 0.9 time = 865
.meas tran vdout1_60ck172 FIND v(dout1_60) AT=865.025n

* CHECK dout1_61 Vdout1_61ck172 = 0 time = 865
.meas tran vdout1_61ck172 FIND v(dout1_61) AT=865.025n

* CHECK dout1_62 Vdout1_62ck172 = 0.9 time = 865
.meas tran vdout1_62ck172 FIND v(dout1_62) AT=865.025n

* CHECK dout1_63 Vdout1_63ck172 = 0 time = 865
.meas tran vdout1_63ck172 FIND v(dout1_63) AT=865.025n

* CHECK dout1_0 Vdout1_0ck174 = 0 time = 875
.meas tran vdout1_0ck174 FIND v(dout1_0) AT=875.025n

* CHECK dout1_1 Vdout1_1ck174 = 0 time = 875
.meas tran vdout1_1ck174 FIND v(dout1_1) AT=875.025n

* CHECK dout1_2 Vdout1_2ck174 = 0.9 time = 875
.meas tran vdout1_2ck174 FIND v(dout1_2) AT=875.025n

* CHECK dout1_3 Vdout1_3ck174 = 0 time = 875
.meas tran vdout1_3ck174 FIND v(dout1_3) AT=875.025n

* CHECK dout1_4 Vdout1_4ck174 = 0.9 time = 875
.meas tran vdout1_4ck174 FIND v(dout1_4) AT=875.025n

* CHECK dout1_5 Vdout1_5ck174 = 0 time = 875
.meas tran vdout1_5ck174 FIND v(dout1_5) AT=875.025n

* CHECK dout1_6 Vdout1_6ck174 = 0 time = 875
.meas tran vdout1_6ck174 FIND v(dout1_6) AT=875.025n

* CHECK dout1_7 Vdout1_7ck174 = 0.9 time = 875
.meas tran vdout1_7ck174 FIND v(dout1_7) AT=875.025n

* CHECK dout1_8 Vdout1_8ck174 = 0.9 time = 875
.meas tran vdout1_8ck174 FIND v(dout1_8) AT=875.025n

* CHECK dout1_9 Vdout1_9ck174 = 0 time = 875
.meas tran vdout1_9ck174 FIND v(dout1_9) AT=875.025n

* CHECK dout1_10 Vdout1_10ck174 = 0 time = 875
.meas tran vdout1_10ck174 FIND v(dout1_10) AT=875.025n

* CHECK dout1_11 Vdout1_11ck174 = 0.9 time = 875
.meas tran vdout1_11ck174 FIND v(dout1_11) AT=875.025n

* CHECK dout1_12 Vdout1_12ck174 = 0 time = 875
.meas tran vdout1_12ck174 FIND v(dout1_12) AT=875.025n

* CHECK dout1_13 Vdout1_13ck174 = 0 time = 875
.meas tran vdout1_13ck174 FIND v(dout1_13) AT=875.025n

* CHECK dout1_14 Vdout1_14ck174 = 0 time = 875
.meas tran vdout1_14ck174 FIND v(dout1_14) AT=875.025n

* CHECK dout1_15 Vdout1_15ck174 = 0 time = 875
.meas tran vdout1_15ck174 FIND v(dout1_15) AT=875.025n

* CHECK dout1_16 Vdout1_16ck174 = 0.9 time = 875
.meas tran vdout1_16ck174 FIND v(dout1_16) AT=875.025n

* CHECK dout1_17 Vdout1_17ck174 = 0.9 time = 875
.meas tran vdout1_17ck174 FIND v(dout1_17) AT=875.025n

* CHECK dout1_18 Vdout1_18ck174 = 0.9 time = 875
.meas tran vdout1_18ck174 FIND v(dout1_18) AT=875.025n

* CHECK dout1_19 Vdout1_19ck174 = 0.9 time = 875
.meas tran vdout1_19ck174 FIND v(dout1_19) AT=875.025n

* CHECK dout1_20 Vdout1_20ck174 = 0.9 time = 875
.meas tran vdout1_20ck174 FIND v(dout1_20) AT=875.025n

* CHECK dout1_21 Vdout1_21ck174 = 0.9 time = 875
.meas tran vdout1_21ck174 FIND v(dout1_21) AT=875.025n

* CHECK dout1_22 Vdout1_22ck174 = 0.9 time = 875
.meas tran vdout1_22ck174 FIND v(dout1_22) AT=875.025n

* CHECK dout1_23 Vdout1_23ck174 = 0 time = 875
.meas tran vdout1_23ck174 FIND v(dout1_23) AT=875.025n

* CHECK dout1_24 Vdout1_24ck174 = 0 time = 875
.meas tran vdout1_24ck174 FIND v(dout1_24) AT=875.025n

* CHECK dout1_25 Vdout1_25ck174 = 0 time = 875
.meas tran vdout1_25ck174 FIND v(dout1_25) AT=875.025n

* CHECK dout1_26 Vdout1_26ck174 = 0.9 time = 875
.meas tran vdout1_26ck174 FIND v(dout1_26) AT=875.025n

* CHECK dout1_27 Vdout1_27ck174 = 0 time = 875
.meas tran vdout1_27ck174 FIND v(dout1_27) AT=875.025n

* CHECK dout1_28 Vdout1_28ck174 = 0.9 time = 875
.meas tran vdout1_28ck174 FIND v(dout1_28) AT=875.025n

* CHECK dout1_29 Vdout1_29ck174 = 0.9 time = 875
.meas tran vdout1_29ck174 FIND v(dout1_29) AT=875.025n

* CHECK dout1_30 Vdout1_30ck174 = 0 time = 875
.meas tran vdout1_30ck174 FIND v(dout1_30) AT=875.025n

* CHECK dout1_31 Vdout1_31ck174 = 0 time = 875
.meas tran vdout1_31ck174 FIND v(dout1_31) AT=875.025n

* CHECK dout1_32 Vdout1_32ck174 = 0 time = 875
.meas tran vdout1_32ck174 FIND v(dout1_32) AT=875.025n

* CHECK dout1_33 Vdout1_33ck174 = 0.9 time = 875
.meas tran vdout1_33ck174 FIND v(dout1_33) AT=875.025n

* CHECK dout1_34 Vdout1_34ck174 = 0 time = 875
.meas tran vdout1_34ck174 FIND v(dout1_34) AT=875.025n

* CHECK dout1_35 Vdout1_35ck174 = 0 time = 875
.meas tran vdout1_35ck174 FIND v(dout1_35) AT=875.025n

* CHECK dout1_36 Vdout1_36ck174 = 0 time = 875
.meas tran vdout1_36ck174 FIND v(dout1_36) AT=875.025n

* CHECK dout1_37 Vdout1_37ck174 = 0 time = 875
.meas tran vdout1_37ck174 FIND v(dout1_37) AT=875.025n

* CHECK dout1_38 Vdout1_38ck174 = 0 time = 875
.meas tran vdout1_38ck174 FIND v(dout1_38) AT=875.025n

* CHECK dout1_39 Vdout1_39ck174 = 0 time = 875
.meas tran vdout1_39ck174 FIND v(dout1_39) AT=875.025n

* CHECK dout1_40 Vdout1_40ck174 = 0.9 time = 875
.meas tran vdout1_40ck174 FIND v(dout1_40) AT=875.025n

* CHECK dout1_41 Vdout1_41ck174 = 0 time = 875
.meas tran vdout1_41ck174 FIND v(dout1_41) AT=875.025n

* CHECK dout1_42 Vdout1_42ck174 = 0 time = 875
.meas tran vdout1_42ck174 FIND v(dout1_42) AT=875.025n

* CHECK dout1_43 Vdout1_43ck174 = 0.9 time = 875
.meas tran vdout1_43ck174 FIND v(dout1_43) AT=875.025n

* CHECK dout1_44 Vdout1_44ck174 = 0.9 time = 875
.meas tran vdout1_44ck174 FIND v(dout1_44) AT=875.025n

* CHECK dout1_45 Vdout1_45ck174 = 0 time = 875
.meas tran vdout1_45ck174 FIND v(dout1_45) AT=875.025n

* CHECK dout1_46 Vdout1_46ck174 = 0 time = 875
.meas tran vdout1_46ck174 FIND v(dout1_46) AT=875.025n

* CHECK dout1_47 Vdout1_47ck174 = 0 time = 875
.meas tran vdout1_47ck174 FIND v(dout1_47) AT=875.025n

* CHECK dout1_48 Vdout1_48ck174 = 0 time = 875
.meas tran vdout1_48ck174 FIND v(dout1_48) AT=875.025n

* CHECK dout1_49 Vdout1_49ck174 = 0.9 time = 875
.meas tran vdout1_49ck174 FIND v(dout1_49) AT=875.025n

* CHECK dout1_50 Vdout1_50ck174 = 0 time = 875
.meas tran vdout1_50ck174 FIND v(dout1_50) AT=875.025n

* CHECK dout1_51 Vdout1_51ck174 = 0 time = 875
.meas tran vdout1_51ck174 FIND v(dout1_51) AT=875.025n

* CHECK dout1_52 Vdout1_52ck174 = 0 time = 875
.meas tran vdout1_52ck174 FIND v(dout1_52) AT=875.025n

* CHECK dout1_53 Vdout1_53ck174 = 0 time = 875
.meas tran vdout1_53ck174 FIND v(dout1_53) AT=875.025n

* CHECK dout1_54 Vdout1_54ck174 = 0.9 time = 875
.meas tran vdout1_54ck174 FIND v(dout1_54) AT=875.025n

* CHECK dout1_55 Vdout1_55ck174 = 0.9 time = 875
.meas tran vdout1_55ck174 FIND v(dout1_55) AT=875.025n

* CHECK dout1_56 Vdout1_56ck174 = 0.9 time = 875
.meas tran vdout1_56ck174 FIND v(dout1_56) AT=875.025n

* CHECK dout1_57 Vdout1_57ck174 = 0 time = 875
.meas tran vdout1_57ck174 FIND v(dout1_57) AT=875.025n

* CHECK dout1_58 Vdout1_58ck174 = 0.9 time = 875
.meas tran vdout1_58ck174 FIND v(dout1_58) AT=875.025n

* CHECK dout1_59 Vdout1_59ck174 = 0 time = 875
.meas tran vdout1_59ck174 FIND v(dout1_59) AT=875.025n

* CHECK dout1_60 Vdout1_60ck174 = 0.9 time = 875
.meas tran vdout1_60ck174 FIND v(dout1_60) AT=875.025n

* CHECK dout1_61 Vdout1_61ck174 = 0 time = 875
.meas tran vdout1_61ck174 FIND v(dout1_61) AT=875.025n

* CHECK dout1_62 Vdout1_62ck174 = 0.9 time = 875
.meas tran vdout1_62ck174 FIND v(dout1_62) AT=875.025n

* CHECK dout1_63 Vdout1_63ck174 = 0 time = 875
.meas tran vdout1_63ck174 FIND v(dout1_63) AT=875.025n

* CHECK dout1_0 Vdout1_0ck175 = 0 time = 880
.meas tran vdout1_0ck175 FIND v(dout1_0) AT=880.025n

* CHECK dout1_1 Vdout1_1ck175 = 0 time = 880
.meas tran vdout1_1ck175 FIND v(dout1_1) AT=880.025n

* CHECK dout1_2 Vdout1_2ck175 = 0.9 time = 880
.meas tran vdout1_2ck175 FIND v(dout1_2) AT=880.025n

* CHECK dout1_3 Vdout1_3ck175 = 0 time = 880
.meas tran vdout1_3ck175 FIND v(dout1_3) AT=880.025n

* CHECK dout1_4 Vdout1_4ck175 = 0.9 time = 880
.meas tran vdout1_4ck175 FIND v(dout1_4) AT=880.025n

* CHECK dout1_5 Vdout1_5ck175 = 0 time = 880
.meas tran vdout1_5ck175 FIND v(dout1_5) AT=880.025n

* CHECK dout1_6 Vdout1_6ck175 = 0 time = 880
.meas tran vdout1_6ck175 FIND v(dout1_6) AT=880.025n

* CHECK dout1_7 Vdout1_7ck175 = 0.9 time = 880
.meas tran vdout1_7ck175 FIND v(dout1_7) AT=880.025n

* CHECK dout1_8 Vdout1_8ck175 = 0.9 time = 880
.meas tran vdout1_8ck175 FIND v(dout1_8) AT=880.025n

* CHECK dout1_9 Vdout1_9ck175 = 0 time = 880
.meas tran vdout1_9ck175 FIND v(dout1_9) AT=880.025n

* CHECK dout1_10 Vdout1_10ck175 = 0 time = 880
.meas tran vdout1_10ck175 FIND v(dout1_10) AT=880.025n

* CHECK dout1_11 Vdout1_11ck175 = 0.9 time = 880
.meas tran vdout1_11ck175 FIND v(dout1_11) AT=880.025n

* CHECK dout1_12 Vdout1_12ck175 = 0 time = 880
.meas tran vdout1_12ck175 FIND v(dout1_12) AT=880.025n

* CHECK dout1_13 Vdout1_13ck175 = 0 time = 880
.meas tran vdout1_13ck175 FIND v(dout1_13) AT=880.025n

* CHECK dout1_14 Vdout1_14ck175 = 0 time = 880
.meas tran vdout1_14ck175 FIND v(dout1_14) AT=880.025n

* CHECK dout1_15 Vdout1_15ck175 = 0 time = 880
.meas tran vdout1_15ck175 FIND v(dout1_15) AT=880.025n

* CHECK dout1_16 Vdout1_16ck175 = 0.9 time = 880
.meas tran vdout1_16ck175 FIND v(dout1_16) AT=880.025n

* CHECK dout1_17 Vdout1_17ck175 = 0.9 time = 880
.meas tran vdout1_17ck175 FIND v(dout1_17) AT=880.025n

* CHECK dout1_18 Vdout1_18ck175 = 0.9 time = 880
.meas tran vdout1_18ck175 FIND v(dout1_18) AT=880.025n

* CHECK dout1_19 Vdout1_19ck175 = 0.9 time = 880
.meas tran vdout1_19ck175 FIND v(dout1_19) AT=880.025n

* CHECK dout1_20 Vdout1_20ck175 = 0.9 time = 880
.meas tran vdout1_20ck175 FIND v(dout1_20) AT=880.025n

* CHECK dout1_21 Vdout1_21ck175 = 0.9 time = 880
.meas tran vdout1_21ck175 FIND v(dout1_21) AT=880.025n

* CHECK dout1_22 Vdout1_22ck175 = 0.9 time = 880
.meas tran vdout1_22ck175 FIND v(dout1_22) AT=880.025n

* CHECK dout1_23 Vdout1_23ck175 = 0 time = 880
.meas tran vdout1_23ck175 FIND v(dout1_23) AT=880.025n

* CHECK dout1_24 Vdout1_24ck175 = 0 time = 880
.meas tran vdout1_24ck175 FIND v(dout1_24) AT=880.025n

* CHECK dout1_25 Vdout1_25ck175 = 0 time = 880
.meas tran vdout1_25ck175 FIND v(dout1_25) AT=880.025n

* CHECK dout1_26 Vdout1_26ck175 = 0.9 time = 880
.meas tran vdout1_26ck175 FIND v(dout1_26) AT=880.025n

* CHECK dout1_27 Vdout1_27ck175 = 0 time = 880
.meas tran vdout1_27ck175 FIND v(dout1_27) AT=880.025n

* CHECK dout1_28 Vdout1_28ck175 = 0.9 time = 880
.meas tran vdout1_28ck175 FIND v(dout1_28) AT=880.025n

* CHECK dout1_29 Vdout1_29ck175 = 0.9 time = 880
.meas tran vdout1_29ck175 FIND v(dout1_29) AT=880.025n

* CHECK dout1_30 Vdout1_30ck175 = 0 time = 880
.meas tran vdout1_30ck175 FIND v(dout1_30) AT=880.025n

* CHECK dout1_31 Vdout1_31ck175 = 0 time = 880
.meas tran vdout1_31ck175 FIND v(dout1_31) AT=880.025n

* CHECK dout1_32 Vdout1_32ck175 = 0 time = 880
.meas tran vdout1_32ck175 FIND v(dout1_32) AT=880.025n

* CHECK dout1_33 Vdout1_33ck175 = 0.9 time = 880
.meas tran vdout1_33ck175 FIND v(dout1_33) AT=880.025n

* CHECK dout1_34 Vdout1_34ck175 = 0 time = 880
.meas tran vdout1_34ck175 FIND v(dout1_34) AT=880.025n

* CHECK dout1_35 Vdout1_35ck175 = 0 time = 880
.meas tran vdout1_35ck175 FIND v(dout1_35) AT=880.025n

* CHECK dout1_36 Vdout1_36ck175 = 0 time = 880
.meas tran vdout1_36ck175 FIND v(dout1_36) AT=880.025n

* CHECK dout1_37 Vdout1_37ck175 = 0 time = 880
.meas tran vdout1_37ck175 FIND v(dout1_37) AT=880.025n

* CHECK dout1_38 Vdout1_38ck175 = 0 time = 880
.meas tran vdout1_38ck175 FIND v(dout1_38) AT=880.025n

* CHECK dout1_39 Vdout1_39ck175 = 0 time = 880
.meas tran vdout1_39ck175 FIND v(dout1_39) AT=880.025n

* CHECK dout1_40 Vdout1_40ck175 = 0.9 time = 880
.meas tran vdout1_40ck175 FIND v(dout1_40) AT=880.025n

* CHECK dout1_41 Vdout1_41ck175 = 0 time = 880
.meas tran vdout1_41ck175 FIND v(dout1_41) AT=880.025n

* CHECK dout1_42 Vdout1_42ck175 = 0 time = 880
.meas tran vdout1_42ck175 FIND v(dout1_42) AT=880.025n

* CHECK dout1_43 Vdout1_43ck175 = 0.9 time = 880
.meas tran vdout1_43ck175 FIND v(dout1_43) AT=880.025n

* CHECK dout1_44 Vdout1_44ck175 = 0.9 time = 880
.meas tran vdout1_44ck175 FIND v(dout1_44) AT=880.025n

* CHECK dout1_45 Vdout1_45ck175 = 0 time = 880
.meas tran vdout1_45ck175 FIND v(dout1_45) AT=880.025n

* CHECK dout1_46 Vdout1_46ck175 = 0 time = 880
.meas tran vdout1_46ck175 FIND v(dout1_46) AT=880.025n

* CHECK dout1_47 Vdout1_47ck175 = 0 time = 880
.meas tran vdout1_47ck175 FIND v(dout1_47) AT=880.025n

* CHECK dout1_48 Vdout1_48ck175 = 0 time = 880
.meas tran vdout1_48ck175 FIND v(dout1_48) AT=880.025n

* CHECK dout1_49 Vdout1_49ck175 = 0.9 time = 880
.meas tran vdout1_49ck175 FIND v(dout1_49) AT=880.025n

* CHECK dout1_50 Vdout1_50ck175 = 0 time = 880
.meas tran vdout1_50ck175 FIND v(dout1_50) AT=880.025n

* CHECK dout1_51 Vdout1_51ck175 = 0 time = 880
.meas tran vdout1_51ck175 FIND v(dout1_51) AT=880.025n

* CHECK dout1_52 Vdout1_52ck175 = 0 time = 880
.meas tran vdout1_52ck175 FIND v(dout1_52) AT=880.025n

* CHECK dout1_53 Vdout1_53ck175 = 0 time = 880
.meas tran vdout1_53ck175 FIND v(dout1_53) AT=880.025n

* CHECK dout1_54 Vdout1_54ck175 = 0.9 time = 880
.meas tran vdout1_54ck175 FIND v(dout1_54) AT=880.025n

* CHECK dout1_55 Vdout1_55ck175 = 0.9 time = 880
.meas tran vdout1_55ck175 FIND v(dout1_55) AT=880.025n

* CHECK dout1_56 Vdout1_56ck175 = 0.9 time = 880
.meas tran vdout1_56ck175 FIND v(dout1_56) AT=880.025n

* CHECK dout1_57 Vdout1_57ck175 = 0 time = 880
.meas tran vdout1_57ck175 FIND v(dout1_57) AT=880.025n

* CHECK dout1_58 Vdout1_58ck175 = 0.9 time = 880
.meas tran vdout1_58ck175 FIND v(dout1_58) AT=880.025n

* CHECK dout1_59 Vdout1_59ck175 = 0 time = 880
.meas tran vdout1_59ck175 FIND v(dout1_59) AT=880.025n

* CHECK dout1_60 Vdout1_60ck175 = 0.9 time = 880
.meas tran vdout1_60ck175 FIND v(dout1_60) AT=880.025n

* CHECK dout1_61 Vdout1_61ck175 = 0 time = 880
.meas tran vdout1_61ck175 FIND v(dout1_61) AT=880.025n

* CHECK dout1_62 Vdout1_62ck175 = 0.9 time = 880
.meas tran vdout1_62ck175 FIND v(dout1_62) AT=880.025n

* CHECK dout1_63 Vdout1_63ck175 = 0 time = 880
.meas tran vdout1_63ck175 FIND v(dout1_63) AT=880.025n

* CHECK dout1_0 Vdout1_0ck180 = 0 time = 905
.meas tran vdout1_0ck180 FIND v(dout1_0) AT=905.025n

* CHECK dout1_1 Vdout1_1ck180 = 0.9 time = 905
.meas tran vdout1_1ck180 FIND v(dout1_1) AT=905.025n

* CHECK dout1_2 Vdout1_2ck180 = 0.9 time = 905
.meas tran vdout1_2ck180 FIND v(dout1_2) AT=905.025n

* CHECK dout1_3 Vdout1_3ck180 = 0 time = 905
.meas tran vdout1_3ck180 FIND v(dout1_3) AT=905.025n

* CHECK dout1_4 Vdout1_4ck180 = 0.9 time = 905
.meas tran vdout1_4ck180 FIND v(dout1_4) AT=905.025n

* CHECK dout1_5 Vdout1_5ck180 = 0 time = 905
.meas tran vdout1_5ck180 FIND v(dout1_5) AT=905.025n

* CHECK dout1_6 Vdout1_6ck180 = 0 time = 905
.meas tran vdout1_6ck180 FIND v(dout1_6) AT=905.025n

* CHECK dout1_7 Vdout1_7ck180 = 0 time = 905
.meas tran vdout1_7ck180 FIND v(dout1_7) AT=905.025n

* CHECK dout1_8 Vdout1_8ck180 = 0.9 time = 905
.meas tran vdout1_8ck180 FIND v(dout1_8) AT=905.025n

* CHECK dout1_9 Vdout1_9ck180 = 0 time = 905
.meas tran vdout1_9ck180 FIND v(dout1_9) AT=905.025n

* CHECK dout1_10 Vdout1_10ck180 = 0.9 time = 905
.meas tran vdout1_10ck180 FIND v(dout1_10) AT=905.025n

* CHECK dout1_11 Vdout1_11ck180 = 0 time = 905
.meas tran vdout1_11ck180 FIND v(dout1_11) AT=905.025n

* CHECK dout1_12 Vdout1_12ck180 = 0.9 time = 905
.meas tran vdout1_12ck180 FIND v(dout1_12) AT=905.025n

* CHECK dout1_13 Vdout1_13ck180 = 0.9 time = 905
.meas tran vdout1_13ck180 FIND v(dout1_13) AT=905.025n

* CHECK dout1_14 Vdout1_14ck180 = 0 time = 905
.meas tran vdout1_14ck180 FIND v(dout1_14) AT=905.025n

* CHECK dout1_15 Vdout1_15ck180 = 0 time = 905
.meas tran vdout1_15ck180 FIND v(dout1_15) AT=905.025n

* CHECK dout1_16 Vdout1_16ck180 = 0 time = 905
.meas tran vdout1_16ck180 FIND v(dout1_16) AT=905.025n

* CHECK dout1_17 Vdout1_17ck180 = 0 time = 905
.meas tran vdout1_17ck180 FIND v(dout1_17) AT=905.025n

* CHECK dout1_18 Vdout1_18ck180 = 0 time = 905
.meas tran vdout1_18ck180 FIND v(dout1_18) AT=905.025n

* CHECK dout1_19 Vdout1_19ck180 = 0.9 time = 905
.meas tran vdout1_19ck180 FIND v(dout1_19) AT=905.025n

* CHECK dout1_20 Vdout1_20ck180 = 0.9 time = 905
.meas tran vdout1_20ck180 FIND v(dout1_20) AT=905.025n

* CHECK dout1_21 Vdout1_21ck180 = 0.9 time = 905
.meas tran vdout1_21ck180 FIND v(dout1_21) AT=905.025n

* CHECK dout1_22 Vdout1_22ck180 = 0 time = 905
.meas tran vdout1_22ck180 FIND v(dout1_22) AT=905.025n

* CHECK dout1_23 Vdout1_23ck180 = 0.9 time = 905
.meas tran vdout1_23ck180 FIND v(dout1_23) AT=905.025n

* CHECK dout1_24 Vdout1_24ck180 = 0.9 time = 905
.meas tran vdout1_24ck180 FIND v(dout1_24) AT=905.025n

* CHECK dout1_25 Vdout1_25ck180 = 0 time = 905
.meas tran vdout1_25ck180 FIND v(dout1_25) AT=905.025n

* CHECK dout1_26 Vdout1_26ck180 = 0.9 time = 905
.meas tran vdout1_26ck180 FIND v(dout1_26) AT=905.025n

* CHECK dout1_27 Vdout1_27ck180 = 0 time = 905
.meas tran vdout1_27ck180 FIND v(dout1_27) AT=905.025n

* CHECK dout1_28 Vdout1_28ck180 = 0 time = 905
.meas tran vdout1_28ck180 FIND v(dout1_28) AT=905.025n

* CHECK dout1_29 Vdout1_29ck180 = 0 time = 905
.meas tran vdout1_29ck180 FIND v(dout1_29) AT=905.025n

* CHECK dout1_30 Vdout1_30ck180 = 0.9 time = 905
.meas tran vdout1_30ck180 FIND v(dout1_30) AT=905.025n

* CHECK dout1_31 Vdout1_31ck180 = 0 time = 905
.meas tran vdout1_31ck180 FIND v(dout1_31) AT=905.025n

* CHECK dout1_32 Vdout1_32ck180 = 0 time = 905
.meas tran vdout1_32ck180 FIND v(dout1_32) AT=905.025n

* CHECK dout1_33 Vdout1_33ck180 = 0 time = 905
.meas tran vdout1_33ck180 FIND v(dout1_33) AT=905.025n

* CHECK dout1_34 Vdout1_34ck180 = 0.9 time = 905
.meas tran vdout1_34ck180 FIND v(dout1_34) AT=905.025n

* CHECK dout1_35 Vdout1_35ck180 = 0 time = 905
.meas tran vdout1_35ck180 FIND v(dout1_35) AT=905.025n

* CHECK dout1_36 Vdout1_36ck180 = 0.9 time = 905
.meas tran vdout1_36ck180 FIND v(dout1_36) AT=905.025n

* CHECK dout1_37 Vdout1_37ck180 = 0.9 time = 905
.meas tran vdout1_37ck180 FIND v(dout1_37) AT=905.025n

* CHECK dout1_38 Vdout1_38ck180 = 0.9 time = 905
.meas tran vdout1_38ck180 FIND v(dout1_38) AT=905.025n

* CHECK dout1_39 Vdout1_39ck180 = 0.9 time = 905
.meas tran vdout1_39ck180 FIND v(dout1_39) AT=905.025n

* CHECK dout1_40 Vdout1_40ck180 = 0.9 time = 905
.meas tran vdout1_40ck180 FIND v(dout1_40) AT=905.025n

* CHECK dout1_41 Vdout1_41ck180 = 0 time = 905
.meas tran vdout1_41ck180 FIND v(dout1_41) AT=905.025n

* CHECK dout1_42 Vdout1_42ck180 = 0 time = 905
.meas tran vdout1_42ck180 FIND v(dout1_42) AT=905.025n

* CHECK dout1_43 Vdout1_43ck180 = 0 time = 905
.meas tran vdout1_43ck180 FIND v(dout1_43) AT=905.025n

* CHECK dout1_44 Vdout1_44ck180 = 0 time = 905
.meas tran vdout1_44ck180 FIND v(dout1_44) AT=905.025n

* CHECK dout1_45 Vdout1_45ck180 = 0 time = 905
.meas tran vdout1_45ck180 FIND v(dout1_45) AT=905.025n

* CHECK dout1_46 Vdout1_46ck180 = 0 time = 905
.meas tran vdout1_46ck180 FIND v(dout1_46) AT=905.025n

* CHECK dout1_47 Vdout1_47ck180 = 0 time = 905
.meas tran vdout1_47ck180 FIND v(dout1_47) AT=905.025n

* CHECK dout1_48 Vdout1_48ck180 = 0.9 time = 905
.meas tran vdout1_48ck180 FIND v(dout1_48) AT=905.025n

* CHECK dout1_49 Vdout1_49ck180 = 0.9 time = 905
.meas tran vdout1_49ck180 FIND v(dout1_49) AT=905.025n

* CHECK dout1_50 Vdout1_50ck180 = 0.9 time = 905
.meas tran vdout1_50ck180 FIND v(dout1_50) AT=905.025n

* CHECK dout1_51 Vdout1_51ck180 = 0 time = 905
.meas tran vdout1_51ck180 FIND v(dout1_51) AT=905.025n

* CHECK dout1_52 Vdout1_52ck180 = 0 time = 905
.meas tran vdout1_52ck180 FIND v(dout1_52) AT=905.025n

* CHECK dout1_53 Vdout1_53ck180 = 0 time = 905
.meas tran vdout1_53ck180 FIND v(dout1_53) AT=905.025n

* CHECK dout1_54 Vdout1_54ck180 = 0 time = 905
.meas tran vdout1_54ck180 FIND v(dout1_54) AT=905.025n

* CHECK dout1_55 Vdout1_55ck180 = 0 time = 905
.meas tran vdout1_55ck180 FIND v(dout1_55) AT=905.025n

* CHECK dout1_56 Vdout1_56ck180 = 0 time = 905
.meas tran vdout1_56ck180 FIND v(dout1_56) AT=905.025n

* CHECK dout1_57 Vdout1_57ck180 = 0.9 time = 905
.meas tran vdout1_57ck180 FIND v(dout1_57) AT=905.025n

* CHECK dout1_58 Vdout1_58ck180 = 0.9 time = 905
.meas tran vdout1_58ck180 FIND v(dout1_58) AT=905.025n

* CHECK dout1_59 Vdout1_59ck180 = 0.9 time = 905
.meas tran vdout1_59ck180 FIND v(dout1_59) AT=905.025n

* CHECK dout1_60 Vdout1_60ck180 = 0.9 time = 905
.meas tran vdout1_60ck180 FIND v(dout1_60) AT=905.025n

* CHECK dout1_61 Vdout1_61ck180 = 0 time = 905
.meas tran vdout1_61ck180 FIND v(dout1_61) AT=905.025n

* CHECK dout1_62 Vdout1_62ck180 = 0.9 time = 905
.meas tran vdout1_62ck180 FIND v(dout1_62) AT=905.025n

* CHECK dout1_63 Vdout1_63ck180 = 0.9 time = 905
.meas tran vdout1_63ck180 FIND v(dout1_63) AT=905.025n

* CHECK dout1_0 Vdout1_0ck186 = 0 time = 935
.meas tran vdout1_0ck186 FIND v(dout1_0) AT=935.025n

* CHECK dout1_1 Vdout1_1ck186 = 0.9 time = 935
.meas tran vdout1_1ck186 FIND v(dout1_1) AT=935.025n

* CHECK dout1_2 Vdout1_2ck186 = 0.9 time = 935
.meas tran vdout1_2ck186 FIND v(dout1_2) AT=935.025n

* CHECK dout1_3 Vdout1_3ck186 = 0 time = 935
.meas tran vdout1_3ck186 FIND v(dout1_3) AT=935.025n

* CHECK dout1_4 Vdout1_4ck186 = 0.9 time = 935
.meas tran vdout1_4ck186 FIND v(dout1_4) AT=935.025n

* CHECK dout1_5 Vdout1_5ck186 = 0.9 time = 935
.meas tran vdout1_5ck186 FIND v(dout1_5) AT=935.025n

* CHECK dout1_6 Vdout1_6ck186 = 0 time = 935
.meas tran vdout1_6ck186 FIND v(dout1_6) AT=935.025n

* CHECK dout1_7 Vdout1_7ck186 = 0.9 time = 935
.meas tran vdout1_7ck186 FIND v(dout1_7) AT=935.025n

* CHECK dout1_8 Vdout1_8ck186 = 0 time = 935
.meas tran vdout1_8ck186 FIND v(dout1_8) AT=935.025n

* CHECK dout1_9 Vdout1_9ck186 = 0 time = 935
.meas tran vdout1_9ck186 FIND v(dout1_9) AT=935.025n

* CHECK dout1_10 Vdout1_10ck186 = 0.9 time = 935
.meas tran vdout1_10ck186 FIND v(dout1_10) AT=935.025n

* CHECK dout1_11 Vdout1_11ck186 = 0.9 time = 935
.meas tran vdout1_11ck186 FIND v(dout1_11) AT=935.025n

* CHECK dout1_12 Vdout1_12ck186 = 0.9 time = 935
.meas tran vdout1_12ck186 FIND v(dout1_12) AT=935.025n

* CHECK dout1_13 Vdout1_13ck186 = 0 time = 935
.meas tran vdout1_13ck186 FIND v(dout1_13) AT=935.025n

* CHECK dout1_14 Vdout1_14ck186 = 0 time = 935
.meas tran vdout1_14ck186 FIND v(dout1_14) AT=935.025n

* CHECK dout1_15 Vdout1_15ck186 = 0 time = 935
.meas tran vdout1_15ck186 FIND v(dout1_15) AT=935.025n

* CHECK dout1_16 Vdout1_16ck186 = 0 time = 935
.meas tran vdout1_16ck186 FIND v(dout1_16) AT=935.025n

* CHECK dout1_17 Vdout1_17ck186 = 0.9 time = 935
.meas tran vdout1_17ck186 FIND v(dout1_17) AT=935.025n

* CHECK dout1_18 Vdout1_18ck186 = 0 time = 935
.meas tran vdout1_18ck186 FIND v(dout1_18) AT=935.025n

* CHECK dout1_19 Vdout1_19ck186 = 0.9 time = 935
.meas tran vdout1_19ck186 FIND v(dout1_19) AT=935.025n

* CHECK dout1_20 Vdout1_20ck186 = 0.9 time = 935
.meas tran vdout1_20ck186 FIND v(dout1_20) AT=935.025n

* CHECK dout1_21 Vdout1_21ck186 = 0 time = 935
.meas tran vdout1_21ck186 FIND v(dout1_21) AT=935.025n

* CHECK dout1_22 Vdout1_22ck186 = 0.9 time = 935
.meas tran vdout1_22ck186 FIND v(dout1_22) AT=935.025n

* CHECK dout1_23 Vdout1_23ck186 = 0.9 time = 935
.meas tran vdout1_23ck186 FIND v(dout1_23) AT=935.025n

* CHECK dout1_24 Vdout1_24ck186 = 0.9 time = 935
.meas tran vdout1_24ck186 FIND v(dout1_24) AT=935.025n

* CHECK dout1_25 Vdout1_25ck186 = 0 time = 935
.meas tran vdout1_25ck186 FIND v(dout1_25) AT=935.025n

* CHECK dout1_26 Vdout1_26ck186 = 0 time = 935
.meas tran vdout1_26ck186 FIND v(dout1_26) AT=935.025n

* CHECK dout1_27 Vdout1_27ck186 = 0.9 time = 935
.meas tran vdout1_27ck186 FIND v(dout1_27) AT=935.025n

* CHECK dout1_28 Vdout1_28ck186 = 0 time = 935
.meas tran vdout1_28ck186 FIND v(dout1_28) AT=935.025n

* CHECK dout1_29 Vdout1_29ck186 = 0 time = 935
.meas tran vdout1_29ck186 FIND v(dout1_29) AT=935.025n

* CHECK dout1_30 Vdout1_30ck186 = 0 time = 935
.meas tran vdout1_30ck186 FIND v(dout1_30) AT=935.025n

* CHECK dout1_31 Vdout1_31ck186 = 0.9 time = 935
.meas tran vdout1_31ck186 FIND v(dout1_31) AT=935.025n

* CHECK dout1_32 Vdout1_32ck186 = 0.9 time = 935
.meas tran vdout1_32ck186 FIND v(dout1_32) AT=935.025n

* CHECK dout1_33 Vdout1_33ck186 = 0.9 time = 935
.meas tran vdout1_33ck186 FIND v(dout1_33) AT=935.025n

* CHECK dout1_34 Vdout1_34ck186 = 0.9 time = 935
.meas tran vdout1_34ck186 FIND v(dout1_34) AT=935.025n

* CHECK dout1_35 Vdout1_35ck186 = 0.9 time = 935
.meas tran vdout1_35ck186 FIND v(dout1_35) AT=935.025n

* CHECK dout1_36 Vdout1_36ck186 = 0 time = 935
.meas tran vdout1_36ck186 FIND v(dout1_36) AT=935.025n

* CHECK dout1_37 Vdout1_37ck186 = 0.9 time = 935
.meas tran vdout1_37ck186 FIND v(dout1_37) AT=935.025n

* CHECK dout1_38 Vdout1_38ck186 = 0.9 time = 935
.meas tran vdout1_38ck186 FIND v(dout1_38) AT=935.025n

* CHECK dout1_39 Vdout1_39ck186 = 0.9 time = 935
.meas tran vdout1_39ck186 FIND v(dout1_39) AT=935.025n

* CHECK dout1_40 Vdout1_40ck186 = 0 time = 935
.meas tran vdout1_40ck186 FIND v(dout1_40) AT=935.025n

* CHECK dout1_41 Vdout1_41ck186 = 0 time = 935
.meas tran vdout1_41ck186 FIND v(dout1_41) AT=935.025n

* CHECK dout1_42 Vdout1_42ck186 = 0.9 time = 935
.meas tran vdout1_42ck186 FIND v(dout1_42) AT=935.025n

* CHECK dout1_43 Vdout1_43ck186 = 0.9 time = 935
.meas tran vdout1_43ck186 FIND v(dout1_43) AT=935.025n

* CHECK dout1_44 Vdout1_44ck186 = 0 time = 935
.meas tran vdout1_44ck186 FIND v(dout1_44) AT=935.025n

* CHECK dout1_45 Vdout1_45ck186 = 0 time = 935
.meas tran vdout1_45ck186 FIND v(dout1_45) AT=935.025n

* CHECK dout1_46 Vdout1_46ck186 = 0.9 time = 935
.meas tran vdout1_46ck186 FIND v(dout1_46) AT=935.025n

* CHECK dout1_47 Vdout1_47ck186 = 0 time = 935
.meas tran vdout1_47ck186 FIND v(dout1_47) AT=935.025n

* CHECK dout1_48 Vdout1_48ck186 = 0.9 time = 935
.meas tran vdout1_48ck186 FIND v(dout1_48) AT=935.025n

* CHECK dout1_49 Vdout1_49ck186 = 0 time = 935
.meas tran vdout1_49ck186 FIND v(dout1_49) AT=935.025n

* CHECK dout1_50 Vdout1_50ck186 = 0 time = 935
.meas tran vdout1_50ck186 FIND v(dout1_50) AT=935.025n

* CHECK dout1_51 Vdout1_51ck186 = 0 time = 935
.meas tran vdout1_51ck186 FIND v(dout1_51) AT=935.025n

* CHECK dout1_52 Vdout1_52ck186 = 0 time = 935
.meas tran vdout1_52ck186 FIND v(dout1_52) AT=935.025n

* CHECK dout1_53 Vdout1_53ck186 = 0 time = 935
.meas tran vdout1_53ck186 FIND v(dout1_53) AT=935.025n

* CHECK dout1_54 Vdout1_54ck186 = 0.9 time = 935
.meas tran vdout1_54ck186 FIND v(dout1_54) AT=935.025n

* CHECK dout1_55 Vdout1_55ck186 = 0.9 time = 935
.meas tran vdout1_55ck186 FIND v(dout1_55) AT=935.025n

* CHECK dout1_56 Vdout1_56ck186 = 0.9 time = 935
.meas tran vdout1_56ck186 FIND v(dout1_56) AT=935.025n

* CHECK dout1_57 Vdout1_57ck186 = 0.9 time = 935
.meas tran vdout1_57ck186 FIND v(dout1_57) AT=935.025n

* CHECK dout1_58 Vdout1_58ck186 = 0.9 time = 935
.meas tran vdout1_58ck186 FIND v(dout1_58) AT=935.025n

* CHECK dout1_59 Vdout1_59ck186 = 0 time = 935
.meas tran vdout1_59ck186 FIND v(dout1_59) AT=935.025n

* CHECK dout1_60 Vdout1_60ck186 = 0.9 time = 935
.meas tran vdout1_60ck186 FIND v(dout1_60) AT=935.025n

* CHECK dout1_61 Vdout1_61ck186 = 0.9 time = 935
.meas tran vdout1_61ck186 FIND v(dout1_61) AT=935.025n

* CHECK dout1_62 Vdout1_62ck186 = 0 time = 935
.meas tran vdout1_62ck186 FIND v(dout1_62) AT=935.025n

* CHECK dout1_63 Vdout1_63ck186 = 0.9 time = 935
.meas tran vdout1_63ck186 FIND v(dout1_63) AT=935.025n

* CHECK dout1_0 Vdout1_0ck188 = 0 time = 945
.meas tran vdout1_0ck188 FIND v(dout1_0) AT=945.025n

* CHECK dout1_1 Vdout1_1ck188 = 0.9 time = 945
.meas tran vdout1_1ck188 FIND v(dout1_1) AT=945.025n

* CHECK dout1_2 Vdout1_2ck188 = 0.9 time = 945
.meas tran vdout1_2ck188 FIND v(dout1_2) AT=945.025n

* CHECK dout1_3 Vdout1_3ck188 = 0.9 time = 945
.meas tran vdout1_3ck188 FIND v(dout1_3) AT=945.025n

* CHECK dout1_4 Vdout1_4ck188 = 0 time = 945
.meas tran vdout1_4ck188 FIND v(dout1_4) AT=945.025n

* CHECK dout1_5 Vdout1_5ck188 = 0.9 time = 945
.meas tran vdout1_5ck188 FIND v(dout1_5) AT=945.025n

* CHECK dout1_6 Vdout1_6ck188 = 0.9 time = 945
.meas tran vdout1_6ck188 FIND v(dout1_6) AT=945.025n

* CHECK dout1_7 Vdout1_7ck188 = 0 time = 945
.meas tran vdout1_7ck188 FIND v(dout1_7) AT=945.025n

* CHECK dout1_8 Vdout1_8ck188 = 0.9 time = 945
.meas tran vdout1_8ck188 FIND v(dout1_8) AT=945.025n

* CHECK dout1_9 Vdout1_9ck188 = 0 time = 945
.meas tran vdout1_9ck188 FIND v(dout1_9) AT=945.025n

* CHECK dout1_10 Vdout1_10ck188 = 0.9 time = 945
.meas tran vdout1_10ck188 FIND v(dout1_10) AT=945.025n

* CHECK dout1_11 Vdout1_11ck188 = 0.9 time = 945
.meas tran vdout1_11ck188 FIND v(dout1_11) AT=945.025n

* CHECK dout1_12 Vdout1_12ck188 = 0.9 time = 945
.meas tran vdout1_12ck188 FIND v(dout1_12) AT=945.025n

* CHECK dout1_13 Vdout1_13ck188 = 0 time = 945
.meas tran vdout1_13ck188 FIND v(dout1_13) AT=945.025n

* CHECK dout1_14 Vdout1_14ck188 = 0 time = 945
.meas tran vdout1_14ck188 FIND v(dout1_14) AT=945.025n

* CHECK dout1_15 Vdout1_15ck188 = 0.9 time = 945
.meas tran vdout1_15ck188 FIND v(dout1_15) AT=945.025n

* CHECK dout1_16 Vdout1_16ck188 = 0.9 time = 945
.meas tran vdout1_16ck188 FIND v(dout1_16) AT=945.025n

* CHECK dout1_17 Vdout1_17ck188 = 0.9 time = 945
.meas tran vdout1_17ck188 FIND v(dout1_17) AT=945.025n

* CHECK dout1_18 Vdout1_18ck188 = 0.9 time = 945
.meas tran vdout1_18ck188 FIND v(dout1_18) AT=945.025n

* CHECK dout1_19 Vdout1_19ck188 = 0 time = 945
.meas tran vdout1_19ck188 FIND v(dout1_19) AT=945.025n

* CHECK dout1_20 Vdout1_20ck188 = 0.9 time = 945
.meas tran vdout1_20ck188 FIND v(dout1_20) AT=945.025n

* CHECK dout1_21 Vdout1_21ck188 = 0.9 time = 945
.meas tran vdout1_21ck188 FIND v(dout1_21) AT=945.025n

* CHECK dout1_22 Vdout1_22ck188 = 0 time = 945
.meas tran vdout1_22ck188 FIND v(dout1_22) AT=945.025n

* CHECK dout1_23 Vdout1_23ck188 = 0 time = 945
.meas tran vdout1_23ck188 FIND v(dout1_23) AT=945.025n

* CHECK dout1_24 Vdout1_24ck188 = 0.9 time = 945
.meas tran vdout1_24ck188 FIND v(dout1_24) AT=945.025n

* CHECK dout1_25 Vdout1_25ck188 = 0 time = 945
.meas tran vdout1_25ck188 FIND v(dout1_25) AT=945.025n

* CHECK dout1_26 Vdout1_26ck188 = 0 time = 945
.meas tran vdout1_26ck188 FIND v(dout1_26) AT=945.025n

* CHECK dout1_27 Vdout1_27ck188 = 0.9 time = 945
.meas tran vdout1_27ck188 FIND v(dout1_27) AT=945.025n

* CHECK dout1_28 Vdout1_28ck188 = 0.9 time = 945
.meas tran vdout1_28ck188 FIND v(dout1_28) AT=945.025n

* CHECK dout1_29 Vdout1_29ck188 = 0 time = 945
.meas tran vdout1_29ck188 FIND v(dout1_29) AT=945.025n

* CHECK dout1_30 Vdout1_30ck188 = 0 time = 945
.meas tran vdout1_30ck188 FIND v(dout1_30) AT=945.025n

* CHECK dout1_31 Vdout1_31ck188 = 0.9 time = 945
.meas tran vdout1_31ck188 FIND v(dout1_31) AT=945.025n

* CHECK dout1_32 Vdout1_32ck188 = 0.9 time = 945
.meas tran vdout1_32ck188 FIND v(dout1_32) AT=945.025n

* CHECK dout1_33 Vdout1_33ck188 = 0.9 time = 945
.meas tran vdout1_33ck188 FIND v(dout1_33) AT=945.025n

* CHECK dout1_34 Vdout1_34ck188 = 0.9 time = 945
.meas tran vdout1_34ck188 FIND v(dout1_34) AT=945.025n

* CHECK dout1_35 Vdout1_35ck188 = 0.9 time = 945
.meas tran vdout1_35ck188 FIND v(dout1_35) AT=945.025n

* CHECK dout1_36 Vdout1_36ck188 = 0 time = 945
.meas tran vdout1_36ck188 FIND v(dout1_36) AT=945.025n

* CHECK dout1_37 Vdout1_37ck188 = 0.9 time = 945
.meas tran vdout1_37ck188 FIND v(dout1_37) AT=945.025n

* CHECK dout1_38 Vdout1_38ck188 = 0 time = 945
.meas tran vdout1_38ck188 FIND v(dout1_38) AT=945.025n

* CHECK dout1_39 Vdout1_39ck188 = 0.9 time = 945
.meas tran vdout1_39ck188 FIND v(dout1_39) AT=945.025n

* CHECK dout1_40 Vdout1_40ck188 = 0.9 time = 945
.meas tran vdout1_40ck188 FIND v(dout1_40) AT=945.025n

* CHECK dout1_41 Vdout1_41ck188 = 0.9 time = 945
.meas tran vdout1_41ck188 FIND v(dout1_41) AT=945.025n

* CHECK dout1_42 Vdout1_42ck188 = 0 time = 945
.meas tran vdout1_42ck188 FIND v(dout1_42) AT=945.025n

* CHECK dout1_43 Vdout1_43ck188 = 0.9 time = 945
.meas tran vdout1_43ck188 FIND v(dout1_43) AT=945.025n

* CHECK dout1_44 Vdout1_44ck188 = 0.9 time = 945
.meas tran vdout1_44ck188 FIND v(dout1_44) AT=945.025n

* CHECK dout1_45 Vdout1_45ck188 = 0 time = 945
.meas tran vdout1_45ck188 FIND v(dout1_45) AT=945.025n

* CHECK dout1_46 Vdout1_46ck188 = 0.9 time = 945
.meas tran vdout1_46ck188 FIND v(dout1_46) AT=945.025n

* CHECK dout1_47 Vdout1_47ck188 = 0.9 time = 945
.meas tran vdout1_47ck188 FIND v(dout1_47) AT=945.025n

* CHECK dout1_48 Vdout1_48ck188 = 0 time = 945
.meas tran vdout1_48ck188 FIND v(dout1_48) AT=945.025n

* CHECK dout1_49 Vdout1_49ck188 = 0 time = 945
.meas tran vdout1_49ck188 FIND v(dout1_49) AT=945.025n

* CHECK dout1_50 Vdout1_50ck188 = 0 time = 945
.meas tran vdout1_50ck188 FIND v(dout1_50) AT=945.025n

* CHECK dout1_51 Vdout1_51ck188 = 0.9 time = 945
.meas tran vdout1_51ck188 FIND v(dout1_51) AT=945.025n

* CHECK dout1_52 Vdout1_52ck188 = 0.9 time = 945
.meas tran vdout1_52ck188 FIND v(dout1_52) AT=945.025n

* CHECK dout1_53 Vdout1_53ck188 = 0 time = 945
.meas tran vdout1_53ck188 FIND v(dout1_53) AT=945.025n

* CHECK dout1_54 Vdout1_54ck188 = 0.9 time = 945
.meas tran vdout1_54ck188 FIND v(dout1_54) AT=945.025n

* CHECK dout1_55 Vdout1_55ck188 = 0.9 time = 945
.meas tran vdout1_55ck188 FIND v(dout1_55) AT=945.025n

* CHECK dout1_56 Vdout1_56ck188 = 0 time = 945
.meas tran vdout1_56ck188 FIND v(dout1_56) AT=945.025n

* CHECK dout1_57 Vdout1_57ck188 = 0.9 time = 945
.meas tran vdout1_57ck188 FIND v(dout1_57) AT=945.025n

* CHECK dout1_58 Vdout1_58ck188 = 0 time = 945
.meas tran vdout1_58ck188 FIND v(dout1_58) AT=945.025n

* CHECK dout1_59 Vdout1_59ck188 = 0 time = 945
.meas tran vdout1_59ck188 FIND v(dout1_59) AT=945.025n

* CHECK dout1_60 Vdout1_60ck188 = 0 time = 945
.meas tran vdout1_60ck188 FIND v(dout1_60) AT=945.025n

* CHECK dout1_61 Vdout1_61ck188 = 0 time = 945
.meas tran vdout1_61ck188 FIND v(dout1_61) AT=945.025n

* CHECK dout1_62 Vdout1_62ck188 = 0.9 time = 945
.meas tran vdout1_62ck188 FIND v(dout1_62) AT=945.025n

* CHECK dout1_63 Vdout1_63ck188 = 0 time = 945
.meas tran vdout1_63ck188 FIND v(dout1_63) AT=945.025n

* CHECK dout1_0 Vdout1_0ck198 = 0.9 time = 995
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=995.025n

* CHECK dout1_1 Vdout1_1ck198 = 0 time = 995
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=995.025n

* CHECK dout1_2 Vdout1_2ck198 = 0 time = 995
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=995.025n

* CHECK dout1_3 Vdout1_3ck198 = 0.9 time = 995
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=995.025n

* CHECK dout1_4 Vdout1_4ck198 = 0 time = 995
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=995.025n

* CHECK dout1_5 Vdout1_5ck198 = 0.9 time = 995
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=995.025n

* CHECK dout1_6 Vdout1_6ck198 = 0.9 time = 995
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=995.025n

* CHECK dout1_7 Vdout1_7ck198 = 0 time = 995
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=995.025n

* CHECK dout1_8 Vdout1_8ck198 = 0.9 time = 995
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=995.025n

* CHECK dout1_9 Vdout1_9ck198 = 0.9 time = 995
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=995.025n

* CHECK dout1_10 Vdout1_10ck198 = 0 time = 995
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=995.025n

* CHECK dout1_11 Vdout1_11ck198 = 0 time = 995
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=995.025n

* CHECK dout1_12 Vdout1_12ck198 = 0.9 time = 995
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=995.025n

* CHECK dout1_13 Vdout1_13ck198 = 0.9 time = 995
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=995.025n

* CHECK dout1_14 Vdout1_14ck198 = 0.9 time = 995
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=995.025n

* CHECK dout1_15 Vdout1_15ck198 = 0 time = 995
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=995.025n

* CHECK dout1_16 Vdout1_16ck198 = 0 time = 995
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=995.025n

* CHECK dout1_17 Vdout1_17ck198 = 0.9 time = 995
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=995.025n

* CHECK dout1_18 Vdout1_18ck198 = 0.9 time = 995
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=995.025n

* CHECK dout1_19 Vdout1_19ck198 = 0.9 time = 995
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=995.025n

* CHECK dout1_20 Vdout1_20ck198 = 0.9 time = 995
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=995.025n

* CHECK dout1_21 Vdout1_21ck198 = 0 time = 995
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=995.025n

* CHECK dout1_22 Vdout1_22ck198 = 0.9 time = 995
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=995.025n

* CHECK dout1_23 Vdout1_23ck198 = 0.9 time = 995
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=995.025n

* CHECK dout1_24 Vdout1_24ck198 = 0.9 time = 995
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=995.025n

* CHECK dout1_25 Vdout1_25ck198 = 0 time = 995
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=995.025n

* CHECK dout1_26 Vdout1_26ck198 = 0 time = 995
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=995.025n

* CHECK dout1_27 Vdout1_27ck198 = 0.9 time = 995
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=995.025n

* CHECK dout1_28 Vdout1_28ck198 = 0.9 time = 995
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=995.025n

* CHECK dout1_29 Vdout1_29ck198 = 0 time = 995
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=995.025n

* CHECK dout1_30 Vdout1_30ck198 = 0 time = 995
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=995.025n

* CHECK dout1_31 Vdout1_31ck198 = 0 time = 995
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=995.025n

* CHECK dout1_32 Vdout1_32ck198 = 0.9 time = 995
.meas tran vdout1_32ck198 FIND v(dout1_32) AT=995.025n

* CHECK dout1_33 Vdout1_33ck198 = 0 time = 995
.meas tran vdout1_33ck198 FIND v(dout1_33) AT=995.025n

* CHECK dout1_34 Vdout1_34ck198 = 0.9 time = 995
.meas tran vdout1_34ck198 FIND v(dout1_34) AT=995.025n

* CHECK dout1_35 Vdout1_35ck198 = 0.9 time = 995
.meas tran vdout1_35ck198 FIND v(dout1_35) AT=995.025n

* CHECK dout1_36 Vdout1_36ck198 = 0.9 time = 995
.meas tran vdout1_36ck198 FIND v(dout1_36) AT=995.025n

* CHECK dout1_37 Vdout1_37ck198 = 0.9 time = 995
.meas tran vdout1_37ck198 FIND v(dout1_37) AT=995.025n

* CHECK dout1_38 Vdout1_38ck198 = 0.9 time = 995
.meas tran vdout1_38ck198 FIND v(dout1_38) AT=995.025n

* CHECK dout1_39 Vdout1_39ck198 = 0 time = 995
.meas tran vdout1_39ck198 FIND v(dout1_39) AT=995.025n

* CHECK dout1_40 Vdout1_40ck198 = 0.9 time = 995
.meas tran vdout1_40ck198 FIND v(dout1_40) AT=995.025n

* CHECK dout1_41 Vdout1_41ck198 = 0.9 time = 995
.meas tran vdout1_41ck198 FIND v(dout1_41) AT=995.025n

* CHECK dout1_42 Vdout1_42ck198 = 0.9 time = 995
.meas tran vdout1_42ck198 FIND v(dout1_42) AT=995.025n

* CHECK dout1_43 Vdout1_43ck198 = 0 time = 995
.meas tran vdout1_43ck198 FIND v(dout1_43) AT=995.025n

* CHECK dout1_44 Vdout1_44ck198 = 0.9 time = 995
.meas tran vdout1_44ck198 FIND v(dout1_44) AT=995.025n

* CHECK dout1_45 Vdout1_45ck198 = 0.9 time = 995
.meas tran vdout1_45ck198 FIND v(dout1_45) AT=995.025n

* CHECK dout1_46 Vdout1_46ck198 = 0.9 time = 995
.meas tran vdout1_46ck198 FIND v(dout1_46) AT=995.025n

* CHECK dout1_47 Vdout1_47ck198 = 0.9 time = 995
.meas tran vdout1_47ck198 FIND v(dout1_47) AT=995.025n

* CHECK dout1_48 Vdout1_48ck198 = 0.9 time = 995
.meas tran vdout1_48ck198 FIND v(dout1_48) AT=995.025n

* CHECK dout1_49 Vdout1_49ck198 = 0.9 time = 995
.meas tran vdout1_49ck198 FIND v(dout1_49) AT=995.025n

* CHECK dout1_50 Vdout1_50ck198 = 0 time = 995
.meas tran vdout1_50ck198 FIND v(dout1_50) AT=995.025n

* CHECK dout1_51 Vdout1_51ck198 = 0 time = 995
.meas tran vdout1_51ck198 FIND v(dout1_51) AT=995.025n

* CHECK dout1_52 Vdout1_52ck198 = 0 time = 995
.meas tran vdout1_52ck198 FIND v(dout1_52) AT=995.025n

* CHECK dout1_53 Vdout1_53ck198 = 0.9 time = 995
.meas tran vdout1_53ck198 FIND v(dout1_53) AT=995.025n

* CHECK dout1_54 Vdout1_54ck198 = 0.9 time = 995
.meas tran vdout1_54ck198 FIND v(dout1_54) AT=995.025n

* CHECK dout1_55 Vdout1_55ck198 = 0 time = 995
.meas tran vdout1_55ck198 FIND v(dout1_55) AT=995.025n

* CHECK dout1_56 Vdout1_56ck198 = 0 time = 995
.meas tran vdout1_56ck198 FIND v(dout1_56) AT=995.025n

* CHECK dout1_57 Vdout1_57ck198 = 0.9 time = 995
.meas tran vdout1_57ck198 FIND v(dout1_57) AT=995.025n

* CHECK dout1_58 Vdout1_58ck198 = 0 time = 995
.meas tran vdout1_58ck198 FIND v(dout1_58) AT=995.025n

* CHECK dout1_59 Vdout1_59ck198 = 0 time = 995
.meas tran vdout1_59ck198 FIND v(dout1_59) AT=995.025n

* CHECK dout1_60 Vdout1_60ck198 = 0.9 time = 995
.meas tran vdout1_60ck198 FIND v(dout1_60) AT=995.025n

* CHECK dout1_61 Vdout1_61ck198 = 0.9 time = 995
.meas tran vdout1_61ck198 FIND v(dout1_61) AT=995.025n

* CHECK dout1_62 Vdout1_62ck198 = 0.9 time = 995
.meas tran vdout1_62ck198 FIND v(dout1_62) AT=995.025n

* CHECK dout1_63 Vdout1_63ck198 = 0.9 time = 995
.meas tran vdout1_63ck198 FIND v(dout1_63) AT=995.025n

* CHECK dout1_0 Vdout1_0ck200 = 0.9 time = 1005
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=1005.025n

* CHECK dout1_1 Vdout1_1ck200 = 0 time = 1005
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=1005.025n

* CHECK dout1_2 Vdout1_2ck200 = 0.9 time = 1005
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=1005.025n

* CHECK dout1_3 Vdout1_3ck200 = 0.9 time = 1005
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=1005.025n

* CHECK dout1_4 Vdout1_4ck200 = 0.9 time = 1005
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=1005.025n

* CHECK dout1_5 Vdout1_5ck200 = 0.9 time = 1005
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=1005.025n

* CHECK dout1_6 Vdout1_6ck200 = 0.9 time = 1005
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=1005.025n

* CHECK dout1_7 Vdout1_7ck200 = 0 time = 1005
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=1005.025n

* CHECK dout1_8 Vdout1_8ck200 = 0 time = 1005
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=1005.025n

* CHECK dout1_9 Vdout1_9ck200 = 0 time = 1005
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=1005.025n

* CHECK dout1_10 Vdout1_10ck200 = 0.9 time = 1005
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=1005.025n

* CHECK dout1_11 Vdout1_11ck200 = 0.9 time = 1005
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=1005.025n

* CHECK dout1_12 Vdout1_12ck200 = 0 time = 1005
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=1005.025n

* CHECK dout1_13 Vdout1_13ck200 = 0.9 time = 1005
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=1005.025n

* CHECK dout1_14 Vdout1_14ck200 = 0 time = 1005
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=1005.025n

* CHECK dout1_15 Vdout1_15ck200 = 0.9 time = 1005
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=1005.025n

* CHECK dout1_16 Vdout1_16ck200 = 0 time = 1005
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=1005.025n

* CHECK dout1_17 Vdout1_17ck200 = 0 time = 1005
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=1005.025n

* CHECK dout1_18 Vdout1_18ck200 = 0.9 time = 1005
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=1005.025n

* CHECK dout1_19 Vdout1_19ck200 = 0.9 time = 1005
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=1005.025n

* CHECK dout1_20 Vdout1_20ck200 = 0.9 time = 1005
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=1005.025n

* CHECK dout1_21 Vdout1_21ck200 = 0 time = 1005
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=1005.025n

* CHECK dout1_22 Vdout1_22ck200 = 0 time = 1005
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=1005.025n

* CHECK dout1_23 Vdout1_23ck200 = 0.9 time = 1005
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=1005.025n

* CHECK dout1_24 Vdout1_24ck200 = 0 time = 1005
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=1005.025n

* CHECK dout1_25 Vdout1_25ck200 = 0 time = 1005
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=1005.025n

* CHECK dout1_26 Vdout1_26ck200 = 0 time = 1005
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=1005.025n

* CHECK dout1_27 Vdout1_27ck200 = 0.9 time = 1005
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=1005.025n

* CHECK dout1_28 Vdout1_28ck200 = 0.9 time = 1005
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=1005.025n

* CHECK dout1_29 Vdout1_29ck200 = 0.9 time = 1005
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=1005.025n

* CHECK dout1_30 Vdout1_30ck200 = 0.9 time = 1005
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=1005.025n

* CHECK dout1_31 Vdout1_31ck200 = 0 time = 1005
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=1005.025n

* CHECK dout1_32 Vdout1_32ck200 = 0 time = 1005
.meas tran vdout1_32ck200 FIND v(dout1_32) AT=1005.025n

* CHECK dout1_33 Vdout1_33ck200 = 0.9 time = 1005
.meas tran vdout1_33ck200 FIND v(dout1_33) AT=1005.025n

* CHECK dout1_34 Vdout1_34ck200 = 0.9 time = 1005
.meas tran vdout1_34ck200 FIND v(dout1_34) AT=1005.025n

* CHECK dout1_35 Vdout1_35ck200 = 0 time = 1005
.meas tran vdout1_35ck200 FIND v(dout1_35) AT=1005.025n

* CHECK dout1_36 Vdout1_36ck200 = 0.9 time = 1005
.meas tran vdout1_36ck200 FIND v(dout1_36) AT=1005.025n

* CHECK dout1_37 Vdout1_37ck200 = 0.9 time = 1005
.meas tran vdout1_37ck200 FIND v(dout1_37) AT=1005.025n

* CHECK dout1_38 Vdout1_38ck200 = 0.9 time = 1005
.meas tran vdout1_38ck200 FIND v(dout1_38) AT=1005.025n

* CHECK dout1_39 Vdout1_39ck200 = 0 time = 1005
.meas tran vdout1_39ck200 FIND v(dout1_39) AT=1005.025n

* CHECK dout1_40 Vdout1_40ck200 = 0 time = 1005
.meas tran vdout1_40ck200 FIND v(dout1_40) AT=1005.025n

* CHECK dout1_41 Vdout1_41ck200 = 0 time = 1005
.meas tran vdout1_41ck200 FIND v(dout1_41) AT=1005.025n

* CHECK dout1_42 Vdout1_42ck200 = 0.9 time = 1005
.meas tran vdout1_42ck200 FIND v(dout1_42) AT=1005.025n

* CHECK dout1_43 Vdout1_43ck200 = 0 time = 1005
.meas tran vdout1_43ck200 FIND v(dout1_43) AT=1005.025n

* CHECK dout1_44 Vdout1_44ck200 = 0 time = 1005
.meas tran vdout1_44ck200 FIND v(dout1_44) AT=1005.025n

* CHECK dout1_45 Vdout1_45ck200 = 0 time = 1005
.meas tran vdout1_45ck200 FIND v(dout1_45) AT=1005.025n

* CHECK dout1_46 Vdout1_46ck200 = 0 time = 1005
.meas tran vdout1_46ck200 FIND v(dout1_46) AT=1005.025n

* CHECK dout1_47 Vdout1_47ck200 = 0 time = 1005
.meas tran vdout1_47ck200 FIND v(dout1_47) AT=1005.025n

* CHECK dout1_48 Vdout1_48ck200 = 0 time = 1005
.meas tran vdout1_48ck200 FIND v(dout1_48) AT=1005.025n

* CHECK dout1_49 Vdout1_49ck200 = 0 time = 1005
.meas tran vdout1_49ck200 FIND v(dout1_49) AT=1005.025n

* CHECK dout1_50 Vdout1_50ck200 = 0 time = 1005
.meas tran vdout1_50ck200 FIND v(dout1_50) AT=1005.025n

* CHECK dout1_51 Vdout1_51ck200 = 0.9 time = 1005
.meas tran vdout1_51ck200 FIND v(dout1_51) AT=1005.025n

* CHECK dout1_52 Vdout1_52ck200 = 0 time = 1005
.meas tran vdout1_52ck200 FIND v(dout1_52) AT=1005.025n

* CHECK dout1_53 Vdout1_53ck200 = 0.9 time = 1005
.meas tran vdout1_53ck200 FIND v(dout1_53) AT=1005.025n

* CHECK dout1_54 Vdout1_54ck200 = 0 time = 1005
.meas tran vdout1_54ck200 FIND v(dout1_54) AT=1005.025n

* CHECK dout1_55 Vdout1_55ck200 = 0.9 time = 1005
.meas tran vdout1_55ck200 FIND v(dout1_55) AT=1005.025n

* CHECK dout1_56 Vdout1_56ck200 = 0 time = 1005
.meas tran vdout1_56ck200 FIND v(dout1_56) AT=1005.025n

* CHECK dout1_57 Vdout1_57ck200 = 0.9 time = 1005
.meas tran vdout1_57ck200 FIND v(dout1_57) AT=1005.025n

* CHECK dout1_58 Vdout1_58ck200 = 0.9 time = 1005
.meas tran vdout1_58ck200 FIND v(dout1_58) AT=1005.025n

* CHECK dout1_59 Vdout1_59ck200 = 0 time = 1005
.meas tran vdout1_59ck200 FIND v(dout1_59) AT=1005.025n

* CHECK dout1_60 Vdout1_60ck200 = 0.9 time = 1005
.meas tran vdout1_60ck200 FIND v(dout1_60) AT=1005.025n

* CHECK dout1_61 Vdout1_61ck200 = 0 time = 1005
.meas tran vdout1_61ck200 FIND v(dout1_61) AT=1005.025n

* CHECK dout1_62 Vdout1_62ck200 = 0.9 time = 1005
.meas tran vdout1_62ck200 FIND v(dout1_62) AT=1005.025n

* CHECK dout1_63 Vdout1_63ck200 = 0 time = 1005
.meas tran vdout1_63ck200 FIND v(dout1_63) AT=1005.025n

* CHECK dout1_0 Vdout1_0ck203 = 0.9 time = 1020
.meas tran vdout1_0ck203 FIND v(dout1_0) AT=1020.025n

* CHECK dout1_1 Vdout1_1ck203 = 0.9 time = 1020
.meas tran vdout1_1ck203 FIND v(dout1_1) AT=1020.025n

* CHECK dout1_2 Vdout1_2ck203 = 0.9 time = 1020
.meas tran vdout1_2ck203 FIND v(dout1_2) AT=1020.025n

* CHECK dout1_3 Vdout1_3ck203 = 0 time = 1020
.meas tran vdout1_3ck203 FIND v(dout1_3) AT=1020.025n

* CHECK dout1_4 Vdout1_4ck203 = 0 time = 1020
.meas tran vdout1_4ck203 FIND v(dout1_4) AT=1020.025n

* CHECK dout1_5 Vdout1_5ck203 = 0 time = 1020
.meas tran vdout1_5ck203 FIND v(dout1_5) AT=1020.025n

* CHECK dout1_6 Vdout1_6ck203 = 0 time = 1020
.meas tran vdout1_6ck203 FIND v(dout1_6) AT=1020.025n

* CHECK dout1_7 Vdout1_7ck203 = 0 time = 1020
.meas tran vdout1_7ck203 FIND v(dout1_7) AT=1020.025n

* CHECK dout1_8 Vdout1_8ck203 = 0.9 time = 1020
.meas tran vdout1_8ck203 FIND v(dout1_8) AT=1020.025n

* CHECK dout1_9 Vdout1_9ck203 = 0 time = 1020
.meas tran vdout1_9ck203 FIND v(dout1_9) AT=1020.025n

* CHECK dout1_10 Vdout1_10ck203 = 0 time = 1020
.meas tran vdout1_10ck203 FIND v(dout1_10) AT=1020.025n

* CHECK dout1_11 Vdout1_11ck203 = 0 time = 1020
.meas tran vdout1_11ck203 FIND v(dout1_11) AT=1020.025n

* CHECK dout1_12 Vdout1_12ck203 = 0.9 time = 1020
.meas tran vdout1_12ck203 FIND v(dout1_12) AT=1020.025n

* CHECK dout1_13 Vdout1_13ck203 = 0.9 time = 1020
.meas tran vdout1_13ck203 FIND v(dout1_13) AT=1020.025n

* CHECK dout1_14 Vdout1_14ck203 = 0 time = 1020
.meas tran vdout1_14ck203 FIND v(dout1_14) AT=1020.025n

* CHECK dout1_15 Vdout1_15ck203 = 0.9 time = 1020
.meas tran vdout1_15ck203 FIND v(dout1_15) AT=1020.025n

* CHECK dout1_16 Vdout1_16ck203 = 0.9 time = 1020
.meas tran vdout1_16ck203 FIND v(dout1_16) AT=1020.025n

* CHECK dout1_17 Vdout1_17ck203 = 0 time = 1020
.meas tran vdout1_17ck203 FIND v(dout1_17) AT=1020.025n

* CHECK dout1_18 Vdout1_18ck203 = 0 time = 1020
.meas tran vdout1_18ck203 FIND v(dout1_18) AT=1020.025n

* CHECK dout1_19 Vdout1_19ck203 = 0.9 time = 1020
.meas tran vdout1_19ck203 FIND v(dout1_19) AT=1020.025n

* CHECK dout1_20 Vdout1_20ck203 = 0.9 time = 1020
.meas tran vdout1_20ck203 FIND v(dout1_20) AT=1020.025n

* CHECK dout1_21 Vdout1_21ck203 = 0.9 time = 1020
.meas tran vdout1_21ck203 FIND v(dout1_21) AT=1020.025n

* CHECK dout1_22 Vdout1_22ck203 = 0 time = 1020
.meas tran vdout1_22ck203 FIND v(dout1_22) AT=1020.025n

* CHECK dout1_23 Vdout1_23ck203 = 0 time = 1020
.meas tran vdout1_23ck203 FIND v(dout1_23) AT=1020.025n

* CHECK dout1_24 Vdout1_24ck203 = 0.9 time = 1020
.meas tran vdout1_24ck203 FIND v(dout1_24) AT=1020.025n

* CHECK dout1_25 Vdout1_25ck203 = 0 time = 1020
.meas tran vdout1_25ck203 FIND v(dout1_25) AT=1020.025n

* CHECK dout1_26 Vdout1_26ck203 = 0 time = 1020
.meas tran vdout1_26ck203 FIND v(dout1_26) AT=1020.025n

* CHECK dout1_27 Vdout1_27ck203 = 0 time = 1020
.meas tran vdout1_27ck203 FIND v(dout1_27) AT=1020.025n

* CHECK dout1_28 Vdout1_28ck203 = 0 time = 1020
.meas tran vdout1_28ck203 FIND v(dout1_28) AT=1020.025n

* CHECK dout1_29 Vdout1_29ck203 = 0 time = 1020
.meas tran vdout1_29ck203 FIND v(dout1_29) AT=1020.025n

* CHECK dout1_30 Vdout1_30ck203 = 0.9 time = 1020
.meas tran vdout1_30ck203 FIND v(dout1_30) AT=1020.025n

* CHECK dout1_31 Vdout1_31ck203 = 0.9 time = 1020
.meas tran vdout1_31ck203 FIND v(dout1_31) AT=1020.025n

* CHECK dout1_32 Vdout1_32ck203 = 0.9 time = 1020
.meas tran vdout1_32ck203 FIND v(dout1_32) AT=1020.025n

* CHECK dout1_33 Vdout1_33ck203 = 0 time = 1020
.meas tran vdout1_33ck203 FIND v(dout1_33) AT=1020.025n

* CHECK dout1_34 Vdout1_34ck203 = 0.9 time = 1020
.meas tran vdout1_34ck203 FIND v(dout1_34) AT=1020.025n

* CHECK dout1_35 Vdout1_35ck203 = 0.9 time = 1020
.meas tran vdout1_35ck203 FIND v(dout1_35) AT=1020.025n

* CHECK dout1_36 Vdout1_36ck203 = 0.9 time = 1020
.meas tran vdout1_36ck203 FIND v(dout1_36) AT=1020.025n

* CHECK dout1_37 Vdout1_37ck203 = 0.9 time = 1020
.meas tran vdout1_37ck203 FIND v(dout1_37) AT=1020.025n

* CHECK dout1_38 Vdout1_38ck203 = 0.9 time = 1020
.meas tran vdout1_38ck203 FIND v(dout1_38) AT=1020.025n

* CHECK dout1_39 Vdout1_39ck203 = 0 time = 1020
.meas tran vdout1_39ck203 FIND v(dout1_39) AT=1020.025n

* CHECK dout1_40 Vdout1_40ck203 = 0.9 time = 1020
.meas tran vdout1_40ck203 FIND v(dout1_40) AT=1020.025n

* CHECK dout1_41 Vdout1_41ck203 = 0.9 time = 1020
.meas tran vdout1_41ck203 FIND v(dout1_41) AT=1020.025n

* CHECK dout1_42 Vdout1_42ck203 = 0.9 time = 1020
.meas tran vdout1_42ck203 FIND v(dout1_42) AT=1020.025n

* CHECK dout1_43 Vdout1_43ck203 = 0 time = 1020
.meas tran vdout1_43ck203 FIND v(dout1_43) AT=1020.025n

* CHECK dout1_44 Vdout1_44ck203 = 0.9 time = 1020
.meas tran vdout1_44ck203 FIND v(dout1_44) AT=1020.025n

* CHECK dout1_45 Vdout1_45ck203 = 0.9 time = 1020
.meas tran vdout1_45ck203 FIND v(dout1_45) AT=1020.025n

* CHECK dout1_46 Vdout1_46ck203 = 0.9 time = 1020
.meas tran vdout1_46ck203 FIND v(dout1_46) AT=1020.025n

* CHECK dout1_47 Vdout1_47ck203 = 0.9 time = 1020
.meas tran vdout1_47ck203 FIND v(dout1_47) AT=1020.025n

* CHECK dout1_48 Vdout1_48ck203 = 0.9 time = 1020
.meas tran vdout1_48ck203 FIND v(dout1_48) AT=1020.025n

* CHECK dout1_49 Vdout1_49ck203 = 0.9 time = 1020
.meas tran vdout1_49ck203 FIND v(dout1_49) AT=1020.025n

* CHECK dout1_50 Vdout1_50ck203 = 0 time = 1020
.meas tran vdout1_50ck203 FIND v(dout1_50) AT=1020.025n

* CHECK dout1_51 Vdout1_51ck203 = 0 time = 1020
.meas tran vdout1_51ck203 FIND v(dout1_51) AT=1020.025n

* CHECK dout1_52 Vdout1_52ck203 = 0 time = 1020
.meas tran vdout1_52ck203 FIND v(dout1_52) AT=1020.025n

* CHECK dout1_53 Vdout1_53ck203 = 0.9 time = 1020
.meas tran vdout1_53ck203 FIND v(dout1_53) AT=1020.025n

* CHECK dout1_54 Vdout1_54ck203 = 0.9 time = 1020
.meas tran vdout1_54ck203 FIND v(dout1_54) AT=1020.025n

* CHECK dout1_55 Vdout1_55ck203 = 0 time = 1020
.meas tran vdout1_55ck203 FIND v(dout1_55) AT=1020.025n

* CHECK dout1_56 Vdout1_56ck203 = 0 time = 1020
.meas tran vdout1_56ck203 FIND v(dout1_56) AT=1020.025n

* CHECK dout1_57 Vdout1_57ck203 = 0.9 time = 1020
.meas tran vdout1_57ck203 FIND v(dout1_57) AT=1020.025n

* CHECK dout1_58 Vdout1_58ck203 = 0 time = 1020
.meas tran vdout1_58ck203 FIND v(dout1_58) AT=1020.025n

* CHECK dout1_59 Vdout1_59ck203 = 0 time = 1020
.meas tran vdout1_59ck203 FIND v(dout1_59) AT=1020.025n

* CHECK dout1_60 Vdout1_60ck203 = 0.9 time = 1020
.meas tran vdout1_60ck203 FIND v(dout1_60) AT=1020.025n

* CHECK dout1_61 Vdout1_61ck203 = 0.9 time = 1020
.meas tran vdout1_61ck203 FIND v(dout1_61) AT=1020.025n

* CHECK dout1_62 Vdout1_62ck203 = 0.9 time = 1020
.meas tran vdout1_62ck203 FIND v(dout1_62) AT=1020.025n

* CHECK dout1_63 Vdout1_63ck203 = 0.9 time = 1020
.meas tran vdout1_63ck203 FIND v(dout1_63) AT=1020.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
