* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_64x80_20.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_64x80_20 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 dout0_64 dout0_65 dout0_66 dout0_67 dout0_68 dout0_69 dout0_70 dout0_71 dout0_72 dout0_73 dout0_74 dout0_75 dout0_76 dout0_77 dout0_78 dout0_79 vdd gnd freepdk45_sram_1rw0r_64x80_20

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f
CD040 dout0_40  0 0.8364f
CD041 dout0_41  0 0.8364f
CD042 dout0_42  0 0.8364f
CD043 dout0_43  0 0.8364f
CD044 dout0_44  0 0.8364f
CD045 dout0_45  0 0.8364f
CD046 dout0_46  0 0.8364f
CD047 dout0_47  0 0.8364f
CD048 dout0_48  0 0.8364f
CD049 dout0_49  0 0.8364f
CD050 dout0_50  0 0.8364f
CD051 dout0_51  0 0.8364f
CD052 dout0_52  0 0.8364f
CD053 dout0_53  0 0.8364f
CD054 dout0_54  0 0.8364f
CD055 dout0_55  0 0.8364f
CD056 dout0_56  0 0.8364f
CD057 dout0_57  0 0.8364f
CD058 dout0_58  0 0.8364f
CD059 dout0_59  0 0.8364f
CD060 dout0_60  0 0.8364f
CD061 dout0_61  0 0.8364f
CD062 dout0_62  0 0.8364f
CD063 dout0_63  0 0.8364f
CD064 dout0_64  0 0.8364f
CD065 dout0_65  0 0.8364f
CD066 dout0_66  0 0.8364f
CD067 dout0_67  0 0.8364f
CD068 dout0_68  0 0.8364f
CD069 dout0_69  0 0.8364f
CD070 dout0_70  0 0.8364f
CD071 dout0_71  0 0.8364f
CD072 dout0_72  0 0.8364f
CD073 dout0_73  0 0.8364f
CD074 dout0_74  0 0.8364f
CD075 dout0_75  0 0.8364f
CD076 dout0_76  0 0.8364f
CD077 dout0_77  0 0.8364f
CD078 dout0_78  0 0.8364f
CD079 dout0_79  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_64x80_20.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_64x80_20.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_64x80_20.s_en
* q:	xfreepdk45_sram_1rw0r_64x80_20.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_64x80_20.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 10110110110111010100101011100110010010110001000011101010110011001100011011011101  to  address 000000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 10011101110001100001001010100100100111111001111111110010010011000100101000101100  to  address 111110 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 10010111101110110000110111001001111000111110101100011110111101011011011011001001  to  address 111110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 10010111101110110000110111001001111000111110101100011110111101011011011011001001 from address 111110 (from port 0) during cycle 4 (20ns - 25ns)
*	Writing (partial) 01111001000000010010111101011110010110001010101001001100101010100110100110111101  to  address 111110 with mask bit 1100 (from port 0) during cycle 5 (25ns - 30ns)
*	Writing (partial) 11001000110101111010000011101111110010001110010001101110110100110001000001111010  to  address 000000 with mask bit 0111 (from port 0) during cycle 6 (30ns - 35ns)
*	Writing 01001100010000000110000001000110110000110010100111100111111101101010101010111011  to  address 000000 (from port 0) during cycle 7 (35ns - 40ns)
*	Reading 01001100010000000110000001000110110000110010100111100111111101101010101010111011 from address 000000 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing 11000011010101000110011100011010101000111101000101000010001010000101000100010111  to  address 111110 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 01001100010000000110000001000110110000110010100111100111111101101010101010111011 from address 000000 (from port 0) during cycle 11 (55ns - 60ns)
*	Writing (partial) 00101100111010101100011101001101110010101110101101001000101111101010000010110101  to  address 111110 with mask bit 1011 (from port 0) during cycle 13 (65ns - 70ns)
*	Reading 00101100111010101100011100011010101000111110101101001000101111101010000010110101 from address 111110 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing 11011010111000000000100010010111000100101110100111110110111001000011011010111100  to  address 111110 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 11011010111000000000100010010111000100101110100111110110111001000011011010111100 from address 111110 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 01001100010000000110000001000110110000110010100111100111111101101010101010111011 from address 000000 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 01001100010000000110000001000110110000110010100111100111111101101010101010111011 from address 000000 (from port 0) during cycle 19 (95ns - 100ns)
*	Writing 10101001110111010011010001011010011110110000011011100101101001100101001000000011  to  address 111110 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 10101001110111010011010001011010011110110000011011100101101001100101001000000011 from address 111110 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 10101001110111010011010001011010011110110000011011100101101001100101001000000011 from address 111110 (from port 0) during cycle 22 (110ns - 115ns)
*	Reading 01001100010000000110000001000110110000110010100111100111111101101010101010111011 from address 000000 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 10101001110111010011010001011010011110110000011011100101101001100101001000000011 from address 111110 (from port 0) during cycle 25 (125ns - 130ns)
*	Writing (partial) 10111111010010110111010010000010000100100110010001101111000110011111000100100000  to  address 000000 with mask bit 1101 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing (partial) 00111100110111100000111101011001011100011101100111111111111101110100100000000110  to  address 111110 with mask bit 0010 (from port 0) during cycle 27 (135ns - 140ns)
*	Writing (partial) 10000111101111111000010011000001001010110001110001100010110000100010100100000100  to  address 000000 with mask bit 0110 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 10111111010010110111010011000001001010110001110001100010110010011111000100100000 from address 000000 (from port 0) during cycle 32 (160ns - 165ns)
*	Writing 01010100100010101011100110010111011101100101001100111011101100010011011000101011  to  address 000000 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 01010100100010101011100110010111011101100101001100111011101100010011011000101011 from address 000000 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 01010100100010101011100110010111011101100101001100111011101100010011011000101011 from address 000000 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 01010100100010101011100110010111011101100101001100111011101100010011011000101011 from address 000000 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 00111000001011010110101000111001111010000010110010110101011000010101001010000110  to  address 111110 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing (partial) 11111111001001010111101101110000111001101101001101011111101000000010111000100010  to  address 000000 with mask bit 0101 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 01010100100010101011101101110000111001100101001100111011101100000010111000100010 from address 000000 (from port 0) during cycle 41 (205ns - 210ns)
*	Writing (partial) 00011111110110000100000000010011001010110010101110001001100100001100001010110100  to  address 000000 with mask bit 1001 (from port 0) during cycle 42 (210ns - 215ns)
*	Reading 00011111110110000100101101110000111001100101001100111011101100001100001010110100 from address 000000 (from port 0) during cycle 43 (215ns - 220ns)
*	Reading 00111000001011010110101000111001111010000010110010110101011000010101001010000110 from address 111110 (from port 0) during cycle 44 (220ns - 225ns)
*	Reading 00111000001011010110101000111001111010000010110010110101011000010101001010000110 from address 111110 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 00111000001011010110101000111001111010000010110010110101011000010101001010000110 from address 111110 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 00011111110110000100101101110000111001100101001100111011101100001100001010110100 from address 000000 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 00011111110110000100101101110000111001100101001100111011101100001100001010110100 from address 000000 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 10010001100111001100111000011110110110011010100011110000110010101110001110101001  to  address 000000 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing (partial) 00100001001110110010110111110010001110111101110111011111111000101001010010100101  to  address 000000 with mask bit 1101 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 00100001001110110010110111110010001110111010100011110000110000101001010010100101 from address 000000 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing (partial) 01111010000100010010011101001100010111101011001100011110110011111111101011111111  to  address 111110 with mask bit 1011 (from port 0) during cycle 52 (260ns - 265ns)
*	Writing 11101010001011100110011110101111011011000001101111100110001001111110010100110100  to  address 111110 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing 00011010001010000010111110111011011100100011000110101010011011010011000100011011  to  address 000000 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 00011010001010000010111110111011011100100011000110101010011011010011000100011011 from address 000000 (from port 0) during cycle 55 (275ns - 280ns)
*	Reading 00011010001010000010111110111011011100100011000110101010011011010011000100011011 from address 000000 (from port 0) during cycle 56 (280ns - 285ns)
*	Writing 01111010110100010110010000000101101000010011000101011010010011001000101111100010  to  address 000000 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 11101010001011100110011110101111011011000001101111100110001001111110010100110100 from address 111110 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 10110101001011111000110011011101010111010011010111111100011001100111100111001011  to  address 111110 (from port 0) during cycle 61 (305ns - 310ns)
*	Writing 01100010001111110101111001011000001010010101111110111111001111110110000111001010  to  address 111110 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 11011011101110111101010010101100111001110011010111000100101111111110111111001111  to  address 000000 (from port 0) during cycle 63 (315ns - 320ns)
*	Reading 01100010001111110101111001011000001010010101111110111111001111110110000111001010 from address 111110 (from port 0) during cycle 64 (320ns - 325ns)
*	Reading 01100010001111110101111001011000001010010101111110111111001111110110000111001010 from address 111110 (from port 0) during cycle 65 (325ns - 330ns)
*	Writing (partial) 01101101101101000001011110110101010101001101100000101001001101100011001011001100  to  address 111110 with mask bit 0010 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 00111100011101111010000111001000011000011001101110010111011111011101101111001101  to  address 000000 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 00111100011101111010000111001000011000011001101110010111011111011101101111001101 from address 000000 (from port 0) during cycle 69 (345ns - 350ns)
*	Reading 00111100011101111010000111001000011000011001101110010111011111011101101111001101 from address 000000 (from port 0) during cycle 71 (355ns - 360ns)
*	Reading 01100010001111110101111001011000001010011101100000101001001111110110000111001010 from address 111110 (from port 0) during cycle 72 (360ns - 365ns)
*	Reading 00111100011101111010000111001000011000011001101110010111011111011101101111001101 from address 000000 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 10010010010001100101011101101111011000111100011110110110000110110001010000001111  to  address 000000 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 01100010001111110101111001011000001010011101100000101001001111110110000111001010 from address 111110 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 10010010010001100101011101101111011000111100011110110110000110110001010000001111 from address 000000 (from port 0) during cycle 76 (380ns - 385ns)
*	Writing (partial) 01001000110010111110111101100100100001001101000010100010000101100000111101101001  to  address 111110 with mask bit 1100 (from port 0) during cycle 77 (385ns - 390ns)
*	Writing (partial) 11110100001100111011111110011001110001100001101100000000001101100110111000010000  to  address 111110 with mask bit 0010 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing (partial) 01100111111000110111011110010100101000101000001001111111010010010000000000101101  to  address 111110 with mask bit 0100 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 01001000110010111110011110010100101000100001101100000000001111110110000111001010 from address 111110 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing (partial) 00000010101101110100110001000000001101111100111110101001011110000011011000100110  to  address 000000 with mask bit 1110 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing 01101111000000111101110111101001100101101101100101011010111111100100100010001110  to  address 111110 (from port 0) during cycle 83 (415ns - 420ns)
*	Writing 01111111010110111001100101100110011000111110110010110111010000001110101111001101  to  address 111110 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing (partial) 00000010110000100000010000101000000101111000010011000111010011010111110011100100  to  address 000000 with mask bit 0010 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 01111111010110111001100101100110011000111110110010110111010000001110101111001101 from address 111110 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing (partial) 11111010011111101011010110010100001101000110100101101001101010110001000110101001  to  address 111110 with mask bit 0101 (from port 0) during cycle 88 (440ns - 445ns)
*	Writing 11010100011101100000001010001100010010100100100010011110011001011101111111000110  to  address 111110 (from port 0) during cycle 91 (455ns - 460ns)
*	Writing (partial) 01011011101101010011000100011010111111001011000001110011011111111011100011000000  to  address 000000 with mask bit 0101 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 00000010101101110100000100011010111111001000010011000111010011111011100011000000 from address 000000 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 11010100011101100000001010001100010010100100100010011110011001011101111111000110 from address 111110 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 11010100011101100000001010001100010010100100100010011110011001011101111111000110 from address 111110 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 11010100011101100000001010001100010010100100100010011110011001011101111111000110 from address 111110 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 11010100011101100000001010001100010010100100100010011110011001011101111111000110 from address 111110 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 00000010101101110100000100011010111111001000010011000111010011111011100011000000 from address 000000 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 00000010101101110100000100011010111111001000010011000111010011111011100011000000 from address 000000 (from port 0) during cycle 105 (525ns - 530ns)
*	Reading 00000010101101110100000100011010111111001000010011000111010011111011100011000000 from address 000000 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 00000010101101110100000100011010111111001000010011000111010011111011100011000000 from address 000000 (from port 0) during cycle 107 (535ns - 540ns)
*	Writing (partial) 10000000110011100111111101011110011110011101001110100111011100101100011000110111  to  address 000000 with mask bit 1100 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 11010100011101100000001010001100010010100100100010011110011001011101111111000110 from address 111110 (from port 0) during cycle 110 (550ns - 555ns)
*	Writing 01010000111101110101000000110100001100001101000010000100000001000100001111111001  to  address 000000 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 01010000111101110101000000110100001100001101000010000100000001000100001111111001 from address 000000 (from port 0) during cycle 113 (565ns - 570ns)
*	Writing 00110110110011011110110110111110110010000110000101110000000101010110100111010111  to  address 111110 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 01010110011100001111110110000010110110001111101001011110101101011111010001001010  to  address 111110 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 01010110110111110000010001101001100000001001111100101000001111010011011101001011  to  address 000000 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 01010110110111110000010001101001100000001001111100101000001111010011011101001011 from address 000000 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 01010110110111110000010001101001100000001001111100101000001111010011011101001011 from address 000000 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 01010110011100001111110110000010110110001111101001011110101101011111010001001010 from address 111110 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing 10100111110111010000110110100101010101001111110111001011000100001111010000110110  to  address 000000 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing (partial) 11010101111101110110101111101110000111101010001100111100110001011010110101101111  to  address 000000 with mask bit 0101 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing (partial) 10101100101111001010100000100100100101001111001001110101111010011001100100000011  to  address 111110 with mask bit 0101 (from port 0) during cycle 127 (635ns - 640ns)
*	Writing 11000010110001010000100000001110111010010001111011110010111101111101011110000100  to  address 000000 (from port 0) during cycle 130 (650ns - 655ns)
*	Reading 01010110011100001111100000100100100101001111101001011110101110011001100100000011 from address 111110 (from port 0) during cycle 131 (655ns - 660ns)
*	Writing (partial) 11001000100111001001010111001001101101011001101000001010110110000111101001010001  to  address 000000 with mask bit 1100 (from port 0) during cycle 133 (665ns - 670ns)
*	Reading 01010110011100001111100000100100100101001111101001011110101110011001100100000011 from address 111110 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing 10011001111110100011010001011010100011011111000000001011000111110111111011111101  to  address 000000 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 10011001111110100011010001011010100011011111000000001011000111110111111011111101 from address 000000 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 01010110011100001111100000100100100101001111101001011110101110011001100100000011 from address 111110 (from port 0) during cycle 139 (695ns - 700ns)
*	Reading 01010110011100001111100000100100100101001111101001011110101110011001100100000011 from address 111110 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 01010110011100001111100000100100100101001111101001011110101110011001100100000011 from address 111110 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 01110111110100111110000000000001101101010101011110111000111010100011001001111000  to  address 000000 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 01110111110100111110000000000001101101010101011110111000111010100011001001111000 from address 000000 (from port 0) during cycle 144 (720ns - 725ns)
*	Reading 01010110011100001111100000100100100101001111101001011110101110011001100100000011 from address 111110 (from port 0) during cycle 145 (725ns - 730ns)
*	Writing 01011111100100101000110000100000000001111010110111111000010111110000110101010100  to  address 111110 (from port 0) during cycle 147 (735ns - 740ns)
*	Writing (partial) 11000000000101000010011111100110011101011110001011111010011110110101000011010011  to  address 000000 with mask bit 1010 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing (partial) 00110011000111001101000110001111111000101001000000011100010001101011110000100100  to  address 111110 with mask bit 1100 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 00110011000111001101000110001111111000101010110111111000010111110000110101010100 from address 111110 (from port 0) during cycle 151 (755ns - 760ns)
*	Writing 10110110100001111001101100110001001100010110101011101011101110111011110010000101  to  address 111110 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 10110110100001111001101100110001001100010110101011101011101110111011110010000101 from address 111110 (from port 0) during cycle 153 (765ns - 770ns)
*	Writing 10111100111000111100010100100001011010100100010011010100010000101000100100110100  to  address 111110 (from port 0) during cycle 154 (770ns - 775ns)
*	Reading 10111100111000111100010100100001011010100100010011010100010000101000100100110100 from address 111110 (from port 0) during cycle 156 (780ns - 785ns)
*	Writing 11001000101011001110110000101110110000010001001011011101011001010000100110110000  to  address 111110 (from port 0) during cycle 157 (785ns - 790ns)
*	Writing 01100111111101001100101110001111110000000110110101001110111011110010011100110011  to  address 111110 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 01100111111101001100101110001111110000000110110101001110111011110010011100110011 from address 111110 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 01100111111101001100101110001111110000000110110101001110111011110010011100110011 from address 111110 (from port 0) during cycle 161 (805ns - 810ns)
*	Writing (partial) 11011010000011110001000111011101110100101111010111100100010000110000111011111110  to  address 000000 with mask bit 1101 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 11011010000011110001000111011101110100101110001011111010011100110000111011111110 from address 000000 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 11011010000011110001000111011101110100101110001011111010011100110000111011111110 from address 000000 (from port 0) during cycle 164 (820ns - 825ns)
*	Writing 10011011000100101110001001000001111100001111000011100111000011110000011000001011  to  address 111110 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing (partial) 00011100100101110010100111010100111011110110000100010111010001010111010000101111  to  address 111110 with mask bit 0011 (from port 0) during cycle 169 (845ns - 850ns)
*	Writing (partial) 11000011111111110000001110010010110110011101101101001111001110111010001000000010  to  address 000000 with mask bit 0001 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing 01100101001110011110011110010100110001011000011011000011110001000110010001111010  to  address 000000 (from port 0) during cycle 173 (865ns - 870ns)
*	Writing 10010010110001001111101001000001001001111111010111011000110100001010000100010100  to  address 000000 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 10011011000100101110001001000001111100000110000100010111010001010111010000101111 from address 111110 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing 10110101000111010001001101111010100100010110011101011111100100000111110100111100  to  address 000000 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 01010001111011000101001110000011010100101011011011111010100000111111111000011011  to  address 000000 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 00000000100111000000011100001111111110010011100101000101111010000101100110100001  to  address 111110 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 01010001111011000101001110000011010100101011011011111010100000111111111000011011 from address 000000 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 01110110100101101110000110110001011101001000011110001000110000000110000000000111  to  address 000000 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 01110100111010100110000101110000101110001101001100010110001000101001101101111101  to  address 000000 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 00000000100111000000011100001111111110010011100101000101111010000101100110100001 from address 111110 (from port 0) during cycle 185 (925ns - 930ns)
*	Writing 01011010001010111111011000000110000010100111100010011011000111001011011011010101  to  address 111110 (from port 0) during cycle 186 (930ns - 935ns)
*	Reading 01110100111010100110000101110000101110001101001100010110001000101001101101111101 from address 000000 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 01101111001101010110010110001001010010111010110101110111110100010000000010101010  to  address 000000 (from port 0) during cycle 188 (940ns - 945ns)
*	Writing (partial) 11101100110000101001100010100001010101001011001110111010100111100111110111010000  to  address 111110 with mask bit 0101 (from port 0) during cycle 189 (945ns - 950ns)
*	Writing 00000100010100110010110101010100110001011101101110000111101101000110011111110000  to  address 111110 (from port 0) during cycle 191 (955ns - 960ns)
*	Reading 01101111001101010110010110001001010010111010110101110111110100010000000010101010 from address 000000 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 00000100010100110010110101010100110001011101101110000111101101000110011111110000 from address 111110 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 00000100010100110010110101010100110001011101101110000111101101000110011111110000 from address 111110 (from port 0) during cycle 195 (975ns - 980ns)
*	Reading 00000100010100110010110101010100110001011101101110000111101101000110011111110000 from address 111110 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 01101111001101010110010110001001010010111010110101110111110100010000000010101010 from address 000000 (from port 0) during cycle 197 (985ns - 990ns)
*	Writing 10000000000110111110000110001011100111000001000000110100100010010010100001011010  to  address 111110 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 10000000000110111110000110001011100111000001000000110100100010010010100001011010 from address 111110 (from port 0) during cycle 199 (995ns - 1000ns)
*	Writing 11011001111001101110101101101101000000110001100001010001100000000001110100110000  to  address 111110 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 11011001111001101110101101101101000000110001100001010001100000000001110100110000 from address 111110 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 01101111001101010110010110001001010010111010110101110111110100010000000010101010 from address 000000 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 01101111001101010110010110001001010010111010110101110111110100010000000010101010 from address 000000 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0.9 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0.9 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0.9 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0.9 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0.9 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0.9 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0.9 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0.9 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0.9 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0.9 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0.9 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0.9 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0.9 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0.9 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0.9 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0.9 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0.9 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0.9 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0.9 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0.9 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0.9 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0.9 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0.9 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0.9 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0.9 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_40 Vdout0_40ck4 = 0.9 time = 25
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=25.025n

* CHECK dout0_41 Vdout0_41ck4 = 0.9 time = 25
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=25.025n

* CHECK dout0_42 Vdout0_42ck4 = 0 time = 25
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=25.025n

* CHECK dout0_43 Vdout0_43ck4 = 0 time = 25
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=25.025n

* CHECK dout0_44 Vdout0_44ck4 = 0 time = 25
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=25.025n

* CHECK dout0_45 Vdout0_45ck4 = 0.9 time = 25
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=25.025n

* CHECK dout0_46 Vdout0_46ck4 = 0.9 time = 25
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=25.025n

* CHECK dout0_47 Vdout0_47ck4 = 0.9 time = 25
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=25.025n

* CHECK dout0_48 Vdout0_48ck4 = 0.9 time = 25
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=25.025n

* CHECK dout0_49 Vdout0_49ck4 = 0 time = 25
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=25.025n

* CHECK dout0_50 Vdout0_50ck4 = 0 time = 25
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=25.025n

* CHECK dout0_51 Vdout0_51ck4 = 0.9 time = 25
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=25.025n

* CHECK dout0_52 Vdout0_52ck4 = 0 time = 25
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=25.025n

* CHECK dout0_53 Vdout0_53ck4 = 0 time = 25
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=25.025n

* CHECK dout0_54 Vdout0_54ck4 = 0.9 time = 25
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=25.025n

* CHECK dout0_55 Vdout0_55ck4 = 0.9 time = 25
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=25.025n

* CHECK dout0_56 Vdout0_56ck4 = 0.9 time = 25
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=25.025n

* CHECK dout0_57 Vdout0_57ck4 = 0 time = 25
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=25.025n

* CHECK dout0_58 Vdout0_58ck4 = 0.9 time = 25
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=25.025n

* CHECK dout0_59 Vdout0_59ck4 = 0.9 time = 25
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=25.025n

* CHECK dout0_60 Vdout0_60ck4 = 0 time = 25
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=25.025n

* CHECK dout0_61 Vdout0_61ck4 = 0 time = 25
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=25.025n

* CHECK dout0_62 Vdout0_62ck4 = 0 time = 25
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=25.025n

* CHECK dout0_63 Vdout0_63ck4 = 0 time = 25
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=25.025n

* CHECK dout0_64 Vdout0_64ck4 = 0.9 time = 25
.meas tran vdout0_64ck4 FIND v(dout0_64) AT=25.025n

* CHECK dout0_65 Vdout0_65ck4 = 0.9 time = 25
.meas tran vdout0_65ck4 FIND v(dout0_65) AT=25.025n

* CHECK dout0_66 Vdout0_66ck4 = 0 time = 25
.meas tran vdout0_66ck4 FIND v(dout0_66) AT=25.025n

* CHECK dout0_67 Vdout0_67ck4 = 0.9 time = 25
.meas tran vdout0_67ck4 FIND v(dout0_67) AT=25.025n

* CHECK dout0_68 Vdout0_68ck4 = 0.9 time = 25
.meas tran vdout0_68ck4 FIND v(dout0_68) AT=25.025n

* CHECK dout0_69 Vdout0_69ck4 = 0.9 time = 25
.meas tran vdout0_69ck4 FIND v(dout0_69) AT=25.025n

* CHECK dout0_70 Vdout0_70ck4 = 0 time = 25
.meas tran vdout0_70ck4 FIND v(dout0_70) AT=25.025n

* CHECK dout0_71 Vdout0_71ck4 = 0.9 time = 25
.meas tran vdout0_71ck4 FIND v(dout0_71) AT=25.025n

* CHECK dout0_72 Vdout0_72ck4 = 0.9 time = 25
.meas tran vdout0_72ck4 FIND v(dout0_72) AT=25.025n

* CHECK dout0_73 Vdout0_73ck4 = 0.9 time = 25
.meas tran vdout0_73ck4 FIND v(dout0_73) AT=25.025n

* CHECK dout0_74 Vdout0_74ck4 = 0.9 time = 25
.meas tran vdout0_74ck4 FIND v(dout0_74) AT=25.025n

* CHECK dout0_75 Vdout0_75ck4 = 0 time = 25
.meas tran vdout0_75ck4 FIND v(dout0_75) AT=25.025n

* CHECK dout0_76 Vdout0_76ck4 = 0.9 time = 25
.meas tran vdout0_76ck4 FIND v(dout0_76) AT=25.025n

* CHECK dout0_77 Vdout0_77ck4 = 0 time = 25
.meas tran vdout0_77ck4 FIND v(dout0_77) AT=25.025n

* CHECK dout0_78 Vdout0_78ck4 = 0 time = 25
.meas tran vdout0_78ck4 FIND v(dout0_78) AT=25.025n

* CHECK dout0_79 Vdout0_79ck4 = 0.9 time = 25
.meas tran vdout0_79ck4 FIND v(dout0_79) AT=25.025n

* CHECK dout0_0 Vdout0_0ck9 = 0.9 time = 50
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=50.025n

* CHECK dout0_1 Vdout0_1ck9 = 0.9 time = 50
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=50.025n

* CHECK dout0_2 Vdout0_2ck9 = 0 time = 50
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=50.025n

* CHECK dout0_3 Vdout0_3ck9 = 0.9 time = 50
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=50.025n

* CHECK dout0_4 Vdout0_4ck9 = 0.9 time = 50
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=50.025n

* CHECK dout0_5 Vdout0_5ck9 = 0.9 time = 50
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=50.025n

* CHECK dout0_6 Vdout0_6ck9 = 0 time = 50
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=50.025n

* CHECK dout0_7 Vdout0_7ck9 = 0.9 time = 50
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=50.025n

* CHECK dout0_8 Vdout0_8ck9 = 0 time = 50
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=50.025n

* CHECK dout0_9 Vdout0_9ck9 = 0.9 time = 50
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=50.025n

* CHECK dout0_10 Vdout0_10ck9 = 0 time = 50
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=50.025n

* CHECK dout0_11 Vdout0_11ck9 = 0.9 time = 50
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=50.025n

* CHECK dout0_12 Vdout0_12ck9 = 0 time = 50
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=50.025n

* CHECK dout0_13 Vdout0_13ck9 = 0.9 time = 50
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=50.025n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 50
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=50.025n

* CHECK dout0_15 Vdout0_15ck9 = 0.9 time = 50
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=50.025n

* CHECK dout0_16 Vdout0_16ck9 = 0 time = 50
.meas tran vdout0_16ck9 FIND v(dout0_16) AT=50.025n

* CHECK dout0_17 Vdout0_17ck9 = 0.9 time = 50
.meas tran vdout0_17ck9 FIND v(dout0_17) AT=50.025n

* CHECK dout0_18 Vdout0_18ck9 = 0.9 time = 50
.meas tran vdout0_18ck9 FIND v(dout0_18) AT=50.025n

* CHECK dout0_19 Vdout0_19ck9 = 0 time = 50
.meas tran vdout0_19ck9 FIND v(dout0_19) AT=50.025n

* CHECK dout0_20 Vdout0_20ck9 = 0.9 time = 50
.meas tran vdout0_20ck9 FIND v(dout0_20) AT=50.025n

* CHECK dout0_21 Vdout0_21ck9 = 0.9 time = 50
.meas tran vdout0_21ck9 FIND v(dout0_21) AT=50.025n

* CHECK dout0_22 Vdout0_22ck9 = 0.9 time = 50
.meas tran vdout0_22ck9 FIND v(dout0_22) AT=50.025n

* CHECK dout0_23 Vdout0_23ck9 = 0.9 time = 50
.meas tran vdout0_23ck9 FIND v(dout0_23) AT=50.025n

* CHECK dout0_24 Vdout0_24ck9 = 0.9 time = 50
.meas tran vdout0_24ck9 FIND v(dout0_24) AT=50.025n

* CHECK dout0_25 Vdout0_25ck9 = 0.9 time = 50
.meas tran vdout0_25ck9 FIND v(dout0_25) AT=50.025n

* CHECK dout0_26 Vdout0_26ck9 = 0.9 time = 50
.meas tran vdout0_26ck9 FIND v(dout0_26) AT=50.025n

* CHECK dout0_27 Vdout0_27ck9 = 0 time = 50
.meas tran vdout0_27ck9 FIND v(dout0_27) AT=50.025n

* CHECK dout0_28 Vdout0_28ck9 = 0 time = 50
.meas tran vdout0_28ck9 FIND v(dout0_28) AT=50.025n

* CHECK dout0_29 Vdout0_29ck9 = 0.9 time = 50
.meas tran vdout0_29ck9 FIND v(dout0_29) AT=50.025n

* CHECK dout0_30 Vdout0_30ck9 = 0.9 time = 50
.meas tran vdout0_30ck9 FIND v(dout0_30) AT=50.025n

* CHECK dout0_31 Vdout0_31ck9 = 0.9 time = 50
.meas tran vdout0_31ck9 FIND v(dout0_31) AT=50.025n

* CHECK dout0_32 Vdout0_32ck9 = 0.9 time = 50
.meas tran vdout0_32ck9 FIND v(dout0_32) AT=50.025n

* CHECK dout0_33 Vdout0_33ck9 = 0 time = 50
.meas tran vdout0_33ck9 FIND v(dout0_33) AT=50.025n

* CHECK dout0_34 Vdout0_34ck9 = 0 time = 50
.meas tran vdout0_34ck9 FIND v(dout0_34) AT=50.025n

* CHECK dout0_35 Vdout0_35ck9 = 0.9 time = 50
.meas tran vdout0_35ck9 FIND v(dout0_35) AT=50.025n

* CHECK dout0_36 Vdout0_36ck9 = 0 time = 50
.meas tran vdout0_36ck9 FIND v(dout0_36) AT=50.025n

* CHECK dout0_37 Vdout0_37ck9 = 0.9 time = 50
.meas tran vdout0_37ck9 FIND v(dout0_37) AT=50.025n

* CHECK dout0_38 Vdout0_38ck9 = 0 time = 50
.meas tran vdout0_38ck9 FIND v(dout0_38) AT=50.025n

* CHECK dout0_39 Vdout0_39ck9 = 0 time = 50
.meas tran vdout0_39ck9 FIND v(dout0_39) AT=50.025n

* CHECK dout0_40 Vdout0_40ck9 = 0.9 time = 50
.meas tran vdout0_40ck9 FIND v(dout0_40) AT=50.025n

* CHECK dout0_41 Vdout0_41ck9 = 0.9 time = 50
.meas tran vdout0_41ck9 FIND v(dout0_41) AT=50.025n

* CHECK dout0_42 Vdout0_42ck9 = 0 time = 50
.meas tran vdout0_42ck9 FIND v(dout0_42) AT=50.025n

* CHECK dout0_43 Vdout0_43ck9 = 0 time = 50
.meas tran vdout0_43ck9 FIND v(dout0_43) AT=50.025n

* CHECK dout0_44 Vdout0_44ck9 = 0 time = 50
.meas tran vdout0_44ck9 FIND v(dout0_44) AT=50.025n

* CHECK dout0_45 Vdout0_45ck9 = 0 time = 50
.meas tran vdout0_45ck9 FIND v(dout0_45) AT=50.025n

* CHECK dout0_46 Vdout0_46ck9 = 0.9 time = 50
.meas tran vdout0_46ck9 FIND v(dout0_46) AT=50.025n

* CHECK dout0_47 Vdout0_47ck9 = 0.9 time = 50
.meas tran vdout0_47ck9 FIND v(dout0_47) AT=50.025n

* CHECK dout0_48 Vdout0_48ck9 = 0 time = 50
.meas tran vdout0_48ck9 FIND v(dout0_48) AT=50.025n

* CHECK dout0_49 Vdout0_49ck9 = 0.9 time = 50
.meas tran vdout0_49ck9 FIND v(dout0_49) AT=50.025n

* CHECK dout0_50 Vdout0_50ck9 = 0.9 time = 50
.meas tran vdout0_50ck9 FIND v(dout0_50) AT=50.025n

* CHECK dout0_51 Vdout0_51ck9 = 0 time = 50
.meas tran vdout0_51ck9 FIND v(dout0_51) AT=50.025n

* CHECK dout0_52 Vdout0_52ck9 = 0 time = 50
.meas tran vdout0_52ck9 FIND v(dout0_52) AT=50.025n

* CHECK dout0_53 Vdout0_53ck9 = 0 time = 50
.meas tran vdout0_53ck9 FIND v(dout0_53) AT=50.025n

* CHECK dout0_54 Vdout0_54ck9 = 0.9 time = 50
.meas tran vdout0_54ck9 FIND v(dout0_54) AT=50.025n

* CHECK dout0_55 Vdout0_55ck9 = 0 time = 50
.meas tran vdout0_55ck9 FIND v(dout0_55) AT=50.025n

* CHECK dout0_56 Vdout0_56ck9 = 0 time = 50
.meas tran vdout0_56ck9 FIND v(dout0_56) AT=50.025n

* CHECK dout0_57 Vdout0_57ck9 = 0 time = 50
.meas tran vdout0_57ck9 FIND v(dout0_57) AT=50.025n

* CHECK dout0_58 Vdout0_58ck9 = 0 time = 50
.meas tran vdout0_58ck9 FIND v(dout0_58) AT=50.025n

* CHECK dout0_59 Vdout0_59ck9 = 0 time = 50
.meas tran vdout0_59ck9 FIND v(dout0_59) AT=50.025n

* CHECK dout0_60 Vdout0_60ck9 = 0 time = 50
.meas tran vdout0_60ck9 FIND v(dout0_60) AT=50.025n

* CHECK dout0_61 Vdout0_61ck9 = 0.9 time = 50
.meas tran vdout0_61ck9 FIND v(dout0_61) AT=50.025n

* CHECK dout0_62 Vdout0_62ck9 = 0.9 time = 50
.meas tran vdout0_62ck9 FIND v(dout0_62) AT=50.025n

* CHECK dout0_63 Vdout0_63ck9 = 0 time = 50
.meas tran vdout0_63ck9 FIND v(dout0_63) AT=50.025n

* CHECK dout0_64 Vdout0_64ck9 = 0 time = 50
.meas tran vdout0_64ck9 FIND v(dout0_64) AT=50.025n

* CHECK dout0_65 Vdout0_65ck9 = 0 time = 50
.meas tran vdout0_65ck9 FIND v(dout0_65) AT=50.025n

* CHECK dout0_66 Vdout0_66ck9 = 0 time = 50
.meas tran vdout0_66ck9 FIND v(dout0_66) AT=50.025n

* CHECK dout0_67 Vdout0_67ck9 = 0 time = 50
.meas tran vdout0_67ck9 FIND v(dout0_67) AT=50.025n

* CHECK dout0_68 Vdout0_68ck9 = 0 time = 50
.meas tran vdout0_68ck9 FIND v(dout0_68) AT=50.025n

* CHECK dout0_69 Vdout0_69ck9 = 0 time = 50
.meas tran vdout0_69ck9 FIND v(dout0_69) AT=50.025n

* CHECK dout0_70 Vdout0_70ck9 = 0.9 time = 50
.meas tran vdout0_70ck9 FIND v(dout0_70) AT=50.025n

* CHECK dout0_71 Vdout0_71ck9 = 0 time = 50
.meas tran vdout0_71ck9 FIND v(dout0_71) AT=50.025n

* CHECK dout0_72 Vdout0_72ck9 = 0 time = 50
.meas tran vdout0_72ck9 FIND v(dout0_72) AT=50.025n

* CHECK dout0_73 Vdout0_73ck9 = 0 time = 50
.meas tran vdout0_73ck9 FIND v(dout0_73) AT=50.025n

* CHECK dout0_74 Vdout0_74ck9 = 0.9 time = 50
.meas tran vdout0_74ck9 FIND v(dout0_74) AT=50.025n

* CHECK dout0_75 Vdout0_75ck9 = 0.9 time = 50
.meas tran vdout0_75ck9 FIND v(dout0_75) AT=50.025n

* CHECK dout0_76 Vdout0_76ck9 = 0 time = 50
.meas tran vdout0_76ck9 FIND v(dout0_76) AT=50.025n

* CHECK dout0_77 Vdout0_77ck9 = 0 time = 50
.meas tran vdout0_77ck9 FIND v(dout0_77) AT=50.025n

* CHECK dout0_78 Vdout0_78ck9 = 0.9 time = 50
.meas tran vdout0_78ck9 FIND v(dout0_78) AT=50.025n

* CHECK dout0_79 Vdout0_79ck9 = 0 time = 50
.meas tran vdout0_79ck9 FIND v(dout0_79) AT=50.025n

* CHECK dout0_0 Vdout0_0ck11 = 0.9 time = 60
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=60.025n

* CHECK dout0_1 Vdout0_1ck11 = 0.9 time = 60
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=60.025n

* CHECK dout0_2 Vdout0_2ck11 = 0 time = 60
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=60.025n

* CHECK dout0_3 Vdout0_3ck11 = 0.9 time = 60
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=60.025n

* CHECK dout0_4 Vdout0_4ck11 = 0.9 time = 60
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=60.025n

* CHECK dout0_5 Vdout0_5ck11 = 0.9 time = 60
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=60.025n

* CHECK dout0_6 Vdout0_6ck11 = 0 time = 60
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=60.025n

* CHECK dout0_7 Vdout0_7ck11 = 0.9 time = 60
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=60.025n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 60
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=60.025n

* CHECK dout0_9 Vdout0_9ck11 = 0.9 time = 60
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=60.025n

* CHECK dout0_10 Vdout0_10ck11 = 0 time = 60
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=60.025n

* CHECK dout0_11 Vdout0_11ck11 = 0.9 time = 60
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=60.025n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 60
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=60.025n

* CHECK dout0_13 Vdout0_13ck11 = 0.9 time = 60
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=60.025n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 60
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=60.025n

* CHECK dout0_15 Vdout0_15ck11 = 0.9 time = 60
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=60.025n

* CHECK dout0_16 Vdout0_16ck11 = 0 time = 60
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=60.025n

* CHECK dout0_17 Vdout0_17ck11 = 0.9 time = 60
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=60.025n

* CHECK dout0_18 Vdout0_18ck11 = 0.9 time = 60
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=60.025n

* CHECK dout0_19 Vdout0_19ck11 = 0 time = 60
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=60.025n

* CHECK dout0_20 Vdout0_20ck11 = 0.9 time = 60
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=60.025n

* CHECK dout0_21 Vdout0_21ck11 = 0.9 time = 60
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=60.025n

* CHECK dout0_22 Vdout0_22ck11 = 0.9 time = 60
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=60.025n

* CHECK dout0_23 Vdout0_23ck11 = 0.9 time = 60
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=60.025n

* CHECK dout0_24 Vdout0_24ck11 = 0.9 time = 60
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=60.025n

* CHECK dout0_25 Vdout0_25ck11 = 0.9 time = 60
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=60.025n

* CHECK dout0_26 Vdout0_26ck11 = 0.9 time = 60
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=60.025n

* CHECK dout0_27 Vdout0_27ck11 = 0 time = 60
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=60.025n

* CHECK dout0_28 Vdout0_28ck11 = 0 time = 60
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=60.025n

* CHECK dout0_29 Vdout0_29ck11 = 0.9 time = 60
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=60.025n

* CHECK dout0_30 Vdout0_30ck11 = 0.9 time = 60
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=60.025n

* CHECK dout0_31 Vdout0_31ck11 = 0.9 time = 60
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=60.025n

* CHECK dout0_32 Vdout0_32ck11 = 0.9 time = 60
.meas tran vdout0_32ck11 FIND v(dout0_32) AT=60.025n

* CHECK dout0_33 Vdout0_33ck11 = 0 time = 60
.meas tran vdout0_33ck11 FIND v(dout0_33) AT=60.025n

* CHECK dout0_34 Vdout0_34ck11 = 0 time = 60
.meas tran vdout0_34ck11 FIND v(dout0_34) AT=60.025n

* CHECK dout0_35 Vdout0_35ck11 = 0.9 time = 60
.meas tran vdout0_35ck11 FIND v(dout0_35) AT=60.025n

* CHECK dout0_36 Vdout0_36ck11 = 0 time = 60
.meas tran vdout0_36ck11 FIND v(dout0_36) AT=60.025n

* CHECK dout0_37 Vdout0_37ck11 = 0.9 time = 60
.meas tran vdout0_37ck11 FIND v(dout0_37) AT=60.025n

* CHECK dout0_38 Vdout0_38ck11 = 0 time = 60
.meas tran vdout0_38ck11 FIND v(dout0_38) AT=60.025n

* CHECK dout0_39 Vdout0_39ck11 = 0 time = 60
.meas tran vdout0_39ck11 FIND v(dout0_39) AT=60.025n

* CHECK dout0_40 Vdout0_40ck11 = 0.9 time = 60
.meas tran vdout0_40ck11 FIND v(dout0_40) AT=60.025n

* CHECK dout0_41 Vdout0_41ck11 = 0.9 time = 60
.meas tran vdout0_41ck11 FIND v(dout0_41) AT=60.025n

* CHECK dout0_42 Vdout0_42ck11 = 0 time = 60
.meas tran vdout0_42ck11 FIND v(dout0_42) AT=60.025n

* CHECK dout0_43 Vdout0_43ck11 = 0 time = 60
.meas tran vdout0_43ck11 FIND v(dout0_43) AT=60.025n

* CHECK dout0_44 Vdout0_44ck11 = 0 time = 60
.meas tran vdout0_44ck11 FIND v(dout0_44) AT=60.025n

* CHECK dout0_45 Vdout0_45ck11 = 0 time = 60
.meas tran vdout0_45ck11 FIND v(dout0_45) AT=60.025n

* CHECK dout0_46 Vdout0_46ck11 = 0.9 time = 60
.meas tran vdout0_46ck11 FIND v(dout0_46) AT=60.025n

* CHECK dout0_47 Vdout0_47ck11 = 0.9 time = 60
.meas tran vdout0_47ck11 FIND v(dout0_47) AT=60.025n

* CHECK dout0_48 Vdout0_48ck11 = 0 time = 60
.meas tran vdout0_48ck11 FIND v(dout0_48) AT=60.025n

* CHECK dout0_49 Vdout0_49ck11 = 0.9 time = 60
.meas tran vdout0_49ck11 FIND v(dout0_49) AT=60.025n

* CHECK dout0_50 Vdout0_50ck11 = 0.9 time = 60
.meas tran vdout0_50ck11 FIND v(dout0_50) AT=60.025n

* CHECK dout0_51 Vdout0_51ck11 = 0 time = 60
.meas tran vdout0_51ck11 FIND v(dout0_51) AT=60.025n

* CHECK dout0_52 Vdout0_52ck11 = 0 time = 60
.meas tran vdout0_52ck11 FIND v(dout0_52) AT=60.025n

* CHECK dout0_53 Vdout0_53ck11 = 0 time = 60
.meas tran vdout0_53ck11 FIND v(dout0_53) AT=60.025n

* CHECK dout0_54 Vdout0_54ck11 = 0.9 time = 60
.meas tran vdout0_54ck11 FIND v(dout0_54) AT=60.025n

* CHECK dout0_55 Vdout0_55ck11 = 0 time = 60
.meas tran vdout0_55ck11 FIND v(dout0_55) AT=60.025n

* CHECK dout0_56 Vdout0_56ck11 = 0 time = 60
.meas tran vdout0_56ck11 FIND v(dout0_56) AT=60.025n

* CHECK dout0_57 Vdout0_57ck11 = 0 time = 60
.meas tran vdout0_57ck11 FIND v(dout0_57) AT=60.025n

* CHECK dout0_58 Vdout0_58ck11 = 0 time = 60
.meas tran vdout0_58ck11 FIND v(dout0_58) AT=60.025n

* CHECK dout0_59 Vdout0_59ck11 = 0 time = 60
.meas tran vdout0_59ck11 FIND v(dout0_59) AT=60.025n

* CHECK dout0_60 Vdout0_60ck11 = 0 time = 60
.meas tran vdout0_60ck11 FIND v(dout0_60) AT=60.025n

* CHECK dout0_61 Vdout0_61ck11 = 0.9 time = 60
.meas tran vdout0_61ck11 FIND v(dout0_61) AT=60.025n

* CHECK dout0_62 Vdout0_62ck11 = 0.9 time = 60
.meas tran vdout0_62ck11 FIND v(dout0_62) AT=60.025n

* CHECK dout0_63 Vdout0_63ck11 = 0 time = 60
.meas tran vdout0_63ck11 FIND v(dout0_63) AT=60.025n

* CHECK dout0_64 Vdout0_64ck11 = 0 time = 60
.meas tran vdout0_64ck11 FIND v(dout0_64) AT=60.025n

* CHECK dout0_65 Vdout0_65ck11 = 0 time = 60
.meas tran vdout0_65ck11 FIND v(dout0_65) AT=60.025n

* CHECK dout0_66 Vdout0_66ck11 = 0 time = 60
.meas tran vdout0_66ck11 FIND v(dout0_66) AT=60.025n

* CHECK dout0_67 Vdout0_67ck11 = 0 time = 60
.meas tran vdout0_67ck11 FIND v(dout0_67) AT=60.025n

* CHECK dout0_68 Vdout0_68ck11 = 0 time = 60
.meas tran vdout0_68ck11 FIND v(dout0_68) AT=60.025n

* CHECK dout0_69 Vdout0_69ck11 = 0 time = 60
.meas tran vdout0_69ck11 FIND v(dout0_69) AT=60.025n

* CHECK dout0_70 Vdout0_70ck11 = 0.9 time = 60
.meas tran vdout0_70ck11 FIND v(dout0_70) AT=60.025n

* CHECK dout0_71 Vdout0_71ck11 = 0 time = 60
.meas tran vdout0_71ck11 FIND v(dout0_71) AT=60.025n

* CHECK dout0_72 Vdout0_72ck11 = 0 time = 60
.meas tran vdout0_72ck11 FIND v(dout0_72) AT=60.025n

* CHECK dout0_73 Vdout0_73ck11 = 0 time = 60
.meas tran vdout0_73ck11 FIND v(dout0_73) AT=60.025n

* CHECK dout0_74 Vdout0_74ck11 = 0.9 time = 60
.meas tran vdout0_74ck11 FIND v(dout0_74) AT=60.025n

* CHECK dout0_75 Vdout0_75ck11 = 0.9 time = 60
.meas tran vdout0_75ck11 FIND v(dout0_75) AT=60.025n

* CHECK dout0_76 Vdout0_76ck11 = 0 time = 60
.meas tran vdout0_76ck11 FIND v(dout0_76) AT=60.025n

* CHECK dout0_77 Vdout0_77ck11 = 0 time = 60
.meas tran vdout0_77ck11 FIND v(dout0_77) AT=60.025n

* CHECK dout0_78 Vdout0_78ck11 = 0.9 time = 60
.meas tran vdout0_78ck11 FIND v(dout0_78) AT=60.025n

* CHECK dout0_79 Vdout0_79ck11 = 0 time = 60
.meas tran vdout0_79ck11 FIND v(dout0_79) AT=60.025n

* CHECK dout0_0 Vdout0_0ck15 = 0.9 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0.9 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 0.9 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 0.9 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0.9 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 0 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 0 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 0.9 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 0.9 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0.9 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 0.9 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 0.9 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 0.9 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 0.9 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 0 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0.9 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 0 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 0 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0.9 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 0 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 0 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0.9 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 0 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_32 Vdout0_32ck15 = 0.9 time = 80
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=80.025n

* CHECK dout0_33 Vdout0_33ck15 = 0.9 time = 80
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=80.025n

* CHECK dout0_34 Vdout0_34ck15 = 0 time = 80
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=80.025n

* CHECK dout0_35 Vdout0_35ck15 = 0.9 time = 80
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=80.025n

* CHECK dout0_36 Vdout0_36ck15 = 0 time = 80
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=80.025n

* CHECK dout0_37 Vdout0_37ck15 = 0.9 time = 80
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=80.025n

* CHECK dout0_38 Vdout0_38ck15 = 0.9 time = 80
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=80.025n

* CHECK dout0_39 Vdout0_39ck15 = 0.9 time = 80
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=80.025n

* CHECK dout0_40 Vdout0_40ck15 = 0.9 time = 80
.meas tran vdout0_40ck15 FIND v(dout0_40) AT=80.025n

* CHECK dout0_41 Vdout0_41ck15 = 0.9 time = 80
.meas tran vdout0_41ck15 FIND v(dout0_41) AT=80.025n

* CHECK dout0_42 Vdout0_42ck15 = 0 time = 80
.meas tran vdout0_42ck15 FIND v(dout0_42) AT=80.025n

* CHECK dout0_43 Vdout0_43ck15 = 0 time = 80
.meas tran vdout0_43ck15 FIND v(dout0_43) AT=80.025n

* CHECK dout0_44 Vdout0_44ck15 = 0 time = 80
.meas tran vdout0_44ck15 FIND v(dout0_44) AT=80.025n

* CHECK dout0_45 Vdout0_45ck15 = 0.9 time = 80
.meas tran vdout0_45ck15 FIND v(dout0_45) AT=80.025n

* CHECK dout0_46 Vdout0_46ck15 = 0 time = 80
.meas tran vdout0_46ck15 FIND v(dout0_46) AT=80.025n

* CHECK dout0_47 Vdout0_47ck15 = 0.9 time = 80
.meas tran vdout0_47ck15 FIND v(dout0_47) AT=80.025n

* CHECK dout0_48 Vdout0_48ck15 = 0 time = 80
.meas tran vdout0_48ck15 FIND v(dout0_48) AT=80.025n

* CHECK dout0_49 Vdout0_49ck15 = 0.9 time = 80
.meas tran vdout0_49ck15 FIND v(dout0_49) AT=80.025n

* CHECK dout0_50 Vdout0_50ck15 = 0 time = 80
.meas tran vdout0_50ck15 FIND v(dout0_50) AT=80.025n

* CHECK dout0_51 Vdout0_51ck15 = 0.9 time = 80
.meas tran vdout0_51ck15 FIND v(dout0_51) AT=80.025n

* CHECK dout0_52 Vdout0_52ck15 = 0.9 time = 80
.meas tran vdout0_52ck15 FIND v(dout0_52) AT=80.025n

* CHECK dout0_53 Vdout0_53ck15 = 0 time = 80
.meas tran vdout0_53ck15 FIND v(dout0_53) AT=80.025n

* CHECK dout0_54 Vdout0_54ck15 = 0 time = 80
.meas tran vdout0_54ck15 FIND v(dout0_54) AT=80.025n

* CHECK dout0_55 Vdout0_55ck15 = 0 time = 80
.meas tran vdout0_55ck15 FIND v(dout0_55) AT=80.025n

* CHECK dout0_56 Vdout0_56ck15 = 0.9 time = 80
.meas tran vdout0_56ck15 FIND v(dout0_56) AT=80.025n

* CHECK dout0_57 Vdout0_57ck15 = 0.9 time = 80
.meas tran vdout0_57ck15 FIND v(dout0_57) AT=80.025n

* CHECK dout0_58 Vdout0_58ck15 = 0.9 time = 80
.meas tran vdout0_58ck15 FIND v(dout0_58) AT=80.025n

* CHECK dout0_59 Vdout0_59ck15 = 0 time = 80
.meas tran vdout0_59ck15 FIND v(dout0_59) AT=80.025n

* CHECK dout0_60 Vdout0_60ck15 = 0 time = 80
.meas tran vdout0_60ck15 FIND v(dout0_60) AT=80.025n

* CHECK dout0_61 Vdout0_61ck15 = 0 time = 80
.meas tran vdout0_61ck15 FIND v(dout0_61) AT=80.025n

* CHECK dout0_62 Vdout0_62ck15 = 0.9 time = 80
.meas tran vdout0_62ck15 FIND v(dout0_62) AT=80.025n

* CHECK dout0_63 Vdout0_63ck15 = 0.9 time = 80
.meas tran vdout0_63ck15 FIND v(dout0_63) AT=80.025n

* CHECK dout0_64 Vdout0_64ck15 = 0 time = 80
.meas tran vdout0_64ck15 FIND v(dout0_64) AT=80.025n

* CHECK dout0_65 Vdout0_65ck15 = 0.9 time = 80
.meas tran vdout0_65ck15 FIND v(dout0_65) AT=80.025n

* CHECK dout0_66 Vdout0_66ck15 = 0 time = 80
.meas tran vdout0_66ck15 FIND v(dout0_66) AT=80.025n

* CHECK dout0_67 Vdout0_67ck15 = 0.9 time = 80
.meas tran vdout0_67ck15 FIND v(dout0_67) AT=80.025n

* CHECK dout0_68 Vdout0_68ck15 = 0 time = 80
.meas tran vdout0_68ck15 FIND v(dout0_68) AT=80.025n

* CHECK dout0_69 Vdout0_69ck15 = 0.9 time = 80
.meas tran vdout0_69ck15 FIND v(dout0_69) AT=80.025n

* CHECK dout0_70 Vdout0_70ck15 = 0.9 time = 80
.meas tran vdout0_70ck15 FIND v(dout0_70) AT=80.025n

* CHECK dout0_71 Vdout0_71ck15 = 0.9 time = 80
.meas tran vdout0_71ck15 FIND v(dout0_71) AT=80.025n

* CHECK dout0_72 Vdout0_72ck15 = 0 time = 80
.meas tran vdout0_72ck15 FIND v(dout0_72) AT=80.025n

* CHECK dout0_73 Vdout0_73ck15 = 0 time = 80
.meas tran vdout0_73ck15 FIND v(dout0_73) AT=80.025n

* CHECK dout0_74 Vdout0_74ck15 = 0.9 time = 80
.meas tran vdout0_74ck15 FIND v(dout0_74) AT=80.025n

* CHECK dout0_75 Vdout0_75ck15 = 0.9 time = 80
.meas tran vdout0_75ck15 FIND v(dout0_75) AT=80.025n

* CHECK dout0_76 Vdout0_76ck15 = 0 time = 80
.meas tran vdout0_76ck15 FIND v(dout0_76) AT=80.025n

* CHECK dout0_77 Vdout0_77ck15 = 0.9 time = 80
.meas tran vdout0_77ck15 FIND v(dout0_77) AT=80.025n

* CHECK dout0_78 Vdout0_78ck15 = 0 time = 80
.meas tran vdout0_78ck15 FIND v(dout0_78) AT=80.025n

* CHECK dout0_79 Vdout0_79ck15 = 0 time = 80
.meas tran vdout0_79ck15 FIND v(dout0_79) AT=80.025n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 90
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=90.025n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 90
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=90.025n

* CHECK dout0_2 Vdout0_2ck17 = 0.9 time = 90
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=90.025n

* CHECK dout0_3 Vdout0_3ck17 = 0.9 time = 90
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=90.025n

* CHECK dout0_4 Vdout0_4ck17 = 0.9 time = 90
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=90.025n

* CHECK dout0_5 Vdout0_5ck17 = 0.9 time = 90
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=90.025n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 90
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=90.025n

* CHECK dout0_7 Vdout0_7ck17 = 0.9 time = 90
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=90.025n

* CHECK dout0_8 Vdout0_8ck17 = 0 time = 90
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=90.025n

* CHECK dout0_9 Vdout0_9ck17 = 0.9 time = 90
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=90.025n

* CHECK dout0_10 Vdout0_10ck17 = 0.9 time = 90
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=90.025n

* CHECK dout0_11 Vdout0_11ck17 = 0 time = 90
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=90.025n

* CHECK dout0_12 Vdout0_12ck17 = 0.9 time = 90
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=90.025n

* CHECK dout0_13 Vdout0_13ck17 = 0.9 time = 90
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=90.025n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 90
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=90.025n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 90
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=90.025n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 90
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=90.025n

* CHECK dout0_17 Vdout0_17ck17 = 0 time = 90
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=90.025n

* CHECK dout0_18 Vdout0_18ck17 = 0.9 time = 90
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=90.025n

* CHECK dout0_19 Vdout0_19ck17 = 0 time = 90
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=90.025n

* CHECK dout0_20 Vdout0_20ck17 = 0 time = 90
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=90.025n

* CHECK dout0_21 Vdout0_21ck17 = 0.9 time = 90
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=90.025n

* CHECK dout0_22 Vdout0_22ck17 = 0.9 time = 90
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=90.025n

* CHECK dout0_23 Vdout0_23ck17 = 0.9 time = 90
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=90.025n

* CHECK dout0_24 Vdout0_24ck17 = 0 time = 90
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=90.025n

* CHECK dout0_25 Vdout0_25ck17 = 0.9 time = 90
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=90.025n

* CHECK dout0_26 Vdout0_26ck17 = 0.9 time = 90
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=90.025n

* CHECK dout0_27 Vdout0_27ck17 = 0 time = 90
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=90.025n

* CHECK dout0_28 Vdout0_28ck17 = 0.9 time = 90
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=90.025n

* CHECK dout0_29 Vdout0_29ck17 = 0.9 time = 90
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=90.025n

* CHECK dout0_30 Vdout0_30ck17 = 0.9 time = 90
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=90.025n

* CHECK dout0_31 Vdout0_31ck17 = 0.9 time = 90
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=90.025n

* CHECK dout0_32 Vdout0_32ck17 = 0.9 time = 90
.meas tran vdout0_32ck17 FIND v(dout0_32) AT=90.025n

* CHECK dout0_33 Vdout0_33ck17 = 0 time = 90
.meas tran vdout0_33ck17 FIND v(dout0_33) AT=90.025n

* CHECK dout0_34 Vdout0_34ck17 = 0 time = 90
.meas tran vdout0_34ck17 FIND v(dout0_34) AT=90.025n

* CHECK dout0_35 Vdout0_35ck17 = 0.9 time = 90
.meas tran vdout0_35ck17 FIND v(dout0_35) AT=90.025n

* CHECK dout0_36 Vdout0_36ck17 = 0 time = 90
.meas tran vdout0_36ck17 FIND v(dout0_36) AT=90.025n

* CHECK dout0_37 Vdout0_37ck17 = 0.9 time = 90
.meas tran vdout0_37ck17 FIND v(dout0_37) AT=90.025n

* CHECK dout0_38 Vdout0_38ck17 = 0.9 time = 90
.meas tran vdout0_38ck17 FIND v(dout0_38) AT=90.025n

* CHECK dout0_39 Vdout0_39ck17 = 0.9 time = 90
.meas tran vdout0_39ck17 FIND v(dout0_39) AT=90.025n

* CHECK dout0_40 Vdout0_40ck17 = 0 time = 90
.meas tran vdout0_40ck17 FIND v(dout0_40) AT=90.025n

* CHECK dout0_41 Vdout0_41ck17 = 0.9 time = 90
.meas tran vdout0_41ck17 FIND v(dout0_41) AT=90.025n

* CHECK dout0_42 Vdout0_42ck17 = 0 time = 90
.meas tran vdout0_42ck17 FIND v(dout0_42) AT=90.025n

* CHECK dout0_43 Vdout0_43ck17 = 0 time = 90
.meas tran vdout0_43ck17 FIND v(dout0_43) AT=90.025n

* CHECK dout0_44 Vdout0_44ck17 = 0.9 time = 90
.meas tran vdout0_44ck17 FIND v(dout0_44) AT=90.025n

* CHECK dout0_45 Vdout0_45ck17 = 0 time = 90
.meas tran vdout0_45ck17 FIND v(dout0_45) AT=90.025n

* CHECK dout0_46 Vdout0_46ck17 = 0 time = 90
.meas tran vdout0_46ck17 FIND v(dout0_46) AT=90.025n

* CHECK dout0_47 Vdout0_47ck17 = 0 time = 90
.meas tran vdout0_47ck17 FIND v(dout0_47) AT=90.025n

* CHECK dout0_48 Vdout0_48ck17 = 0.9 time = 90
.meas tran vdout0_48ck17 FIND v(dout0_48) AT=90.025n

* CHECK dout0_49 Vdout0_49ck17 = 0.9 time = 90
.meas tran vdout0_49ck17 FIND v(dout0_49) AT=90.025n

* CHECK dout0_50 Vdout0_50ck17 = 0.9 time = 90
.meas tran vdout0_50ck17 FIND v(dout0_50) AT=90.025n

* CHECK dout0_51 Vdout0_51ck17 = 0 time = 90
.meas tran vdout0_51ck17 FIND v(dout0_51) AT=90.025n

* CHECK dout0_52 Vdout0_52ck17 = 0.9 time = 90
.meas tran vdout0_52ck17 FIND v(dout0_52) AT=90.025n

* CHECK dout0_53 Vdout0_53ck17 = 0 time = 90
.meas tran vdout0_53ck17 FIND v(dout0_53) AT=90.025n

* CHECK dout0_54 Vdout0_54ck17 = 0 time = 90
.meas tran vdout0_54ck17 FIND v(dout0_54) AT=90.025n

* CHECK dout0_55 Vdout0_55ck17 = 0.9 time = 90
.meas tran vdout0_55ck17 FIND v(dout0_55) AT=90.025n

* CHECK dout0_56 Vdout0_56ck17 = 0 time = 90
.meas tran vdout0_56ck17 FIND v(dout0_56) AT=90.025n

* CHECK dout0_57 Vdout0_57ck17 = 0 time = 90
.meas tran vdout0_57ck17 FIND v(dout0_57) AT=90.025n

* CHECK dout0_58 Vdout0_58ck17 = 0 time = 90
.meas tran vdout0_58ck17 FIND v(dout0_58) AT=90.025n

* CHECK dout0_59 Vdout0_59ck17 = 0.9 time = 90
.meas tran vdout0_59ck17 FIND v(dout0_59) AT=90.025n

* CHECK dout0_60 Vdout0_60ck17 = 0 time = 90
.meas tran vdout0_60ck17 FIND v(dout0_60) AT=90.025n

* CHECK dout0_61 Vdout0_61ck17 = 0 time = 90
.meas tran vdout0_61ck17 FIND v(dout0_61) AT=90.025n

* CHECK dout0_62 Vdout0_62ck17 = 0 time = 90
.meas tran vdout0_62ck17 FIND v(dout0_62) AT=90.025n

* CHECK dout0_63 Vdout0_63ck17 = 0 time = 90
.meas tran vdout0_63ck17 FIND v(dout0_63) AT=90.025n

* CHECK dout0_64 Vdout0_64ck17 = 0 time = 90
.meas tran vdout0_64ck17 FIND v(dout0_64) AT=90.025n

* CHECK dout0_65 Vdout0_65ck17 = 0 time = 90
.meas tran vdout0_65ck17 FIND v(dout0_65) AT=90.025n

* CHECK dout0_66 Vdout0_66ck17 = 0 time = 90
.meas tran vdout0_66ck17 FIND v(dout0_66) AT=90.025n

* CHECK dout0_67 Vdout0_67ck17 = 0 time = 90
.meas tran vdout0_67ck17 FIND v(dout0_67) AT=90.025n

* CHECK dout0_68 Vdout0_68ck17 = 0 time = 90
.meas tran vdout0_68ck17 FIND v(dout0_68) AT=90.025n

* CHECK dout0_69 Vdout0_69ck17 = 0.9 time = 90
.meas tran vdout0_69ck17 FIND v(dout0_69) AT=90.025n

* CHECK dout0_70 Vdout0_70ck17 = 0.9 time = 90
.meas tran vdout0_70ck17 FIND v(dout0_70) AT=90.025n

* CHECK dout0_71 Vdout0_71ck17 = 0.9 time = 90
.meas tran vdout0_71ck17 FIND v(dout0_71) AT=90.025n

* CHECK dout0_72 Vdout0_72ck17 = 0 time = 90
.meas tran vdout0_72ck17 FIND v(dout0_72) AT=90.025n

* CHECK dout0_73 Vdout0_73ck17 = 0.9 time = 90
.meas tran vdout0_73ck17 FIND v(dout0_73) AT=90.025n

* CHECK dout0_74 Vdout0_74ck17 = 0 time = 90
.meas tran vdout0_74ck17 FIND v(dout0_74) AT=90.025n

* CHECK dout0_75 Vdout0_75ck17 = 0.9 time = 90
.meas tran vdout0_75ck17 FIND v(dout0_75) AT=90.025n

* CHECK dout0_76 Vdout0_76ck17 = 0.9 time = 90
.meas tran vdout0_76ck17 FIND v(dout0_76) AT=90.025n

* CHECK dout0_77 Vdout0_77ck17 = 0 time = 90
.meas tran vdout0_77ck17 FIND v(dout0_77) AT=90.025n

* CHECK dout0_78 Vdout0_78ck17 = 0.9 time = 90
.meas tran vdout0_78ck17 FIND v(dout0_78) AT=90.025n

* CHECK dout0_79 Vdout0_79ck17 = 0.9 time = 90
.meas tran vdout0_79ck17 FIND v(dout0_79) AT=90.025n

* CHECK dout0_0 Vdout0_0ck18 = 0.9 time = 95
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=95.025n

* CHECK dout0_1 Vdout0_1ck18 = 0.9 time = 95
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=95.025n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 95
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=95.025n

* CHECK dout0_3 Vdout0_3ck18 = 0.9 time = 95
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=95.025n

* CHECK dout0_4 Vdout0_4ck18 = 0.9 time = 95
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=95.025n

* CHECK dout0_5 Vdout0_5ck18 = 0.9 time = 95
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=95.025n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 95
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=95.025n

* CHECK dout0_7 Vdout0_7ck18 = 0.9 time = 95
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=95.025n

* CHECK dout0_8 Vdout0_8ck18 = 0 time = 95
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=95.025n

* CHECK dout0_9 Vdout0_9ck18 = 0.9 time = 95
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=95.025n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 95
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=95.025n

* CHECK dout0_11 Vdout0_11ck18 = 0.9 time = 95
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=95.025n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 95
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=95.025n

* CHECK dout0_13 Vdout0_13ck18 = 0.9 time = 95
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=95.025n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 95
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=95.025n

* CHECK dout0_15 Vdout0_15ck18 = 0.9 time = 95
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=95.025n

* CHECK dout0_16 Vdout0_16ck18 = 0 time = 95
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=95.025n

* CHECK dout0_17 Vdout0_17ck18 = 0.9 time = 95
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=95.025n

* CHECK dout0_18 Vdout0_18ck18 = 0.9 time = 95
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=95.025n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 95
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=95.025n

* CHECK dout0_20 Vdout0_20ck18 = 0.9 time = 95
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=95.025n

* CHECK dout0_21 Vdout0_21ck18 = 0.9 time = 95
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=95.025n

* CHECK dout0_22 Vdout0_22ck18 = 0.9 time = 95
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=95.025n

* CHECK dout0_23 Vdout0_23ck18 = 0.9 time = 95
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=95.025n

* CHECK dout0_24 Vdout0_24ck18 = 0.9 time = 95
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=95.025n

* CHECK dout0_25 Vdout0_25ck18 = 0.9 time = 95
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=95.025n

* CHECK dout0_26 Vdout0_26ck18 = 0.9 time = 95
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=95.025n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 95
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=95.025n

* CHECK dout0_28 Vdout0_28ck18 = 0 time = 95
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=95.025n

* CHECK dout0_29 Vdout0_29ck18 = 0.9 time = 95
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=95.025n

* CHECK dout0_30 Vdout0_30ck18 = 0.9 time = 95
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=95.025n

* CHECK dout0_31 Vdout0_31ck18 = 0.9 time = 95
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=95.025n

* CHECK dout0_32 Vdout0_32ck18 = 0.9 time = 95
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=95.025n

* CHECK dout0_33 Vdout0_33ck18 = 0 time = 95
.meas tran vdout0_33ck18 FIND v(dout0_33) AT=95.025n

* CHECK dout0_34 Vdout0_34ck18 = 0 time = 95
.meas tran vdout0_34ck18 FIND v(dout0_34) AT=95.025n

* CHECK dout0_35 Vdout0_35ck18 = 0.9 time = 95
.meas tran vdout0_35ck18 FIND v(dout0_35) AT=95.025n

* CHECK dout0_36 Vdout0_36ck18 = 0 time = 95
.meas tran vdout0_36ck18 FIND v(dout0_36) AT=95.025n

* CHECK dout0_37 Vdout0_37ck18 = 0.9 time = 95
.meas tran vdout0_37ck18 FIND v(dout0_37) AT=95.025n

* CHECK dout0_38 Vdout0_38ck18 = 0 time = 95
.meas tran vdout0_38ck18 FIND v(dout0_38) AT=95.025n

* CHECK dout0_39 Vdout0_39ck18 = 0 time = 95
.meas tran vdout0_39ck18 FIND v(dout0_39) AT=95.025n

* CHECK dout0_40 Vdout0_40ck18 = 0.9 time = 95
.meas tran vdout0_40ck18 FIND v(dout0_40) AT=95.025n

* CHECK dout0_41 Vdout0_41ck18 = 0.9 time = 95
.meas tran vdout0_41ck18 FIND v(dout0_41) AT=95.025n

* CHECK dout0_42 Vdout0_42ck18 = 0 time = 95
.meas tran vdout0_42ck18 FIND v(dout0_42) AT=95.025n

* CHECK dout0_43 Vdout0_43ck18 = 0 time = 95
.meas tran vdout0_43ck18 FIND v(dout0_43) AT=95.025n

* CHECK dout0_44 Vdout0_44ck18 = 0 time = 95
.meas tran vdout0_44ck18 FIND v(dout0_44) AT=95.025n

* CHECK dout0_45 Vdout0_45ck18 = 0 time = 95
.meas tran vdout0_45ck18 FIND v(dout0_45) AT=95.025n

* CHECK dout0_46 Vdout0_46ck18 = 0.9 time = 95
.meas tran vdout0_46ck18 FIND v(dout0_46) AT=95.025n

* CHECK dout0_47 Vdout0_47ck18 = 0.9 time = 95
.meas tran vdout0_47ck18 FIND v(dout0_47) AT=95.025n

* CHECK dout0_48 Vdout0_48ck18 = 0 time = 95
.meas tran vdout0_48ck18 FIND v(dout0_48) AT=95.025n

* CHECK dout0_49 Vdout0_49ck18 = 0.9 time = 95
.meas tran vdout0_49ck18 FIND v(dout0_49) AT=95.025n

* CHECK dout0_50 Vdout0_50ck18 = 0.9 time = 95
.meas tran vdout0_50ck18 FIND v(dout0_50) AT=95.025n

* CHECK dout0_51 Vdout0_51ck18 = 0 time = 95
.meas tran vdout0_51ck18 FIND v(dout0_51) AT=95.025n

* CHECK dout0_52 Vdout0_52ck18 = 0 time = 95
.meas tran vdout0_52ck18 FIND v(dout0_52) AT=95.025n

* CHECK dout0_53 Vdout0_53ck18 = 0 time = 95
.meas tran vdout0_53ck18 FIND v(dout0_53) AT=95.025n

* CHECK dout0_54 Vdout0_54ck18 = 0.9 time = 95
.meas tran vdout0_54ck18 FIND v(dout0_54) AT=95.025n

* CHECK dout0_55 Vdout0_55ck18 = 0 time = 95
.meas tran vdout0_55ck18 FIND v(dout0_55) AT=95.025n

* CHECK dout0_56 Vdout0_56ck18 = 0 time = 95
.meas tran vdout0_56ck18 FIND v(dout0_56) AT=95.025n

* CHECK dout0_57 Vdout0_57ck18 = 0 time = 95
.meas tran vdout0_57ck18 FIND v(dout0_57) AT=95.025n

* CHECK dout0_58 Vdout0_58ck18 = 0 time = 95
.meas tran vdout0_58ck18 FIND v(dout0_58) AT=95.025n

* CHECK dout0_59 Vdout0_59ck18 = 0 time = 95
.meas tran vdout0_59ck18 FIND v(dout0_59) AT=95.025n

* CHECK dout0_60 Vdout0_60ck18 = 0 time = 95
.meas tran vdout0_60ck18 FIND v(dout0_60) AT=95.025n

* CHECK dout0_61 Vdout0_61ck18 = 0.9 time = 95
.meas tran vdout0_61ck18 FIND v(dout0_61) AT=95.025n

* CHECK dout0_62 Vdout0_62ck18 = 0.9 time = 95
.meas tran vdout0_62ck18 FIND v(dout0_62) AT=95.025n

* CHECK dout0_63 Vdout0_63ck18 = 0 time = 95
.meas tran vdout0_63ck18 FIND v(dout0_63) AT=95.025n

* CHECK dout0_64 Vdout0_64ck18 = 0 time = 95
.meas tran vdout0_64ck18 FIND v(dout0_64) AT=95.025n

* CHECK dout0_65 Vdout0_65ck18 = 0 time = 95
.meas tran vdout0_65ck18 FIND v(dout0_65) AT=95.025n

* CHECK dout0_66 Vdout0_66ck18 = 0 time = 95
.meas tran vdout0_66ck18 FIND v(dout0_66) AT=95.025n

* CHECK dout0_67 Vdout0_67ck18 = 0 time = 95
.meas tran vdout0_67ck18 FIND v(dout0_67) AT=95.025n

* CHECK dout0_68 Vdout0_68ck18 = 0 time = 95
.meas tran vdout0_68ck18 FIND v(dout0_68) AT=95.025n

* CHECK dout0_69 Vdout0_69ck18 = 0 time = 95
.meas tran vdout0_69ck18 FIND v(dout0_69) AT=95.025n

* CHECK dout0_70 Vdout0_70ck18 = 0.9 time = 95
.meas tran vdout0_70ck18 FIND v(dout0_70) AT=95.025n

* CHECK dout0_71 Vdout0_71ck18 = 0 time = 95
.meas tran vdout0_71ck18 FIND v(dout0_71) AT=95.025n

* CHECK dout0_72 Vdout0_72ck18 = 0 time = 95
.meas tran vdout0_72ck18 FIND v(dout0_72) AT=95.025n

* CHECK dout0_73 Vdout0_73ck18 = 0 time = 95
.meas tran vdout0_73ck18 FIND v(dout0_73) AT=95.025n

* CHECK dout0_74 Vdout0_74ck18 = 0.9 time = 95
.meas tran vdout0_74ck18 FIND v(dout0_74) AT=95.025n

* CHECK dout0_75 Vdout0_75ck18 = 0.9 time = 95
.meas tran vdout0_75ck18 FIND v(dout0_75) AT=95.025n

* CHECK dout0_76 Vdout0_76ck18 = 0 time = 95
.meas tran vdout0_76ck18 FIND v(dout0_76) AT=95.025n

* CHECK dout0_77 Vdout0_77ck18 = 0 time = 95
.meas tran vdout0_77ck18 FIND v(dout0_77) AT=95.025n

* CHECK dout0_78 Vdout0_78ck18 = 0.9 time = 95
.meas tran vdout0_78ck18 FIND v(dout0_78) AT=95.025n

* CHECK dout0_79 Vdout0_79ck18 = 0 time = 95
.meas tran vdout0_79ck18 FIND v(dout0_79) AT=95.025n

* CHECK dout0_0 Vdout0_0ck19 = 0.9 time = 100
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=100.025n

* CHECK dout0_1 Vdout0_1ck19 = 0.9 time = 100
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=100.025n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 100
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=100.025n

* CHECK dout0_3 Vdout0_3ck19 = 0.9 time = 100
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=100.025n

* CHECK dout0_4 Vdout0_4ck19 = 0.9 time = 100
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=100.025n

* CHECK dout0_5 Vdout0_5ck19 = 0.9 time = 100
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=100.025n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 100
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=100.025n

* CHECK dout0_7 Vdout0_7ck19 = 0.9 time = 100
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=100.025n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 100
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=100.025n

* CHECK dout0_9 Vdout0_9ck19 = 0.9 time = 100
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=100.025n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 100
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=100.025n

* CHECK dout0_11 Vdout0_11ck19 = 0.9 time = 100
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=100.025n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 100
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=100.025n

* CHECK dout0_13 Vdout0_13ck19 = 0.9 time = 100
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=100.025n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 100
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=100.025n

* CHECK dout0_15 Vdout0_15ck19 = 0.9 time = 100
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=100.025n

* CHECK dout0_16 Vdout0_16ck19 = 0 time = 100
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=100.025n

* CHECK dout0_17 Vdout0_17ck19 = 0.9 time = 100
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=100.025n

* CHECK dout0_18 Vdout0_18ck19 = 0.9 time = 100
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=100.025n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 100
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=100.025n

* CHECK dout0_20 Vdout0_20ck19 = 0.9 time = 100
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=100.025n

* CHECK dout0_21 Vdout0_21ck19 = 0.9 time = 100
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=100.025n

* CHECK dout0_22 Vdout0_22ck19 = 0.9 time = 100
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=100.025n

* CHECK dout0_23 Vdout0_23ck19 = 0.9 time = 100
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=100.025n

* CHECK dout0_24 Vdout0_24ck19 = 0.9 time = 100
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=100.025n

* CHECK dout0_25 Vdout0_25ck19 = 0.9 time = 100
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=100.025n

* CHECK dout0_26 Vdout0_26ck19 = 0.9 time = 100
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=100.025n

* CHECK dout0_27 Vdout0_27ck19 = 0 time = 100
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=100.025n

* CHECK dout0_28 Vdout0_28ck19 = 0 time = 100
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=100.025n

* CHECK dout0_29 Vdout0_29ck19 = 0.9 time = 100
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=100.025n

* CHECK dout0_30 Vdout0_30ck19 = 0.9 time = 100
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=100.025n

* CHECK dout0_31 Vdout0_31ck19 = 0.9 time = 100
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=100.025n

* CHECK dout0_32 Vdout0_32ck19 = 0.9 time = 100
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=100.025n

* CHECK dout0_33 Vdout0_33ck19 = 0 time = 100
.meas tran vdout0_33ck19 FIND v(dout0_33) AT=100.025n

* CHECK dout0_34 Vdout0_34ck19 = 0 time = 100
.meas tran vdout0_34ck19 FIND v(dout0_34) AT=100.025n

* CHECK dout0_35 Vdout0_35ck19 = 0.9 time = 100
.meas tran vdout0_35ck19 FIND v(dout0_35) AT=100.025n

* CHECK dout0_36 Vdout0_36ck19 = 0 time = 100
.meas tran vdout0_36ck19 FIND v(dout0_36) AT=100.025n

* CHECK dout0_37 Vdout0_37ck19 = 0.9 time = 100
.meas tran vdout0_37ck19 FIND v(dout0_37) AT=100.025n

* CHECK dout0_38 Vdout0_38ck19 = 0 time = 100
.meas tran vdout0_38ck19 FIND v(dout0_38) AT=100.025n

* CHECK dout0_39 Vdout0_39ck19 = 0 time = 100
.meas tran vdout0_39ck19 FIND v(dout0_39) AT=100.025n

* CHECK dout0_40 Vdout0_40ck19 = 0.9 time = 100
.meas tran vdout0_40ck19 FIND v(dout0_40) AT=100.025n

* CHECK dout0_41 Vdout0_41ck19 = 0.9 time = 100
.meas tran vdout0_41ck19 FIND v(dout0_41) AT=100.025n

* CHECK dout0_42 Vdout0_42ck19 = 0 time = 100
.meas tran vdout0_42ck19 FIND v(dout0_42) AT=100.025n

* CHECK dout0_43 Vdout0_43ck19 = 0 time = 100
.meas tran vdout0_43ck19 FIND v(dout0_43) AT=100.025n

* CHECK dout0_44 Vdout0_44ck19 = 0 time = 100
.meas tran vdout0_44ck19 FIND v(dout0_44) AT=100.025n

* CHECK dout0_45 Vdout0_45ck19 = 0 time = 100
.meas tran vdout0_45ck19 FIND v(dout0_45) AT=100.025n

* CHECK dout0_46 Vdout0_46ck19 = 0.9 time = 100
.meas tran vdout0_46ck19 FIND v(dout0_46) AT=100.025n

* CHECK dout0_47 Vdout0_47ck19 = 0.9 time = 100
.meas tran vdout0_47ck19 FIND v(dout0_47) AT=100.025n

* CHECK dout0_48 Vdout0_48ck19 = 0 time = 100
.meas tran vdout0_48ck19 FIND v(dout0_48) AT=100.025n

* CHECK dout0_49 Vdout0_49ck19 = 0.9 time = 100
.meas tran vdout0_49ck19 FIND v(dout0_49) AT=100.025n

* CHECK dout0_50 Vdout0_50ck19 = 0.9 time = 100
.meas tran vdout0_50ck19 FIND v(dout0_50) AT=100.025n

* CHECK dout0_51 Vdout0_51ck19 = 0 time = 100
.meas tran vdout0_51ck19 FIND v(dout0_51) AT=100.025n

* CHECK dout0_52 Vdout0_52ck19 = 0 time = 100
.meas tran vdout0_52ck19 FIND v(dout0_52) AT=100.025n

* CHECK dout0_53 Vdout0_53ck19 = 0 time = 100
.meas tran vdout0_53ck19 FIND v(dout0_53) AT=100.025n

* CHECK dout0_54 Vdout0_54ck19 = 0.9 time = 100
.meas tran vdout0_54ck19 FIND v(dout0_54) AT=100.025n

* CHECK dout0_55 Vdout0_55ck19 = 0 time = 100
.meas tran vdout0_55ck19 FIND v(dout0_55) AT=100.025n

* CHECK dout0_56 Vdout0_56ck19 = 0 time = 100
.meas tran vdout0_56ck19 FIND v(dout0_56) AT=100.025n

* CHECK dout0_57 Vdout0_57ck19 = 0 time = 100
.meas tran vdout0_57ck19 FIND v(dout0_57) AT=100.025n

* CHECK dout0_58 Vdout0_58ck19 = 0 time = 100
.meas tran vdout0_58ck19 FIND v(dout0_58) AT=100.025n

* CHECK dout0_59 Vdout0_59ck19 = 0 time = 100
.meas tran vdout0_59ck19 FIND v(dout0_59) AT=100.025n

* CHECK dout0_60 Vdout0_60ck19 = 0 time = 100
.meas tran vdout0_60ck19 FIND v(dout0_60) AT=100.025n

* CHECK dout0_61 Vdout0_61ck19 = 0.9 time = 100
.meas tran vdout0_61ck19 FIND v(dout0_61) AT=100.025n

* CHECK dout0_62 Vdout0_62ck19 = 0.9 time = 100
.meas tran vdout0_62ck19 FIND v(dout0_62) AT=100.025n

* CHECK dout0_63 Vdout0_63ck19 = 0 time = 100
.meas tran vdout0_63ck19 FIND v(dout0_63) AT=100.025n

* CHECK dout0_64 Vdout0_64ck19 = 0 time = 100
.meas tran vdout0_64ck19 FIND v(dout0_64) AT=100.025n

* CHECK dout0_65 Vdout0_65ck19 = 0 time = 100
.meas tran vdout0_65ck19 FIND v(dout0_65) AT=100.025n

* CHECK dout0_66 Vdout0_66ck19 = 0 time = 100
.meas tran vdout0_66ck19 FIND v(dout0_66) AT=100.025n

* CHECK dout0_67 Vdout0_67ck19 = 0 time = 100
.meas tran vdout0_67ck19 FIND v(dout0_67) AT=100.025n

* CHECK dout0_68 Vdout0_68ck19 = 0 time = 100
.meas tran vdout0_68ck19 FIND v(dout0_68) AT=100.025n

* CHECK dout0_69 Vdout0_69ck19 = 0 time = 100
.meas tran vdout0_69ck19 FIND v(dout0_69) AT=100.025n

* CHECK dout0_70 Vdout0_70ck19 = 0.9 time = 100
.meas tran vdout0_70ck19 FIND v(dout0_70) AT=100.025n

* CHECK dout0_71 Vdout0_71ck19 = 0 time = 100
.meas tran vdout0_71ck19 FIND v(dout0_71) AT=100.025n

* CHECK dout0_72 Vdout0_72ck19 = 0 time = 100
.meas tran vdout0_72ck19 FIND v(dout0_72) AT=100.025n

* CHECK dout0_73 Vdout0_73ck19 = 0 time = 100
.meas tran vdout0_73ck19 FIND v(dout0_73) AT=100.025n

* CHECK dout0_74 Vdout0_74ck19 = 0.9 time = 100
.meas tran vdout0_74ck19 FIND v(dout0_74) AT=100.025n

* CHECK dout0_75 Vdout0_75ck19 = 0.9 time = 100
.meas tran vdout0_75ck19 FIND v(dout0_75) AT=100.025n

* CHECK dout0_76 Vdout0_76ck19 = 0 time = 100
.meas tran vdout0_76ck19 FIND v(dout0_76) AT=100.025n

* CHECK dout0_77 Vdout0_77ck19 = 0 time = 100
.meas tran vdout0_77ck19 FIND v(dout0_77) AT=100.025n

* CHECK dout0_78 Vdout0_78ck19 = 0.9 time = 100
.meas tran vdout0_78ck19 FIND v(dout0_78) AT=100.025n

* CHECK dout0_79 Vdout0_79ck19 = 0 time = 100
.meas tran vdout0_79ck19 FIND v(dout0_79) AT=100.025n

* CHECK dout0_0 Vdout0_0ck21 = 0.9 time = 110
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=110.025n

* CHECK dout0_1 Vdout0_1ck21 = 0.9 time = 110
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=110.025n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 110
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=110.025n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 110
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=110.025n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 110
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=110.025n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 110
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=110.025n

* CHECK dout0_6 Vdout0_6ck21 = 0 time = 110
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=110.025n

* CHECK dout0_7 Vdout0_7ck21 = 0 time = 110
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=110.025n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 110
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=110.025n

* CHECK dout0_9 Vdout0_9ck21 = 0.9 time = 110
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=110.025n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 110
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=110.025n

* CHECK dout0_11 Vdout0_11ck21 = 0 time = 110
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=110.025n

* CHECK dout0_12 Vdout0_12ck21 = 0.9 time = 110
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=110.025n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 110
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=110.025n

* CHECK dout0_14 Vdout0_14ck21 = 0.9 time = 110
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=110.025n

* CHECK dout0_15 Vdout0_15ck21 = 0 time = 110
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=110.025n

* CHECK dout0_16 Vdout0_16ck21 = 0 time = 110
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=110.025n

* CHECK dout0_17 Vdout0_17ck21 = 0.9 time = 110
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=110.025n

* CHECK dout0_18 Vdout0_18ck21 = 0.9 time = 110
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=110.025n

* CHECK dout0_19 Vdout0_19ck21 = 0 time = 110
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=110.025n

* CHECK dout0_20 Vdout0_20ck21 = 0 time = 110
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=110.025n

* CHECK dout0_21 Vdout0_21ck21 = 0.9 time = 110
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=110.025n

* CHECK dout0_22 Vdout0_22ck21 = 0 time = 110
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=110.025n

* CHECK dout0_23 Vdout0_23ck21 = 0.9 time = 110
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=110.025n

* CHECK dout0_24 Vdout0_24ck21 = 0.9 time = 110
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=110.025n

* CHECK dout0_25 Vdout0_25ck21 = 0 time = 110
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=110.025n

* CHECK dout0_26 Vdout0_26ck21 = 0.9 time = 110
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=110.025n

* CHECK dout0_27 Vdout0_27ck21 = 0 time = 110
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=110.025n

* CHECK dout0_28 Vdout0_28ck21 = 0 time = 110
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=110.025n

* CHECK dout0_29 Vdout0_29ck21 = 0.9 time = 110
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=110.025n

* CHECK dout0_30 Vdout0_30ck21 = 0.9 time = 110
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=110.025n

* CHECK dout0_31 Vdout0_31ck21 = 0.9 time = 110
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=110.025n

* CHECK dout0_32 Vdout0_32ck21 = 0 time = 110
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=110.025n

* CHECK dout0_33 Vdout0_33ck21 = 0.9 time = 110
.meas tran vdout0_33ck21 FIND v(dout0_33) AT=110.025n

* CHECK dout0_34 Vdout0_34ck21 = 0.9 time = 110
.meas tran vdout0_34ck21 FIND v(dout0_34) AT=110.025n

* CHECK dout0_35 Vdout0_35ck21 = 0 time = 110
.meas tran vdout0_35ck21 FIND v(dout0_35) AT=110.025n

* CHECK dout0_36 Vdout0_36ck21 = 0 time = 110
.meas tran vdout0_36ck21 FIND v(dout0_36) AT=110.025n

* CHECK dout0_37 Vdout0_37ck21 = 0 time = 110
.meas tran vdout0_37ck21 FIND v(dout0_37) AT=110.025n

* CHECK dout0_38 Vdout0_38ck21 = 0 time = 110
.meas tran vdout0_38ck21 FIND v(dout0_38) AT=110.025n

* CHECK dout0_39 Vdout0_39ck21 = 0 time = 110
.meas tran vdout0_39ck21 FIND v(dout0_39) AT=110.025n

* CHECK dout0_40 Vdout0_40ck21 = 0.9 time = 110
.meas tran vdout0_40ck21 FIND v(dout0_40) AT=110.025n

* CHECK dout0_41 Vdout0_41ck21 = 0.9 time = 110
.meas tran vdout0_41ck21 FIND v(dout0_41) AT=110.025n

* CHECK dout0_42 Vdout0_42ck21 = 0 time = 110
.meas tran vdout0_42ck21 FIND v(dout0_42) AT=110.025n

* CHECK dout0_43 Vdout0_43ck21 = 0.9 time = 110
.meas tran vdout0_43ck21 FIND v(dout0_43) AT=110.025n

* CHECK dout0_44 Vdout0_44ck21 = 0.9 time = 110
.meas tran vdout0_44ck21 FIND v(dout0_44) AT=110.025n

* CHECK dout0_45 Vdout0_45ck21 = 0.9 time = 110
.meas tran vdout0_45ck21 FIND v(dout0_45) AT=110.025n

* CHECK dout0_46 Vdout0_46ck21 = 0.9 time = 110
.meas tran vdout0_46ck21 FIND v(dout0_46) AT=110.025n

* CHECK dout0_47 Vdout0_47ck21 = 0 time = 110
.meas tran vdout0_47ck21 FIND v(dout0_47) AT=110.025n

* CHECK dout0_48 Vdout0_48ck21 = 0 time = 110
.meas tran vdout0_48ck21 FIND v(dout0_48) AT=110.025n

* CHECK dout0_49 Vdout0_49ck21 = 0.9 time = 110
.meas tran vdout0_49ck21 FIND v(dout0_49) AT=110.025n

* CHECK dout0_50 Vdout0_50ck21 = 0 time = 110
.meas tran vdout0_50ck21 FIND v(dout0_50) AT=110.025n

* CHECK dout0_51 Vdout0_51ck21 = 0.9 time = 110
.meas tran vdout0_51ck21 FIND v(dout0_51) AT=110.025n

* CHECK dout0_52 Vdout0_52ck21 = 0.9 time = 110
.meas tran vdout0_52ck21 FIND v(dout0_52) AT=110.025n

* CHECK dout0_53 Vdout0_53ck21 = 0 time = 110
.meas tran vdout0_53ck21 FIND v(dout0_53) AT=110.025n

* CHECK dout0_54 Vdout0_54ck21 = 0.9 time = 110
.meas tran vdout0_54ck21 FIND v(dout0_54) AT=110.025n

* CHECK dout0_55 Vdout0_55ck21 = 0 time = 110
.meas tran vdout0_55ck21 FIND v(dout0_55) AT=110.025n

* CHECK dout0_56 Vdout0_56ck21 = 0 time = 110
.meas tran vdout0_56ck21 FIND v(dout0_56) AT=110.025n

* CHECK dout0_57 Vdout0_57ck21 = 0 time = 110
.meas tran vdout0_57ck21 FIND v(dout0_57) AT=110.025n

* CHECK dout0_58 Vdout0_58ck21 = 0.9 time = 110
.meas tran vdout0_58ck21 FIND v(dout0_58) AT=110.025n

* CHECK dout0_59 Vdout0_59ck21 = 0 time = 110
.meas tran vdout0_59ck21 FIND v(dout0_59) AT=110.025n

* CHECK dout0_60 Vdout0_60ck21 = 0.9 time = 110
.meas tran vdout0_60ck21 FIND v(dout0_60) AT=110.025n

* CHECK dout0_61 Vdout0_61ck21 = 0.9 time = 110
.meas tran vdout0_61ck21 FIND v(dout0_61) AT=110.025n

* CHECK dout0_62 Vdout0_62ck21 = 0 time = 110
.meas tran vdout0_62ck21 FIND v(dout0_62) AT=110.025n

* CHECK dout0_63 Vdout0_63ck21 = 0 time = 110
.meas tran vdout0_63ck21 FIND v(dout0_63) AT=110.025n

* CHECK dout0_64 Vdout0_64ck21 = 0.9 time = 110
.meas tran vdout0_64ck21 FIND v(dout0_64) AT=110.025n

* CHECK dout0_65 Vdout0_65ck21 = 0 time = 110
.meas tran vdout0_65ck21 FIND v(dout0_65) AT=110.025n

* CHECK dout0_66 Vdout0_66ck21 = 0.9 time = 110
.meas tran vdout0_66ck21 FIND v(dout0_66) AT=110.025n

* CHECK dout0_67 Vdout0_67ck21 = 0.9 time = 110
.meas tran vdout0_67ck21 FIND v(dout0_67) AT=110.025n

* CHECK dout0_68 Vdout0_68ck21 = 0.9 time = 110
.meas tran vdout0_68ck21 FIND v(dout0_68) AT=110.025n

* CHECK dout0_69 Vdout0_69ck21 = 0 time = 110
.meas tran vdout0_69ck21 FIND v(dout0_69) AT=110.025n

* CHECK dout0_70 Vdout0_70ck21 = 0.9 time = 110
.meas tran vdout0_70ck21 FIND v(dout0_70) AT=110.025n

* CHECK dout0_71 Vdout0_71ck21 = 0.9 time = 110
.meas tran vdout0_71ck21 FIND v(dout0_71) AT=110.025n

* CHECK dout0_72 Vdout0_72ck21 = 0.9 time = 110
.meas tran vdout0_72ck21 FIND v(dout0_72) AT=110.025n

* CHECK dout0_73 Vdout0_73ck21 = 0 time = 110
.meas tran vdout0_73ck21 FIND v(dout0_73) AT=110.025n

* CHECK dout0_74 Vdout0_74ck21 = 0 time = 110
.meas tran vdout0_74ck21 FIND v(dout0_74) AT=110.025n

* CHECK dout0_75 Vdout0_75ck21 = 0.9 time = 110
.meas tran vdout0_75ck21 FIND v(dout0_75) AT=110.025n

* CHECK dout0_76 Vdout0_76ck21 = 0 time = 110
.meas tran vdout0_76ck21 FIND v(dout0_76) AT=110.025n

* CHECK dout0_77 Vdout0_77ck21 = 0.9 time = 110
.meas tran vdout0_77ck21 FIND v(dout0_77) AT=110.025n

* CHECK dout0_78 Vdout0_78ck21 = 0 time = 110
.meas tran vdout0_78ck21 FIND v(dout0_78) AT=110.025n

* CHECK dout0_79 Vdout0_79ck21 = 0.9 time = 110
.meas tran vdout0_79ck21 FIND v(dout0_79) AT=110.025n

* CHECK dout0_0 Vdout0_0ck22 = 0.9 time = 115
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=115.025n

* CHECK dout0_1 Vdout0_1ck22 = 0.9 time = 115
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=115.025n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 115
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=115.025n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 115
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=115.025n

* CHECK dout0_4 Vdout0_4ck22 = 0 time = 115
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=115.025n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 115
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=115.025n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 115
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=115.025n

* CHECK dout0_7 Vdout0_7ck22 = 0 time = 115
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=115.025n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 115
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=115.025n

* CHECK dout0_9 Vdout0_9ck22 = 0.9 time = 115
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=115.025n

* CHECK dout0_10 Vdout0_10ck22 = 0 time = 115
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=115.025n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 115
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=115.025n

* CHECK dout0_12 Vdout0_12ck22 = 0.9 time = 115
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=115.025n

* CHECK dout0_13 Vdout0_13ck22 = 0 time = 115
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=115.025n

* CHECK dout0_14 Vdout0_14ck22 = 0.9 time = 115
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=115.025n

* CHECK dout0_15 Vdout0_15ck22 = 0 time = 115
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=115.025n

* CHECK dout0_16 Vdout0_16ck22 = 0 time = 115
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=115.025n

* CHECK dout0_17 Vdout0_17ck22 = 0.9 time = 115
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=115.025n

* CHECK dout0_18 Vdout0_18ck22 = 0.9 time = 115
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=115.025n

* CHECK dout0_19 Vdout0_19ck22 = 0 time = 115
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=115.025n

* CHECK dout0_20 Vdout0_20ck22 = 0 time = 115
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=115.025n

* CHECK dout0_21 Vdout0_21ck22 = 0.9 time = 115
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=115.025n

* CHECK dout0_22 Vdout0_22ck22 = 0 time = 115
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=115.025n

* CHECK dout0_23 Vdout0_23ck22 = 0.9 time = 115
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=115.025n

* CHECK dout0_24 Vdout0_24ck22 = 0.9 time = 115
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=115.025n

* CHECK dout0_25 Vdout0_25ck22 = 0 time = 115
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=115.025n

* CHECK dout0_26 Vdout0_26ck22 = 0.9 time = 115
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=115.025n

* CHECK dout0_27 Vdout0_27ck22 = 0 time = 115
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=115.025n

* CHECK dout0_28 Vdout0_28ck22 = 0 time = 115
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=115.025n

* CHECK dout0_29 Vdout0_29ck22 = 0.9 time = 115
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=115.025n

* CHECK dout0_30 Vdout0_30ck22 = 0.9 time = 115
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=115.025n

* CHECK dout0_31 Vdout0_31ck22 = 0.9 time = 115
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=115.025n

* CHECK dout0_32 Vdout0_32ck22 = 0 time = 115
.meas tran vdout0_32ck22 FIND v(dout0_32) AT=115.025n

* CHECK dout0_33 Vdout0_33ck22 = 0.9 time = 115
.meas tran vdout0_33ck22 FIND v(dout0_33) AT=115.025n

* CHECK dout0_34 Vdout0_34ck22 = 0.9 time = 115
.meas tran vdout0_34ck22 FIND v(dout0_34) AT=115.025n

* CHECK dout0_35 Vdout0_35ck22 = 0 time = 115
.meas tran vdout0_35ck22 FIND v(dout0_35) AT=115.025n

* CHECK dout0_36 Vdout0_36ck22 = 0 time = 115
.meas tran vdout0_36ck22 FIND v(dout0_36) AT=115.025n

* CHECK dout0_37 Vdout0_37ck22 = 0 time = 115
.meas tran vdout0_37ck22 FIND v(dout0_37) AT=115.025n

* CHECK dout0_38 Vdout0_38ck22 = 0 time = 115
.meas tran vdout0_38ck22 FIND v(dout0_38) AT=115.025n

* CHECK dout0_39 Vdout0_39ck22 = 0 time = 115
.meas tran vdout0_39ck22 FIND v(dout0_39) AT=115.025n

* CHECK dout0_40 Vdout0_40ck22 = 0.9 time = 115
.meas tran vdout0_40ck22 FIND v(dout0_40) AT=115.025n

* CHECK dout0_41 Vdout0_41ck22 = 0.9 time = 115
.meas tran vdout0_41ck22 FIND v(dout0_41) AT=115.025n

* CHECK dout0_42 Vdout0_42ck22 = 0 time = 115
.meas tran vdout0_42ck22 FIND v(dout0_42) AT=115.025n

* CHECK dout0_43 Vdout0_43ck22 = 0.9 time = 115
.meas tran vdout0_43ck22 FIND v(dout0_43) AT=115.025n

* CHECK dout0_44 Vdout0_44ck22 = 0.9 time = 115
.meas tran vdout0_44ck22 FIND v(dout0_44) AT=115.025n

* CHECK dout0_45 Vdout0_45ck22 = 0.9 time = 115
.meas tran vdout0_45ck22 FIND v(dout0_45) AT=115.025n

* CHECK dout0_46 Vdout0_46ck22 = 0.9 time = 115
.meas tran vdout0_46ck22 FIND v(dout0_46) AT=115.025n

* CHECK dout0_47 Vdout0_47ck22 = 0 time = 115
.meas tran vdout0_47ck22 FIND v(dout0_47) AT=115.025n

* CHECK dout0_48 Vdout0_48ck22 = 0 time = 115
.meas tran vdout0_48ck22 FIND v(dout0_48) AT=115.025n

* CHECK dout0_49 Vdout0_49ck22 = 0.9 time = 115
.meas tran vdout0_49ck22 FIND v(dout0_49) AT=115.025n

* CHECK dout0_50 Vdout0_50ck22 = 0 time = 115
.meas tran vdout0_50ck22 FIND v(dout0_50) AT=115.025n

* CHECK dout0_51 Vdout0_51ck22 = 0.9 time = 115
.meas tran vdout0_51ck22 FIND v(dout0_51) AT=115.025n

* CHECK dout0_52 Vdout0_52ck22 = 0.9 time = 115
.meas tran vdout0_52ck22 FIND v(dout0_52) AT=115.025n

* CHECK dout0_53 Vdout0_53ck22 = 0 time = 115
.meas tran vdout0_53ck22 FIND v(dout0_53) AT=115.025n

* CHECK dout0_54 Vdout0_54ck22 = 0.9 time = 115
.meas tran vdout0_54ck22 FIND v(dout0_54) AT=115.025n

* CHECK dout0_55 Vdout0_55ck22 = 0 time = 115
.meas tran vdout0_55ck22 FIND v(dout0_55) AT=115.025n

* CHECK dout0_56 Vdout0_56ck22 = 0 time = 115
.meas tran vdout0_56ck22 FIND v(dout0_56) AT=115.025n

* CHECK dout0_57 Vdout0_57ck22 = 0 time = 115
.meas tran vdout0_57ck22 FIND v(dout0_57) AT=115.025n

* CHECK dout0_58 Vdout0_58ck22 = 0.9 time = 115
.meas tran vdout0_58ck22 FIND v(dout0_58) AT=115.025n

* CHECK dout0_59 Vdout0_59ck22 = 0 time = 115
.meas tran vdout0_59ck22 FIND v(dout0_59) AT=115.025n

* CHECK dout0_60 Vdout0_60ck22 = 0.9 time = 115
.meas tran vdout0_60ck22 FIND v(dout0_60) AT=115.025n

* CHECK dout0_61 Vdout0_61ck22 = 0.9 time = 115
.meas tran vdout0_61ck22 FIND v(dout0_61) AT=115.025n

* CHECK dout0_62 Vdout0_62ck22 = 0 time = 115
.meas tran vdout0_62ck22 FIND v(dout0_62) AT=115.025n

* CHECK dout0_63 Vdout0_63ck22 = 0 time = 115
.meas tran vdout0_63ck22 FIND v(dout0_63) AT=115.025n

* CHECK dout0_64 Vdout0_64ck22 = 0.9 time = 115
.meas tran vdout0_64ck22 FIND v(dout0_64) AT=115.025n

* CHECK dout0_65 Vdout0_65ck22 = 0 time = 115
.meas tran vdout0_65ck22 FIND v(dout0_65) AT=115.025n

* CHECK dout0_66 Vdout0_66ck22 = 0.9 time = 115
.meas tran vdout0_66ck22 FIND v(dout0_66) AT=115.025n

* CHECK dout0_67 Vdout0_67ck22 = 0.9 time = 115
.meas tran vdout0_67ck22 FIND v(dout0_67) AT=115.025n

* CHECK dout0_68 Vdout0_68ck22 = 0.9 time = 115
.meas tran vdout0_68ck22 FIND v(dout0_68) AT=115.025n

* CHECK dout0_69 Vdout0_69ck22 = 0 time = 115
.meas tran vdout0_69ck22 FIND v(dout0_69) AT=115.025n

* CHECK dout0_70 Vdout0_70ck22 = 0.9 time = 115
.meas tran vdout0_70ck22 FIND v(dout0_70) AT=115.025n

* CHECK dout0_71 Vdout0_71ck22 = 0.9 time = 115
.meas tran vdout0_71ck22 FIND v(dout0_71) AT=115.025n

* CHECK dout0_72 Vdout0_72ck22 = 0.9 time = 115
.meas tran vdout0_72ck22 FIND v(dout0_72) AT=115.025n

* CHECK dout0_73 Vdout0_73ck22 = 0 time = 115
.meas tran vdout0_73ck22 FIND v(dout0_73) AT=115.025n

* CHECK dout0_74 Vdout0_74ck22 = 0 time = 115
.meas tran vdout0_74ck22 FIND v(dout0_74) AT=115.025n

* CHECK dout0_75 Vdout0_75ck22 = 0.9 time = 115
.meas tran vdout0_75ck22 FIND v(dout0_75) AT=115.025n

* CHECK dout0_76 Vdout0_76ck22 = 0 time = 115
.meas tran vdout0_76ck22 FIND v(dout0_76) AT=115.025n

* CHECK dout0_77 Vdout0_77ck22 = 0.9 time = 115
.meas tran vdout0_77ck22 FIND v(dout0_77) AT=115.025n

* CHECK dout0_78 Vdout0_78ck22 = 0 time = 115
.meas tran vdout0_78ck22 FIND v(dout0_78) AT=115.025n

* CHECK dout0_79 Vdout0_79ck22 = 0.9 time = 115
.meas tran vdout0_79ck22 FIND v(dout0_79) AT=115.025n

* CHECK dout0_0 Vdout0_0ck23 = 0.9 time = 120
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=120.025n

* CHECK dout0_1 Vdout0_1ck23 = 0.9 time = 120
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=120.025n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 120
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=120.025n

* CHECK dout0_3 Vdout0_3ck23 = 0.9 time = 120
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=120.025n

* CHECK dout0_4 Vdout0_4ck23 = 0.9 time = 120
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=120.025n

* CHECK dout0_5 Vdout0_5ck23 = 0.9 time = 120
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=120.025n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 120
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=120.025n

* CHECK dout0_7 Vdout0_7ck23 = 0.9 time = 120
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=120.025n

* CHECK dout0_8 Vdout0_8ck23 = 0 time = 120
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=120.025n

* CHECK dout0_9 Vdout0_9ck23 = 0.9 time = 120
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=120.025n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 120
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=120.025n

* CHECK dout0_11 Vdout0_11ck23 = 0.9 time = 120
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=120.025n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 120
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=120.025n

* CHECK dout0_13 Vdout0_13ck23 = 0.9 time = 120
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=120.025n

* CHECK dout0_14 Vdout0_14ck23 = 0 time = 120
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=120.025n

* CHECK dout0_15 Vdout0_15ck23 = 0.9 time = 120
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=120.025n

* CHECK dout0_16 Vdout0_16ck23 = 0 time = 120
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=120.025n

* CHECK dout0_17 Vdout0_17ck23 = 0.9 time = 120
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=120.025n

* CHECK dout0_18 Vdout0_18ck23 = 0.9 time = 120
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=120.025n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 120
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=120.025n

* CHECK dout0_20 Vdout0_20ck23 = 0.9 time = 120
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=120.025n

* CHECK dout0_21 Vdout0_21ck23 = 0.9 time = 120
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=120.025n

* CHECK dout0_22 Vdout0_22ck23 = 0.9 time = 120
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=120.025n

* CHECK dout0_23 Vdout0_23ck23 = 0.9 time = 120
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=120.025n

* CHECK dout0_24 Vdout0_24ck23 = 0.9 time = 120
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=120.025n

* CHECK dout0_25 Vdout0_25ck23 = 0.9 time = 120
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=120.025n

* CHECK dout0_26 Vdout0_26ck23 = 0.9 time = 120
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=120.025n

* CHECK dout0_27 Vdout0_27ck23 = 0 time = 120
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=120.025n

* CHECK dout0_28 Vdout0_28ck23 = 0 time = 120
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=120.025n

* CHECK dout0_29 Vdout0_29ck23 = 0.9 time = 120
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=120.025n

* CHECK dout0_30 Vdout0_30ck23 = 0.9 time = 120
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=120.025n

* CHECK dout0_31 Vdout0_31ck23 = 0.9 time = 120
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=120.025n

* CHECK dout0_32 Vdout0_32ck23 = 0.9 time = 120
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=120.025n

* CHECK dout0_33 Vdout0_33ck23 = 0 time = 120
.meas tran vdout0_33ck23 FIND v(dout0_33) AT=120.025n

* CHECK dout0_34 Vdout0_34ck23 = 0 time = 120
.meas tran vdout0_34ck23 FIND v(dout0_34) AT=120.025n

* CHECK dout0_35 Vdout0_35ck23 = 0.9 time = 120
.meas tran vdout0_35ck23 FIND v(dout0_35) AT=120.025n

* CHECK dout0_36 Vdout0_36ck23 = 0 time = 120
.meas tran vdout0_36ck23 FIND v(dout0_36) AT=120.025n

* CHECK dout0_37 Vdout0_37ck23 = 0.9 time = 120
.meas tran vdout0_37ck23 FIND v(dout0_37) AT=120.025n

* CHECK dout0_38 Vdout0_38ck23 = 0 time = 120
.meas tran vdout0_38ck23 FIND v(dout0_38) AT=120.025n

* CHECK dout0_39 Vdout0_39ck23 = 0 time = 120
.meas tran vdout0_39ck23 FIND v(dout0_39) AT=120.025n

* CHECK dout0_40 Vdout0_40ck23 = 0.9 time = 120
.meas tran vdout0_40ck23 FIND v(dout0_40) AT=120.025n

* CHECK dout0_41 Vdout0_41ck23 = 0.9 time = 120
.meas tran vdout0_41ck23 FIND v(dout0_41) AT=120.025n

* CHECK dout0_42 Vdout0_42ck23 = 0 time = 120
.meas tran vdout0_42ck23 FIND v(dout0_42) AT=120.025n

* CHECK dout0_43 Vdout0_43ck23 = 0 time = 120
.meas tran vdout0_43ck23 FIND v(dout0_43) AT=120.025n

* CHECK dout0_44 Vdout0_44ck23 = 0 time = 120
.meas tran vdout0_44ck23 FIND v(dout0_44) AT=120.025n

* CHECK dout0_45 Vdout0_45ck23 = 0 time = 120
.meas tran vdout0_45ck23 FIND v(dout0_45) AT=120.025n

* CHECK dout0_46 Vdout0_46ck23 = 0.9 time = 120
.meas tran vdout0_46ck23 FIND v(dout0_46) AT=120.025n

* CHECK dout0_47 Vdout0_47ck23 = 0.9 time = 120
.meas tran vdout0_47ck23 FIND v(dout0_47) AT=120.025n

* CHECK dout0_48 Vdout0_48ck23 = 0 time = 120
.meas tran vdout0_48ck23 FIND v(dout0_48) AT=120.025n

* CHECK dout0_49 Vdout0_49ck23 = 0.9 time = 120
.meas tran vdout0_49ck23 FIND v(dout0_49) AT=120.025n

* CHECK dout0_50 Vdout0_50ck23 = 0.9 time = 120
.meas tran vdout0_50ck23 FIND v(dout0_50) AT=120.025n

* CHECK dout0_51 Vdout0_51ck23 = 0 time = 120
.meas tran vdout0_51ck23 FIND v(dout0_51) AT=120.025n

* CHECK dout0_52 Vdout0_52ck23 = 0 time = 120
.meas tran vdout0_52ck23 FIND v(dout0_52) AT=120.025n

* CHECK dout0_53 Vdout0_53ck23 = 0 time = 120
.meas tran vdout0_53ck23 FIND v(dout0_53) AT=120.025n

* CHECK dout0_54 Vdout0_54ck23 = 0.9 time = 120
.meas tran vdout0_54ck23 FIND v(dout0_54) AT=120.025n

* CHECK dout0_55 Vdout0_55ck23 = 0 time = 120
.meas tran vdout0_55ck23 FIND v(dout0_55) AT=120.025n

* CHECK dout0_56 Vdout0_56ck23 = 0 time = 120
.meas tran vdout0_56ck23 FIND v(dout0_56) AT=120.025n

* CHECK dout0_57 Vdout0_57ck23 = 0 time = 120
.meas tran vdout0_57ck23 FIND v(dout0_57) AT=120.025n

* CHECK dout0_58 Vdout0_58ck23 = 0 time = 120
.meas tran vdout0_58ck23 FIND v(dout0_58) AT=120.025n

* CHECK dout0_59 Vdout0_59ck23 = 0 time = 120
.meas tran vdout0_59ck23 FIND v(dout0_59) AT=120.025n

* CHECK dout0_60 Vdout0_60ck23 = 0 time = 120
.meas tran vdout0_60ck23 FIND v(dout0_60) AT=120.025n

* CHECK dout0_61 Vdout0_61ck23 = 0.9 time = 120
.meas tran vdout0_61ck23 FIND v(dout0_61) AT=120.025n

* CHECK dout0_62 Vdout0_62ck23 = 0.9 time = 120
.meas tran vdout0_62ck23 FIND v(dout0_62) AT=120.025n

* CHECK dout0_63 Vdout0_63ck23 = 0 time = 120
.meas tran vdout0_63ck23 FIND v(dout0_63) AT=120.025n

* CHECK dout0_64 Vdout0_64ck23 = 0 time = 120
.meas tran vdout0_64ck23 FIND v(dout0_64) AT=120.025n

* CHECK dout0_65 Vdout0_65ck23 = 0 time = 120
.meas tran vdout0_65ck23 FIND v(dout0_65) AT=120.025n

* CHECK dout0_66 Vdout0_66ck23 = 0 time = 120
.meas tran vdout0_66ck23 FIND v(dout0_66) AT=120.025n

* CHECK dout0_67 Vdout0_67ck23 = 0 time = 120
.meas tran vdout0_67ck23 FIND v(dout0_67) AT=120.025n

* CHECK dout0_68 Vdout0_68ck23 = 0 time = 120
.meas tran vdout0_68ck23 FIND v(dout0_68) AT=120.025n

* CHECK dout0_69 Vdout0_69ck23 = 0 time = 120
.meas tran vdout0_69ck23 FIND v(dout0_69) AT=120.025n

* CHECK dout0_70 Vdout0_70ck23 = 0.9 time = 120
.meas tran vdout0_70ck23 FIND v(dout0_70) AT=120.025n

* CHECK dout0_71 Vdout0_71ck23 = 0 time = 120
.meas tran vdout0_71ck23 FIND v(dout0_71) AT=120.025n

* CHECK dout0_72 Vdout0_72ck23 = 0 time = 120
.meas tran vdout0_72ck23 FIND v(dout0_72) AT=120.025n

* CHECK dout0_73 Vdout0_73ck23 = 0 time = 120
.meas tran vdout0_73ck23 FIND v(dout0_73) AT=120.025n

* CHECK dout0_74 Vdout0_74ck23 = 0.9 time = 120
.meas tran vdout0_74ck23 FIND v(dout0_74) AT=120.025n

* CHECK dout0_75 Vdout0_75ck23 = 0.9 time = 120
.meas tran vdout0_75ck23 FIND v(dout0_75) AT=120.025n

* CHECK dout0_76 Vdout0_76ck23 = 0 time = 120
.meas tran vdout0_76ck23 FIND v(dout0_76) AT=120.025n

* CHECK dout0_77 Vdout0_77ck23 = 0 time = 120
.meas tran vdout0_77ck23 FIND v(dout0_77) AT=120.025n

* CHECK dout0_78 Vdout0_78ck23 = 0.9 time = 120
.meas tran vdout0_78ck23 FIND v(dout0_78) AT=120.025n

* CHECK dout0_79 Vdout0_79ck23 = 0 time = 120
.meas tran vdout0_79ck23 FIND v(dout0_79) AT=120.025n

* CHECK dout0_0 Vdout0_0ck25 = 0.9 time = 130
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=130.025n

* CHECK dout0_1 Vdout0_1ck25 = 0.9 time = 130
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=130.025n

* CHECK dout0_2 Vdout0_2ck25 = 0 time = 130
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=130.025n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 130
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=130.025n

* CHECK dout0_4 Vdout0_4ck25 = 0 time = 130
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=130.025n

* CHECK dout0_5 Vdout0_5ck25 = 0 time = 130
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=130.025n

* CHECK dout0_6 Vdout0_6ck25 = 0 time = 130
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=130.025n

* CHECK dout0_7 Vdout0_7ck25 = 0 time = 130
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=130.025n

* CHECK dout0_8 Vdout0_8ck25 = 0 time = 130
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=130.025n

* CHECK dout0_9 Vdout0_9ck25 = 0.9 time = 130
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=130.025n

* CHECK dout0_10 Vdout0_10ck25 = 0 time = 130
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=130.025n

* CHECK dout0_11 Vdout0_11ck25 = 0 time = 130
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=130.025n

* CHECK dout0_12 Vdout0_12ck25 = 0.9 time = 130
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=130.025n

* CHECK dout0_13 Vdout0_13ck25 = 0 time = 130
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=130.025n

* CHECK dout0_14 Vdout0_14ck25 = 0.9 time = 130
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=130.025n

* CHECK dout0_15 Vdout0_15ck25 = 0 time = 130
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=130.025n

* CHECK dout0_16 Vdout0_16ck25 = 0 time = 130
.meas tran vdout0_16ck25 FIND v(dout0_16) AT=130.025n

* CHECK dout0_17 Vdout0_17ck25 = 0.9 time = 130
.meas tran vdout0_17ck25 FIND v(dout0_17) AT=130.025n

* CHECK dout0_18 Vdout0_18ck25 = 0.9 time = 130
.meas tran vdout0_18ck25 FIND v(dout0_18) AT=130.025n

* CHECK dout0_19 Vdout0_19ck25 = 0 time = 130
.meas tran vdout0_19ck25 FIND v(dout0_19) AT=130.025n

* CHECK dout0_20 Vdout0_20ck25 = 0 time = 130
.meas tran vdout0_20ck25 FIND v(dout0_20) AT=130.025n

* CHECK dout0_21 Vdout0_21ck25 = 0.9 time = 130
.meas tran vdout0_21ck25 FIND v(dout0_21) AT=130.025n

* CHECK dout0_22 Vdout0_22ck25 = 0 time = 130
.meas tran vdout0_22ck25 FIND v(dout0_22) AT=130.025n

* CHECK dout0_23 Vdout0_23ck25 = 0.9 time = 130
.meas tran vdout0_23ck25 FIND v(dout0_23) AT=130.025n

* CHECK dout0_24 Vdout0_24ck25 = 0.9 time = 130
.meas tran vdout0_24ck25 FIND v(dout0_24) AT=130.025n

* CHECK dout0_25 Vdout0_25ck25 = 0 time = 130
.meas tran vdout0_25ck25 FIND v(dout0_25) AT=130.025n

* CHECK dout0_26 Vdout0_26ck25 = 0.9 time = 130
.meas tran vdout0_26ck25 FIND v(dout0_26) AT=130.025n

* CHECK dout0_27 Vdout0_27ck25 = 0 time = 130
.meas tran vdout0_27ck25 FIND v(dout0_27) AT=130.025n

* CHECK dout0_28 Vdout0_28ck25 = 0 time = 130
.meas tran vdout0_28ck25 FIND v(dout0_28) AT=130.025n

* CHECK dout0_29 Vdout0_29ck25 = 0.9 time = 130
.meas tran vdout0_29ck25 FIND v(dout0_29) AT=130.025n

* CHECK dout0_30 Vdout0_30ck25 = 0.9 time = 130
.meas tran vdout0_30ck25 FIND v(dout0_30) AT=130.025n

* CHECK dout0_31 Vdout0_31ck25 = 0.9 time = 130
.meas tran vdout0_31ck25 FIND v(dout0_31) AT=130.025n

* CHECK dout0_32 Vdout0_32ck25 = 0 time = 130
.meas tran vdout0_32ck25 FIND v(dout0_32) AT=130.025n

* CHECK dout0_33 Vdout0_33ck25 = 0.9 time = 130
.meas tran vdout0_33ck25 FIND v(dout0_33) AT=130.025n

* CHECK dout0_34 Vdout0_34ck25 = 0.9 time = 130
.meas tran vdout0_34ck25 FIND v(dout0_34) AT=130.025n

* CHECK dout0_35 Vdout0_35ck25 = 0 time = 130
.meas tran vdout0_35ck25 FIND v(dout0_35) AT=130.025n

* CHECK dout0_36 Vdout0_36ck25 = 0 time = 130
.meas tran vdout0_36ck25 FIND v(dout0_36) AT=130.025n

* CHECK dout0_37 Vdout0_37ck25 = 0 time = 130
.meas tran vdout0_37ck25 FIND v(dout0_37) AT=130.025n

* CHECK dout0_38 Vdout0_38ck25 = 0 time = 130
.meas tran vdout0_38ck25 FIND v(dout0_38) AT=130.025n

* CHECK dout0_39 Vdout0_39ck25 = 0 time = 130
.meas tran vdout0_39ck25 FIND v(dout0_39) AT=130.025n

* CHECK dout0_40 Vdout0_40ck25 = 0.9 time = 130
.meas tran vdout0_40ck25 FIND v(dout0_40) AT=130.025n

* CHECK dout0_41 Vdout0_41ck25 = 0.9 time = 130
.meas tran vdout0_41ck25 FIND v(dout0_41) AT=130.025n

* CHECK dout0_42 Vdout0_42ck25 = 0 time = 130
.meas tran vdout0_42ck25 FIND v(dout0_42) AT=130.025n

* CHECK dout0_43 Vdout0_43ck25 = 0.9 time = 130
.meas tran vdout0_43ck25 FIND v(dout0_43) AT=130.025n

* CHECK dout0_44 Vdout0_44ck25 = 0.9 time = 130
.meas tran vdout0_44ck25 FIND v(dout0_44) AT=130.025n

* CHECK dout0_45 Vdout0_45ck25 = 0.9 time = 130
.meas tran vdout0_45ck25 FIND v(dout0_45) AT=130.025n

* CHECK dout0_46 Vdout0_46ck25 = 0.9 time = 130
.meas tran vdout0_46ck25 FIND v(dout0_46) AT=130.025n

* CHECK dout0_47 Vdout0_47ck25 = 0 time = 130
.meas tran vdout0_47ck25 FIND v(dout0_47) AT=130.025n

* CHECK dout0_48 Vdout0_48ck25 = 0 time = 130
.meas tran vdout0_48ck25 FIND v(dout0_48) AT=130.025n

* CHECK dout0_49 Vdout0_49ck25 = 0.9 time = 130
.meas tran vdout0_49ck25 FIND v(dout0_49) AT=130.025n

* CHECK dout0_50 Vdout0_50ck25 = 0 time = 130
.meas tran vdout0_50ck25 FIND v(dout0_50) AT=130.025n

* CHECK dout0_51 Vdout0_51ck25 = 0.9 time = 130
.meas tran vdout0_51ck25 FIND v(dout0_51) AT=130.025n

* CHECK dout0_52 Vdout0_52ck25 = 0.9 time = 130
.meas tran vdout0_52ck25 FIND v(dout0_52) AT=130.025n

* CHECK dout0_53 Vdout0_53ck25 = 0 time = 130
.meas tran vdout0_53ck25 FIND v(dout0_53) AT=130.025n

* CHECK dout0_54 Vdout0_54ck25 = 0.9 time = 130
.meas tran vdout0_54ck25 FIND v(dout0_54) AT=130.025n

* CHECK dout0_55 Vdout0_55ck25 = 0 time = 130
.meas tran vdout0_55ck25 FIND v(dout0_55) AT=130.025n

* CHECK dout0_56 Vdout0_56ck25 = 0 time = 130
.meas tran vdout0_56ck25 FIND v(dout0_56) AT=130.025n

* CHECK dout0_57 Vdout0_57ck25 = 0 time = 130
.meas tran vdout0_57ck25 FIND v(dout0_57) AT=130.025n

* CHECK dout0_58 Vdout0_58ck25 = 0.9 time = 130
.meas tran vdout0_58ck25 FIND v(dout0_58) AT=130.025n

* CHECK dout0_59 Vdout0_59ck25 = 0 time = 130
.meas tran vdout0_59ck25 FIND v(dout0_59) AT=130.025n

* CHECK dout0_60 Vdout0_60ck25 = 0.9 time = 130
.meas tran vdout0_60ck25 FIND v(dout0_60) AT=130.025n

* CHECK dout0_61 Vdout0_61ck25 = 0.9 time = 130
.meas tran vdout0_61ck25 FIND v(dout0_61) AT=130.025n

* CHECK dout0_62 Vdout0_62ck25 = 0 time = 130
.meas tran vdout0_62ck25 FIND v(dout0_62) AT=130.025n

* CHECK dout0_63 Vdout0_63ck25 = 0 time = 130
.meas tran vdout0_63ck25 FIND v(dout0_63) AT=130.025n

* CHECK dout0_64 Vdout0_64ck25 = 0.9 time = 130
.meas tran vdout0_64ck25 FIND v(dout0_64) AT=130.025n

* CHECK dout0_65 Vdout0_65ck25 = 0 time = 130
.meas tran vdout0_65ck25 FIND v(dout0_65) AT=130.025n

* CHECK dout0_66 Vdout0_66ck25 = 0.9 time = 130
.meas tran vdout0_66ck25 FIND v(dout0_66) AT=130.025n

* CHECK dout0_67 Vdout0_67ck25 = 0.9 time = 130
.meas tran vdout0_67ck25 FIND v(dout0_67) AT=130.025n

* CHECK dout0_68 Vdout0_68ck25 = 0.9 time = 130
.meas tran vdout0_68ck25 FIND v(dout0_68) AT=130.025n

* CHECK dout0_69 Vdout0_69ck25 = 0 time = 130
.meas tran vdout0_69ck25 FIND v(dout0_69) AT=130.025n

* CHECK dout0_70 Vdout0_70ck25 = 0.9 time = 130
.meas tran vdout0_70ck25 FIND v(dout0_70) AT=130.025n

* CHECK dout0_71 Vdout0_71ck25 = 0.9 time = 130
.meas tran vdout0_71ck25 FIND v(dout0_71) AT=130.025n

* CHECK dout0_72 Vdout0_72ck25 = 0.9 time = 130
.meas tran vdout0_72ck25 FIND v(dout0_72) AT=130.025n

* CHECK dout0_73 Vdout0_73ck25 = 0 time = 130
.meas tran vdout0_73ck25 FIND v(dout0_73) AT=130.025n

* CHECK dout0_74 Vdout0_74ck25 = 0 time = 130
.meas tran vdout0_74ck25 FIND v(dout0_74) AT=130.025n

* CHECK dout0_75 Vdout0_75ck25 = 0.9 time = 130
.meas tran vdout0_75ck25 FIND v(dout0_75) AT=130.025n

* CHECK dout0_76 Vdout0_76ck25 = 0 time = 130
.meas tran vdout0_76ck25 FIND v(dout0_76) AT=130.025n

* CHECK dout0_77 Vdout0_77ck25 = 0.9 time = 130
.meas tran vdout0_77ck25 FIND v(dout0_77) AT=130.025n

* CHECK dout0_78 Vdout0_78ck25 = 0 time = 130
.meas tran vdout0_78ck25 FIND v(dout0_78) AT=130.025n

* CHECK dout0_79 Vdout0_79ck25 = 0.9 time = 130
.meas tran vdout0_79ck25 FIND v(dout0_79) AT=130.025n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 165
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=165.025n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 165
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=165.025n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 165
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=165.025n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 165
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=165.025n

* CHECK dout0_4 Vdout0_4ck32 = 0 time = 165
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=165.025n

* CHECK dout0_5 Vdout0_5ck32 = 0.9 time = 165
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=165.025n

* CHECK dout0_6 Vdout0_6ck32 = 0 time = 165
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=165.025n

* CHECK dout0_7 Vdout0_7ck32 = 0 time = 165
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=165.025n

* CHECK dout0_8 Vdout0_8ck32 = 0.9 time = 165
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=165.025n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 165
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=165.025n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 165
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=165.025n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 165
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=165.025n

* CHECK dout0_12 Vdout0_12ck32 = 0.9 time = 165
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=165.025n

* CHECK dout0_13 Vdout0_13ck32 = 0.9 time = 165
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=165.025n

* CHECK dout0_14 Vdout0_14ck32 = 0.9 time = 165
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=165.025n

* CHECK dout0_15 Vdout0_15ck32 = 0.9 time = 165
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=165.025n

* CHECK dout0_16 Vdout0_16ck32 = 0.9 time = 165
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=165.025n

* CHECK dout0_17 Vdout0_17ck32 = 0 time = 165
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=165.025n

* CHECK dout0_18 Vdout0_18ck32 = 0 time = 165
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=165.025n

* CHECK dout0_19 Vdout0_19ck32 = 0.9 time = 165
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=165.025n

* CHECK dout0_20 Vdout0_20ck32 = 0 time = 165
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=165.025n

* CHECK dout0_21 Vdout0_21ck32 = 0 time = 165
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=165.025n

* CHECK dout0_22 Vdout0_22ck32 = 0.9 time = 165
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=165.025n

* CHECK dout0_23 Vdout0_23ck32 = 0.9 time = 165
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=165.025n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 165
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=165.025n

* CHECK dout0_25 Vdout0_25ck32 = 0.9 time = 165
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=165.025n

* CHECK dout0_26 Vdout0_26ck32 = 0 time = 165
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=165.025n

* CHECK dout0_27 Vdout0_27ck32 = 0 time = 165
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=165.025n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 165
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=165.025n

* CHECK dout0_29 Vdout0_29ck32 = 0.9 time = 165
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=165.025n

* CHECK dout0_30 Vdout0_30ck32 = 0.9 time = 165
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=165.025n

* CHECK dout0_31 Vdout0_31ck32 = 0 time = 165
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=165.025n

* CHECK dout0_32 Vdout0_32ck32 = 0 time = 165
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=165.025n

* CHECK dout0_33 Vdout0_33ck32 = 0 time = 165
.meas tran vdout0_33ck32 FIND v(dout0_33) AT=165.025n

* CHECK dout0_34 Vdout0_34ck32 = 0.9 time = 165
.meas tran vdout0_34ck32 FIND v(dout0_34) AT=165.025n

* CHECK dout0_35 Vdout0_35ck32 = 0.9 time = 165
.meas tran vdout0_35ck32 FIND v(dout0_35) AT=165.025n

* CHECK dout0_36 Vdout0_36ck32 = 0.9 time = 165
.meas tran vdout0_36ck32 FIND v(dout0_36) AT=165.025n

* CHECK dout0_37 Vdout0_37ck32 = 0 time = 165
.meas tran vdout0_37ck32 FIND v(dout0_37) AT=165.025n

* CHECK dout0_38 Vdout0_38ck32 = 0 time = 165
.meas tran vdout0_38ck32 FIND v(dout0_38) AT=165.025n

* CHECK dout0_39 Vdout0_39ck32 = 0 time = 165
.meas tran vdout0_39ck32 FIND v(dout0_39) AT=165.025n

* CHECK dout0_40 Vdout0_40ck32 = 0.9 time = 165
.meas tran vdout0_40ck32 FIND v(dout0_40) AT=165.025n

* CHECK dout0_41 Vdout0_41ck32 = 0.9 time = 165
.meas tran vdout0_41ck32 FIND v(dout0_41) AT=165.025n

* CHECK dout0_42 Vdout0_42ck32 = 0 time = 165
.meas tran vdout0_42ck32 FIND v(dout0_42) AT=165.025n

* CHECK dout0_43 Vdout0_43ck32 = 0.9 time = 165
.meas tran vdout0_43ck32 FIND v(dout0_43) AT=165.025n

* CHECK dout0_44 Vdout0_44ck32 = 0 time = 165
.meas tran vdout0_44ck32 FIND v(dout0_44) AT=165.025n

* CHECK dout0_45 Vdout0_45ck32 = 0.9 time = 165
.meas tran vdout0_45ck32 FIND v(dout0_45) AT=165.025n

* CHECK dout0_46 Vdout0_46ck32 = 0 time = 165
.meas tran vdout0_46ck32 FIND v(dout0_46) AT=165.025n

* CHECK dout0_47 Vdout0_47ck32 = 0 time = 165
.meas tran vdout0_47ck32 FIND v(dout0_47) AT=165.025n

* CHECK dout0_48 Vdout0_48ck32 = 0.9 time = 165
.meas tran vdout0_48ck32 FIND v(dout0_48) AT=165.025n

* CHECK dout0_49 Vdout0_49ck32 = 0 time = 165
.meas tran vdout0_49ck32 FIND v(dout0_49) AT=165.025n

* CHECK dout0_50 Vdout0_50ck32 = 0 time = 165
.meas tran vdout0_50ck32 FIND v(dout0_50) AT=165.025n

* CHECK dout0_51 Vdout0_51ck32 = 0 time = 165
.meas tran vdout0_51ck32 FIND v(dout0_51) AT=165.025n

* CHECK dout0_52 Vdout0_52ck32 = 0 time = 165
.meas tran vdout0_52ck32 FIND v(dout0_52) AT=165.025n

* CHECK dout0_53 Vdout0_53ck32 = 0 time = 165
.meas tran vdout0_53ck32 FIND v(dout0_53) AT=165.025n

* CHECK dout0_54 Vdout0_54ck32 = 0.9 time = 165
.meas tran vdout0_54ck32 FIND v(dout0_54) AT=165.025n

* CHECK dout0_55 Vdout0_55ck32 = 0.9 time = 165
.meas tran vdout0_55ck32 FIND v(dout0_55) AT=165.025n

* CHECK dout0_56 Vdout0_56ck32 = 0 time = 165
.meas tran vdout0_56ck32 FIND v(dout0_56) AT=165.025n

* CHECK dout0_57 Vdout0_57ck32 = 0 time = 165
.meas tran vdout0_57ck32 FIND v(dout0_57) AT=165.025n

* CHECK dout0_58 Vdout0_58ck32 = 0.9 time = 165
.meas tran vdout0_58ck32 FIND v(dout0_58) AT=165.025n

* CHECK dout0_59 Vdout0_59ck32 = 0 time = 165
.meas tran vdout0_59ck32 FIND v(dout0_59) AT=165.025n

* CHECK dout0_60 Vdout0_60ck32 = 0.9 time = 165
.meas tran vdout0_60ck32 FIND v(dout0_60) AT=165.025n

* CHECK dout0_61 Vdout0_61ck32 = 0.9 time = 165
.meas tran vdout0_61ck32 FIND v(dout0_61) AT=165.025n

* CHECK dout0_62 Vdout0_62ck32 = 0.9 time = 165
.meas tran vdout0_62ck32 FIND v(dout0_62) AT=165.025n

* CHECK dout0_63 Vdout0_63ck32 = 0 time = 165
.meas tran vdout0_63ck32 FIND v(dout0_63) AT=165.025n

* CHECK dout0_64 Vdout0_64ck32 = 0.9 time = 165
.meas tran vdout0_64ck32 FIND v(dout0_64) AT=165.025n

* CHECK dout0_65 Vdout0_65ck32 = 0.9 time = 165
.meas tran vdout0_65ck32 FIND v(dout0_65) AT=165.025n

* CHECK dout0_66 Vdout0_66ck32 = 0 time = 165
.meas tran vdout0_66ck32 FIND v(dout0_66) AT=165.025n

* CHECK dout0_67 Vdout0_67ck32 = 0.9 time = 165
.meas tran vdout0_67ck32 FIND v(dout0_67) AT=165.025n

* CHECK dout0_68 Vdout0_68ck32 = 0 time = 165
.meas tran vdout0_68ck32 FIND v(dout0_68) AT=165.025n

* CHECK dout0_69 Vdout0_69ck32 = 0 time = 165
.meas tran vdout0_69ck32 FIND v(dout0_69) AT=165.025n

* CHECK dout0_70 Vdout0_70ck32 = 0.9 time = 165
.meas tran vdout0_70ck32 FIND v(dout0_70) AT=165.025n

* CHECK dout0_71 Vdout0_71ck32 = 0 time = 165
.meas tran vdout0_71ck32 FIND v(dout0_71) AT=165.025n

* CHECK dout0_72 Vdout0_72ck32 = 0.9 time = 165
.meas tran vdout0_72ck32 FIND v(dout0_72) AT=165.025n

* CHECK dout0_73 Vdout0_73ck32 = 0.9 time = 165
.meas tran vdout0_73ck32 FIND v(dout0_73) AT=165.025n

* CHECK dout0_74 Vdout0_74ck32 = 0.9 time = 165
.meas tran vdout0_74ck32 FIND v(dout0_74) AT=165.025n

* CHECK dout0_75 Vdout0_75ck32 = 0.9 time = 165
.meas tran vdout0_75ck32 FIND v(dout0_75) AT=165.025n

* CHECK dout0_76 Vdout0_76ck32 = 0.9 time = 165
.meas tran vdout0_76ck32 FIND v(dout0_76) AT=165.025n

* CHECK dout0_77 Vdout0_77ck32 = 0.9 time = 165
.meas tran vdout0_77ck32 FIND v(dout0_77) AT=165.025n

* CHECK dout0_78 Vdout0_78ck32 = 0 time = 165
.meas tran vdout0_78ck32 FIND v(dout0_78) AT=165.025n

* CHECK dout0_79 Vdout0_79ck32 = 0.9 time = 165
.meas tran vdout0_79ck32 FIND v(dout0_79) AT=165.025n

* CHECK dout0_0 Vdout0_0ck34 = 0.9 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 0.9 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 0.9 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 0.9 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0.9 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 0.9 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 0.9 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 0.9 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 0.9 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 0 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 0 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 0 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 0.9 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 0.9 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 0 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 0.9 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 0.9 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0.9 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 0.9 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 0.9 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 0.9 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 0 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 0 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_32 Vdout0_32ck34 = 0.9 time = 175
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=175.025n

* CHECK dout0_33 Vdout0_33ck34 = 0.9 time = 175
.meas tran vdout0_33ck34 FIND v(dout0_33) AT=175.025n

* CHECK dout0_34 Vdout0_34ck34 = 0 time = 175
.meas tran vdout0_34ck34 FIND v(dout0_34) AT=175.025n

* CHECK dout0_35 Vdout0_35ck34 = 0 time = 175
.meas tran vdout0_35ck34 FIND v(dout0_35) AT=175.025n

* CHECK dout0_36 Vdout0_36ck34 = 0.9 time = 175
.meas tran vdout0_36ck34 FIND v(dout0_36) AT=175.025n

* CHECK dout0_37 Vdout0_37ck34 = 0 time = 175
.meas tran vdout0_37ck34 FIND v(dout0_37) AT=175.025n

* CHECK dout0_38 Vdout0_38ck34 = 0.9 time = 175
.meas tran vdout0_38ck34 FIND v(dout0_38) AT=175.025n

* CHECK dout0_39 Vdout0_39ck34 = 0 time = 175
.meas tran vdout0_39ck34 FIND v(dout0_39) AT=175.025n

* CHECK dout0_40 Vdout0_40ck34 = 0 time = 175
.meas tran vdout0_40ck34 FIND v(dout0_40) AT=175.025n

* CHECK dout0_41 Vdout0_41ck34 = 0.9 time = 175
.meas tran vdout0_41ck34 FIND v(dout0_41) AT=175.025n

* CHECK dout0_42 Vdout0_42ck34 = 0.9 time = 175
.meas tran vdout0_42ck34 FIND v(dout0_42) AT=175.025n

* CHECK dout0_43 Vdout0_43ck34 = 0 time = 175
.meas tran vdout0_43ck34 FIND v(dout0_43) AT=175.025n

* CHECK dout0_44 Vdout0_44ck34 = 0.9 time = 175
.meas tran vdout0_44ck34 FIND v(dout0_44) AT=175.025n

* CHECK dout0_45 Vdout0_45ck34 = 0.9 time = 175
.meas tran vdout0_45ck34 FIND v(dout0_45) AT=175.025n

* CHECK dout0_46 Vdout0_46ck34 = 0.9 time = 175
.meas tran vdout0_46ck34 FIND v(dout0_46) AT=175.025n

* CHECK dout0_47 Vdout0_47ck34 = 0 time = 175
.meas tran vdout0_47ck34 FIND v(dout0_47) AT=175.025n

* CHECK dout0_48 Vdout0_48ck34 = 0.9 time = 175
.meas tran vdout0_48ck34 FIND v(dout0_48) AT=175.025n

* CHECK dout0_49 Vdout0_49ck34 = 0.9 time = 175
.meas tran vdout0_49ck34 FIND v(dout0_49) AT=175.025n

* CHECK dout0_50 Vdout0_50ck34 = 0.9 time = 175
.meas tran vdout0_50ck34 FIND v(dout0_50) AT=175.025n

* CHECK dout0_51 Vdout0_51ck34 = 0 time = 175
.meas tran vdout0_51ck34 FIND v(dout0_51) AT=175.025n

* CHECK dout0_52 Vdout0_52ck34 = 0.9 time = 175
.meas tran vdout0_52ck34 FIND v(dout0_52) AT=175.025n

* CHECK dout0_53 Vdout0_53ck34 = 0 time = 175
.meas tran vdout0_53ck34 FIND v(dout0_53) AT=175.025n

* CHECK dout0_54 Vdout0_54ck34 = 0 time = 175
.meas tran vdout0_54ck34 FIND v(dout0_54) AT=175.025n

* CHECK dout0_55 Vdout0_55ck34 = 0.9 time = 175
.meas tran vdout0_55ck34 FIND v(dout0_55) AT=175.025n

* CHECK dout0_56 Vdout0_56ck34 = 0.9 time = 175
.meas tran vdout0_56ck34 FIND v(dout0_56) AT=175.025n

* CHECK dout0_57 Vdout0_57ck34 = 0 time = 175
.meas tran vdout0_57ck34 FIND v(dout0_57) AT=175.025n

* CHECK dout0_58 Vdout0_58ck34 = 0 time = 175
.meas tran vdout0_58ck34 FIND v(dout0_58) AT=175.025n

* CHECK dout0_59 Vdout0_59ck34 = 0.9 time = 175
.meas tran vdout0_59ck34 FIND v(dout0_59) AT=175.025n

* CHECK dout0_60 Vdout0_60ck34 = 0.9 time = 175
.meas tran vdout0_60ck34 FIND v(dout0_60) AT=175.025n

* CHECK dout0_61 Vdout0_61ck34 = 0.9 time = 175
.meas tran vdout0_61ck34 FIND v(dout0_61) AT=175.025n

* CHECK dout0_62 Vdout0_62ck34 = 0 time = 175
.meas tran vdout0_62ck34 FIND v(dout0_62) AT=175.025n

* CHECK dout0_63 Vdout0_63ck34 = 0.9 time = 175
.meas tran vdout0_63ck34 FIND v(dout0_63) AT=175.025n

* CHECK dout0_64 Vdout0_64ck34 = 0 time = 175
.meas tran vdout0_64ck34 FIND v(dout0_64) AT=175.025n

* CHECK dout0_65 Vdout0_65ck34 = 0.9 time = 175
.meas tran vdout0_65ck34 FIND v(dout0_65) AT=175.025n

* CHECK dout0_66 Vdout0_66ck34 = 0 time = 175
.meas tran vdout0_66ck34 FIND v(dout0_66) AT=175.025n

* CHECK dout0_67 Vdout0_67ck34 = 0.9 time = 175
.meas tran vdout0_67ck34 FIND v(dout0_67) AT=175.025n

* CHECK dout0_68 Vdout0_68ck34 = 0 time = 175
.meas tran vdout0_68ck34 FIND v(dout0_68) AT=175.025n

* CHECK dout0_69 Vdout0_69ck34 = 0 time = 175
.meas tran vdout0_69ck34 FIND v(dout0_69) AT=175.025n

* CHECK dout0_70 Vdout0_70ck34 = 0 time = 175
.meas tran vdout0_70ck34 FIND v(dout0_70) AT=175.025n

* CHECK dout0_71 Vdout0_71ck34 = 0.9 time = 175
.meas tran vdout0_71ck34 FIND v(dout0_71) AT=175.025n

* CHECK dout0_72 Vdout0_72ck34 = 0 time = 175
.meas tran vdout0_72ck34 FIND v(dout0_72) AT=175.025n

* CHECK dout0_73 Vdout0_73ck34 = 0 time = 175
.meas tran vdout0_73ck34 FIND v(dout0_73) AT=175.025n

* CHECK dout0_74 Vdout0_74ck34 = 0.9 time = 175
.meas tran vdout0_74ck34 FIND v(dout0_74) AT=175.025n

* CHECK dout0_75 Vdout0_75ck34 = 0 time = 175
.meas tran vdout0_75ck34 FIND v(dout0_75) AT=175.025n

* CHECK dout0_76 Vdout0_76ck34 = 0.9 time = 175
.meas tran vdout0_76ck34 FIND v(dout0_76) AT=175.025n

* CHECK dout0_77 Vdout0_77ck34 = 0 time = 175
.meas tran vdout0_77ck34 FIND v(dout0_77) AT=175.025n

* CHECK dout0_78 Vdout0_78ck34 = 0.9 time = 175
.meas tran vdout0_78ck34 FIND v(dout0_78) AT=175.025n

* CHECK dout0_79 Vdout0_79ck34 = 0 time = 175
.meas tran vdout0_79ck34 FIND v(dout0_79) AT=175.025n

* CHECK dout0_0 Vdout0_0ck36 = 0.9 time = 185
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=185.025n

* CHECK dout0_1 Vdout0_1ck36 = 0.9 time = 185
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=185.025n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 185
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=185.025n

* CHECK dout0_3 Vdout0_3ck36 = 0.9 time = 185
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=185.025n

* CHECK dout0_4 Vdout0_4ck36 = 0 time = 185
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=185.025n

* CHECK dout0_5 Vdout0_5ck36 = 0.9 time = 185
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=185.025n

* CHECK dout0_6 Vdout0_6ck36 = 0 time = 185
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=185.025n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 185
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=185.025n

* CHECK dout0_8 Vdout0_8ck36 = 0 time = 185
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=185.025n

* CHECK dout0_9 Vdout0_9ck36 = 0.9 time = 185
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=185.025n

* CHECK dout0_10 Vdout0_10ck36 = 0.9 time = 185
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=185.025n

* CHECK dout0_11 Vdout0_11ck36 = 0 time = 185
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=185.025n

* CHECK dout0_12 Vdout0_12ck36 = 0.9 time = 185
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=185.025n

* CHECK dout0_13 Vdout0_13ck36 = 0.9 time = 185
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=185.025n

* CHECK dout0_14 Vdout0_14ck36 = 0 time = 185
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=185.025n

* CHECK dout0_15 Vdout0_15ck36 = 0 time = 185
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=185.025n

* CHECK dout0_16 Vdout0_16ck36 = 0.9 time = 185
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=185.025n

* CHECK dout0_17 Vdout0_17ck36 = 0 time = 185
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=185.025n

* CHECK dout0_18 Vdout0_18ck36 = 0 time = 185
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=185.025n

* CHECK dout0_19 Vdout0_19ck36 = 0 time = 185
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=185.025n

* CHECK dout0_20 Vdout0_20ck36 = 0.9 time = 185
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=185.025n

* CHECK dout0_21 Vdout0_21ck36 = 0.9 time = 185
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=185.025n

* CHECK dout0_22 Vdout0_22ck36 = 0 time = 185
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=185.025n

* CHECK dout0_23 Vdout0_23ck36 = 0.9 time = 185
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=185.025n

* CHECK dout0_24 Vdout0_24ck36 = 0.9 time = 185
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=185.025n

* CHECK dout0_25 Vdout0_25ck36 = 0.9 time = 185
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=185.025n

* CHECK dout0_26 Vdout0_26ck36 = 0 time = 185
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=185.025n

* CHECK dout0_27 Vdout0_27ck36 = 0.9 time = 185
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=185.025n

* CHECK dout0_28 Vdout0_28ck36 = 0.9 time = 185
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=185.025n

* CHECK dout0_29 Vdout0_29ck36 = 0.9 time = 185
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=185.025n

* CHECK dout0_30 Vdout0_30ck36 = 0 time = 185
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=185.025n

* CHECK dout0_31 Vdout0_31ck36 = 0 time = 185
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=185.025n

* CHECK dout0_32 Vdout0_32ck36 = 0.9 time = 185
.meas tran vdout0_32ck36 FIND v(dout0_32) AT=185.025n

* CHECK dout0_33 Vdout0_33ck36 = 0.9 time = 185
.meas tran vdout0_33ck36 FIND v(dout0_33) AT=185.025n

* CHECK dout0_34 Vdout0_34ck36 = 0 time = 185
.meas tran vdout0_34ck36 FIND v(dout0_34) AT=185.025n

* CHECK dout0_35 Vdout0_35ck36 = 0 time = 185
.meas tran vdout0_35ck36 FIND v(dout0_35) AT=185.025n

* CHECK dout0_36 Vdout0_36ck36 = 0.9 time = 185
.meas tran vdout0_36ck36 FIND v(dout0_36) AT=185.025n

* CHECK dout0_37 Vdout0_37ck36 = 0 time = 185
.meas tran vdout0_37ck36 FIND v(dout0_37) AT=185.025n

* CHECK dout0_38 Vdout0_38ck36 = 0.9 time = 185
.meas tran vdout0_38ck36 FIND v(dout0_38) AT=185.025n

* CHECK dout0_39 Vdout0_39ck36 = 0 time = 185
.meas tran vdout0_39ck36 FIND v(dout0_39) AT=185.025n

* CHECK dout0_40 Vdout0_40ck36 = 0 time = 185
.meas tran vdout0_40ck36 FIND v(dout0_40) AT=185.025n

* CHECK dout0_41 Vdout0_41ck36 = 0.9 time = 185
.meas tran vdout0_41ck36 FIND v(dout0_41) AT=185.025n

* CHECK dout0_42 Vdout0_42ck36 = 0.9 time = 185
.meas tran vdout0_42ck36 FIND v(dout0_42) AT=185.025n

* CHECK dout0_43 Vdout0_43ck36 = 0 time = 185
.meas tran vdout0_43ck36 FIND v(dout0_43) AT=185.025n

* CHECK dout0_44 Vdout0_44ck36 = 0.9 time = 185
.meas tran vdout0_44ck36 FIND v(dout0_44) AT=185.025n

* CHECK dout0_45 Vdout0_45ck36 = 0.9 time = 185
.meas tran vdout0_45ck36 FIND v(dout0_45) AT=185.025n

* CHECK dout0_46 Vdout0_46ck36 = 0.9 time = 185
.meas tran vdout0_46ck36 FIND v(dout0_46) AT=185.025n

* CHECK dout0_47 Vdout0_47ck36 = 0 time = 185
.meas tran vdout0_47ck36 FIND v(dout0_47) AT=185.025n

* CHECK dout0_48 Vdout0_48ck36 = 0.9 time = 185
.meas tran vdout0_48ck36 FIND v(dout0_48) AT=185.025n

* CHECK dout0_49 Vdout0_49ck36 = 0.9 time = 185
.meas tran vdout0_49ck36 FIND v(dout0_49) AT=185.025n

* CHECK dout0_50 Vdout0_50ck36 = 0.9 time = 185
.meas tran vdout0_50ck36 FIND v(dout0_50) AT=185.025n

* CHECK dout0_51 Vdout0_51ck36 = 0 time = 185
.meas tran vdout0_51ck36 FIND v(dout0_51) AT=185.025n

* CHECK dout0_52 Vdout0_52ck36 = 0.9 time = 185
.meas tran vdout0_52ck36 FIND v(dout0_52) AT=185.025n

* CHECK dout0_53 Vdout0_53ck36 = 0 time = 185
.meas tran vdout0_53ck36 FIND v(dout0_53) AT=185.025n

* CHECK dout0_54 Vdout0_54ck36 = 0 time = 185
.meas tran vdout0_54ck36 FIND v(dout0_54) AT=185.025n

* CHECK dout0_55 Vdout0_55ck36 = 0.9 time = 185
.meas tran vdout0_55ck36 FIND v(dout0_55) AT=185.025n

* CHECK dout0_56 Vdout0_56ck36 = 0.9 time = 185
.meas tran vdout0_56ck36 FIND v(dout0_56) AT=185.025n

* CHECK dout0_57 Vdout0_57ck36 = 0 time = 185
.meas tran vdout0_57ck36 FIND v(dout0_57) AT=185.025n

* CHECK dout0_58 Vdout0_58ck36 = 0 time = 185
.meas tran vdout0_58ck36 FIND v(dout0_58) AT=185.025n

* CHECK dout0_59 Vdout0_59ck36 = 0.9 time = 185
.meas tran vdout0_59ck36 FIND v(dout0_59) AT=185.025n

* CHECK dout0_60 Vdout0_60ck36 = 0.9 time = 185
.meas tran vdout0_60ck36 FIND v(dout0_60) AT=185.025n

* CHECK dout0_61 Vdout0_61ck36 = 0.9 time = 185
.meas tran vdout0_61ck36 FIND v(dout0_61) AT=185.025n

* CHECK dout0_62 Vdout0_62ck36 = 0 time = 185
.meas tran vdout0_62ck36 FIND v(dout0_62) AT=185.025n

* CHECK dout0_63 Vdout0_63ck36 = 0.9 time = 185
.meas tran vdout0_63ck36 FIND v(dout0_63) AT=185.025n

* CHECK dout0_64 Vdout0_64ck36 = 0 time = 185
.meas tran vdout0_64ck36 FIND v(dout0_64) AT=185.025n

* CHECK dout0_65 Vdout0_65ck36 = 0.9 time = 185
.meas tran vdout0_65ck36 FIND v(dout0_65) AT=185.025n

* CHECK dout0_66 Vdout0_66ck36 = 0 time = 185
.meas tran vdout0_66ck36 FIND v(dout0_66) AT=185.025n

* CHECK dout0_67 Vdout0_67ck36 = 0.9 time = 185
.meas tran vdout0_67ck36 FIND v(dout0_67) AT=185.025n

* CHECK dout0_68 Vdout0_68ck36 = 0 time = 185
.meas tran vdout0_68ck36 FIND v(dout0_68) AT=185.025n

* CHECK dout0_69 Vdout0_69ck36 = 0 time = 185
.meas tran vdout0_69ck36 FIND v(dout0_69) AT=185.025n

* CHECK dout0_70 Vdout0_70ck36 = 0 time = 185
.meas tran vdout0_70ck36 FIND v(dout0_70) AT=185.025n

* CHECK dout0_71 Vdout0_71ck36 = 0.9 time = 185
.meas tran vdout0_71ck36 FIND v(dout0_71) AT=185.025n

* CHECK dout0_72 Vdout0_72ck36 = 0 time = 185
.meas tran vdout0_72ck36 FIND v(dout0_72) AT=185.025n

* CHECK dout0_73 Vdout0_73ck36 = 0 time = 185
.meas tran vdout0_73ck36 FIND v(dout0_73) AT=185.025n

* CHECK dout0_74 Vdout0_74ck36 = 0.9 time = 185
.meas tran vdout0_74ck36 FIND v(dout0_74) AT=185.025n

* CHECK dout0_75 Vdout0_75ck36 = 0 time = 185
.meas tran vdout0_75ck36 FIND v(dout0_75) AT=185.025n

* CHECK dout0_76 Vdout0_76ck36 = 0.9 time = 185
.meas tran vdout0_76ck36 FIND v(dout0_76) AT=185.025n

* CHECK dout0_77 Vdout0_77ck36 = 0 time = 185
.meas tran vdout0_77ck36 FIND v(dout0_77) AT=185.025n

* CHECK dout0_78 Vdout0_78ck36 = 0.9 time = 185
.meas tran vdout0_78ck36 FIND v(dout0_78) AT=185.025n

* CHECK dout0_79 Vdout0_79ck36 = 0 time = 185
.meas tran vdout0_79ck36 FIND v(dout0_79) AT=185.025n

* CHECK dout0_0 Vdout0_0ck37 = 0.9 time = 190
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=190.025n

* CHECK dout0_1 Vdout0_1ck37 = 0.9 time = 190
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=190.025n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 190
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=190.025n

* CHECK dout0_3 Vdout0_3ck37 = 0.9 time = 190
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=190.025n

* CHECK dout0_4 Vdout0_4ck37 = 0 time = 190
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=190.025n

* CHECK dout0_5 Vdout0_5ck37 = 0.9 time = 190
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=190.025n

* CHECK dout0_6 Vdout0_6ck37 = 0 time = 190
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=190.025n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 190
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=190.025n

* CHECK dout0_8 Vdout0_8ck37 = 0 time = 190
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=190.025n

* CHECK dout0_9 Vdout0_9ck37 = 0.9 time = 190
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=190.025n

* CHECK dout0_10 Vdout0_10ck37 = 0.9 time = 190
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=190.025n

* CHECK dout0_11 Vdout0_11ck37 = 0 time = 190
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=190.025n

* CHECK dout0_12 Vdout0_12ck37 = 0.9 time = 190
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=190.025n

* CHECK dout0_13 Vdout0_13ck37 = 0.9 time = 190
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=190.025n

* CHECK dout0_14 Vdout0_14ck37 = 0 time = 190
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=190.025n

* CHECK dout0_15 Vdout0_15ck37 = 0 time = 190
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=190.025n

* CHECK dout0_16 Vdout0_16ck37 = 0.9 time = 190
.meas tran vdout0_16ck37 FIND v(dout0_16) AT=190.025n

* CHECK dout0_17 Vdout0_17ck37 = 0 time = 190
.meas tran vdout0_17ck37 FIND v(dout0_17) AT=190.025n

* CHECK dout0_18 Vdout0_18ck37 = 0 time = 190
.meas tran vdout0_18ck37 FIND v(dout0_18) AT=190.025n

* CHECK dout0_19 Vdout0_19ck37 = 0 time = 190
.meas tran vdout0_19ck37 FIND v(dout0_19) AT=190.025n

* CHECK dout0_20 Vdout0_20ck37 = 0.9 time = 190
.meas tran vdout0_20ck37 FIND v(dout0_20) AT=190.025n

* CHECK dout0_21 Vdout0_21ck37 = 0.9 time = 190
.meas tran vdout0_21ck37 FIND v(dout0_21) AT=190.025n

* CHECK dout0_22 Vdout0_22ck37 = 0 time = 190
.meas tran vdout0_22ck37 FIND v(dout0_22) AT=190.025n

* CHECK dout0_23 Vdout0_23ck37 = 0.9 time = 190
.meas tran vdout0_23ck37 FIND v(dout0_23) AT=190.025n

* CHECK dout0_24 Vdout0_24ck37 = 0.9 time = 190
.meas tran vdout0_24ck37 FIND v(dout0_24) AT=190.025n

* CHECK dout0_25 Vdout0_25ck37 = 0.9 time = 190
.meas tran vdout0_25ck37 FIND v(dout0_25) AT=190.025n

* CHECK dout0_26 Vdout0_26ck37 = 0 time = 190
.meas tran vdout0_26ck37 FIND v(dout0_26) AT=190.025n

* CHECK dout0_27 Vdout0_27ck37 = 0.9 time = 190
.meas tran vdout0_27ck37 FIND v(dout0_27) AT=190.025n

* CHECK dout0_28 Vdout0_28ck37 = 0.9 time = 190
.meas tran vdout0_28ck37 FIND v(dout0_28) AT=190.025n

* CHECK dout0_29 Vdout0_29ck37 = 0.9 time = 190
.meas tran vdout0_29ck37 FIND v(dout0_29) AT=190.025n

* CHECK dout0_30 Vdout0_30ck37 = 0 time = 190
.meas tran vdout0_30ck37 FIND v(dout0_30) AT=190.025n

* CHECK dout0_31 Vdout0_31ck37 = 0 time = 190
.meas tran vdout0_31ck37 FIND v(dout0_31) AT=190.025n

* CHECK dout0_32 Vdout0_32ck37 = 0.9 time = 190
.meas tran vdout0_32ck37 FIND v(dout0_32) AT=190.025n

* CHECK dout0_33 Vdout0_33ck37 = 0.9 time = 190
.meas tran vdout0_33ck37 FIND v(dout0_33) AT=190.025n

* CHECK dout0_34 Vdout0_34ck37 = 0 time = 190
.meas tran vdout0_34ck37 FIND v(dout0_34) AT=190.025n

* CHECK dout0_35 Vdout0_35ck37 = 0 time = 190
.meas tran vdout0_35ck37 FIND v(dout0_35) AT=190.025n

* CHECK dout0_36 Vdout0_36ck37 = 0.9 time = 190
.meas tran vdout0_36ck37 FIND v(dout0_36) AT=190.025n

* CHECK dout0_37 Vdout0_37ck37 = 0 time = 190
.meas tran vdout0_37ck37 FIND v(dout0_37) AT=190.025n

* CHECK dout0_38 Vdout0_38ck37 = 0.9 time = 190
.meas tran vdout0_38ck37 FIND v(dout0_38) AT=190.025n

* CHECK dout0_39 Vdout0_39ck37 = 0 time = 190
.meas tran vdout0_39ck37 FIND v(dout0_39) AT=190.025n

* CHECK dout0_40 Vdout0_40ck37 = 0 time = 190
.meas tran vdout0_40ck37 FIND v(dout0_40) AT=190.025n

* CHECK dout0_41 Vdout0_41ck37 = 0.9 time = 190
.meas tran vdout0_41ck37 FIND v(dout0_41) AT=190.025n

* CHECK dout0_42 Vdout0_42ck37 = 0.9 time = 190
.meas tran vdout0_42ck37 FIND v(dout0_42) AT=190.025n

* CHECK dout0_43 Vdout0_43ck37 = 0 time = 190
.meas tran vdout0_43ck37 FIND v(dout0_43) AT=190.025n

* CHECK dout0_44 Vdout0_44ck37 = 0.9 time = 190
.meas tran vdout0_44ck37 FIND v(dout0_44) AT=190.025n

* CHECK dout0_45 Vdout0_45ck37 = 0.9 time = 190
.meas tran vdout0_45ck37 FIND v(dout0_45) AT=190.025n

* CHECK dout0_46 Vdout0_46ck37 = 0.9 time = 190
.meas tran vdout0_46ck37 FIND v(dout0_46) AT=190.025n

* CHECK dout0_47 Vdout0_47ck37 = 0 time = 190
.meas tran vdout0_47ck37 FIND v(dout0_47) AT=190.025n

* CHECK dout0_48 Vdout0_48ck37 = 0.9 time = 190
.meas tran vdout0_48ck37 FIND v(dout0_48) AT=190.025n

* CHECK dout0_49 Vdout0_49ck37 = 0.9 time = 190
.meas tran vdout0_49ck37 FIND v(dout0_49) AT=190.025n

* CHECK dout0_50 Vdout0_50ck37 = 0.9 time = 190
.meas tran vdout0_50ck37 FIND v(dout0_50) AT=190.025n

* CHECK dout0_51 Vdout0_51ck37 = 0 time = 190
.meas tran vdout0_51ck37 FIND v(dout0_51) AT=190.025n

* CHECK dout0_52 Vdout0_52ck37 = 0.9 time = 190
.meas tran vdout0_52ck37 FIND v(dout0_52) AT=190.025n

* CHECK dout0_53 Vdout0_53ck37 = 0 time = 190
.meas tran vdout0_53ck37 FIND v(dout0_53) AT=190.025n

* CHECK dout0_54 Vdout0_54ck37 = 0 time = 190
.meas tran vdout0_54ck37 FIND v(dout0_54) AT=190.025n

* CHECK dout0_55 Vdout0_55ck37 = 0.9 time = 190
.meas tran vdout0_55ck37 FIND v(dout0_55) AT=190.025n

* CHECK dout0_56 Vdout0_56ck37 = 0.9 time = 190
.meas tran vdout0_56ck37 FIND v(dout0_56) AT=190.025n

* CHECK dout0_57 Vdout0_57ck37 = 0 time = 190
.meas tran vdout0_57ck37 FIND v(dout0_57) AT=190.025n

* CHECK dout0_58 Vdout0_58ck37 = 0 time = 190
.meas tran vdout0_58ck37 FIND v(dout0_58) AT=190.025n

* CHECK dout0_59 Vdout0_59ck37 = 0.9 time = 190
.meas tran vdout0_59ck37 FIND v(dout0_59) AT=190.025n

* CHECK dout0_60 Vdout0_60ck37 = 0.9 time = 190
.meas tran vdout0_60ck37 FIND v(dout0_60) AT=190.025n

* CHECK dout0_61 Vdout0_61ck37 = 0.9 time = 190
.meas tran vdout0_61ck37 FIND v(dout0_61) AT=190.025n

* CHECK dout0_62 Vdout0_62ck37 = 0 time = 190
.meas tran vdout0_62ck37 FIND v(dout0_62) AT=190.025n

* CHECK dout0_63 Vdout0_63ck37 = 0.9 time = 190
.meas tran vdout0_63ck37 FIND v(dout0_63) AT=190.025n

* CHECK dout0_64 Vdout0_64ck37 = 0 time = 190
.meas tran vdout0_64ck37 FIND v(dout0_64) AT=190.025n

* CHECK dout0_65 Vdout0_65ck37 = 0.9 time = 190
.meas tran vdout0_65ck37 FIND v(dout0_65) AT=190.025n

* CHECK dout0_66 Vdout0_66ck37 = 0 time = 190
.meas tran vdout0_66ck37 FIND v(dout0_66) AT=190.025n

* CHECK dout0_67 Vdout0_67ck37 = 0.9 time = 190
.meas tran vdout0_67ck37 FIND v(dout0_67) AT=190.025n

* CHECK dout0_68 Vdout0_68ck37 = 0 time = 190
.meas tran vdout0_68ck37 FIND v(dout0_68) AT=190.025n

* CHECK dout0_69 Vdout0_69ck37 = 0 time = 190
.meas tran vdout0_69ck37 FIND v(dout0_69) AT=190.025n

* CHECK dout0_70 Vdout0_70ck37 = 0 time = 190
.meas tran vdout0_70ck37 FIND v(dout0_70) AT=190.025n

* CHECK dout0_71 Vdout0_71ck37 = 0.9 time = 190
.meas tran vdout0_71ck37 FIND v(dout0_71) AT=190.025n

* CHECK dout0_72 Vdout0_72ck37 = 0 time = 190
.meas tran vdout0_72ck37 FIND v(dout0_72) AT=190.025n

* CHECK dout0_73 Vdout0_73ck37 = 0 time = 190
.meas tran vdout0_73ck37 FIND v(dout0_73) AT=190.025n

* CHECK dout0_74 Vdout0_74ck37 = 0.9 time = 190
.meas tran vdout0_74ck37 FIND v(dout0_74) AT=190.025n

* CHECK dout0_75 Vdout0_75ck37 = 0 time = 190
.meas tran vdout0_75ck37 FIND v(dout0_75) AT=190.025n

* CHECK dout0_76 Vdout0_76ck37 = 0.9 time = 190
.meas tran vdout0_76ck37 FIND v(dout0_76) AT=190.025n

* CHECK dout0_77 Vdout0_77ck37 = 0 time = 190
.meas tran vdout0_77ck37 FIND v(dout0_77) AT=190.025n

* CHECK dout0_78 Vdout0_78ck37 = 0.9 time = 190
.meas tran vdout0_78ck37 FIND v(dout0_78) AT=190.025n

* CHECK dout0_79 Vdout0_79ck37 = 0 time = 190
.meas tran vdout0_79ck37 FIND v(dout0_79) AT=190.025n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 210
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=210.025n

* CHECK dout0_1 Vdout0_1ck41 = 0.9 time = 210
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=210.025n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 210
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=210.025n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 210
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=210.025n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 210
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=210.025n

* CHECK dout0_5 Vdout0_5ck41 = 0.9 time = 210
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=210.025n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 210
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=210.025n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 210
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=210.025n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 210
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=210.025n

* CHECK dout0_9 Vdout0_9ck41 = 0.9 time = 210
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=210.025n

* CHECK dout0_10 Vdout0_10ck41 = 0.9 time = 210
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=210.025n

* CHECK dout0_11 Vdout0_11ck41 = 0.9 time = 210
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=210.025n

* CHECK dout0_12 Vdout0_12ck41 = 0 time = 210
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=210.025n

* CHECK dout0_13 Vdout0_13ck41 = 0.9 time = 210
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=210.025n

* CHECK dout0_14 Vdout0_14ck41 = 0 time = 210
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=210.025n

* CHECK dout0_15 Vdout0_15ck41 = 0 time = 210
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=210.025n

* CHECK dout0_16 Vdout0_16ck41 = 0 time = 210
.meas tran vdout0_16ck41 FIND v(dout0_16) AT=210.025n

* CHECK dout0_17 Vdout0_17ck41 = 0 time = 210
.meas tran vdout0_17ck41 FIND v(dout0_17) AT=210.025n

* CHECK dout0_18 Vdout0_18ck41 = 0 time = 210
.meas tran vdout0_18ck41 FIND v(dout0_18) AT=210.025n

* CHECK dout0_19 Vdout0_19ck41 = 0 time = 210
.meas tran vdout0_19ck41 FIND v(dout0_19) AT=210.025n

* CHECK dout0_20 Vdout0_20ck41 = 0.9 time = 210
.meas tran vdout0_20ck41 FIND v(dout0_20) AT=210.025n

* CHECK dout0_21 Vdout0_21ck41 = 0.9 time = 210
.meas tran vdout0_21ck41 FIND v(dout0_21) AT=210.025n

* CHECK dout0_22 Vdout0_22ck41 = 0 time = 210
.meas tran vdout0_22ck41 FIND v(dout0_22) AT=210.025n

* CHECK dout0_23 Vdout0_23ck41 = 0.9 time = 210
.meas tran vdout0_23ck41 FIND v(dout0_23) AT=210.025n

* CHECK dout0_24 Vdout0_24ck41 = 0.9 time = 210
.meas tran vdout0_24ck41 FIND v(dout0_24) AT=210.025n

* CHECK dout0_25 Vdout0_25ck41 = 0.9 time = 210
.meas tran vdout0_25ck41 FIND v(dout0_25) AT=210.025n

* CHECK dout0_26 Vdout0_26ck41 = 0 time = 210
.meas tran vdout0_26ck41 FIND v(dout0_26) AT=210.025n

* CHECK dout0_27 Vdout0_27ck41 = 0.9 time = 210
.meas tran vdout0_27ck41 FIND v(dout0_27) AT=210.025n

* CHECK dout0_28 Vdout0_28ck41 = 0.9 time = 210
.meas tran vdout0_28ck41 FIND v(dout0_28) AT=210.025n

* CHECK dout0_29 Vdout0_29ck41 = 0.9 time = 210
.meas tran vdout0_29ck41 FIND v(dout0_29) AT=210.025n

* CHECK dout0_30 Vdout0_30ck41 = 0 time = 210
.meas tran vdout0_30ck41 FIND v(dout0_30) AT=210.025n

* CHECK dout0_31 Vdout0_31ck41 = 0 time = 210
.meas tran vdout0_31ck41 FIND v(dout0_31) AT=210.025n

* CHECK dout0_32 Vdout0_32ck41 = 0.9 time = 210
.meas tran vdout0_32ck41 FIND v(dout0_32) AT=210.025n

* CHECK dout0_33 Vdout0_33ck41 = 0.9 time = 210
.meas tran vdout0_33ck41 FIND v(dout0_33) AT=210.025n

* CHECK dout0_34 Vdout0_34ck41 = 0 time = 210
.meas tran vdout0_34ck41 FIND v(dout0_34) AT=210.025n

* CHECK dout0_35 Vdout0_35ck41 = 0 time = 210
.meas tran vdout0_35ck41 FIND v(dout0_35) AT=210.025n

* CHECK dout0_36 Vdout0_36ck41 = 0.9 time = 210
.meas tran vdout0_36ck41 FIND v(dout0_36) AT=210.025n

* CHECK dout0_37 Vdout0_37ck41 = 0 time = 210
.meas tran vdout0_37ck41 FIND v(dout0_37) AT=210.025n

* CHECK dout0_38 Vdout0_38ck41 = 0.9 time = 210
.meas tran vdout0_38ck41 FIND v(dout0_38) AT=210.025n

* CHECK dout0_39 Vdout0_39ck41 = 0 time = 210
.meas tran vdout0_39ck41 FIND v(dout0_39) AT=210.025n

* CHECK dout0_40 Vdout0_40ck41 = 0 time = 210
.meas tran vdout0_40ck41 FIND v(dout0_40) AT=210.025n

* CHECK dout0_41 Vdout0_41ck41 = 0.9 time = 210
.meas tran vdout0_41ck41 FIND v(dout0_41) AT=210.025n

* CHECK dout0_42 Vdout0_42ck41 = 0.9 time = 210
.meas tran vdout0_42ck41 FIND v(dout0_42) AT=210.025n

* CHECK dout0_43 Vdout0_43ck41 = 0 time = 210
.meas tran vdout0_43ck41 FIND v(dout0_43) AT=210.025n

* CHECK dout0_44 Vdout0_44ck41 = 0 time = 210
.meas tran vdout0_44ck41 FIND v(dout0_44) AT=210.025n

* CHECK dout0_45 Vdout0_45ck41 = 0.9 time = 210
.meas tran vdout0_45ck41 FIND v(dout0_45) AT=210.025n

* CHECK dout0_46 Vdout0_46ck41 = 0.9 time = 210
.meas tran vdout0_46ck41 FIND v(dout0_46) AT=210.025n

* CHECK dout0_47 Vdout0_47ck41 = 0.9 time = 210
.meas tran vdout0_47ck41 FIND v(dout0_47) AT=210.025n

* CHECK dout0_48 Vdout0_48ck41 = 0 time = 210
.meas tran vdout0_48ck41 FIND v(dout0_48) AT=210.025n

* CHECK dout0_49 Vdout0_49ck41 = 0 time = 210
.meas tran vdout0_49ck41 FIND v(dout0_49) AT=210.025n

* CHECK dout0_50 Vdout0_50ck41 = 0 time = 210
.meas tran vdout0_50ck41 FIND v(dout0_50) AT=210.025n

* CHECK dout0_51 Vdout0_51ck41 = 0 time = 210
.meas tran vdout0_51ck41 FIND v(dout0_51) AT=210.025n

* CHECK dout0_52 Vdout0_52ck41 = 0.9 time = 210
.meas tran vdout0_52ck41 FIND v(dout0_52) AT=210.025n

* CHECK dout0_53 Vdout0_53ck41 = 0.9 time = 210
.meas tran vdout0_53ck41 FIND v(dout0_53) AT=210.025n

* CHECK dout0_54 Vdout0_54ck41 = 0.9 time = 210
.meas tran vdout0_54ck41 FIND v(dout0_54) AT=210.025n

* CHECK dout0_55 Vdout0_55ck41 = 0 time = 210
.meas tran vdout0_55ck41 FIND v(dout0_55) AT=210.025n

* CHECK dout0_56 Vdout0_56ck41 = 0.9 time = 210
.meas tran vdout0_56ck41 FIND v(dout0_56) AT=210.025n

* CHECK dout0_57 Vdout0_57ck41 = 0.9 time = 210
.meas tran vdout0_57ck41 FIND v(dout0_57) AT=210.025n

* CHECK dout0_58 Vdout0_58ck41 = 0 time = 210
.meas tran vdout0_58ck41 FIND v(dout0_58) AT=210.025n

* CHECK dout0_59 Vdout0_59ck41 = 0.9 time = 210
.meas tran vdout0_59ck41 FIND v(dout0_59) AT=210.025n

* CHECK dout0_60 Vdout0_60ck41 = 0.9 time = 210
.meas tran vdout0_60ck41 FIND v(dout0_60) AT=210.025n

* CHECK dout0_61 Vdout0_61ck41 = 0.9 time = 210
.meas tran vdout0_61ck41 FIND v(dout0_61) AT=210.025n

* CHECK dout0_62 Vdout0_62ck41 = 0 time = 210
.meas tran vdout0_62ck41 FIND v(dout0_62) AT=210.025n

* CHECK dout0_63 Vdout0_63ck41 = 0.9 time = 210
.meas tran vdout0_63ck41 FIND v(dout0_63) AT=210.025n

* CHECK dout0_64 Vdout0_64ck41 = 0 time = 210
.meas tran vdout0_64ck41 FIND v(dout0_64) AT=210.025n

* CHECK dout0_65 Vdout0_65ck41 = 0.9 time = 210
.meas tran vdout0_65ck41 FIND v(dout0_65) AT=210.025n

* CHECK dout0_66 Vdout0_66ck41 = 0 time = 210
.meas tran vdout0_66ck41 FIND v(dout0_66) AT=210.025n

* CHECK dout0_67 Vdout0_67ck41 = 0.9 time = 210
.meas tran vdout0_67ck41 FIND v(dout0_67) AT=210.025n

* CHECK dout0_68 Vdout0_68ck41 = 0 time = 210
.meas tran vdout0_68ck41 FIND v(dout0_68) AT=210.025n

* CHECK dout0_69 Vdout0_69ck41 = 0 time = 210
.meas tran vdout0_69ck41 FIND v(dout0_69) AT=210.025n

* CHECK dout0_70 Vdout0_70ck41 = 0 time = 210
.meas tran vdout0_70ck41 FIND v(dout0_70) AT=210.025n

* CHECK dout0_71 Vdout0_71ck41 = 0.9 time = 210
.meas tran vdout0_71ck41 FIND v(dout0_71) AT=210.025n

* CHECK dout0_72 Vdout0_72ck41 = 0 time = 210
.meas tran vdout0_72ck41 FIND v(dout0_72) AT=210.025n

* CHECK dout0_73 Vdout0_73ck41 = 0 time = 210
.meas tran vdout0_73ck41 FIND v(dout0_73) AT=210.025n

* CHECK dout0_74 Vdout0_74ck41 = 0.9 time = 210
.meas tran vdout0_74ck41 FIND v(dout0_74) AT=210.025n

* CHECK dout0_75 Vdout0_75ck41 = 0 time = 210
.meas tran vdout0_75ck41 FIND v(dout0_75) AT=210.025n

* CHECK dout0_76 Vdout0_76ck41 = 0.9 time = 210
.meas tran vdout0_76ck41 FIND v(dout0_76) AT=210.025n

* CHECK dout0_77 Vdout0_77ck41 = 0 time = 210
.meas tran vdout0_77ck41 FIND v(dout0_77) AT=210.025n

* CHECK dout0_78 Vdout0_78ck41 = 0.9 time = 210
.meas tran vdout0_78ck41 FIND v(dout0_78) AT=210.025n

* CHECK dout0_79 Vdout0_79ck41 = 0 time = 210
.meas tran vdout0_79ck41 FIND v(dout0_79) AT=210.025n

* CHECK dout0_0 Vdout0_0ck43 = 0 time = 220
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=220.025n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 220
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=220.025n

* CHECK dout0_2 Vdout0_2ck43 = 0.9 time = 220
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=220.025n

* CHECK dout0_3 Vdout0_3ck43 = 0 time = 220
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=220.025n

* CHECK dout0_4 Vdout0_4ck43 = 0.9 time = 220
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=220.025n

* CHECK dout0_5 Vdout0_5ck43 = 0.9 time = 220
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=220.025n

* CHECK dout0_6 Vdout0_6ck43 = 0 time = 220
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=220.025n

* CHECK dout0_7 Vdout0_7ck43 = 0.9 time = 220
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=220.025n

* CHECK dout0_8 Vdout0_8ck43 = 0 time = 220
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=220.025n

* CHECK dout0_9 Vdout0_9ck43 = 0.9 time = 220
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=220.025n

* CHECK dout0_10 Vdout0_10ck43 = 0 time = 220
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=220.025n

* CHECK dout0_11 Vdout0_11ck43 = 0 time = 220
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=220.025n

* CHECK dout0_12 Vdout0_12ck43 = 0 time = 220
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=220.025n

* CHECK dout0_13 Vdout0_13ck43 = 0 time = 220
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=220.025n

* CHECK dout0_14 Vdout0_14ck43 = 0.9 time = 220
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=220.025n

* CHECK dout0_15 Vdout0_15ck43 = 0.9 time = 220
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=220.025n

* CHECK dout0_16 Vdout0_16ck43 = 0 time = 220
.meas tran vdout0_16ck43 FIND v(dout0_16) AT=220.025n

* CHECK dout0_17 Vdout0_17ck43 = 0 time = 220
.meas tran vdout0_17ck43 FIND v(dout0_17) AT=220.025n

* CHECK dout0_18 Vdout0_18ck43 = 0 time = 220
.meas tran vdout0_18ck43 FIND v(dout0_18) AT=220.025n

* CHECK dout0_19 Vdout0_19ck43 = 0 time = 220
.meas tran vdout0_19ck43 FIND v(dout0_19) AT=220.025n

* CHECK dout0_20 Vdout0_20ck43 = 0.9 time = 220
.meas tran vdout0_20ck43 FIND v(dout0_20) AT=220.025n

* CHECK dout0_21 Vdout0_21ck43 = 0.9 time = 220
.meas tran vdout0_21ck43 FIND v(dout0_21) AT=220.025n

* CHECK dout0_22 Vdout0_22ck43 = 0 time = 220
.meas tran vdout0_22ck43 FIND v(dout0_22) AT=220.025n

* CHECK dout0_23 Vdout0_23ck43 = 0.9 time = 220
.meas tran vdout0_23ck43 FIND v(dout0_23) AT=220.025n

* CHECK dout0_24 Vdout0_24ck43 = 0.9 time = 220
.meas tran vdout0_24ck43 FIND v(dout0_24) AT=220.025n

* CHECK dout0_25 Vdout0_25ck43 = 0.9 time = 220
.meas tran vdout0_25ck43 FIND v(dout0_25) AT=220.025n

* CHECK dout0_26 Vdout0_26ck43 = 0 time = 220
.meas tran vdout0_26ck43 FIND v(dout0_26) AT=220.025n

* CHECK dout0_27 Vdout0_27ck43 = 0.9 time = 220
.meas tran vdout0_27ck43 FIND v(dout0_27) AT=220.025n

* CHECK dout0_28 Vdout0_28ck43 = 0.9 time = 220
.meas tran vdout0_28ck43 FIND v(dout0_28) AT=220.025n

* CHECK dout0_29 Vdout0_29ck43 = 0.9 time = 220
.meas tran vdout0_29ck43 FIND v(dout0_29) AT=220.025n

* CHECK dout0_30 Vdout0_30ck43 = 0 time = 220
.meas tran vdout0_30ck43 FIND v(dout0_30) AT=220.025n

* CHECK dout0_31 Vdout0_31ck43 = 0 time = 220
.meas tran vdout0_31ck43 FIND v(dout0_31) AT=220.025n

* CHECK dout0_32 Vdout0_32ck43 = 0.9 time = 220
.meas tran vdout0_32ck43 FIND v(dout0_32) AT=220.025n

* CHECK dout0_33 Vdout0_33ck43 = 0.9 time = 220
.meas tran vdout0_33ck43 FIND v(dout0_33) AT=220.025n

* CHECK dout0_34 Vdout0_34ck43 = 0 time = 220
.meas tran vdout0_34ck43 FIND v(dout0_34) AT=220.025n

* CHECK dout0_35 Vdout0_35ck43 = 0 time = 220
.meas tran vdout0_35ck43 FIND v(dout0_35) AT=220.025n

* CHECK dout0_36 Vdout0_36ck43 = 0.9 time = 220
.meas tran vdout0_36ck43 FIND v(dout0_36) AT=220.025n

* CHECK dout0_37 Vdout0_37ck43 = 0 time = 220
.meas tran vdout0_37ck43 FIND v(dout0_37) AT=220.025n

* CHECK dout0_38 Vdout0_38ck43 = 0.9 time = 220
.meas tran vdout0_38ck43 FIND v(dout0_38) AT=220.025n

* CHECK dout0_39 Vdout0_39ck43 = 0 time = 220
.meas tran vdout0_39ck43 FIND v(dout0_39) AT=220.025n

* CHECK dout0_40 Vdout0_40ck43 = 0 time = 220
.meas tran vdout0_40ck43 FIND v(dout0_40) AT=220.025n

* CHECK dout0_41 Vdout0_41ck43 = 0.9 time = 220
.meas tran vdout0_41ck43 FIND v(dout0_41) AT=220.025n

* CHECK dout0_42 Vdout0_42ck43 = 0.9 time = 220
.meas tran vdout0_42ck43 FIND v(dout0_42) AT=220.025n

* CHECK dout0_43 Vdout0_43ck43 = 0 time = 220
.meas tran vdout0_43ck43 FIND v(dout0_43) AT=220.025n

* CHECK dout0_44 Vdout0_44ck43 = 0 time = 220
.meas tran vdout0_44ck43 FIND v(dout0_44) AT=220.025n

* CHECK dout0_45 Vdout0_45ck43 = 0.9 time = 220
.meas tran vdout0_45ck43 FIND v(dout0_45) AT=220.025n

* CHECK dout0_46 Vdout0_46ck43 = 0.9 time = 220
.meas tran vdout0_46ck43 FIND v(dout0_46) AT=220.025n

* CHECK dout0_47 Vdout0_47ck43 = 0.9 time = 220
.meas tran vdout0_47ck43 FIND v(dout0_47) AT=220.025n

* CHECK dout0_48 Vdout0_48ck43 = 0 time = 220
.meas tran vdout0_48ck43 FIND v(dout0_48) AT=220.025n

* CHECK dout0_49 Vdout0_49ck43 = 0 time = 220
.meas tran vdout0_49ck43 FIND v(dout0_49) AT=220.025n

* CHECK dout0_50 Vdout0_50ck43 = 0 time = 220
.meas tran vdout0_50ck43 FIND v(dout0_50) AT=220.025n

* CHECK dout0_51 Vdout0_51ck43 = 0 time = 220
.meas tran vdout0_51ck43 FIND v(dout0_51) AT=220.025n

* CHECK dout0_52 Vdout0_52ck43 = 0.9 time = 220
.meas tran vdout0_52ck43 FIND v(dout0_52) AT=220.025n

* CHECK dout0_53 Vdout0_53ck43 = 0.9 time = 220
.meas tran vdout0_53ck43 FIND v(dout0_53) AT=220.025n

* CHECK dout0_54 Vdout0_54ck43 = 0.9 time = 220
.meas tran vdout0_54ck43 FIND v(dout0_54) AT=220.025n

* CHECK dout0_55 Vdout0_55ck43 = 0 time = 220
.meas tran vdout0_55ck43 FIND v(dout0_55) AT=220.025n

* CHECK dout0_56 Vdout0_56ck43 = 0.9 time = 220
.meas tran vdout0_56ck43 FIND v(dout0_56) AT=220.025n

* CHECK dout0_57 Vdout0_57ck43 = 0.9 time = 220
.meas tran vdout0_57ck43 FIND v(dout0_57) AT=220.025n

* CHECK dout0_58 Vdout0_58ck43 = 0 time = 220
.meas tran vdout0_58ck43 FIND v(dout0_58) AT=220.025n

* CHECK dout0_59 Vdout0_59ck43 = 0.9 time = 220
.meas tran vdout0_59ck43 FIND v(dout0_59) AT=220.025n

* CHECK dout0_60 Vdout0_60ck43 = 0 time = 220
.meas tran vdout0_60ck43 FIND v(dout0_60) AT=220.025n

* CHECK dout0_61 Vdout0_61ck43 = 0 time = 220
.meas tran vdout0_61ck43 FIND v(dout0_61) AT=220.025n

* CHECK dout0_62 Vdout0_62ck43 = 0.9 time = 220
.meas tran vdout0_62ck43 FIND v(dout0_62) AT=220.025n

* CHECK dout0_63 Vdout0_63ck43 = 0 time = 220
.meas tran vdout0_63ck43 FIND v(dout0_63) AT=220.025n

* CHECK dout0_64 Vdout0_64ck43 = 0 time = 220
.meas tran vdout0_64ck43 FIND v(dout0_64) AT=220.025n

* CHECK dout0_65 Vdout0_65ck43 = 0 time = 220
.meas tran vdout0_65ck43 FIND v(dout0_65) AT=220.025n

* CHECK dout0_66 Vdout0_66ck43 = 0 time = 220
.meas tran vdout0_66ck43 FIND v(dout0_66) AT=220.025n

* CHECK dout0_67 Vdout0_67ck43 = 0.9 time = 220
.meas tran vdout0_67ck43 FIND v(dout0_67) AT=220.025n

* CHECK dout0_68 Vdout0_68ck43 = 0.9 time = 220
.meas tran vdout0_68ck43 FIND v(dout0_68) AT=220.025n

* CHECK dout0_69 Vdout0_69ck43 = 0 time = 220
.meas tran vdout0_69ck43 FIND v(dout0_69) AT=220.025n

* CHECK dout0_70 Vdout0_70ck43 = 0.9 time = 220
.meas tran vdout0_70ck43 FIND v(dout0_70) AT=220.025n

* CHECK dout0_71 Vdout0_71ck43 = 0.9 time = 220
.meas tran vdout0_71ck43 FIND v(dout0_71) AT=220.025n

* CHECK dout0_72 Vdout0_72ck43 = 0.9 time = 220
.meas tran vdout0_72ck43 FIND v(dout0_72) AT=220.025n

* CHECK dout0_73 Vdout0_73ck43 = 0.9 time = 220
.meas tran vdout0_73ck43 FIND v(dout0_73) AT=220.025n

* CHECK dout0_74 Vdout0_74ck43 = 0.9 time = 220
.meas tran vdout0_74ck43 FIND v(dout0_74) AT=220.025n

* CHECK dout0_75 Vdout0_75ck43 = 0.9 time = 220
.meas tran vdout0_75ck43 FIND v(dout0_75) AT=220.025n

* CHECK dout0_76 Vdout0_76ck43 = 0.9 time = 220
.meas tran vdout0_76ck43 FIND v(dout0_76) AT=220.025n

* CHECK dout0_77 Vdout0_77ck43 = 0 time = 220
.meas tran vdout0_77ck43 FIND v(dout0_77) AT=220.025n

* CHECK dout0_78 Vdout0_78ck43 = 0 time = 220
.meas tran vdout0_78ck43 FIND v(dout0_78) AT=220.025n

* CHECK dout0_79 Vdout0_79ck43 = 0 time = 220
.meas tran vdout0_79ck43 FIND v(dout0_79) AT=220.025n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 225
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=225.025n

* CHECK dout0_1 Vdout0_1ck44 = 0.9 time = 225
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=225.025n

* CHECK dout0_2 Vdout0_2ck44 = 0.9 time = 225
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=225.025n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 225
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=225.025n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 225
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=225.025n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 225
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=225.025n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 225
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=225.025n

* CHECK dout0_7 Vdout0_7ck44 = 0.9 time = 225
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=225.025n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 225
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=225.025n

* CHECK dout0_9 Vdout0_9ck44 = 0.9 time = 225
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=225.025n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 225
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=225.025n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 225
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=225.025n

* CHECK dout0_12 Vdout0_12ck44 = 0.9 time = 225
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=225.025n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 225
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=225.025n

* CHECK dout0_14 Vdout0_14ck44 = 0.9 time = 225
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=225.025n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 225
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=225.025n

* CHECK dout0_16 Vdout0_16ck44 = 0.9 time = 225
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=225.025n

* CHECK dout0_17 Vdout0_17ck44 = 0 time = 225
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=225.025n

* CHECK dout0_18 Vdout0_18ck44 = 0 time = 225
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=225.025n

* CHECK dout0_19 Vdout0_19ck44 = 0 time = 225
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=225.025n

* CHECK dout0_20 Vdout0_20ck44 = 0 time = 225
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=225.025n

* CHECK dout0_21 Vdout0_21ck44 = 0.9 time = 225
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=225.025n

* CHECK dout0_22 Vdout0_22ck44 = 0.9 time = 225
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=225.025n

* CHECK dout0_23 Vdout0_23ck44 = 0 time = 225
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=225.025n

* CHECK dout0_24 Vdout0_24ck44 = 0.9 time = 225
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=225.025n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 225
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=225.025n

* CHECK dout0_26 Vdout0_26ck44 = 0.9 time = 225
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=225.025n

* CHECK dout0_27 Vdout0_27ck44 = 0 time = 225
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=225.025n

* CHECK dout0_28 Vdout0_28ck44 = 0.9 time = 225
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=225.025n

* CHECK dout0_29 Vdout0_29ck44 = 0.9 time = 225
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=225.025n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 225
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=225.025n

* CHECK dout0_31 Vdout0_31ck44 = 0.9 time = 225
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=225.025n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 225
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=225.025n

* CHECK dout0_33 Vdout0_33ck44 = 0 time = 225
.meas tran vdout0_33ck44 FIND v(dout0_33) AT=225.025n

* CHECK dout0_34 Vdout0_34ck44 = 0.9 time = 225
.meas tran vdout0_34ck44 FIND v(dout0_34) AT=225.025n

* CHECK dout0_35 Vdout0_35ck44 = 0.9 time = 225
.meas tran vdout0_35ck44 FIND v(dout0_35) AT=225.025n

* CHECK dout0_36 Vdout0_36ck44 = 0 time = 225
.meas tran vdout0_36ck44 FIND v(dout0_36) AT=225.025n

* CHECK dout0_37 Vdout0_37ck44 = 0.9 time = 225
.meas tran vdout0_37ck44 FIND v(dout0_37) AT=225.025n

* CHECK dout0_38 Vdout0_38ck44 = 0 time = 225
.meas tran vdout0_38ck44 FIND v(dout0_38) AT=225.025n

* CHECK dout0_39 Vdout0_39ck44 = 0 time = 225
.meas tran vdout0_39ck44 FIND v(dout0_39) AT=225.025n

* CHECK dout0_40 Vdout0_40ck44 = 0 time = 225
.meas tran vdout0_40ck44 FIND v(dout0_40) AT=225.025n

* CHECK dout0_41 Vdout0_41ck44 = 0 time = 225
.meas tran vdout0_41ck44 FIND v(dout0_41) AT=225.025n

* CHECK dout0_42 Vdout0_42ck44 = 0 time = 225
.meas tran vdout0_42ck44 FIND v(dout0_42) AT=225.025n

* CHECK dout0_43 Vdout0_43ck44 = 0.9 time = 225
.meas tran vdout0_43ck44 FIND v(dout0_43) AT=225.025n

* CHECK dout0_44 Vdout0_44ck44 = 0 time = 225
.meas tran vdout0_44ck44 FIND v(dout0_44) AT=225.025n

* CHECK dout0_45 Vdout0_45ck44 = 0.9 time = 225
.meas tran vdout0_45ck44 FIND v(dout0_45) AT=225.025n

* CHECK dout0_46 Vdout0_46ck44 = 0.9 time = 225
.meas tran vdout0_46ck44 FIND v(dout0_46) AT=225.025n

* CHECK dout0_47 Vdout0_47ck44 = 0.9 time = 225
.meas tran vdout0_47ck44 FIND v(dout0_47) AT=225.025n

* CHECK dout0_48 Vdout0_48ck44 = 0.9 time = 225
.meas tran vdout0_48ck44 FIND v(dout0_48) AT=225.025n

* CHECK dout0_49 Vdout0_49ck44 = 0 time = 225
.meas tran vdout0_49ck44 FIND v(dout0_49) AT=225.025n

* CHECK dout0_50 Vdout0_50ck44 = 0 time = 225
.meas tran vdout0_50ck44 FIND v(dout0_50) AT=225.025n

* CHECK dout0_51 Vdout0_51ck44 = 0.9 time = 225
.meas tran vdout0_51ck44 FIND v(dout0_51) AT=225.025n

* CHECK dout0_52 Vdout0_52ck44 = 0.9 time = 225
.meas tran vdout0_52ck44 FIND v(dout0_52) AT=225.025n

* CHECK dout0_53 Vdout0_53ck44 = 0.9 time = 225
.meas tran vdout0_53ck44 FIND v(dout0_53) AT=225.025n

* CHECK dout0_54 Vdout0_54ck44 = 0 time = 225
.meas tran vdout0_54ck44 FIND v(dout0_54) AT=225.025n

* CHECK dout0_55 Vdout0_55ck44 = 0 time = 225
.meas tran vdout0_55ck44 FIND v(dout0_55) AT=225.025n

* CHECK dout0_56 Vdout0_56ck44 = 0 time = 225
.meas tran vdout0_56ck44 FIND v(dout0_56) AT=225.025n

* CHECK dout0_57 Vdout0_57ck44 = 0.9 time = 225
.meas tran vdout0_57ck44 FIND v(dout0_57) AT=225.025n

* CHECK dout0_58 Vdout0_58ck44 = 0 time = 225
.meas tran vdout0_58ck44 FIND v(dout0_58) AT=225.025n

* CHECK dout0_59 Vdout0_59ck44 = 0.9 time = 225
.meas tran vdout0_59ck44 FIND v(dout0_59) AT=225.025n

* CHECK dout0_60 Vdout0_60ck44 = 0 time = 225
.meas tran vdout0_60ck44 FIND v(dout0_60) AT=225.025n

* CHECK dout0_61 Vdout0_61ck44 = 0.9 time = 225
.meas tran vdout0_61ck44 FIND v(dout0_61) AT=225.025n

* CHECK dout0_62 Vdout0_62ck44 = 0.9 time = 225
.meas tran vdout0_62ck44 FIND v(dout0_62) AT=225.025n

* CHECK dout0_63 Vdout0_63ck44 = 0 time = 225
.meas tran vdout0_63ck44 FIND v(dout0_63) AT=225.025n

* CHECK dout0_64 Vdout0_64ck44 = 0.9 time = 225
.meas tran vdout0_64ck44 FIND v(dout0_64) AT=225.025n

* CHECK dout0_65 Vdout0_65ck44 = 0 time = 225
.meas tran vdout0_65ck44 FIND v(dout0_65) AT=225.025n

* CHECK dout0_66 Vdout0_66ck44 = 0.9 time = 225
.meas tran vdout0_66ck44 FIND v(dout0_66) AT=225.025n

* CHECK dout0_67 Vdout0_67ck44 = 0.9 time = 225
.meas tran vdout0_67ck44 FIND v(dout0_67) AT=225.025n

* CHECK dout0_68 Vdout0_68ck44 = 0 time = 225
.meas tran vdout0_68ck44 FIND v(dout0_68) AT=225.025n

* CHECK dout0_69 Vdout0_69ck44 = 0.9 time = 225
.meas tran vdout0_69ck44 FIND v(dout0_69) AT=225.025n

* CHECK dout0_70 Vdout0_70ck44 = 0 time = 225
.meas tran vdout0_70ck44 FIND v(dout0_70) AT=225.025n

* CHECK dout0_71 Vdout0_71ck44 = 0 time = 225
.meas tran vdout0_71ck44 FIND v(dout0_71) AT=225.025n

* CHECK dout0_72 Vdout0_72ck44 = 0 time = 225
.meas tran vdout0_72ck44 FIND v(dout0_72) AT=225.025n

* CHECK dout0_73 Vdout0_73ck44 = 0 time = 225
.meas tran vdout0_73ck44 FIND v(dout0_73) AT=225.025n

* CHECK dout0_74 Vdout0_74ck44 = 0 time = 225
.meas tran vdout0_74ck44 FIND v(dout0_74) AT=225.025n

* CHECK dout0_75 Vdout0_75ck44 = 0.9 time = 225
.meas tran vdout0_75ck44 FIND v(dout0_75) AT=225.025n

* CHECK dout0_76 Vdout0_76ck44 = 0.9 time = 225
.meas tran vdout0_76ck44 FIND v(dout0_76) AT=225.025n

* CHECK dout0_77 Vdout0_77ck44 = 0.9 time = 225
.meas tran vdout0_77ck44 FIND v(dout0_77) AT=225.025n

* CHECK dout0_78 Vdout0_78ck44 = 0 time = 225
.meas tran vdout0_78ck44 FIND v(dout0_78) AT=225.025n

* CHECK dout0_79 Vdout0_79ck44 = 0 time = 225
.meas tran vdout0_79ck44 FIND v(dout0_79) AT=225.025n

* CHECK dout0_0 Vdout0_0ck45 = 0 time = 230
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=230.025n

* CHECK dout0_1 Vdout0_1ck45 = 0.9 time = 230
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=230.025n

* CHECK dout0_2 Vdout0_2ck45 = 0.9 time = 230
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=230.025n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 230
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=230.025n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 230
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=230.025n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 230
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=230.025n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 230
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=230.025n

* CHECK dout0_7 Vdout0_7ck45 = 0.9 time = 230
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=230.025n

* CHECK dout0_8 Vdout0_8ck45 = 0 time = 230
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=230.025n

* CHECK dout0_9 Vdout0_9ck45 = 0.9 time = 230
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=230.025n

* CHECK dout0_10 Vdout0_10ck45 = 0 time = 230
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=230.025n

* CHECK dout0_11 Vdout0_11ck45 = 0 time = 230
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=230.025n

* CHECK dout0_12 Vdout0_12ck45 = 0.9 time = 230
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=230.025n

* CHECK dout0_13 Vdout0_13ck45 = 0 time = 230
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=230.025n

* CHECK dout0_14 Vdout0_14ck45 = 0.9 time = 230
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=230.025n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 230
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=230.025n

* CHECK dout0_16 Vdout0_16ck45 = 0.9 time = 230
.meas tran vdout0_16ck45 FIND v(dout0_16) AT=230.025n

* CHECK dout0_17 Vdout0_17ck45 = 0 time = 230
.meas tran vdout0_17ck45 FIND v(dout0_17) AT=230.025n

* CHECK dout0_18 Vdout0_18ck45 = 0 time = 230
.meas tran vdout0_18ck45 FIND v(dout0_18) AT=230.025n

* CHECK dout0_19 Vdout0_19ck45 = 0 time = 230
.meas tran vdout0_19ck45 FIND v(dout0_19) AT=230.025n

* CHECK dout0_20 Vdout0_20ck45 = 0 time = 230
.meas tran vdout0_20ck45 FIND v(dout0_20) AT=230.025n

* CHECK dout0_21 Vdout0_21ck45 = 0.9 time = 230
.meas tran vdout0_21ck45 FIND v(dout0_21) AT=230.025n

* CHECK dout0_22 Vdout0_22ck45 = 0.9 time = 230
.meas tran vdout0_22ck45 FIND v(dout0_22) AT=230.025n

* CHECK dout0_23 Vdout0_23ck45 = 0 time = 230
.meas tran vdout0_23ck45 FIND v(dout0_23) AT=230.025n

* CHECK dout0_24 Vdout0_24ck45 = 0.9 time = 230
.meas tran vdout0_24ck45 FIND v(dout0_24) AT=230.025n

* CHECK dout0_25 Vdout0_25ck45 = 0 time = 230
.meas tran vdout0_25ck45 FIND v(dout0_25) AT=230.025n

* CHECK dout0_26 Vdout0_26ck45 = 0.9 time = 230
.meas tran vdout0_26ck45 FIND v(dout0_26) AT=230.025n

* CHECK dout0_27 Vdout0_27ck45 = 0 time = 230
.meas tran vdout0_27ck45 FIND v(dout0_27) AT=230.025n

* CHECK dout0_28 Vdout0_28ck45 = 0.9 time = 230
.meas tran vdout0_28ck45 FIND v(dout0_28) AT=230.025n

* CHECK dout0_29 Vdout0_29ck45 = 0.9 time = 230
.meas tran vdout0_29ck45 FIND v(dout0_29) AT=230.025n

* CHECK dout0_30 Vdout0_30ck45 = 0 time = 230
.meas tran vdout0_30ck45 FIND v(dout0_30) AT=230.025n

* CHECK dout0_31 Vdout0_31ck45 = 0.9 time = 230
.meas tran vdout0_31ck45 FIND v(dout0_31) AT=230.025n

* CHECK dout0_32 Vdout0_32ck45 = 0 time = 230
.meas tran vdout0_32ck45 FIND v(dout0_32) AT=230.025n

* CHECK dout0_33 Vdout0_33ck45 = 0 time = 230
.meas tran vdout0_33ck45 FIND v(dout0_33) AT=230.025n

* CHECK dout0_34 Vdout0_34ck45 = 0.9 time = 230
.meas tran vdout0_34ck45 FIND v(dout0_34) AT=230.025n

* CHECK dout0_35 Vdout0_35ck45 = 0.9 time = 230
.meas tran vdout0_35ck45 FIND v(dout0_35) AT=230.025n

* CHECK dout0_36 Vdout0_36ck45 = 0 time = 230
.meas tran vdout0_36ck45 FIND v(dout0_36) AT=230.025n

* CHECK dout0_37 Vdout0_37ck45 = 0.9 time = 230
.meas tran vdout0_37ck45 FIND v(dout0_37) AT=230.025n

* CHECK dout0_38 Vdout0_38ck45 = 0 time = 230
.meas tran vdout0_38ck45 FIND v(dout0_38) AT=230.025n

* CHECK dout0_39 Vdout0_39ck45 = 0 time = 230
.meas tran vdout0_39ck45 FIND v(dout0_39) AT=230.025n

* CHECK dout0_40 Vdout0_40ck45 = 0 time = 230
.meas tran vdout0_40ck45 FIND v(dout0_40) AT=230.025n

* CHECK dout0_41 Vdout0_41ck45 = 0 time = 230
.meas tran vdout0_41ck45 FIND v(dout0_41) AT=230.025n

* CHECK dout0_42 Vdout0_42ck45 = 0 time = 230
.meas tran vdout0_42ck45 FIND v(dout0_42) AT=230.025n

* CHECK dout0_43 Vdout0_43ck45 = 0.9 time = 230
.meas tran vdout0_43ck45 FIND v(dout0_43) AT=230.025n

* CHECK dout0_44 Vdout0_44ck45 = 0 time = 230
.meas tran vdout0_44ck45 FIND v(dout0_44) AT=230.025n

* CHECK dout0_45 Vdout0_45ck45 = 0.9 time = 230
.meas tran vdout0_45ck45 FIND v(dout0_45) AT=230.025n

* CHECK dout0_46 Vdout0_46ck45 = 0.9 time = 230
.meas tran vdout0_46ck45 FIND v(dout0_46) AT=230.025n

* CHECK dout0_47 Vdout0_47ck45 = 0.9 time = 230
.meas tran vdout0_47ck45 FIND v(dout0_47) AT=230.025n

* CHECK dout0_48 Vdout0_48ck45 = 0.9 time = 230
.meas tran vdout0_48ck45 FIND v(dout0_48) AT=230.025n

* CHECK dout0_49 Vdout0_49ck45 = 0 time = 230
.meas tran vdout0_49ck45 FIND v(dout0_49) AT=230.025n

* CHECK dout0_50 Vdout0_50ck45 = 0 time = 230
.meas tran vdout0_50ck45 FIND v(dout0_50) AT=230.025n

* CHECK dout0_51 Vdout0_51ck45 = 0.9 time = 230
.meas tran vdout0_51ck45 FIND v(dout0_51) AT=230.025n

* CHECK dout0_52 Vdout0_52ck45 = 0.9 time = 230
.meas tran vdout0_52ck45 FIND v(dout0_52) AT=230.025n

* CHECK dout0_53 Vdout0_53ck45 = 0.9 time = 230
.meas tran vdout0_53ck45 FIND v(dout0_53) AT=230.025n

* CHECK dout0_54 Vdout0_54ck45 = 0 time = 230
.meas tran vdout0_54ck45 FIND v(dout0_54) AT=230.025n

* CHECK dout0_55 Vdout0_55ck45 = 0 time = 230
.meas tran vdout0_55ck45 FIND v(dout0_55) AT=230.025n

* CHECK dout0_56 Vdout0_56ck45 = 0 time = 230
.meas tran vdout0_56ck45 FIND v(dout0_56) AT=230.025n

* CHECK dout0_57 Vdout0_57ck45 = 0.9 time = 230
.meas tran vdout0_57ck45 FIND v(dout0_57) AT=230.025n

* CHECK dout0_58 Vdout0_58ck45 = 0 time = 230
.meas tran vdout0_58ck45 FIND v(dout0_58) AT=230.025n

* CHECK dout0_59 Vdout0_59ck45 = 0.9 time = 230
.meas tran vdout0_59ck45 FIND v(dout0_59) AT=230.025n

* CHECK dout0_60 Vdout0_60ck45 = 0 time = 230
.meas tran vdout0_60ck45 FIND v(dout0_60) AT=230.025n

* CHECK dout0_61 Vdout0_61ck45 = 0.9 time = 230
.meas tran vdout0_61ck45 FIND v(dout0_61) AT=230.025n

* CHECK dout0_62 Vdout0_62ck45 = 0.9 time = 230
.meas tran vdout0_62ck45 FIND v(dout0_62) AT=230.025n

* CHECK dout0_63 Vdout0_63ck45 = 0 time = 230
.meas tran vdout0_63ck45 FIND v(dout0_63) AT=230.025n

* CHECK dout0_64 Vdout0_64ck45 = 0.9 time = 230
.meas tran vdout0_64ck45 FIND v(dout0_64) AT=230.025n

* CHECK dout0_65 Vdout0_65ck45 = 0 time = 230
.meas tran vdout0_65ck45 FIND v(dout0_65) AT=230.025n

* CHECK dout0_66 Vdout0_66ck45 = 0.9 time = 230
.meas tran vdout0_66ck45 FIND v(dout0_66) AT=230.025n

* CHECK dout0_67 Vdout0_67ck45 = 0.9 time = 230
.meas tran vdout0_67ck45 FIND v(dout0_67) AT=230.025n

* CHECK dout0_68 Vdout0_68ck45 = 0 time = 230
.meas tran vdout0_68ck45 FIND v(dout0_68) AT=230.025n

* CHECK dout0_69 Vdout0_69ck45 = 0.9 time = 230
.meas tran vdout0_69ck45 FIND v(dout0_69) AT=230.025n

* CHECK dout0_70 Vdout0_70ck45 = 0 time = 230
.meas tran vdout0_70ck45 FIND v(dout0_70) AT=230.025n

* CHECK dout0_71 Vdout0_71ck45 = 0 time = 230
.meas tran vdout0_71ck45 FIND v(dout0_71) AT=230.025n

* CHECK dout0_72 Vdout0_72ck45 = 0 time = 230
.meas tran vdout0_72ck45 FIND v(dout0_72) AT=230.025n

* CHECK dout0_73 Vdout0_73ck45 = 0 time = 230
.meas tran vdout0_73ck45 FIND v(dout0_73) AT=230.025n

* CHECK dout0_74 Vdout0_74ck45 = 0 time = 230
.meas tran vdout0_74ck45 FIND v(dout0_74) AT=230.025n

* CHECK dout0_75 Vdout0_75ck45 = 0.9 time = 230
.meas tran vdout0_75ck45 FIND v(dout0_75) AT=230.025n

* CHECK dout0_76 Vdout0_76ck45 = 0.9 time = 230
.meas tran vdout0_76ck45 FIND v(dout0_76) AT=230.025n

* CHECK dout0_77 Vdout0_77ck45 = 0.9 time = 230
.meas tran vdout0_77ck45 FIND v(dout0_77) AT=230.025n

* CHECK dout0_78 Vdout0_78ck45 = 0 time = 230
.meas tran vdout0_78ck45 FIND v(dout0_78) AT=230.025n

* CHECK dout0_79 Vdout0_79ck45 = 0 time = 230
.meas tran vdout0_79ck45 FIND v(dout0_79) AT=230.025n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 235
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=235.025n

* CHECK dout0_1 Vdout0_1ck46 = 0.9 time = 235
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=235.025n

* CHECK dout0_2 Vdout0_2ck46 = 0.9 time = 235
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=235.025n

* CHECK dout0_3 Vdout0_3ck46 = 0 time = 235
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=235.025n

* CHECK dout0_4 Vdout0_4ck46 = 0 time = 235
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=235.025n

* CHECK dout0_5 Vdout0_5ck46 = 0 time = 235
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=235.025n

* CHECK dout0_6 Vdout0_6ck46 = 0 time = 235
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=235.025n

* CHECK dout0_7 Vdout0_7ck46 = 0.9 time = 235
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=235.025n

* CHECK dout0_8 Vdout0_8ck46 = 0 time = 235
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=235.025n

* CHECK dout0_9 Vdout0_9ck46 = 0.9 time = 235
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=235.025n

* CHECK dout0_10 Vdout0_10ck46 = 0 time = 235
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=235.025n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 235
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=235.025n

* CHECK dout0_12 Vdout0_12ck46 = 0.9 time = 235
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=235.025n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 235
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=235.025n

* CHECK dout0_14 Vdout0_14ck46 = 0.9 time = 235
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=235.025n

* CHECK dout0_15 Vdout0_15ck46 = 0 time = 235
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=235.025n

* CHECK dout0_16 Vdout0_16ck46 = 0.9 time = 235
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=235.025n

* CHECK dout0_17 Vdout0_17ck46 = 0 time = 235
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=235.025n

* CHECK dout0_18 Vdout0_18ck46 = 0 time = 235
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=235.025n

* CHECK dout0_19 Vdout0_19ck46 = 0 time = 235
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=235.025n

* CHECK dout0_20 Vdout0_20ck46 = 0 time = 235
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=235.025n

* CHECK dout0_21 Vdout0_21ck46 = 0.9 time = 235
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=235.025n

* CHECK dout0_22 Vdout0_22ck46 = 0.9 time = 235
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=235.025n

* CHECK dout0_23 Vdout0_23ck46 = 0 time = 235
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=235.025n

* CHECK dout0_24 Vdout0_24ck46 = 0.9 time = 235
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=235.025n

* CHECK dout0_25 Vdout0_25ck46 = 0 time = 235
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=235.025n

* CHECK dout0_26 Vdout0_26ck46 = 0.9 time = 235
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=235.025n

* CHECK dout0_27 Vdout0_27ck46 = 0 time = 235
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=235.025n

* CHECK dout0_28 Vdout0_28ck46 = 0.9 time = 235
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=235.025n

* CHECK dout0_29 Vdout0_29ck46 = 0.9 time = 235
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=235.025n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 235
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=235.025n

* CHECK dout0_31 Vdout0_31ck46 = 0.9 time = 235
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=235.025n

* CHECK dout0_32 Vdout0_32ck46 = 0 time = 235
.meas tran vdout0_32ck46 FIND v(dout0_32) AT=235.025n

* CHECK dout0_33 Vdout0_33ck46 = 0 time = 235
.meas tran vdout0_33ck46 FIND v(dout0_33) AT=235.025n

* CHECK dout0_34 Vdout0_34ck46 = 0.9 time = 235
.meas tran vdout0_34ck46 FIND v(dout0_34) AT=235.025n

* CHECK dout0_35 Vdout0_35ck46 = 0.9 time = 235
.meas tran vdout0_35ck46 FIND v(dout0_35) AT=235.025n

* CHECK dout0_36 Vdout0_36ck46 = 0 time = 235
.meas tran vdout0_36ck46 FIND v(dout0_36) AT=235.025n

* CHECK dout0_37 Vdout0_37ck46 = 0.9 time = 235
.meas tran vdout0_37ck46 FIND v(dout0_37) AT=235.025n

* CHECK dout0_38 Vdout0_38ck46 = 0 time = 235
.meas tran vdout0_38ck46 FIND v(dout0_38) AT=235.025n

* CHECK dout0_39 Vdout0_39ck46 = 0 time = 235
.meas tran vdout0_39ck46 FIND v(dout0_39) AT=235.025n

* CHECK dout0_40 Vdout0_40ck46 = 0 time = 235
.meas tran vdout0_40ck46 FIND v(dout0_40) AT=235.025n

* CHECK dout0_41 Vdout0_41ck46 = 0 time = 235
.meas tran vdout0_41ck46 FIND v(dout0_41) AT=235.025n

* CHECK dout0_42 Vdout0_42ck46 = 0 time = 235
.meas tran vdout0_42ck46 FIND v(dout0_42) AT=235.025n

* CHECK dout0_43 Vdout0_43ck46 = 0.9 time = 235
.meas tran vdout0_43ck46 FIND v(dout0_43) AT=235.025n

* CHECK dout0_44 Vdout0_44ck46 = 0 time = 235
.meas tran vdout0_44ck46 FIND v(dout0_44) AT=235.025n

* CHECK dout0_45 Vdout0_45ck46 = 0.9 time = 235
.meas tran vdout0_45ck46 FIND v(dout0_45) AT=235.025n

* CHECK dout0_46 Vdout0_46ck46 = 0.9 time = 235
.meas tran vdout0_46ck46 FIND v(dout0_46) AT=235.025n

* CHECK dout0_47 Vdout0_47ck46 = 0.9 time = 235
.meas tran vdout0_47ck46 FIND v(dout0_47) AT=235.025n

* CHECK dout0_48 Vdout0_48ck46 = 0.9 time = 235
.meas tran vdout0_48ck46 FIND v(dout0_48) AT=235.025n

* CHECK dout0_49 Vdout0_49ck46 = 0 time = 235
.meas tran vdout0_49ck46 FIND v(dout0_49) AT=235.025n

* CHECK dout0_50 Vdout0_50ck46 = 0 time = 235
.meas tran vdout0_50ck46 FIND v(dout0_50) AT=235.025n

* CHECK dout0_51 Vdout0_51ck46 = 0.9 time = 235
.meas tran vdout0_51ck46 FIND v(dout0_51) AT=235.025n

* CHECK dout0_52 Vdout0_52ck46 = 0.9 time = 235
.meas tran vdout0_52ck46 FIND v(dout0_52) AT=235.025n

* CHECK dout0_53 Vdout0_53ck46 = 0.9 time = 235
.meas tran vdout0_53ck46 FIND v(dout0_53) AT=235.025n

* CHECK dout0_54 Vdout0_54ck46 = 0 time = 235
.meas tran vdout0_54ck46 FIND v(dout0_54) AT=235.025n

* CHECK dout0_55 Vdout0_55ck46 = 0 time = 235
.meas tran vdout0_55ck46 FIND v(dout0_55) AT=235.025n

* CHECK dout0_56 Vdout0_56ck46 = 0 time = 235
.meas tran vdout0_56ck46 FIND v(dout0_56) AT=235.025n

* CHECK dout0_57 Vdout0_57ck46 = 0.9 time = 235
.meas tran vdout0_57ck46 FIND v(dout0_57) AT=235.025n

* CHECK dout0_58 Vdout0_58ck46 = 0 time = 235
.meas tran vdout0_58ck46 FIND v(dout0_58) AT=235.025n

* CHECK dout0_59 Vdout0_59ck46 = 0.9 time = 235
.meas tran vdout0_59ck46 FIND v(dout0_59) AT=235.025n

* CHECK dout0_60 Vdout0_60ck46 = 0 time = 235
.meas tran vdout0_60ck46 FIND v(dout0_60) AT=235.025n

* CHECK dout0_61 Vdout0_61ck46 = 0.9 time = 235
.meas tran vdout0_61ck46 FIND v(dout0_61) AT=235.025n

* CHECK dout0_62 Vdout0_62ck46 = 0.9 time = 235
.meas tran vdout0_62ck46 FIND v(dout0_62) AT=235.025n

* CHECK dout0_63 Vdout0_63ck46 = 0 time = 235
.meas tran vdout0_63ck46 FIND v(dout0_63) AT=235.025n

* CHECK dout0_64 Vdout0_64ck46 = 0.9 time = 235
.meas tran vdout0_64ck46 FIND v(dout0_64) AT=235.025n

* CHECK dout0_65 Vdout0_65ck46 = 0 time = 235
.meas tran vdout0_65ck46 FIND v(dout0_65) AT=235.025n

* CHECK dout0_66 Vdout0_66ck46 = 0.9 time = 235
.meas tran vdout0_66ck46 FIND v(dout0_66) AT=235.025n

* CHECK dout0_67 Vdout0_67ck46 = 0.9 time = 235
.meas tran vdout0_67ck46 FIND v(dout0_67) AT=235.025n

* CHECK dout0_68 Vdout0_68ck46 = 0 time = 235
.meas tran vdout0_68ck46 FIND v(dout0_68) AT=235.025n

* CHECK dout0_69 Vdout0_69ck46 = 0.9 time = 235
.meas tran vdout0_69ck46 FIND v(dout0_69) AT=235.025n

* CHECK dout0_70 Vdout0_70ck46 = 0 time = 235
.meas tran vdout0_70ck46 FIND v(dout0_70) AT=235.025n

* CHECK dout0_71 Vdout0_71ck46 = 0 time = 235
.meas tran vdout0_71ck46 FIND v(dout0_71) AT=235.025n

* CHECK dout0_72 Vdout0_72ck46 = 0 time = 235
.meas tran vdout0_72ck46 FIND v(dout0_72) AT=235.025n

* CHECK dout0_73 Vdout0_73ck46 = 0 time = 235
.meas tran vdout0_73ck46 FIND v(dout0_73) AT=235.025n

* CHECK dout0_74 Vdout0_74ck46 = 0 time = 235
.meas tran vdout0_74ck46 FIND v(dout0_74) AT=235.025n

* CHECK dout0_75 Vdout0_75ck46 = 0.9 time = 235
.meas tran vdout0_75ck46 FIND v(dout0_75) AT=235.025n

* CHECK dout0_76 Vdout0_76ck46 = 0.9 time = 235
.meas tran vdout0_76ck46 FIND v(dout0_76) AT=235.025n

* CHECK dout0_77 Vdout0_77ck46 = 0.9 time = 235
.meas tran vdout0_77ck46 FIND v(dout0_77) AT=235.025n

* CHECK dout0_78 Vdout0_78ck46 = 0 time = 235
.meas tran vdout0_78ck46 FIND v(dout0_78) AT=235.025n

* CHECK dout0_79 Vdout0_79ck46 = 0 time = 235
.meas tran vdout0_79ck46 FIND v(dout0_79) AT=235.025n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 240
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=240.025n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 240
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=240.025n

* CHECK dout0_2 Vdout0_2ck47 = 0.9 time = 240
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=240.025n

* CHECK dout0_3 Vdout0_3ck47 = 0 time = 240
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=240.025n

* CHECK dout0_4 Vdout0_4ck47 = 0.9 time = 240
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=240.025n

* CHECK dout0_5 Vdout0_5ck47 = 0.9 time = 240
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=240.025n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 240
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=240.025n

* CHECK dout0_7 Vdout0_7ck47 = 0.9 time = 240
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=240.025n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 240
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=240.025n

* CHECK dout0_9 Vdout0_9ck47 = 0.9 time = 240
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=240.025n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 240
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=240.025n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 240
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=240.025n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 240
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=240.025n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 240
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=240.025n

* CHECK dout0_14 Vdout0_14ck47 = 0.9 time = 240
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=240.025n

* CHECK dout0_15 Vdout0_15ck47 = 0.9 time = 240
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=240.025n

* CHECK dout0_16 Vdout0_16ck47 = 0 time = 240
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=240.025n

* CHECK dout0_17 Vdout0_17ck47 = 0 time = 240
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=240.025n

* CHECK dout0_18 Vdout0_18ck47 = 0 time = 240
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=240.025n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 240
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=240.025n

* CHECK dout0_20 Vdout0_20ck47 = 0.9 time = 240
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=240.025n

* CHECK dout0_21 Vdout0_21ck47 = 0.9 time = 240
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=240.025n

* CHECK dout0_22 Vdout0_22ck47 = 0 time = 240
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=240.025n

* CHECK dout0_23 Vdout0_23ck47 = 0.9 time = 240
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=240.025n

* CHECK dout0_24 Vdout0_24ck47 = 0.9 time = 240
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=240.025n

* CHECK dout0_25 Vdout0_25ck47 = 0.9 time = 240
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=240.025n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 240
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=240.025n

* CHECK dout0_27 Vdout0_27ck47 = 0.9 time = 240
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=240.025n

* CHECK dout0_28 Vdout0_28ck47 = 0.9 time = 240
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=240.025n

* CHECK dout0_29 Vdout0_29ck47 = 0.9 time = 240
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=240.025n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 240
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=240.025n

* CHECK dout0_31 Vdout0_31ck47 = 0 time = 240
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=240.025n

* CHECK dout0_32 Vdout0_32ck47 = 0.9 time = 240
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=240.025n

* CHECK dout0_33 Vdout0_33ck47 = 0.9 time = 240
.meas tran vdout0_33ck47 FIND v(dout0_33) AT=240.025n

* CHECK dout0_34 Vdout0_34ck47 = 0 time = 240
.meas tran vdout0_34ck47 FIND v(dout0_34) AT=240.025n

* CHECK dout0_35 Vdout0_35ck47 = 0 time = 240
.meas tran vdout0_35ck47 FIND v(dout0_35) AT=240.025n

* CHECK dout0_36 Vdout0_36ck47 = 0.9 time = 240
.meas tran vdout0_36ck47 FIND v(dout0_36) AT=240.025n

* CHECK dout0_37 Vdout0_37ck47 = 0 time = 240
.meas tran vdout0_37ck47 FIND v(dout0_37) AT=240.025n

* CHECK dout0_38 Vdout0_38ck47 = 0.9 time = 240
.meas tran vdout0_38ck47 FIND v(dout0_38) AT=240.025n

* CHECK dout0_39 Vdout0_39ck47 = 0 time = 240
.meas tran vdout0_39ck47 FIND v(dout0_39) AT=240.025n

* CHECK dout0_40 Vdout0_40ck47 = 0 time = 240
.meas tran vdout0_40ck47 FIND v(dout0_40) AT=240.025n

* CHECK dout0_41 Vdout0_41ck47 = 0.9 time = 240
.meas tran vdout0_41ck47 FIND v(dout0_41) AT=240.025n

* CHECK dout0_42 Vdout0_42ck47 = 0.9 time = 240
.meas tran vdout0_42ck47 FIND v(dout0_42) AT=240.025n

* CHECK dout0_43 Vdout0_43ck47 = 0 time = 240
.meas tran vdout0_43ck47 FIND v(dout0_43) AT=240.025n

* CHECK dout0_44 Vdout0_44ck47 = 0 time = 240
.meas tran vdout0_44ck47 FIND v(dout0_44) AT=240.025n

* CHECK dout0_45 Vdout0_45ck47 = 0.9 time = 240
.meas tran vdout0_45ck47 FIND v(dout0_45) AT=240.025n

* CHECK dout0_46 Vdout0_46ck47 = 0.9 time = 240
.meas tran vdout0_46ck47 FIND v(dout0_46) AT=240.025n

* CHECK dout0_47 Vdout0_47ck47 = 0.9 time = 240
.meas tran vdout0_47ck47 FIND v(dout0_47) AT=240.025n

* CHECK dout0_48 Vdout0_48ck47 = 0 time = 240
.meas tran vdout0_48ck47 FIND v(dout0_48) AT=240.025n

* CHECK dout0_49 Vdout0_49ck47 = 0 time = 240
.meas tran vdout0_49ck47 FIND v(dout0_49) AT=240.025n

* CHECK dout0_50 Vdout0_50ck47 = 0 time = 240
.meas tran vdout0_50ck47 FIND v(dout0_50) AT=240.025n

* CHECK dout0_51 Vdout0_51ck47 = 0 time = 240
.meas tran vdout0_51ck47 FIND v(dout0_51) AT=240.025n

* CHECK dout0_52 Vdout0_52ck47 = 0.9 time = 240
.meas tran vdout0_52ck47 FIND v(dout0_52) AT=240.025n

* CHECK dout0_53 Vdout0_53ck47 = 0.9 time = 240
.meas tran vdout0_53ck47 FIND v(dout0_53) AT=240.025n

* CHECK dout0_54 Vdout0_54ck47 = 0.9 time = 240
.meas tran vdout0_54ck47 FIND v(dout0_54) AT=240.025n

* CHECK dout0_55 Vdout0_55ck47 = 0 time = 240
.meas tran vdout0_55ck47 FIND v(dout0_55) AT=240.025n

* CHECK dout0_56 Vdout0_56ck47 = 0.9 time = 240
.meas tran vdout0_56ck47 FIND v(dout0_56) AT=240.025n

* CHECK dout0_57 Vdout0_57ck47 = 0.9 time = 240
.meas tran vdout0_57ck47 FIND v(dout0_57) AT=240.025n

* CHECK dout0_58 Vdout0_58ck47 = 0 time = 240
.meas tran vdout0_58ck47 FIND v(dout0_58) AT=240.025n

* CHECK dout0_59 Vdout0_59ck47 = 0.9 time = 240
.meas tran vdout0_59ck47 FIND v(dout0_59) AT=240.025n

* CHECK dout0_60 Vdout0_60ck47 = 0 time = 240
.meas tran vdout0_60ck47 FIND v(dout0_60) AT=240.025n

* CHECK dout0_61 Vdout0_61ck47 = 0 time = 240
.meas tran vdout0_61ck47 FIND v(dout0_61) AT=240.025n

* CHECK dout0_62 Vdout0_62ck47 = 0.9 time = 240
.meas tran vdout0_62ck47 FIND v(dout0_62) AT=240.025n

* CHECK dout0_63 Vdout0_63ck47 = 0 time = 240
.meas tran vdout0_63ck47 FIND v(dout0_63) AT=240.025n

* CHECK dout0_64 Vdout0_64ck47 = 0 time = 240
.meas tran vdout0_64ck47 FIND v(dout0_64) AT=240.025n

* CHECK dout0_65 Vdout0_65ck47 = 0 time = 240
.meas tran vdout0_65ck47 FIND v(dout0_65) AT=240.025n

* CHECK dout0_66 Vdout0_66ck47 = 0 time = 240
.meas tran vdout0_66ck47 FIND v(dout0_66) AT=240.025n

* CHECK dout0_67 Vdout0_67ck47 = 0.9 time = 240
.meas tran vdout0_67ck47 FIND v(dout0_67) AT=240.025n

* CHECK dout0_68 Vdout0_68ck47 = 0.9 time = 240
.meas tran vdout0_68ck47 FIND v(dout0_68) AT=240.025n

* CHECK dout0_69 Vdout0_69ck47 = 0 time = 240
.meas tran vdout0_69ck47 FIND v(dout0_69) AT=240.025n

* CHECK dout0_70 Vdout0_70ck47 = 0.9 time = 240
.meas tran vdout0_70ck47 FIND v(dout0_70) AT=240.025n

* CHECK dout0_71 Vdout0_71ck47 = 0.9 time = 240
.meas tran vdout0_71ck47 FIND v(dout0_71) AT=240.025n

* CHECK dout0_72 Vdout0_72ck47 = 0.9 time = 240
.meas tran vdout0_72ck47 FIND v(dout0_72) AT=240.025n

* CHECK dout0_73 Vdout0_73ck47 = 0.9 time = 240
.meas tran vdout0_73ck47 FIND v(dout0_73) AT=240.025n

* CHECK dout0_74 Vdout0_74ck47 = 0.9 time = 240
.meas tran vdout0_74ck47 FIND v(dout0_74) AT=240.025n

* CHECK dout0_75 Vdout0_75ck47 = 0.9 time = 240
.meas tran vdout0_75ck47 FIND v(dout0_75) AT=240.025n

* CHECK dout0_76 Vdout0_76ck47 = 0.9 time = 240
.meas tran vdout0_76ck47 FIND v(dout0_76) AT=240.025n

* CHECK dout0_77 Vdout0_77ck47 = 0 time = 240
.meas tran vdout0_77ck47 FIND v(dout0_77) AT=240.025n

* CHECK dout0_78 Vdout0_78ck47 = 0 time = 240
.meas tran vdout0_78ck47 FIND v(dout0_78) AT=240.025n

* CHECK dout0_79 Vdout0_79ck47 = 0 time = 240
.meas tran vdout0_79ck47 FIND v(dout0_79) AT=240.025n

* CHECK dout0_0 Vdout0_0ck48 = 0 time = 245
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=245.025n

* CHECK dout0_1 Vdout0_1ck48 = 0 time = 245
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=245.025n

* CHECK dout0_2 Vdout0_2ck48 = 0.9 time = 245
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=245.025n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 245
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=245.025n

* CHECK dout0_4 Vdout0_4ck48 = 0.9 time = 245
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=245.025n

* CHECK dout0_5 Vdout0_5ck48 = 0.9 time = 245
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=245.025n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 245
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=245.025n

* CHECK dout0_7 Vdout0_7ck48 = 0.9 time = 245
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=245.025n

* CHECK dout0_8 Vdout0_8ck48 = 0 time = 245
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=245.025n

* CHECK dout0_9 Vdout0_9ck48 = 0.9 time = 245
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=245.025n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 245
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=245.025n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 245
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=245.025n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 245
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=245.025n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 245
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=245.025n

* CHECK dout0_14 Vdout0_14ck48 = 0.9 time = 245
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=245.025n

* CHECK dout0_15 Vdout0_15ck48 = 0.9 time = 245
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=245.025n

* CHECK dout0_16 Vdout0_16ck48 = 0 time = 245
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=245.025n

* CHECK dout0_17 Vdout0_17ck48 = 0 time = 245
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=245.025n

* CHECK dout0_18 Vdout0_18ck48 = 0 time = 245
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=245.025n

* CHECK dout0_19 Vdout0_19ck48 = 0 time = 245
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=245.025n

* CHECK dout0_20 Vdout0_20ck48 = 0.9 time = 245
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=245.025n

* CHECK dout0_21 Vdout0_21ck48 = 0.9 time = 245
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=245.025n

* CHECK dout0_22 Vdout0_22ck48 = 0 time = 245
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=245.025n

* CHECK dout0_23 Vdout0_23ck48 = 0.9 time = 245
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=245.025n

* CHECK dout0_24 Vdout0_24ck48 = 0.9 time = 245
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=245.025n

* CHECK dout0_25 Vdout0_25ck48 = 0.9 time = 245
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=245.025n

* CHECK dout0_26 Vdout0_26ck48 = 0 time = 245
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=245.025n

* CHECK dout0_27 Vdout0_27ck48 = 0.9 time = 245
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=245.025n

* CHECK dout0_28 Vdout0_28ck48 = 0.9 time = 245
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=245.025n

* CHECK dout0_29 Vdout0_29ck48 = 0.9 time = 245
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=245.025n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 245
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=245.025n

* CHECK dout0_31 Vdout0_31ck48 = 0 time = 245
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=245.025n

* CHECK dout0_32 Vdout0_32ck48 = 0.9 time = 245
.meas tran vdout0_32ck48 FIND v(dout0_32) AT=245.025n

* CHECK dout0_33 Vdout0_33ck48 = 0.9 time = 245
.meas tran vdout0_33ck48 FIND v(dout0_33) AT=245.025n

* CHECK dout0_34 Vdout0_34ck48 = 0 time = 245
.meas tran vdout0_34ck48 FIND v(dout0_34) AT=245.025n

* CHECK dout0_35 Vdout0_35ck48 = 0 time = 245
.meas tran vdout0_35ck48 FIND v(dout0_35) AT=245.025n

* CHECK dout0_36 Vdout0_36ck48 = 0.9 time = 245
.meas tran vdout0_36ck48 FIND v(dout0_36) AT=245.025n

* CHECK dout0_37 Vdout0_37ck48 = 0 time = 245
.meas tran vdout0_37ck48 FIND v(dout0_37) AT=245.025n

* CHECK dout0_38 Vdout0_38ck48 = 0.9 time = 245
.meas tran vdout0_38ck48 FIND v(dout0_38) AT=245.025n

* CHECK dout0_39 Vdout0_39ck48 = 0 time = 245
.meas tran vdout0_39ck48 FIND v(dout0_39) AT=245.025n

* CHECK dout0_40 Vdout0_40ck48 = 0 time = 245
.meas tran vdout0_40ck48 FIND v(dout0_40) AT=245.025n

* CHECK dout0_41 Vdout0_41ck48 = 0.9 time = 245
.meas tran vdout0_41ck48 FIND v(dout0_41) AT=245.025n

* CHECK dout0_42 Vdout0_42ck48 = 0.9 time = 245
.meas tran vdout0_42ck48 FIND v(dout0_42) AT=245.025n

* CHECK dout0_43 Vdout0_43ck48 = 0 time = 245
.meas tran vdout0_43ck48 FIND v(dout0_43) AT=245.025n

* CHECK dout0_44 Vdout0_44ck48 = 0 time = 245
.meas tran vdout0_44ck48 FIND v(dout0_44) AT=245.025n

* CHECK dout0_45 Vdout0_45ck48 = 0.9 time = 245
.meas tran vdout0_45ck48 FIND v(dout0_45) AT=245.025n

* CHECK dout0_46 Vdout0_46ck48 = 0.9 time = 245
.meas tran vdout0_46ck48 FIND v(dout0_46) AT=245.025n

* CHECK dout0_47 Vdout0_47ck48 = 0.9 time = 245
.meas tran vdout0_47ck48 FIND v(dout0_47) AT=245.025n

* CHECK dout0_48 Vdout0_48ck48 = 0 time = 245
.meas tran vdout0_48ck48 FIND v(dout0_48) AT=245.025n

* CHECK dout0_49 Vdout0_49ck48 = 0 time = 245
.meas tran vdout0_49ck48 FIND v(dout0_49) AT=245.025n

* CHECK dout0_50 Vdout0_50ck48 = 0 time = 245
.meas tran vdout0_50ck48 FIND v(dout0_50) AT=245.025n

* CHECK dout0_51 Vdout0_51ck48 = 0 time = 245
.meas tran vdout0_51ck48 FIND v(dout0_51) AT=245.025n

* CHECK dout0_52 Vdout0_52ck48 = 0.9 time = 245
.meas tran vdout0_52ck48 FIND v(dout0_52) AT=245.025n

* CHECK dout0_53 Vdout0_53ck48 = 0.9 time = 245
.meas tran vdout0_53ck48 FIND v(dout0_53) AT=245.025n

* CHECK dout0_54 Vdout0_54ck48 = 0.9 time = 245
.meas tran vdout0_54ck48 FIND v(dout0_54) AT=245.025n

* CHECK dout0_55 Vdout0_55ck48 = 0 time = 245
.meas tran vdout0_55ck48 FIND v(dout0_55) AT=245.025n

* CHECK dout0_56 Vdout0_56ck48 = 0.9 time = 245
.meas tran vdout0_56ck48 FIND v(dout0_56) AT=245.025n

* CHECK dout0_57 Vdout0_57ck48 = 0.9 time = 245
.meas tran vdout0_57ck48 FIND v(dout0_57) AT=245.025n

* CHECK dout0_58 Vdout0_58ck48 = 0 time = 245
.meas tran vdout0_58ck48 FIND v(dout0_58) AT=245.025n

* CHECK dout0_59 Vdout0_59ck48 = 0.9 time = 245
.meas tran vdout0_59ck48 FIND v(dout0_59) AT=245.025n

* CHECK dout0_60 Vdout0_60ck48 = 0 time = 245
.meas tran vdout0_60ck48 FIND v(dout0_60) AT=245.025n

* CHECK dout0_61 Vdout0_61ck48 = 0 time = 245
.meas tran vdout0_61ck48 FIND v(dout0_61) AT=245.025n

* CHECK dout0_62 Vdout0_62ck48 = 0.9 time = 245
.meas tran vdout0_62ck48 FIND v(dout0_62) AT=245.025n

* CHECK dout0_63 Vdout0_63ck48 = 0 time = 245
.meas tran vdout0_63ck48 FIND v(dout0_63) AT=245.025n

* CHECK dout0_64 Vdout0_64ck48 = 0 time = 245
.meas tran vdout0_64ck48 FIND v(dout0_64) AT=245.025n

* CHECK dout0_65 Vdout0_65ck48 = 0 time = 245
.meas tran vdout0_65ck48 FIND v(dout0_65) AT=245.025n

* CHECK dout0_66 Vdout0_66ck48 = 0 time = 245
.meas tran vdout0_66ck48 FIND v(dout0_66) AT=245.025n

* CHECK dout0_67 Vdout0_67ck48 = 0.9 time = 245
.meas tran vdout0_67ck48 FIND v(dout0_67) AT=245.025n

* CHECK dout0_68 Vdout0_68ck48 = 0.9 time = 245
.meas tran vdout0_68ck48 FIND v(dout0_68) AT=245.025n

* CHECK dout0_69 Vdout0_69ck48 = 0 time = 245
.meas tran vdout0_69ck48 FIND v(dout0_69) AT=245.025n

* CHECK dout0_70 Vdout0_70ck48 = 0.9 time = 245
.meas tran vdout0_70ck48 FIND v(dout0_70) AT=245.025n

* CHECK dout0_71 Vdout0_71ck48 = 0.9 time = 245
.meas tran vdout0_71ck48 FIND v(dout0_71) AT=245.025n

* CHECK dout0_72 Vdout0_72ck48 = 0.9 time = 245
.meas tran vdout0_72ck48 FIND v(dout0_72) AT=245.025n

* CHECK dout0_73 Vdout0_73ck48 = 0.9 time = 245
.meas tran vdout0_73ck48 FIND v(dout0_73) AT=245.025n

* CHECK dout0_74 Vdout0_74ck48 = 0.9 time = 245
.meas tran vdout0_74ck48 FIND v(dout0_74) AT=245.025n

* CHECK dout0_75 Vdout0_75ck48 = 0.9 time = 245
.meas tran vdout0_75ck48 FIND v(dout0_75) AT=245.025n

* CHECK dout0_76 Vdout0_76ck48 = 0.9 time = 245
.meas tran vdout0_76ck48 FIND v(dout0_76) AT=245.025n

* CHECK dout0_77 Vdout0_77ck48 = 0 time = 245
.meas tran vdout0_77ck48 FIND v(dout0_77) AT=245.025n

* CHECK dout0_78 Vdout0_78ck48 = 0 time = 245
.meas tran vdout0_78ck48 FIND v(dout0_78) AT=245.025n

* CHECK dout0_79 Vdout0_79ck48 = 0 time = 245
.meas tran vdout0_79ck48 FIND v(dout0_79) AT=245.025n

* CHECK dout0_0 Vdout0_0ck51 = 0.9 time = 260
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=260.025n

* CHECK dout0_1 Vdout0_1ck51 = 0 time = 260
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=260.025n

* CHECK dout0_2 Vdout0_2ck51 = 0.9 time = 260
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=260.025n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 260
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=260.025n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 260
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=260.025n

* CHECK dout0_5 Vdout0_5ck51 = 0.9 time = 260
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=260.025n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 260
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=260.025n

* CHECK dout0_7 Vdout0_7ck51 = 0.9 time = 260
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=260.025n

* CHECK dout0_8 Vdout0_8ck51 = 0 time = 260
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=260.025n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 260
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=260.025n

* CHECK dout0_10 Vdout0_10ck51 = 0.9 time = 260
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=260.025n

* CHECK dout0_11 Vdout0_11ck51 = 0 time = 260
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=260.025n

* CHECK dout0_12 Vdout0_12ck51 = 0.9 time = 260
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=260.025n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 260
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=260.025n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 260
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=260.025n

* CHECK dout0_15 Vdout0_15ck51 = 0.9 time = 260
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=260.025n

* CHECK dout0_16 Vdout0_16ck51 = 0 time = 260
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=260.025n

* CHECK dout0_17 Vdout0_17ck51 = 0.9 time = 260
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=260.025n

* CHECK dout0_18 Vdout0_18ck51 = 0 time = 260
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=260.025n

* CHECK dout0_19 Vdout0_19ck51 = 0 time = 260
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=260.025n

* CHECK dout0_20 Vdout0_20ck51 = 0 time = 260
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=260.025n

* CHECK dout0_21 Vdout0_21ck51 = 0 time = 260
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=260.025n

* CHECK dout0_22 Vdout0_22ck51 = 0.9 time = 260
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=260.025n

* CHECK dout0_23 Vdout0_23ck51 = 0.9 time = 260
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=260.025n

* CHECK dout0_24 Vdout0_24ck51 = 0 time = 260
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=260.025n

* CHECK dout0_25 Vdout0_25ck51 = 0 time = 260
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=260.025n

* CHECK dout0_26 Vdout0_26ck51 = 0 time = 260
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=260.025n

* CHECK dout0_27 Vdout0_27ck51 = 0 time = 260
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=260.025n

* CHECK dout0_28 Vdout0_28ck51 = 0.9 time = 260
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=260.025n

* CHECK dout0_29 Vdout0_29ck51 = 0.9 time = 260
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=260.025n

* CHECK dout0_30 Vdout0_30ck51 = 0.9 time = 260
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=260.025n

* CHECK dout0_31 Vdout0_31ck51 = 0.9 time = 260
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=260.025n

* CHECK dout0_32 Vdout0_32ck51 = 0 time = 260
.meas tran vdout0_32ck51 FIND v(dout0_32) AT=260.025n

* CHECK dout0_33 Vdout0_33ck51 = 0 time = 260
.meas tran vdout0_33ck51 FIND v(dout0_33) AT=260.025n

* CHECK dout0_34 Vdout0_34ck51 = 0 time = 260
.meas tran vdout0_34ck51 FIND v(dout0_34) AT=260.025n

* CHECK dout0_35 Vdout0_35ck51 = 0.9 time = 260
.meas tran vdout0_35ck51 FIND v(dout0_35) AT=260.025n

* CHECK dout0_36 Vdout0_36ck51 = 0 time = 260
.meas tran vdout0_36ck51 FIND v(dout0_36) AT=260.025n

* CHECK dout0_37 Vdout0_37ck51 = 0.9 time = 260
.meas tran vdout0_37ck51 FIND v(dout0_37) AT=260.025n

* CHECK dout0_38 Vdout0_38ck51 = 0 time = 260
.meas tran vdout0_38ck51 FIND v(dout0_38) AT=260.025n

* CHECK dout0_39 Vdout0_39ck51 = 0.9 time = 260
.meas tran vdout0_39ck51 FIND v(dout0_39) AT=260.025n

* CHECK dout0_40 Vdout0_40ck51 = 0.9 time = 260
.meas tran vdout0_40ck51 FIND v(dout0_40) AT=260.025n

* CHECK dout0_41 Vdout0_41ck51 = 0.9 time = 260
.meas tran vdout0_41ck51 FIND v(dout0_41) AT=260.025n

* CHECK dout0_42 Vdout0_42ck51 = 0 time = 260
.meas tran vdout0_42ck51 FIND v(dout0_42) AT=260.025n

* CHECK dout0_43 Vdout0_43ck51 = 0.9 time = 260
.meas tran vdout0_43ck51 FIND v(dout0_43) AT=260.025n

* CHECK dout0_44 Vdout0_44ck51 = 0.9 time = 260
.meas tran vdout0_44ck51 FIND v(dout0_44) AT=260.025n

* CHECK dout0_45 Vdout0_45ck51 = 0.9 time = 260
.meas tran vdout0_45ck51 FIND v(dout0_45) AT=260.025n

* CHECK dout0_46 Vdout0_46ck51 = 0 time = 260
.meas tran vdout0_46ck51 FIND v(dout0_46) AT=260.025n

* CHECK dout0_47 Vdout0_47ck51 = 0 time = 260
.meas tran vdout0_47ck51 FIND v(dout0_47) AT=260.025n

* CHECK dout0_48 Vdout0_48ck51 = 0 time = 260
.meas tran vdout0_48ck51 FIND v(dout0_48) AT=260.025n

* CHECK dout0_49 Vdout0_49ck51 = 0.9 time = 260
.meas tran vdout0_49ck51 FIND v(dout0_49) AT=260.025n

* CHECK dout0_50 Vdout0_50ck51 = 0 time = 260
.meas tran vdout0_50ck51 FIND v(dout0_50) AT=260.025n

* CHECK dout0_51 Vdout0_51ck51 = 0 time = 260
.meas tran vdout0_51ck51 FIND v(dout0_51) AT=260.025n

* CHECK dout0_52 Vdout0_52ck51 = 0.9 time = 260
.meas tran vdout0_52ck51 FIND v(dout0_52) AT=260.025n

* CHECK dout0_53 Vdout0_53ck51 = 0.9 time = 260
.meas tran vdout0_53ck51 FIND v(dout0_53) AT=260.025n

* CHECK dout0_54 Vdout0_54ck51 = 0.9 time = 260
.meas tran vdout0_54ck51 FIND v(dout0_54) AT=260.025n

* CHECK dout0_55 Vdout0_55ck51 = 0.9 time = 260
.meas tran vdout0_55ck51 FIND v(dout0_55) AT=260.025n

* CHECK dout0_56 Vdout0_56ck51 = 0.9 time = 260
.meas tran vdout0_56ck51 FIND v(dout0_56) AT=260.025n

* CHECK dout0_57 Vdout0_57ck51 = 0 time = 260
.meas tran vdout0_57ck51 FIND v(dout0_57) AT=260.025n

* CHECK dout0_58 Vdout0_58ck51 = 0.9 time = 260
.meas tran vdout0_58ck51 FIND v(dout0_58) AT=260.025n

* CHECK dout0_59 Vdout0_59ck51 = 0.9 time = 260
.meas tran vdout0_59ck51 FIND v(dout0_59) AT=260.025n

* CHECK dout0_60 Vdout0_60ck51 = 0 time = 260
.meas tran vdout0_60ck51 FIND v(dout0_60) AT=260.025n

* CHECK dout0_61 Vdout0_61ck51 = 0.9 time = 260
.meas tran vdout0_61ck51 FIND v(dout0_61) AT=260.025n

* CHECK dout0_62 Vdout0_62ck51 = 0 time = 260
.meas tran vdout0_62ck51 FIND v(dout0_62) AT=260.025n

* CHECK dout0_63 Vdout0_63ck51 = 0 time = 260
.meas tran vdout0_63ck51 FIND v(dout0_63) AT=260.025n

* CHECK dout0_64 Vdout0_64ck51 = 0.9 time = 260
.meas tran vdout0_64ck51 FIND v(dout0_64) AT=260.025n

* CHECK dout0_65 Vdout0_65ck51 = 0.9 time = 260
.meas tran vdout0_65ck51 FIND v(dout0_65) AT=260.025n

* CHECK dout0_66 Vdout0_66ck51 = 0 time = 260
.meas tran vdout0_66ck51 FIND v(dout0_66) AT=260.025n

* CHECK dout0_67 Vdout0_67ck51 = 0.9 time = 260
.meas tran vdout0_67ck51 FIND v(dout0_67) AT=260.025n

* CHECK dout0_68 Vdout0_68ck51 = 0.9 time = 260
.meas tran vdout0_68ck51 FIND v(dout0_68) AT=260.025n

* CHECK dout0_69 Vdout0_69ck51 = 0.9 time = 260
.meas tran vdout0_69ck51 FIND v(dout0_69) AT=260.025n

* CHECK dout0_70 Vdout0_70ck51 = 0 time = 260
.meas tran vdout0_70ck51 FIND v(dout0_70) AT=260.025n

* CHECK dout0_71 Vdout0_71ck51 = 0 time = 260
.meas tran vdout0_71ck51 FIND v(dout0_71) AT=260.025n

* CHECK dout0_72 Vdout0_72ck51 = 0.9 time = 260
.meas tran vdout0_72ck51 FIND v(dout0_72) AT=260.025n

* CHECK dout0_73 Vdout0_73ck51 = 0 time = 260
.meas tran vdout0_73ck51 FIND v(dout0_73) AT=260.025n

* CHECK dout0_74 Vdout0_74ck51 = 0 time = 260
.meas tran vdout0_74ck51 FIND v(dout0_74) AT=260.025n

* CHECK dout0_75 Vdout0_75ck51 = 0 time = 260
.meas tran vdout0_75ck51 FIND v(dout0_75) AT=260.025n

* CHECK dout0_76 Vdout0_76ck51 = 0 time = 260
.meas tran vdout0_76ck51 FIND v(dout0_76) AT=260.025n

* CHECK dout0_77 Vdout0_77ck51 = 0.9 time = 260
.meas tran vdout0_77ck51 FIND v(dout0_77) AT=260.025n

* CHECK dout0_78 Vdout0_78ck51 = 0 time = 260
.meas tran vdout0_78ck51 FIND v(dout0_78) AT=260.025n

* CHECK dout0_79 Vdout0_79ck51 = 0 time = 260
.meas tran vdout0_79ck51 FIND v(dout0_79) AT=260.025n

* CHECK dout0_0 Vdout0_0ck55 = 0.9 time = 280
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=280.025n

* CHECK dout0_1 Vdout0_1ck55 = 0.9 time = 280
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=280.025n

* CHECK dout0_2 Vdout0_2ck55 = 0 time = 280
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=280.025n

* CHECK dout0_3 Vdout0_3ck55 = 0.9 time = 280
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=280.025n

* CHECK dout0_4 Vdout0_4ck55 = 0.9 time = 280
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=280.025n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 280
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=280.025n

* CHECK dout0_6 Vdout0_6ck55 = 0 time = 280
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=280.025n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 280
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=280.025n

* CHECK dout0_8 Vdout0_8ck55 = 0.9 time = 280
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=280.025n

* CHECK dout0_9 Vdout0_9ck55 = 0 time = 280
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=280.025n

* CHECK dout0_10 Vdout0_10ck55 = 0 time = 280
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=280.025n

* CHECK dout0_11 Vdout0_11ck55 = 0 time = 280
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=280.025n

* CHECK dout0_12 Vdout0_12ck55 = 0.9 time = 280
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=280.025n

* CHECK dout0_13 Vdout0_13ck55 = 0.9 time = 280
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=280.025n

* CHECK dout0_14 Vdout0_14ck55 = 0 time = 280
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=280.025n

* CHECK dout0_15 Vdout0_15ck55 = 0 time = 280
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=280.025n

* CHECK dout0_16 Vdout0_16ck55 = 0.9 time = 280
.meas tran vdout0_16ck55 FIND v(dout0_16) AT=280.025n

* CHECK dout0_17 Vdout0_17ck55 = 0 time = 280
.meas tran vdout0_17ck55 FIND v(dout0_17) AT=280.025n

* CHECK dout0_18 Vdout0_18ck55 = 0.9 time = 280
.meas tran vdout0_18ck55 FIND v(dout0_18) AT=280.025n

* CHECK dout0_19 Vdout0_19ck55 = 0.9 time = 280
.meas tran vdout0_19ck55 FIND v(dout0_19) AT=280.025n

* CHECK dout0_20 Vdout0_20ck55 = 0 time = 280
.meas tran vdout0_20ck55 FIND v(dout0_20) AT=280.025n

* CHECK dout0_21 Vdout0_21ck55 = 0.9 time = 280
.meas tran vdout0_21ck55 FIND v(dout0_21) AT=280.025n

* CHECK dout0_22 Vdout0_22ck55 = 0.9 time = 280
.meas tran vdout0_22ck55 FIND v(dout0_22) AT=280.025n

* CHECK dout0_23 Vdout0_23ck55 = 0 time = 280
.meas tran vdout0_23ck55 FIND v(dout0_23) AT=280.025n

* CHECK dout0_24 Vdout0_24ck55 = 0 time = 280
.meas tran vdout0_24ck55 FIND v(dout0_24) AT=280.025n

* CHECK dout0_25 Vdout0_25ck55 = 0.9 time = 280
.meas tran vdout0_25ck55 FIND v(dout0_25) AT=280.025n

* CHECK dout0_26 Vdout0_26ck55 = 0 time = 280
.meas tran vdout0_26ck55 FIND v(dout0_26) AT=280.025n

* CHECK dout0_27 Vdout0_27ck55 = 0.9 time = 280
.meas tran vdout0_27ck55 FIND v(dout0_27) AT=280.025n

* CHECK dout0_28 Vdout0_28ck55 = 0 time = 280
.meas tran vdout0_28ck55 FIND v(dout0_28) AT=280.025n

* CHECK dout0_29 Vdout0_29ck55 = 0.9 time = 280
.meas tran vdout0_29ck55 FIND v(dout0_29) AT=280.025n

* CHECK dout0_30 Vdout0_30ck55 = 0 time = 280
.meas tran vdout0_30ck55 FIND v(dout0_30) AT=280.025n

* CHECK dout0_31 Vdout0_31ck55 = 0.9 time = 280
.meas tran vdout0_31ck55 FIND v(dout0_31) AT=280.025n

* CHECK dout0_32 Vdout0_32ck55 = 0.9 time = 280
.meas tran vdout0_32ck55 FIND v(dout0_32) AT=280.025n

* CHECK dout0_33 Vdout0_33ck55 = 0 time = 280
.meas tran vdout0_33ck55 FIND v(dout0_33) AT=280.025n

* CHECK dout0_34 Vdout0_34ck55 = 0 time = 280
.meas tran vdout0_34ck55 FIND v(dout0_34) AT=280.025n

* CHECK dout0_35 Vdout0_35ck55 = 0 time = 280
.meas tran vdout0_35ck55 FIND v(dout0_35) AT=280.025n

* CHECK dout0_36 Vdout0_36ck55 = 0.9 time = 280
.meas tran vdout0_36ck55 FIND v(dout0_36) AT=280.025n

* CHECK dout0_37 Vdout0_37ck55 = 0.9 time = 280
.meas tran vdout0_37ck55 FIND v(dout0_37) AT=280.025n

* CHECK dout0_38 Vdout0_38ck55 = 0 time = 280
.meas tran vdout0_38ck55 FIND v(dout0_38) AT=280.025n

* CHECK dout0_39 Vdout0_39ck55 = 0 time = 280
.meas tran vdout0_39ck55 FIND v(dout0_39) AT=280.025n

* CHECK dout0_40 Vdout0_40ck55 = 0 time = 280
.meas tran vdout0_40ck55 FIND v(dout0_40) AT=280.025n

* CHECK dout0_41 Vdout0_41ck55 = 0.9 time = 280
.meas tran vdout0_41ck55 FIND v(dout0_41) AT=280.025n

* CHECK dout0_42 Vdout0_42ck55 = 0 time = 280
.meas tran vdout0_42ck55 FIND v(dout0_42) AT=280.025n

* CHECK dout0_43 Vdout0_43ck55 = 0 time = 280
.meas tran vdout0_43ck55 FIND v(dout0_43) AT=280.025n

* CHECK dout0_44 Vdout0_44ck55 = 0.9 time = 280
.meas tran vdout0_44ck55 FIND v(dout0_44) AT=280.025n

* CHECK dout0_45 Vdout0_45ck55 = 0.9 time = 280
.meas tran vdout0_45ck55 FIND v(dout0_45) AT=280.025n

* CHECK dout0_46 Vdout0_46ck55 = 0.9 time = 280
.meas tran vdout0_46ck55 FIND v(dout0_46) AT=280.025n

* CHECK dout0_47 Vdout0_47ck55 = 0 time = 280
.meas tran vdout0_47ck55 FIND v(dout0_47) AT=280.025n

* CHECK dout0_48 Vdout0_48ck55 = 0.9 time = 280
.meas tran vdout0_48ck55 FIND v(dout0_48) AT=280.025n

* CHECK dout0_49 Vdout0_49ck55 = 0.9 time = 280
.meas tran vdout0_49ck55 FIND v(dout0_49) AT=280.025n

* CHECK dout0_50 Vdout0_50ck55 = 0 time = 280
.meas tran vdout0_50ck55 FIND v(dout0_50) AT=280.025n

* CHECK dout0_51 Vdout0_51ck55 = 0.9 time = 280
.meas tran vdout0_51ck55 FIND v(dout0_51) AT=280.025n

* CHECK dout0_52 Vdout0_52ck55 = 0.9 time = 280
.meas tran vdout0_52ck55 FIND v(dout0_52) AT=280.025n

* CHECK dout0_53 Vdout0_53ck55 = 0.9 time = 280
.meas tran vdout0_53ck55 FIND v(dout0_53) AT=280.025n

* CHECK dout0_54 Vdout0_54ck55 = 0 time = 280
.meas tran vdout0_54ck55 FIND v(dout0_54) AT=280.025n

* CHECK dout0_55 Vdout0_55ck55 = 0.9 time = 280
.meas tran vdout0_55ck55 FIND v(dout0_55) AT=280.025n

* CHECK dout0_56 Vdout0_56ck55 = 0.9 time = 280
.meas tran vdout0_56ck55 FIND v(dout0_56) AT=280.025n

* CHECK dout0_57 Vdout0_57ck55 = 0.9 time = 280
.meas tran vdout0_57ck55 FIND v(dout0_57) AT=280.025n

* CHECK dout0_58 Vdout0_58ck55 = 0.9 time = 280
.meas tran vdout0_58ck55 FIND v(dout0_58) AT=280.025n

* CHECK dout0_59 Vdout0_59ck55 = 0.9 time = 280
.meas tran vdout0_59ck55 FIND v(dout0_59) AT=280.025n

* CHECK dout0_60 Vdout0_60ck55 = 0 time = 280
.meas tran vdout0_60ck55 FIND v(dout0_60) AT=280.025n

* CHECK dout0_61 Vdout0_61ck55 = 0.9 time = 280
.meas tran vdout0_61ck55 FIND v(dout0_61) AT=280.025n

* CHECK dout0_62 Vdout0_62ck55 = 0 time = 280
.meas tran vdout0_62ck55 FIND v(dout0_62) AT=280.025n

* CHECK dout0_63 Vdout0_63ck55 = 0 time = 280
.meas tran vdout0_63ck55 FIND v(dout0_63) AT=280.025n

* CHECK dout0_64 Vdout0_64ck55 = 0 time = 280
.meas tran vdout0_64ck55 FIND v(dout0_64) AT=280.025n

* CHECK dout0_65 Vdout0_65ck55 = 0 time = 280
.meas tran vdout0_65ck55 FIND v(dout0_65) AT=280.025n

* CHECK dout0_66 Vdout0_66ck55 = 0 time = 280
.meas tran vdout0_66ck55 FIND v(dout0_66) AT=280.025n

* CHECK dout0_67 Vdout0_67ck55 = 0.9 time = 280
.meas tran vdout0_67ck55 FIND v(dout0_67) AT=280.025n

* CHECK dout0_68 Vdout0_68ck55 = 0 time = 280
.meas tran vdout0_68ck55 FIND v(dout0_68) AT=280.025n

* CHECK dout0_69 Vdout0_69ck55 = 0.9 time = 280
.meas tran vdout0_69ck55 FIND v(dout0_69) AT=280.025n

* CHECK dout0_70 Vdout0_70ck55 = 0 time = 280
.meas tran vdout0_70ck55 FIND v(dout0_70) AT=280.025n

* CHECK dout0_71 Vdout0_71ck55 = 0 time = 280
.meas tran vdout0_71ck55 FIND v(dout0_71) AT=280.025n

* CHECK dout0_72 Vdout0_72ck55 = 0 time = 280
.meas tran vdout0_72ck55 FIND v(dout0_72) AT=280.025n

* CHECK dout0_73 Vdout0_73ck55 = 0.9 time = 280
.meas tran vdout0_73ck55 FIND v(dout0_73) AT=280.025n

* CHECK dout0_74 Vdout0_74ck55 = 0 time = 280
.meas tran vdout0_74ck55 FIND v(dout0_74) AT=280.025n

* CHECK dout0_75 Vdout0_75ck55 = 0.9 time = 280
.meas tran vdout0_75ck55 FIND v(dout0_75) AT=280.025n

* CHECK dout0_76 Vdout0_76ck55 = 0.9 time = 280
.meas tran vdout0_76ck55 FIND v(dout0_76) AT=280.025n

* CHECK dout0_77 Vdout0_77ck55 = 0 time = 280
.meas tran vdout0_77ck55 FIND v(dout0_77) AT=280.025n

* CHECK dout0_78 Vdout0_78ck55 = 0 time = 280
.meas tran vdout0_78ck55 FIND v(dout0_78) AT=280.025n

* CHECK dout0_79 Vdout0_79ck55 = 0 time = 280
.meas tran vdout0_79ck55 FIND v(dout0_79) AT=280.025n

* CHECK dout0_0 Vdout0_0ck56 = 0.9 time = 285
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=285.025n

* CHECK dout0_1 Vdout0_1ck56 = 0.9 time = 285
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=285.025n

* CHECK dout0_2 Vdout0_2ck56 = 0 time = 285
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=285.025n

* CHECK dout0_3 Vdout0_3ck56 = 0.9 time = 285
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=285.025n

* CHECK dout0_4 Vdout0_4ck56 = 0.9 time = 285
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=285.025n

* CHECK dout0_5 Vdout0_5ck56 = 0 time = 285
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=285.025n

* CHECK dout0_6 Vdout0_6ck56 = 0 time = 285
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=285.025n

* CHECK dout0_7 Vdout0_7ck56 = 0 time = 285
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=285.025n

* CHECK dout0_8 Vdout0_8ck56 = 0.9 time = 285
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=285.025n

* CHECK dout0_9 Vdout0_9ck56 = 0 time = 285
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=285.025n

* CHECK dout0_10 Vdout0_10ck56 = 0 time = 285
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=285.025n

* CHECK dout0_11 Vdout0_11ck56 = 0 time = 285
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=285.025n

* CHECK dout0_12 Vdout0_12ck56 = 0.9 time = 285
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=285.025n

* CHECK dout0_13 Vdout0_13ck56 = 0.9 time = 285
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=285.025n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 285
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=285.025n

* CHECK dout0_15 Vdout0_15ck56 = 0 time = 285
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=285.025n

* CHECK dout0_16 Vdout0_16ck56 = 0.9 time = 285
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=285.025n

* CHECK dout0_17 Vdout0_17ck56 = 0 time = 285
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=285.025n

* CHECK dout0_18 Vdout0_18ck56 = 0.9 time = 285
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=285.025n

* CHECK dout0_19 Vdout0_19ck56 = 0.9 time = 285
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=285.025n

* CHECK dout0_20 Vdout0_20ck56 = 0 time = 285
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=285.025n

* CHECK dout0_21 Vdout0_21ck56 = 0.9 time = 285
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=285.025n

* CHECK dout0_22 Vdout0_22ck56 = 0.9 time = 285
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=285.025n

* CHECK dout0_23 Vdout0_23ck56 = 0 time = 285
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=285.025n

* CHECK dout0_24 Vdout0_24ck56 = 0 time = 285
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=285.025n

* CHECK dout0_25 Vdout0_25ck56 = 0.9 time = 285
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=285.025n

* CHECK dout0_26 Vdout0_26ck56 = 0 time = 285
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=285.025n

* CHECK dout0_27 Vdout0_27ck56 = 0.9 time = 285
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=285.025n

* CHECK dout0_28 Vdout0_28ck56 = 0 time = 285
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=285.025n

* CHECK dout0_29 Vdout0_29ck56 = 0.9 time = 285
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=285.025n

* CHECK dout0_30 Vdout0_30ck56 = 0 time = 285
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=285.025n

* CHECK dout0_31 Vdout0_31ck56 = 0.9 time = 285
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=285.025n

* CHECK dout0_32 Vdout0_32ck56 = 0.9 time = 285
.meas tran vdout0_32ck56 FIND v(dout0_32) AT=285.025n

* CHECK dout0_33 Vdout0_33ck56 = 0 time = 285
.meas tran vdout0_33ck56 FIND v(dout0_33) AT=285.025n

* CHECK dout0_34 Vdout0_34ck56 = 0 time = 285
.meas tran vdout0_34ck56 FIND v(dout0_34) AT=285.025n

* CHECK dout0_35 Vdout0_35ck56 = 0 time = 285
.meas tran vdout0_35ck56 FIND v(dout0_35) AT=285.025n

* CHECK dout0_36 Vdout0_36ck56 = 0.9 time = 285
.meas tran vdout0_36ck56 FIND v(dout0_36) AT=285.025n

* CHECK dout0_37 Vdout0_37ck56 = 0.9 time = 285
.meas tran vdout0_37ck56 FIND v(dout0_37) AT=285.025n

* CHECK dout0_38 Vdout0_38ck56 = 0 time = 285
.meas tran vdout0_38ck56 FIND v(dout0_38) AT=285.025n

* CHECK dout0_39 Vdout0_39ck56 = 0 time = 285
.meas tran vdout0_39ck56 FIND v(dout0_39) AT=285.025n

* CHECK dout0_40 Vdout0_40ck56 = 0 time = 285
.meas tran vdout0_40ck56 FIND v(dout0_40) AT=285.025n

* CHECK dout0_41 Vdout0_41ck56 = 0.9 time = 285
.meas tran vdout0_41ck56 FIND v(dout0_41) AT=285.025n

* CHECK dout0_42 Vdout0_42ck56 = 0 time = 285
.meas tran vdout0_42ck56 FIND v(dout0_42) AT=285.025n

* CHECK dout0_43 Vdout0_43ck56 = 0 time = 285
.meas tran vdout0_43ck56 FIND v(dout0_43) AT=285.025n

* CHECK dout0_44 Vdout0_44ck56 = 0.9 time = 285
.meas tran vdout0_44ck56 FIND v(dout0_44) AT=285.025n

* CHECK dout0_45 Vdout0_45ck56 = 0.9 time = 285
.meas tran vdout0_45ck56 FIND v(dout0_45) AT=285.025n

* CHECK dout0_46 Vdout0_46ck56 = 0.9 time = 285
.meas tran vdout0_46ck56 FIND v(dout0_46) AT=285.025n

* CHECK dout0_47 Vdout0_47ck56 = 0 time = 285
.meas tran vdout0_47ck56 FIND v(dout0_47) AT=285.025n

* CHECK dout0_48 Vdout0_48ck56 = 0.9 time = 285
.meas tran vdout0_48ck56 FIND v(dout0_48) AT=285.025n

* CHECK dout0_49 Vdout0_49ck56 = 0.9 time = 285
.meas tran vdout0_49ck56 FIND v(dout0_49) AT=285.025n

* CHECK dout0_50 Vdout0_50ck56 = 0 time = 285
.meas tran vdout0_50ck56 FIND v(dout0_50) AT=285.025n

* CHECK dout0_51 Vdout0_51ck56 = 0.9 time = 285
.meas tran vdout0_51ck56 FIND v(dout0_51) AT=285.025n

* CHECK dout0_52 Vdout0_52ck56 = 0.9 time = 285
.meas tran vdout0_52ck56 FIND v(dout0_52) AT=285.025n

* CHECK dout0_53 Vdout0_53ck56 = 0.9 time = 285
.meas tran vdout0_53ck56 FIND v(dout0_53) AT=285.025n

* CHECK dout0_54 Vdout0_54ck56 = 0 time = 285
.meas tran vdout0_54ck56 FIND v(dout0_54) AT=285.025n

* CHECK dout0_55 Vdout0_55ck56 = 0.9 time = 285
.meas tran vdout0_55ck56 FIND v(dout0_55) AT=285.025n

* CHECK dout0_56 Vdout0_56ck56 = 0.9 time = 285
.meas tran vdout0_56ck56 FIND v(dout0_56) AT=285.025n

* CHECK dout0_57 Vdout0_57ck56 = 0.9 time = 285
.meas tran vdout0_57ck56 FIND v(dout0_57) AT=285.025n

* CHECK dout0_58 Vdout0_58ck56 = 0.9 time = 285
.meas tran vdout0_58ck56 FIND v(dout0_58) AT=285.025n

* CHECK dout0_59 Vdout0_59ck56 = 0.9 time = 285
.meas tran vdout0_59ck56 FIND v(dout0_59) AT=285.025n

* CHECK dout0_60 Vdout0_60ck56 = 0 time = 285
.meas tran vdout0_60ck56 FIND v(dout0_60) AT=285.025n

* CHECK dout0_61 Vdout0_61ck56 = 0.9 time = 285
.meas tran vdout0_61ck56 FIND v(dout0_61) AT=285.025n

* CHECK dout0_62 Vdout0_62ck56 = 0 time = 285
.meas tran vdout0_62ck56 FIND v(dout0_62) AT=285.025n

* CHECK dout0_63 Vdout0_63ck56 = 0 time = 285
.meas tran vdout0_63ck56 FIND v(dout0_63) AT=285.025n

* CHECK dout0_64 Vdout0_64ck56 = 0 time = 285
.meas tran vdout0_64ck56 FIND v(dout0_64) AT=285.025n

* CHECK dout0_65 Vdout0_65ck56 = 0 time = 285
.meas tran vdout0_65ck56 FIND v(dout0_65) AT=285.025n

* CHECK dout0_66 Vdout0_66ck56 = 0 time = 285
.meas tran vdout0_66ck56 FIND v(dout0_66) AT=285.025n

* CHECK dout0_67 Vdout0_67ck56 = 0.9 time = 285
.meas tran vdout0_67ck56 FIND v(dout0_67) AT=285.025n

* CHECK dout0_68 Vdout0_68ck56 = 0 time = 285
.meas tran vdout0_68ck56 FIND v(dout0_68) AT=285.025n

* CHECK dout0_69 Vdout0_69ck56 = 0.9 time = 285
.meas tran vdout0_69ck56 FIND v(dout0_69) AT=285.025n

* CHECK dout0_70 Vdout0_70ck56 = 0 time = 285
.meas tran vdout0_70ck56 FIND v(dout0_70) AT=285.025n

* CHECK dout0_71 Vdout0_71ck56 = 0 time = 285
.meas tran vdout0_71ck56 FIND v(dout0_71) AT=285.025n

* CHECK dout0_72 Vdout0_72ck56 = 0 time = 285
.meas tran vdout0_72ck56 FIND v(dout0_72) AT=285.025n

* CHECK dout0_73 Vdout0_73ck56 = 0.9 time = 285
.meas tran vdout0_73ck56 FIND v(dout0_73) AT=285.025n

* CHECK dout0_74 Vdout0_74ck56 = 0 time = 285
.meas tran vdout0_74ck56 FIND v(dout0_74) AT=285.025n

* CHECK dout0_75 Vdout0_75ck56 = 0.9 time = 285
.meas tran vdout0_75ck56 FIND v(dout0_75) AT=285.025n

* CHECK dout0_76 Vdout0_76ck56 = 0.9 time = 285
.meas tran vdout0_76ck56 FIND v(dout0_76) AT=285.025n

* CHECK dout0_77 Vdout0_77ck56 = 0 time = 285
.meas tran vdout0_77ck56 FIND v(dout0_77) AT=285.025n

* CHECK dout0_78 Vdout0_78ck56 = 0 time = 285
.meas tran vdout0_78ck56 FIND v(dout0_78) AT=285.025n

* CHECK dout0_79 Vdout0_79ck56 = 0 time = 285
.meas tran vdout0_79ck56 FIND v(dout0_79) AT=285.025n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 295
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=295.025n

* CHECK dout0_1 Vdout0_1ck58 = 0 time = 295
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=295.025n

* CHECK dout0_2 Vdout0_2ck58 = 0.9 time = 295
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=295.025n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 295
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=295.025n

* CHECK dout0_4 Vdout0_4ck58 = 0.9 time = 295
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=295.025n

* CHECK dout0_5 Vdout0_5ck58 = 0.9 time = 295
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=295.025n

* CHECK dout0_6 Vdout0_6ck58 = 0 time = 295
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=295.025n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 295
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=295.025n

* CHECK dout0_8 Vdout0_8ck58 = 0.9 time = 295
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=295.025n

* CHECK dout0_9 Vdout0_9ck58 = 0 time = 295
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=295.025n

* CHECK dout0_10 Vdout0_10ck58 = 0.9 time = 295
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=295.025n

* CHECK dout0_11 Vdout0_11ck58 = 0 time = 295
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=295.025n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 295
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=295.025n

* CHECK dout0_13 Vdout0_13ck58 = 0.9 time = 295
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=295.025n

* CHECK dout0_14 Vdout0_14ck58 = 0.9 time = 295
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=295.025n

* CHECK dout0_15 Vdout0_15ck58 = 0.9 time = 295
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=295.025n

* CHECK dout0_16 Vdout0_16ck58 = 0.9 time = 295
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=295.025n

* CHECK dout0_17 Vdout0_17ck58 = 0.9 time = 295
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=295.025n

* CHECK dout0_18 Vdout0_18ck58 = 0.9 time = 295
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=295.025n

* CHECK dout0_19 Vdout0_19ck58 = 0 time = 295
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=295.025n

* CHECK dout0_20 Vdout0_20ck58 = 0 time = 295
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=295.025n

* CHECK dout0_21 Vdout0_21ck58 = 0.9 time = 295
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=295.025n

* CHECK dout0_22 Vdout0_22ck58 = 0 time = 295
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=295.025n

* CHECK dout0_23 Vdout0_23ck58 = 0 time = 295
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=295.025n

* CHECK dout0_24 Vdout0_24ck58 = 0 time = 295
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=295.025n

* CHECK dout0_25 Vdout0_25ck58 = 0.9 time = 295
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=295.025n

* CHECK dout0_26 Vdout0_26ck58 = 0.9 time = 295
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=295.025n

* CHECK dout0_27 Vdout0_27ck58 = 0 time = 295
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=295.025n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 295
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=295.025n

* CHECK dout0_29 Vdout0_29ck58 = 0.9 time = 295
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=295.025n

* CHECK dout0_30 Vdout0_30ck58 = 0.9 time = 295
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=295.025n

* CHECK dout0_31 Vdout0_31ck58 = 0.9 time = 295
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=295.025n

* CHECK dout0_32 Vdout0_32ck58 = 0.9 time = 295
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=295.025n

* CHECK dout0_33 Vdout0_33ck58 = 0.9 time = 295
.meas tran vdout0_33ck58 FIND v(dout0_33) AT=295.025n

* CHECK dout0_34 Vdout0_34ck58 = 0 time = 295
.meas tran vdout0_34ck58 FIND v(dout0_34) AT=295.025n

* CHECK dout0_35 Vdout0_35ck58 = 0.9 time = 295
.meas tran vdout0_35ck58 FIND v(dout0_35) AT=295.025n

* CHECK dout0_36 Vdout0_36ck58 = 0.9 time = 295
.meas tran vdout0_36ck58 FIND v(dout0_36) AT=295.025n

* CHECK dout0_37 Vdout0_37ck58 = 0 time = 295
.meas tran vdout0_37ck58 FIND v(dout0_37) AT=295.025n

* CHECK dout0_38 Vdout0_38ck58 = 0 time = 295
.meas tran vdout0_38ck58 FIND v(dout0_38) AT=295.025n

* CHECK dout0_39 Vdout0_39ck58 = 0 time = 295
.meas tran vdout0_39ck58 FIND v(dout0_39) AT=295.025n

* CHECK dout0_40 Vdout0_40ck58 = 0 time = 295
.meas tran vdout0_40ck58 FIND v(dout0_40) AT=295.025n

* CHECK dout0_41 Vdout0_41ck58 = 0 time = 295
.meas tran vdout0_41ck58 FIND v(dout0_41) AT=295.025n

* CHECK dout0_42 Vdout0_42ck58 = 0.9 time = 295
.meas tran vdout0_42ck58 FIND v(dout0_42) AT=295.025n

* CHECK dout0_43 Vdout0_43ck58 = 0.9 time = 295
.meas tran vdout0_43ck58 FIND v(dout0_43) AT=295.025n

* CHECK dout0_44 Vdout0_44ck58 = 0 time = 295
.meas tran vdout0_44ck58 FIND v(dout0_44) AT=295.025n

* CHECK dout0_45 Vdout0_45ck58 = 0.9 time = 295
.meas tran vdout0_45ck58 FIND v(dout0_45) AT=295.025n

* CHECK dout0_46 Vdout0_46ck58 = 0.9 time = 295
.meas tran vdout0_46ck58 FIND v(dout0_46) AT=295.025n

* CHECK dout0_47 Vdout0_47ck58 = 0 time = 295
.meas tran vdout0_47ck58 FIND v(dout0_47) AT=295.025n

* CHECK dout0_48 Vdout0_48ck58 = 0.9 time = 295
.meas tran vdout0_48ck58 FIND v(dout0_48) AT=295.025n

* CHECK dout0_49 Vdout0_49ck58 = 0.9 time = 295
.meas tran vdout0_49ck58 FIND v(dout0_49) AT=295.025n

* CHECK dout0_50 Vdout0_50ck58 = 0.9 time = 295
.meas tran vdout0_50ck58 FIND v(dout0_50) AT=295.025n

* CHECK dout0_51 Vdout0_51ck58 = 0.9 time = 295
.meas tran vdout0_51ck58 FIND v(dout0_51) AT=295.025n

* CHECK dout0_52 Vdout0_52ck58 = 0 time = 295
.meas tran vdout0_52ck58 FIND v(dout0_52) AT=295.025n

* CHECK dout0_53 Vdout0_53ck58 = 0.9 time = 295
.meas tran vdout0_53ck58 FIND v(dout0_53) AT=295.025n

* CHECK dout0_54 Vdout0_54ck58 = 0 time = 295
.meas tran vdout0_54ck58 FIND v(dout0_54) AT=295.025n

* CHECK dout0_55 Vdout0_55ck58 = 0.9 time = 295
.meas tran vdout0_55ck58 FIND v(dout0_55) AT=295.025n

* CHECK dout0_56 Vdout0_56ck58 = 0.9 time = 295
.meas tran vdout0_56ck58 FIND v(dout0_56) AT=295.025n

* CHECK dout0_57 Vdout0_57ck58 = 0.9 time = 295
.meas tran vdout0_57ck58 FIND v(dout0_57) AT=295.025n

* CHECK dout0_58 Vdout0_58ck58 = 0.9 time = 295
.meas tran vdout0_58ck58 FIND v(dout0_58) AT=295.025n

* CHECK dout0_59 Vdout0_59ck58 = 0 time = 295
.meas tran vdout0_59ck58 FIND v(dout0_59) AT=295.025n

* CHECK dout0_60 Vdout0_60ck58 = 0 time = 295
.meas tran vdout0_60ck58 FIND v(dout0_60) AT=295.025n

* CHECK dout0_61 Vdout0_61ck58 = 0.9 time = 295
.meas tran vdout0_61ck58 FIND v(dout0_61) AT=295.025n

* CHECK dout0_62 Vdout0_62ck58 = 0.9 time = 295
.meas tran vdout0_62ck58 FIND v(dout0_62) AT=295.025n

* CHECK dout0_63 Vdout0_63ck58 = 0 time = 295
.meas tran vdout0_63ck58 FIND v(dout0_63) AT=295.025n

* CHECK dout0_64 Vdout0_64ck58 = 0 time = 295
.meas tran vdout0_64ck58 FIND v(dout0_64) AT=295.025n

* CHECK dout0_65 Vdout0_65ck58 = 0.9 time = 295
.meas tran vdout0_65ck58 FIND v(dout0_65) AT=295.025n

* CHECK dout0_66 Vdout0_66ck58 = 0.9 time = 295
.meas tran vdout0_66ck58 FIND v(dout0_66) AT=295.025n

* CHECK dout0_67 Vdout0_67ck58 = 0.9 time = 295
.meas tran vdout0_67ck58 FIND v(dout0_67) AT=295.025n

* CHECK dout0_68 Vdout0_68ck58 = 0 time = 295
.meas tran vdout0_68ck58 FIND v(dout0_68) AT=295.025n

* CHECK dout0_69 Vdout0_69ck58 = 0.9 time = 295
.meas tran vdout0_69ck58 FIND v(dout0_69) AT=295.025n

* CHECK dout0_70 Vdout0_70ck58 = 0 time = 295
.meas tran vdout0_70ck58 FIND v(dout0_70) AT=295.025n

* CHECK dout0_71 Vdout0_71ck58 = 0 time = 295
.meas tran vdout0_71ck58 FIND v(dout0_71) AT=295.025n

* CHECK dout0_72 Vdout0_72ck58 = 0 time = 295
.meas tran vdout0_72ck58 FIND v(dout0_72) AT=295.025n

* CHECK dout0_73 Vdout0_73ck58 = 0.9 time = 295
.meas tran vdout0_73ck58 FIND v(dout0_73) AT=295.025n

* CHECK dout0_74 Vdout0_74ck58 = 0 time = 295
.meas tran vdout0_74ck58 FIND v(dout0_74) AT=295.025n

* CHECK dout0_75 Vdout0_75ck58 = 0.9 time = 295
.meas tran vdout0_75ck58 FIND v(dout0_75) AT=295.025n

* CHECK dout0_76 Vdout0_76ck58 = 0 time = 295
.meas tran vdout0_76ck58 FIND v(dout0_76) AT=295.025n

* CHECK dout0_77 Vdout0_77ck58 = 0.9 time = 295
.meas tran vdout0_77ck58 FIND v(dout0_77) AT=295.025n

* CHECK dout0_78 Vdout0_78ck58 = 0.9 time = 295
.meas tran vdout0_78ck58 FIND v(dout0_78) AT=295.025n

* CHECK dout0_79 Vdout0_79ck58 = 0.9 time = 295
.meas tran vdout0_79ck58 FIND v(dout0_79) AT=295.025n

* CHECK dout0_0 Vdout0_0ck64 = 0 time = 325
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=325.025n

* CHECK dout0_1 Vdout0_1ck64 = 0.9 time = 325
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=325.025n

* CHECK dout0_2 Vdout0_2ck64 = 0 time = 325
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=325.025n

* CHECK dout0_3 Vdout0_3ck64 = 0.9 time = 325
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=325.025n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 325
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=325.025n

* CHECK dout0_5 Vdout0_5ck64 = 0 time = 325
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=325.025n

* CHECK dout0_6 Vdout0_6ck64 = 0.9 time = 325
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=325.025n

* CHECK dout0_7 Vdout0_7ck64 = 0.9 time = 325
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=325.025n

* CHECK dout0_8 Vdout0_8ck64 = 0.9 time = 325
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=325.025n

* CHECK dout0_9 Vdout0_9ck64 = 0 time = 325
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=325.025n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 325
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=325.025n

* CHECK dout0_11 Vdout0_11ck64 = 0 time = 325
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=325.025n

* CHECK dout0_12 Vdout0_12ck64 = 0 time = 325
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=325.025n

* CHECK dout0_13 Vdout0_13ck64 = 0.9 time = 325
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=325.025n

* CHECK dout0_14 Vdout0_14ck64 = 0.9 time = 325
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=325.025n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 325
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=325.025n

* CHECK dout0_16 Vdout0_16ck64 = 0.9 time = 325
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=325.025n

* CHECK dout0_17 Vdout0_17ck64 = 0.9 time = 325
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=325.025n

* CHECK dout0_18 Vdout0_18ck64 = 0.9 time = 325
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=325.025n

* CHECK dout0_19 Vdout0_19ck64 = 0.9 time = 325
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=325.025n

* CHECK dout0_20 Vdout0_20ck64 = 0.9 time = 325
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=325.025n

* CHECK dout0_21 Vdout0_21ck64 = 0.9 time = 325
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=325.025n

* CHECK dout0_22 Vdout0_22ck64 = 0 time = 325
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=325.025n

* CHECK dout0_23 Vdout0_23ck64 = 0 time = 325
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=325.025n

* CHECK dout0_24 Vdout0_24ck64 = 0.9 time = 325
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=325.025n

* CHECK dout0_25 Vdout0_25ck64 = 0.9 time = 325
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=325.025n

* CHECK dout0_26 Vdout0_26ck64 = 0.9 time = 325
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=325.025n

* CHECK dout0_27 Vdout0_27ck64 = 0.9 time = 325
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=325.025n

* CHECK dout0_28 Vdout0_28ck64 = 0.9 time = 325
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=325.025n

* CHECK dout0_29 Vdout0_29ck64 = 0.9 time = 325
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=325.025n

* CHECK dout0_30 Vdout0_30ck64 = 0 time = 325
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=325.025n

* CHECK dout0_31 Vdout0_31ck64 = 0.9 time = 325
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=325.025n

* CHECK dout0_32 Vdout0_32ck64 = 0.9 time = 325
.meas tran vdout0_32ck64 FIND v(dout0_32) AT=325.025n

* CHECK dout0_33 Vdout0_33ck64 = 0.9 time = 325
.meas tran vdout0_33ck64 FIND v(dout0_33) AT=325.025n

* CHECK dout0_34 Vdout0_34ck64 = 0.9 time = 325
.meas tran vdout0_34ck64 FIND v(dout0_34) AT=325.025n

* CHECK dout0_35 Vdout0_35ck64 = 0.9 time = 325
.meas tran vdout0_35ck64 FIND v(dout0_35) AT=325.025n

* CHECK dout0_36 Vdout0_36ck64 = 0.9 time = 325
.meas tran vdout0_36ck64 FIND v(dout0_36) AT=325.025n

* CHECK dout0_37 Vdout0_37ck64 = 0 time = 325
.meas tran vdout0_37ck64 FIND v(dout0_37) AT=325.025n

* CHECK dout0_38 Vdout0_38ck64 = 0.9 time = 325
.meas tran vdout0_38ck64 FIND v(dout0_38) AT=325.025n

* CHECK dout0_39 Vdout0_39ck64 = 0 time = 325
.meas tran vdout0_39ck64 FIND v(dout0_39) AT=325.025n

* CHECK dout0_40 Vdout0_40ck64 = 0.9 time = 325
.meas tran vdout0_40ck64 FIND v(dout0_40) AT=325.025n

* CHECK dout0_41 Vdout0_41ck64 = 0 time = 325
.meas tran vdout0_41ck64 FIND v(dout0_41) AT=325.025n

* CHECK dout0_42 Vdout0_42ck64 = 0 time = 325
.meas tran vdout0_42ck64 FIND v(dout0_42) AT=325.025n

* CHECK dout0_43 Vdout0_43ck64 = 0.9 time = 325
.meas tran vdout0_43ck64 FIND v(dout0_43) AT=325.025n

* CHECK dout0_44 Vdout0_44ck64 = 0 time = 325
.meas tran vdout0_44ck64 FIND v(dout0_44) AT=325.025n

* CHECK dout0_45 Vdout0_45ck64 = 0.9 time = 325
.meas tran vdout0_45ck64 FIND v(dout0_45) AT=325.025n

* CHECK dout0_46 Vdout0_46ck64 = 0 time = 325
.meas tran vdout0_46ck64 FIND v(dout0_46) AT=325.025n

* CHECK dout0_47 Vdout0_47ck64 = 0 time = 325
.meas tran vdout0_47ck64 FIND v(dout0_47) AT=325.025n

* CHECK dout0_48 Vdout0_48ck64 = 0 time = 325
.meas tran vdout0_48ck64 FIND v(dout0_48) AT=325.025n

* CHECK dout0_49 Vdout0_49ck64 = 0 time = 325
.meas tran vdout0_49ck64 FIND v(dout0_49) AT=325.025n

* CHECK dout0_50 Vdout0_50ck64 = 0 time = 325
.meas tran vdout0_50ck64 FIND v(dout0_50) AT=325.025n

* CHECK dout0_51 Vdout0_51ck64 = 0.9 time = 325
.meas tran vdout0_51ck64 FIND v(dout0_51) AT=325.025n

* CHECK dout0_52 Vdout0_52ck64 = 0.9 time = 325
.meas tran vdout0_52ck64 FIND v(dout0_52) AT=325.025n

* CHECK dout0_53 Vdout0_53ck64 = 0 time = 325
.meas tran vdout0_53ck64 FIND v(dout0_53) AT=325.025n

* CHECK dout0_54 Vdout0_54ck64 = 0.9 time = 325
.meas tran vdout0_54ck64 FIND v(dout0_54) AT=325.025n

* CHECK dout0_55 Vdout0_55ck64 = 0 time = 325
.meas tran vdout0_55ck64 FIND v(dout0_55) AT=325.025n

* CHECK dout0_56 Vdout0_56ck64 = 0 time = 325
.meas tran vdout0_56ck64 FIND v(dout0_56) AT=325.025n

* CHECK dout0_57 Vdout0_57ck64 = 0.9 time = 325
.meas tran vdout0_57ck64 FIND v(dout0_57) AT=325.025n

* CHECK dout0_58 Vdout0_58ck64 = 0.9 time = 325
.meas tran vdout0_58ck64 FIND v(dout0_58) AT=325.025n

* CHECK dout0_59 Vdout0_59ck64 = 0.9 time = 325
.meas tran vdout0_59ck64 FIND v(dout0_59) AT=325.025n

* CHECK dout0_60 Vdout0_60ck64 = 0.9 time = 325
.meas tran vdout0_60ck64 FIND v(dout0_60) AT=325.025n

* CHECK dout0_61 Vdout0_61ck64 = 0 time = 325
.meas tran vdout0_61ck64 FIND v(dout0_61) AT=325.025n

* CHECK dout0_62 Vdout0_62ck64 = 0.9 time = 325
.meas tran vdout0_62ck64 FIND v(dout0_62) AT=325.025n

* CHECK dout0_63 Vdout0_63ck64 = 0 time = 325
.meas tran vdout0_63ck64 FIND v(dout0_63) AT=325.025n

* CHECK dout0_64 Vdout0_64ck64 = 0.9 time = 325
.meas tran vdout0_64ck64 FIND v(dout0_64) AT=325.025n

* CHECK dout0_65 Vdout0_65ck64 = 0.9 time = 325
.meas tran vdout0_65ck64 FIND v(dout0_65) AT=325.025n

* CHECK dout0_66 Vdout0_66ck64 = 0.9 time = 325
.meas tran vdout0_66ck64 FIND v(dout0_66) AT=325.025n

* CHECK dout0_67 Vdout0_67ck64 = 0.9 time = 325
.meas tran vdout0_67ck64 FIND v(dout0_67) AT=325.025n

* CHECK dout0_68 Vdout0_68ck64 = 0.9 time = 325
.meas tran vdout0_68ck64 FIND v(dout0_68) AT=325.025n

* CHECK dout0_69 Vdout0_69ck64 = 0.9 time = 325
.meas tran vdout0_69ck64 FIND v(dout0_69) AT=325.025n

* CHECK dout0_70 Vdout0_70ck64 = 0 time = 325
.meas tran vdout0_70ck64 FIND v(dout0_70) AT=325.025n

* CHECK dout0_71 Vdout0_71ck64 = 0 time = 325
.meas tran vdout0_71ck64 FIND v(dout0_71) AT=325.025n

* CHECK dout0_72 Vdout0_72ck64 = 0 time = 325
.meas tran vdout0_72ck64 FIND v(dout0_72) AT=325.025n

* CHECK dout0_73 Vdout0_73ck64 = 0.9 time = 325
.meas tran vdout0_73ck64 FIND v(dout0_73) AT=325.025n

* CHECK dout0_74 Vdout0_74ck64 = 0 time = 325
.meas tran vdout0_74ck64 FIND v(dout0_74) AT=325.025n

* CHECK dout0_75 Vdout0_75ck64 = 0 time = 325
.meas tran vdout0_75ck64 FIND v(dout0_75) AT=325.025n

* CHECK dout0_76 Vdout0_76ck64 = 0 time = 325
.meas tran vdout0_76ck64 FIND v(dout0_76) AT=325.025n

* CHECK dout0_77 Vdout0_77ck64 = 0.9 time = 325
.meas tran vdout0_77ck64 FIND v(dout0_77) AT=325.025n

* CHECK dout0_78 Vdout0_78ck64 = 0.9 time = 325
.meas tran vdout0_78ck64 FIND v(dout0_78) AT=325.025n

* CHECK dout0_79 Vdout0_79ck64 = 0 time = 325
.meas tran vdout0_79ck64 FIND v(dout0_79) AT=325.025n

* CHECK dout0_0 Vdout0_0ck65 = 0 time = 330
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=330.025n

* CHECK dout0_1 Vdout0_1ck65 = 0.9 time = 330
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=330.025n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 330
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=330.025n

* CHECK dout0_3 Vdout0_3ck65 = 0.9 time = 330
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=330.025n

* CHECK dout0_4 Vdout0_4ck65 = 0 time = 330
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=330.025n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 330
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=330.025n

* CHECK dout0_6 Vdout0_6ck65 = 0.9 time = 330
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=330.025n

* CHECK dout0_7 Vdout0_7ck65 = 0.9 time = 330
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=330.025n

* CHECK dout0_8 Vdout0_8ck65 = 0.9 time = 330
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=330.025n

* CHECK dout0_9 Vdout0_9ck65 = 0 time = 330
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=330.025n

* CHECK dout0_10 Vdout0_10ck65 = 0 time = 330
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=330.025n

* CHECK dout0_11 Vdout0_11ck65 = 0 time = 330
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=330.025n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 330
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=330.025n

* CHECK dout0_13 Vdout0_13ck65 = 0.9 time = 330
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=330.025n

* CHECK dout0_14 Vdout0_14ck65 = 0.9 time = 330
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=330.025n

* CHECK dout0_15 Vdout0_15ck65 = 0 time = 330
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=330.025n

* CHECK dout0_16 Vdout0_16ck65 = 0.9 time = 330
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=330.025n

* CHECK dout0_17 Vdout0_17ck65 = 0.9 time = 330
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=330.025n

* CHECK dout0_18 Vdout0_18ck65 = 0.9 time = 330
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=330.025n

* CHECK dout0_19 Vdout0_19ck65 = 0.9 time = 330
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=330.025n

* CHECK dout0_20 Vdout0_20ck65 = 0.9 time = 330
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=330.025n

* CHECK dout0_21 Vdout0_21ck65 = 0.9 time = 330
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=330.025n

* CHECK dout0_22 Vdout0_22ck65 = 0 time = 330
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=330.025n

* CHECK dout0_23 Vdout0_23ck65 = 0 time = 330
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=330.025n

* CHECK dout0_24 Vdout0_24ck65 = 0.9 time = 330
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=330.025n

* CHECK dout0_25 Vdout0_25ck65 = 0.9 time = 330
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=330.025n

* CHECK dout0_26 Vdout0_26ck65 = 0.9 time = 330
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=330.025n

* CHECK dout0_27 Vdout0_27ck65 = 0.9 time = 330
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=330.025n

* CHECK dout0_28 Vdout0_28ck65 = 0.9 time = 330
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=330.025n

* CHECK dout0_29 Vdout0_29ck65 = 0.9 time = 330
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=330.025n

* CHECK dout0_30 Vdout0_30ck65 = 0 time = 330
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=330.025n

* CHECK dout0_31 Vdout0_31ck65 = 0.9 time = 330
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=330.025n

* CHECK dout0_32 Vdout0_32ck65 = 0.9 time = 330
.meas tran vdout0_32ck65 FIND v(dout0_32) AT=330.025n

* CHECK dout0_33 Vdout0_33ck65 = 0.9 time = 330
.meas tran vdout0_33ck65 FIND v(dout0_33) AT=330.025n

* CHECK dout0_34 Vdout0_34ck65 = 0.9 time = 330
.meas tran vdout0_34ck65 FIND v(dout0_34) AT=330.025n

* CHECK dout0_35 Vdout0_35ck65 = 0.9 time = 330
.meas tran vdout0_35ck65 FIND v(dout0_35) AT=330.025n

* CHECK dout0_36 Vdout0_36ck65 = 0.9 time = 330
.meas tran vdout0_36ck65 FIND v(dout0_36) AT=330.025n

* CHECK dout0_37 Vdout0_37ck65 = 0 time = 330
.meas tran vdout0_37ck65 FIND v(dout0_37) AT=330.025n

* CHECK dout0_38 Vdout0_38ck65 = 0.9 time = 330
.meas tran vdout0_38ck65 FIND v(dout0_38) AT=330.025n

* CHECK dout0_39 Vdout0_39ck65 = 0 time = 330
.meas tran vdout0_39ck65 FIND v(dout0_39) AT=330.025n

* CHECK dout0_40 Vdout0_40ck65 = 0.9 time = 330
.meas tran vdout0_40ck65 FIND v(dout0_40) AT=330.025n

* CHECK dout0_41 Vdout0_41ck65 = 0 time = 330
.meas tran vdout0_41ck65 FIND v(dout0_41) AT=330.025n

* CHECK dout0_42 Vdout0_42ck65 = 0 time = 330
.meas tran vdout0_42ck65 FIND v(dout0_42) AT=330.025n

* CHECK dout0_43 Vdout0_43ck65 = 0.9 time = 330
.meas tran vdout0_43ck65 FIND v(dout0_43) AT=330.025n

* CHECK dout0_44 Vdout0_44ck65 = 0 time = 330
.meas tran vdout0_44ck65 FIND v(dout0_44) AT=330.025n

* CHECK dout0_45 Vdout0_45ck65 = 0.9 time = 330
.meas tran vdout0_45ck65 FIND v(dout0_45) AT=330.025n

* CHECK dout0_46 Vdout0_46ck65 = 0 time = 330
.meas tran vdout0_46ck65 FIND v(dout0_46) AT=330.025n

* CHECK dout0_47 Vdout0_47ck65 = 0 time = 330
.meas tran vdout0_47ck65 FIND v(dout0_47) AT=330.025n

* CHECK dout0_48 Vdout0_48ck65 = 0 time = 330
.meas tran vdout0_48ck65 FIND v(dout0_48) AT=330.025n

* CHECK dout0_49 Vdout0_49ck65 = 0 time = 330
.meas tran vdout0_49ck65 FIND v(dout0_49) AT=330.025n

* CHECK dout0_50 Vdout0_50ck65 = 0 time = 330
.meas tran vdout0_50ck65 FIND v(dout0_50) AT=330.025n

* CHECK dout0_51 Vdout0_51ck65 = 0.9 time = 330
.meas tran vdout0_51ck65 FIND v(dout0_51) AT=330.025n

* CHECK dout0_52 Vdout0_52ck65 = 0.9 time = 330
.meas tran vdout0_52ck65 FIND v(dout0_52) AT=330.025n

* CHECK dout0_53 Vdout0_53ck65 = 0 time = 330
.meas tran vdout0_53ck65 FIND v(dout0_53) AT=330.025n

* CHECK dout0_54 Vdout0_54ck65 = 0.9 time = 330
.meas tran vdout0_54ck65 FIND v(dout0_54) AT=330.025n

* CHECK dout0_55 Vdout0_55ck65 = 0 time = 330
.meas tran vdout0_55ck65 FIND v(dout0_55) AT=330.025n

* CHECK dout0_56 Vdout0_56ck65 = 0 time = 330
.meas tran vdout0_56ck65 FIND v(dout0_56) AT=330.025n

* CHECK dout0_57 Vdout0_57ck65 = 0.9 time = 330
.meas tran vdout0_57ck65 FIND v(dout0_57) AT=330.025n

* CHECK dout0_58 Vdout0_58ck65 = 0.9 time = 330
.meas tran vdout0_58ck65 FIND v(dout0_58) AT=330.025n

* CHECK dout0_59 Vdout0_59ck65 = 0.9 time = 330
.meas tran vdout0_59ck65 FIND v(dout0_59) AT=330.025n

* CHECK dout0_60 Vdout0_60ck65 = 0.9 time = 330
.meas tran vdout0_60ck65 FIND v(dout0_60) AT=330.025n

* CHECK dout0_61 Vdout0_61ck65 = 0 time = 330
.meas tran vdout0_61ck65 FIND v(dout0_61) AT=330.025n

* CHECK dout0_62 Vdout0_62ck65 = 0.9 time = 330
.meas tran vdout0_62ck65 FIND v(dout0_62) AT=330.025n

* CHECK dout0_63 Vdout0_63ck65 = 0 time = 330
.meas tran vdout0_63ck65 FIND v(dout0_63) AT=330.025n

* CHECK dout0_64 Vdout0_64ck65 = 0.9 time = 330
.meas tran vdout0_64ck65 FIND v(dout0_64) AT=330.025n

* CHECK dout0_65 Vdout0_65ck65 = 0.9 time = 330
.meas tran vdout0_65ck65 FIND v(dout0_65) AT=330.025n

* CHECK dout0_66 Vdout0_66ck65 = 0.9 time = 330
.meas tran vdout0_66ck65 FIND v(dout0_66) AT=330.025n

* CHECK dout0_67 Vdout0_67ck65 = 0.9 time = 330
.meas tran vdout0_67ck65 FIND v(dout0_67) AT=330.025n

* CHECK dout0_68 Vdout0_68ck65 = 0.9 time = 330
.meas tran vdout0_68ck65 FIND v(dout0_68) AT=330.025n

* CHECK dout0_69 Vdout0_69ck65 = 0.9 time = 330
.meas tran vdout0_69ck65 FIND v(dout0_69) AT=330.025n

* CHECK dout0_70 Vdout0_70ck65 = 0 time = 330
.meas tran vdout0_70ck65 FIND v(dout0_70) AT=330.025n

* CHECK dout0_71 Vdout0_71ck65 = 0 time = 330
.meas tran vdout0_71ck65 FIND v(dout0_71) AT=330.025n

* CHECK dout0_72 Vdout0_72ck65 = 0 time = 330
.meas tran vdout0_72ck65 FIND v(dout0_72) AT=330.025n

* CHECK dout0_73 Vdout0_73ck65 = 0.9 time = 330
.meas tran vdout0_73ck65 FIND v(dout0_73) AT=330.025n

* CHECK dout0_74 Vdout0_74ck65 = 0 time = 330
.meas tran vdout0_74ck65 FIND v(dout0_74) AT=330.025n

* CHECK dout0_75 Vdout0_75ck65 = 0 time = 330
.meas tran vdout0_75ck65 FIND v(dout0_75) AT=330.025n

* CHECK dout0_76 Vdout0_76ck65 = 0 time = 330
.meas tran vdout0_76ck65 FIND v(dout0_76) AT=330.025n

* CHECK dout0_77 Vdout0_77ck65 = 0.9 time = 330
.meas tran vdout0_77ck65 FIND v(dout0_77) AT=330.025n

* CHECK dout0_78 Vdout0_78ck65 = 0.9 time = 330
.meas tran vdout0_78ck65 FIND v(dout0_78) AT=330.025n

* CHECK dout0_79 Vdout0_79ck65 = 0 time = 330
.meas tran vdout0_79ck65 FIND v(dout0_79) AT=330.025n

* CHECK dout0_0 Vdout0_0ck69 = 0.9 time = 350
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=350.025n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 350
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=350.025n

* CHECK dout0_2 Vdout0_2ck69 = 0.9 time = 350
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=350.025n

* CHECK dout0_3 Vdout0_3ck69 = 0.9 time = 350
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=350.025n

* CHECK dout0_4 Vdout0_4ck69 = 0 time = 350
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=350.025n

* CHECK dout0_5 Vdout0_5ck69 = 0 time = 350
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=350.025n

* CHECK dout0_6 Vdout0_6ck69 = 0.9 time = 350
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=350.025n

* CHECK dout0_7 Vdout0_7ck69 = 0.9 time = 350
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=350.025n

* CHECK dout0_8 Vdout0_8ck69 = 0.9 time = 350
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=350.025n

* CHECK dout0_9 Vdout0_9ck69 = 0.9 time = 350
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=350.025n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 350
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=350.025n

* CHECK dout0_11 Vdout0_11ck69 = 0.9 time = 350
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=350.025n

* CHECK dout0_12 Vdout0_12ck69 = 0.9 time = 350
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=350.025n

* CHECK dout0_13 Vdout0_13ck69 = 0 time = 350
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=350.025n

* CHECK dout0_14 Vdout0_14ck69 = 0.9 time = 350
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=350.025n

* CHECK dout0_15 Vdout0_15ck69 = 0.9 time = 350
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=350.025n

* CHECK dout0_16 Vdout0_16ck69 = 0.9 time = 350
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=350.025n

* CHECK dout0_17 Vdout0_17ck69 = 0 time = 350
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=350.025n

* CHECK dout0_18 Vdout0_18ck69 = 0.9 time = 350
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=350.025n

* CHECK dout0_19 Vdout0_19ck69 = 0.9 time = 350
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=350.025n

* CHECK dout0_20 Vdout0_20ck69 = 0.9 time = 350
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=350.025n

* CHECK dout0_21 Vdout0_21ck69 = 0.9 time = 350
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=350.025n

* CHECK dout0_22 Vdout0_22ck69 = 0.9 time = 350
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=350.025n

* CHECK dout0_23 Vdout0_23ck69 = 0 time = 350
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=350.025n

* CHECK dout0_24 Vdout0_24ck69 = 0.9 time = 350
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=350.025n

* CHECK dout0_25 Vdout0_25ck69 = 0.9 time = 350
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=350.025n

* CHECK dout0_26 Vdout0_26ck69 = 0.9 time = 350
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=350.025n

* CHECK dout0_27 Vdout0_27ck69 = 0 time = 350
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=350.025n

* CHECK dout0_28 Vdout0_28ck69 = 0.9 time = 350
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=350.025n

* CHECK dout0_29 Vdout0_29ck69 = 0 time = 350
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=350.025n

* CHECK dout0_30 Vdout0_30ck69 = 0 time = 350
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=350.025n

* CHECK dout0_31 Vdout0_31ck69 = 0.9 time = 350
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=350.025n

* CHECK dout0_32 Vdout0_32ck69 = 0.9 time = 350
.meas tran vdout0_32ck69 FIND v(dout0_32) AT=350.025n

* CHECK dout0_33 Vdout0_33ck69 = 0.9 time = 350
.meas tran vdout0_33ck69 FIND v(dout0_33) AT=350.025n

* CHECK dout0_34 Vdout0_34ck69 = 0 time = 350
.meas tran vdout0_34ck69 FIND v(dout0_34) AT=350.025n

* CHECK dout0_35 Vdout0_35ck69 = 0.9 time = 350
.meas tran vdout0_35ck69 FIND v(dout0_35) AT=350.025n

* CHECK dout0_36 Vdout0_36ck69 = 0.9 time = 350
.meas tran vdout0_36ck69 FIND v(dout0_36) AT=350.025n

* CHECK dout0_37 Vdout0_37ck69 = 0 time = 350
.meas tran vdout0_37ck69 FIND v(dout0_37) AT=350.025n

* CHECK dout0_38 Vdout0_38ck69 = 0 time = 350
.meas tran vdout0_38ck69 FIND v(dout0_38) AT=350.025n

* CHECK dout0_39 Vdout0_39ck69 = 0.9 time = 350
.meas tran vdout0_39ck69 FIND v(dout0_39) AT=350.025n

* CHECK dout0_40 Vdout0_40ck69 = 0.9 time = 350
.meas tran vdout0_40ck69 FIND v(dout0_40) AT=350.025n

* CHECK dout0_41 Vdout0_41ck69 = 0 time = 350
.meas tran vdout0_41ck69 FIND v(dout0_41) AT=350.025n

* CHECK dout0_42 Vdout0_42ck69 = 0 time = 350
.meas tran vdout0_42ck69 FIND v(dout0_42) AT=350.025n

* CHECK dout0_43 Vdout0_43ck69 = 0 time = 350
.meas tran vdout0_43ck69 FIND v(dout0_43) AT=350.025n

* CHECK dout0_44 Vdout0_44ck69 = 0 time = 350
.meas tran vdout0_44ck69 FIND v(dout0_44) AT=350.025n

* CHECK dout0_45 Vdout0_45ck69 = 0.9 time = 350
.meas tran vdout0_45ck69 FIND v(dout0_45) AT=350.025n

* CHECK dout0_46 Vdout0_46ck69 = 0.9 time = 350
.meas tran vdout0_46ck69 FIND v(dout0_46) AT=350.025n

* CHECK dout0_47 Vdout0_47ck69 = 0 time = 350
.meas tran vdout0_47ck69 FIND v(dout0_47) AT=350.025n

* CHECK dout0_48 Vdout0_48ck69 = 0 time = 350
.meas tran vdout0_48ck69 FIND v(dout0_48) AT=350.025n

* CHECK dout0_49 Vdout0_49ck69 = 0 time = 350
.meas tran vdout0_49ck69 FIND v(dout0_49) AT=350.025n

* CHECK dout0_50 Vdout0_50ck69 = 0 time = 350
.meas tran vdout0_50ck69 FIND v(dout0_50) AT=350.025n

* CHECK dout0_51 Vdout0_51ck69 = 0.9 time = 350
.meas tran vdout0_51ck69 FIND v(dout0_51) AT=350.025n

* CHECK dout0_52 Vdout0_52ck69 = 0 time = 350
.meas tran vdout0_52ck69 FIND v(dout0_52) AT=350.025n

* CHECK dout0_53 Vdout0_53ck69 = 0 time = 350
.meas tran vdout0_53ck69 FIND v(dout0_53) AT=350.025n

* CHECK dout0_54 Vdout0_54ck69 = 0.9 time = 350
.meas tran vdout0_54ck69 FIND v(dout0_54) AT=350.025n

* CHECK dout0_55 Vdout0_55ck69 = 0.9 time = 350
.meas tran vdout0_55ck69 FIND v(dout0_55) AT=350.025n

* CHECK dout0_56 Vdout0_56ck69 = 0.9 time = 350
.meas tran vdout0_56ck69 FIND v(dout0_56) AT=350.025n

* CHECK dout0_57 Vdout0_57ck69 = 0 time = 350
.meas tran vdout0_57ck69 FIND v(dout0_57) AT=350.025n

* CHECK dout0_58 Vdout0_58ck69 = 0 time = 350
.meas tran vdout0_58ck69 FIND v(dout0_58) AT=350.025n

* CHECK dout0_59 Vdout0_59ck69 = 0 time = 350
.meas tran vdout0_59ck69 FIND v(dout0_59) AT=350.025n

* CHECK dout0_60 Vdout0_60ck69 = 0 time = 350
.meas tran vdout0_60ck69 FIND v(dout0_60) AT=350.025n

* CHECK dout0_61 Vdout0_61ck69 = 0.9 time = 350
.meas tran vdout0_61ck69 FIND v(dout0_61) AT=350.025n

* CHECK dout0_62 Vdout0_62ck69 = 0 time = 350
.meas tran vdout0_62ck69 FIND v(dout0_62) AT=350.025n

* CHECK dout0_63 Vdout0_63ck69 = 0.9 time = 350
.meas tran vdout0_63ck69 FIND v(dout0_63) AT=350.025n

* CHECK dout0_64 Vdout0_64ck69 = 0.9 time = 350
.meas tran vdout0_64ck69 FIND v(dout0_64) AT=350.025n

* CHECK dout0_65 Vdout0_65ck69 = 0.9 time = 350
.meas tran vdout0_65ck69 FIND v(dout0_65) AT=350.025n

* CHECK dout0_66 Vdout0_66ck69 = 0.9 time = 350
.meas tran vdout0_66ck69 FIND v(dout0_66) AT=350.025n

* CHECK dout0_67 Vdout0_67ck69 = 0 time = 350
.meas tran vdout0_67ck69 FIND v(dout0_67) AT=350.025n

* CHECK dout0_68 Vdout0_68ck69 = 0.9 time = 350
.meas tran vdout0_68ck69 FIND v(dout0_68) AT=350.025n

* CHECK dout0_69 Vdout0_69ck69 = 0.9 time = 350
.meas tran vdout0_69ck69 FIND v(dout0_69) AT=350.025n

* CHECK dout0_70 Vdout0_70ck69 = 0.9 time = 350
.meas tran vdout0_70ck69 FIND v(dout0_70) AT=350.025n

* CHECK dout0_71 Vdout0_71ck69 = 0 time = 350
.meas tran vdout0_71ck69 FIND v(dout0_71) AT=350.025n

* CHECK dout0_72 Vdout0_72ck69 = 0 time = 350
.meas tran vdout0_72ck69 FIND v(dout0_72) AT=350.025n

* CHECK dout0_73 Vdout0_73ck69 = 0 time = 350
.meas tran vdout0_73ck69 FIND v(dout0_73) AT=350.025n

* CHECK dout0_74 Vdout0_74ck69 = 0.9 time = 350
.meas tran vdout0_74ck69 FIND v(dout0_74) AT=350.025n

* CHECK dout0_75 Vdout0_75ck69 = 0.9 time = 350
.meas tran vdout0_75ck69 FIND v(dout0_75) AT=350.025n

* CHECK dout0_76 Vdout0_76ck69 = 0.9 time = 350
.meas tran vdout0_76ck69 FIND v(dout0_76) AT=350.025n

* CHECK dout0_77 Vdout0_77ck69 = 0.9 time = 350
.meas tran vdout0_77ck69 FIND v(dout0_77) AT=350.025n

* CHECK dout0_78 Vdout0_78ck69 = 0 time = 350
.meas tran vdout0_78ck69 FIND v(dout0_78) AT=350.025n

* CHECK dout0_79 Vdout0_79ck69 = 0 time = 350
.meas tran vdout0_79ck69 FIND v(dout0_79) AT=350.025n

* CHECK dout0_0 Vdout0_0ck71 = 0.9 time = 360
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=360.025n

* CHECK dout0_1 Vdout0_1ck71 = 0 time = 360
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=360.025n

* CHECK dout0_2 Vdout0_2ck71 = 0.9 time = 360
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=360.025n

* CHECK dout0_3 Vdout0_3ck71 = 0.9 time = 360
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=360.025n

* CHECK dout0_4 Vdout0_4ck71 = 0 time = 360
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=360.025n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 360
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=360.025n

* CHECK dout0_6 Vdout0_6ck71 = 0.9 time = 360
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=360.025n

* CHECK dout0_7 Vdout0_7ck71 = 0.9 time = 360
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=360.025n

* CHECK dout0_8 Vdout0_8ck71 = 0.9 time = 360
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=360.025n

* CHECK dout0_9 Vdout0_9ck71 = 0.9 time = 360
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=360.025n

* CHECK dout0_10 Vdout0_10ck71 = 0 time = 360
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=360.025n

* CHECK dout0_11 Vdout0_11ck71 = 0.9 time = 360
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=360.025n

* CHECK dout0_12 Vdout0_12ck71 = 0.9 time = 360
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=360.025n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 360
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=360.025n

* CHECK dout0_14 Vdout0_14ck71 = 0.9 time = 360
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=360.025n

* CHECK dout0_15 Vdout0_15ck71 = 0.9 time = 360
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=360.025n

* CHECK dout0_16 Vdout0_16ck71 = 0.9 time = 360
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=360.025n

* CHECK dout0_17 Vdout0_17ck71 = 0 time = 360
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=360.025n

* CHECK dout0_18 Vdout0_18ck71 = 0.9 time = 360
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=360.025n

* CHECK dout0_19 Vdout0_19ck71 = 0.9 time = 360
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=360.025n

* CHECK dout0_20 Vdout0_20ck71 = 0.9 time = 360
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=360.025n

* CHECK dout0_21 Vdout0_21ck71 = 0.9 time = 360
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=360.025n

* CHECK dout0_22 Vdout0_22ck71 = 0.9 time = 360
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=360.025n

* CHECK dout0_23 Vdout0_23ck71 = 0 time = 360
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=360.025n

* CHECK dout0_24 Vdout0_24ck71 = 0.9 time = 360
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=360.025n

* CHECK dout0_25 Vdout0_25ck71 = 0.9 time = 360
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=360.025n

* CHECK dout0_26 Vdout0_26ck71 = 0.9 time = 360
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=360.025n

* CHECK dout0_27 Vdout0_27ck71 = 0 time = 360
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=360.025n

* CHECK dout0_28 Vdout0_28ck71 = 0.9 time = 360
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=360.025n

* CHECK dout0_29 Vdout0_29ck71 = 0 time = 360
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=360.025n

* CHECK dout0_30 Vdout0_30ck71 = 0 time = 360
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=360.025n

* CHECK dout0_31 Vdout0_31ck71 = 0.9 time = 360
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=360.025n

* CHECK dout0_32 Vdout0_32ck71 = 0.9 time = 360
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=360.025n

* CHECK dout0_33 Vdout0_33ck71 = 0.9 time = 360
.meas tran vdout0_33ck71 FIND v(dout0_33) AT=360.025n

* CHECK dout0_34 Vdout0_34ck71 = 0 time = 360
.meas tran vdout0_34ck71 FIND v(dout0_34) AT=360.025n

* CHECK dout0_35 Vdout0_35ck71 = 0.9 time = 360
.meas tran vdout0_35ck71 FIND v(dout0_35) AT=360.025n

* CHECK dout0_36 Vdout0_36ck71 = 0.9 time = 360
.meas tran vdout0_36ck71 FIND v(dout0_36) AT=360.025n

* CHECK dout0_37 Vdout0_37ck71 = 0 time = 360
.meas tran vdout0_37ck71 FIND v(dout0_37) AT=360.025n

* CHECK dout0_38 Vdout0_38ck71 = 0 time = 360
.meas tran vdout0_38ck71 FIND v(dout0_38) AT=360.025n

* CHECK dout0_39 Vdout0_39ck71 = 0.9 time = 360
.meas tran vdout0_39ck71 FIND v(dout0_39) AT=360.025n

* CHECK dout0_40 Vdout0_40ck71 = 0.9 time = 360
.meas tran vdout0_40ck71 FIND v(dout0_40) AT=360.025n

* CHECK dout0_41 Vdout0_41ck71 = 0 time = 360
.meas tran vdout0_41ck71 FIND v(dout0_41) AT=360.025n

* CHECK dout0_42 Vdout0_42ck71 = 0 time = 360
.meas tran vdout0_42ck71 FIND v(dout0_42) AT=360.025n

* CHECK dout0_43 Vdout0_43ck71 = 0 time = 360
.meas tran vdout0_43ck71 FIND v(dout0_43) AT=360.025n

* CHECK dout0_44 Vdout0_44ck71 = 0 time = 360
.meas tran vdout0_44ck71 FIND v(dout0_44) AT=360.025n

* CHECK dout0_45 Vdout0_45ck71 = 0.9 time = 360
.meas tran vdout0_45ck71 FIND v(dout0_45) AT=360.025n

* CHECK dout0_46 Vdout0_46ck71 = 0.9 time = 360
.meas tran vdout0_46ck71 FIND v(dout0_46) AT=360.025n

* CHECK dout0_47 Vdout0_47ck71 = 0 time = 360
.meas tran vdout0_47ck71 FIND v(dout0_47) AT=360.025n

* CHECK dout0_48 Vdout0_48ck71 = 0 time = 360
.meas tran vdout0_48ck71 FIND v(dout0_48) AT=360.025n

* CHECK dout0_49 Vdout0_49ck71 = 0 time = 360
.meas tran vdout0_49ck71 FIND v(dout0_49) AT=360.025n

* CHECK dout0_50 Vdout0_50ck71 = 0 time = 360
.meas tran vdout0_50ck71 FIND v(dout0_50) AT=360.025n

* CHECK dout0_51 Vdout0_51ck71 = 0.9 time = 360
.meas tran vdout0_51ck71 FIND v(dout0_51) AT=360.025n

* CHECK dout0_52 Vdout0_52ck71 = 0 time = 360
.meas tran vdout0_52ck71 FIND v(dout0_52) AT=360.025n

* CHECK dout0_53 Vdout0_53ck71 = 0 time = 360
.meas tran vdout0_53ck71 FIND v(dout0_53) AT=360.025n

* CHECK dout0_54 Vdout0_54ck71 = 0.9 time = 360
.meas tran vdout0_54ck71 FIND v(dout0_54) AT=360.025n

* CHECK dout0_55 Vdout0_55ck71 = 0.9 time = 360
.meas tran vdout0_55ck71 FIND v(dout0_55) AT=360.025n

* CHECK dout0_56 Vdout0_56ck71 = 0.9 time = 360
.meas tran vdout0_56ck71 FIND v(dout0_56) AT=360.025n

* CHECK dout0_57 Vdout0_57ck71 = 0 time = 360
.meas tran vdout0_57ck71 FIND v(dout0_57) AT=360.025n

* CHECK dout0_58 Vdout0_58ck71 = 0 time = 360
.meas tran vdout0_58ck71 FIND v(dout0_58) AT=360.025n

* CHECK dout0_59 Vdout0_59ck71 = 0 time = 360
.meas tran vdout0_59ck71 FIND v(dout0_59) AT=360.025n

* CHECK dout0_60 Vdout0_60ck71 = 0 time = 360
.meas tran vdout0_60ck71 FIND v(dout0_60) AT=360.025n

* CHECK dout0_61 Vdout0_61ck71 = 0.9 time = 360
.meas tran vdout0_61ck71 FIND v(dout0_61) AT=360.025n

* CHECK dout0_62 Vdout0_62ck71 = 0 time = 360
.meas tran vdout0_62ck71 FIND v(dout0_62) AT=360.025n

* CHECK dout0_63 Vdout0_63ck71 = 0.9 time = 360
.meas tran vdout0_63ck71 FIND v(dout0_63) AT=360.025n

* CHECK dout0_64 Vdout0_64ck71 = 0.9 time = 360
.meas tran vdout0_64ck71 FIND v(dout0_64) AT=360.025n

* CHECK dout0_65 Vdout0_65ck71 = 0.9 time = 360
.meas tran vdout0_65ck71 FIND v(dout0_65) AT=360.025n

* CHECK dout0_66 Vdout0_66ck71 = 0.9 time = 360
.meas tran vdout0_66ck71 FIND v(dout0_66) AT=360.025n

* CHECK dout0_67 Vdout0_67ck71 = 0 time = 360
.meas tran vdout0_67ck71 FIND v(dout0_67) AT=360.025n

* CHECK dout0_68 Vdout0_68ck71 = 0.9 time = 360
.meas tran vdout0_68ck71 FIND v(dout0_68) AT=360.025n

* CHECK dout0_69 Vdout0_69ck71 = 0.9 time = 360
.meas tran vdout0_69ck71 FIND v(dout0_69) AT=360.025n

* CHECK dout0_70 Vdout0_70ck71 = 0.9 time = 360
.meas tran vdout0_70ck71 FIND v(dout0_70) AT=360.025n

* CHECK dout0_71 Vdout0_71ck71 = 0 time = 360
.meas tran vdout0_71ck71 FIND v(dout0_71) AT=360.025n

* CHECK dout0_72 Vdout0_72ck71 = 0 time = 360
.meas tran vdout0_72ck71 FIND v(dout0_72) AT=360.025n

* CHECK dout0_73 Vdout0_73ck71 = 0 time = 360
.meas tran vdout0_73ck71 FIND v(dout0_73) AT=360.025n

* CHECK dout0_74 Vdout0_74ck71 = 0.9 time = 360
.meas tran vdout0_74ck71 FIND v(dout0_74) AT=360.025n

* CHECK dout0_75 Vdout0_75ck71 = 0.9 time = 360
.meas tran vdout0_75ck71 FIND v(dout0_75) AT=360.025n

* CHECK dout0_76 Vdout0_76ck71 = 0.9 time = 360
.meas tran vdout0_76ck71 FIND v(dout0_76) AT=360.025n

* CHECK dout0_77 Vdout0_77ck71 = 0.9 time = 360
.meas tran vdout0_77ck71 FIND v(dout0_77) AT=360.025n

* CHECK dout0_78 Vdout0_78ck71 = 0 time = 360
.meas tran vdout0_78ck71 FIND v(dout0_78) AT=360.025n

* CHECK dout0_79 Vdout0_79ck71 = 0 time = 360
.meas tran vdout0_79ck71 FIND v(dout0_79) AT=360.025n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 365
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=365.025n

* CHECK dout0_1 Vdout0_1ck72 = 0.9 time = 365
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=365.025n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 365
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=365.025n

* CHECK dout0_3 Vdout0_3ck72 = 0.9 time = 365
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=365.025n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 365
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=365.025n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 365
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=365.025n

* CHECK dout0_6 Vdout0_6ck72 = 0.9 time = 365
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=365.025n

* CHECK dout0_7 Vdout0_7ck72 = 0.9 time = 365
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=365.025n

* CHECK dout0_8 Vdout0_8ck72 = 0.9 time = 365
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=365.025n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 365
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=365.025n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 365
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=365.025n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 365
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=365.025n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 365
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=365.025n

* CHECK dout0_13 Vdout0_13ck72 = 0.9 time = 365
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=365.025n

* CHECK dout0_14 Vdout0_14ck72 = 0.9 time = 365
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=365.025n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 365
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=365.025n

* CHECK dout0_16 Vdout0_16ck72 = 0.9 time = 365
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=365.025n

* CHECK dout0_17 Vdout0_17ck72 = 0.9 time = 365
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=365.025n

* CHECK dout0_18 Vdout0_18ck72 = 0.9 time = 365
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=365.025n

* CHECK dout0_19 Vdout0_19ck72 = 0.9 time = 365
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=365.025n

* CHECK dout0_20 Vdout0_20ck72 = 0.9 time = 365
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=365.025n

* CHECK dout0_21 Vdout0_21ck72 = 0.9 time = 365
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=365.025n

* CHECK dout0_22 Vdout0_22ck72 = 0 time = 365
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=365.025n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 365
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=365.025n

* CHECK dout0_24 Vdout0_24ck72 = 0.9 time = 365
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=365.025n

* CHECK dout0_25 Vdout0_25ck72 = 0 time = 365
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=365.025n

* CHECK dout0_26 Vdout0_26ck72 = 0 time = 365
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=365.025n

* CHECK dout0_27 Vdout0_27ck72 = 0.9 time = 365
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=365.025n

* CHECK dout0_28 Vdout0_28ck72 = 0 time = 365
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=365.025n

* CHECK dout0_29 Vdout0_29ck72 = 0.9 time = 365
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=365.025n

* CHECK dout0_30 Vdout0_30ck72 = 0 time = 365
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=365.025n

* CHECK dout0_31 Vdout0_31ck72 = 0 time = 365
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=365.025n

* CHECK dout0_32 Vdout0_32ck72 = 0 time = 365
.meas tran vdout0_32ck72 FIND v(dout0_32) AT=365.025n

* CHECK dout0_33 Vdout0_33ck72 = 0 time = 365
.meas tran vdout0_33ck72 FIND v(dout0_33) AT=365.025n

* CHECK dout0_34 Vdout0_34ck72 = 0 time = 365
.meas tran vdout0_34ck72 FIND v(dout0_34) AT=365.025n

* CHECK dout0_35 Vdout0_35ck72 = 0.9 time = 365
.meas tran vdout0_35ck72 FIND v(dout0_35) AT=365.025n

* CHECK dout0_36 Vdout0_36ck72 = 0.9 time = 365
.meas tran vdout0_36ck72 FIND v(dout0_36) AT=365.025n

* CHECK dout0_37 Vdout0_37ck72 = 0 time = 365
.meas tran vdout0_37ck72 FIND v(dout0_37) AT=365.025n

* CHECK dout0_38 Vdout0_38ck72 = 0.9 time = 365
.meas tran vdout0_38ck72 FIND v(dout0_38) AT=365.025n

* CHECK dout0_39 Vdout0_39ck72 = 0.9 time = 365
.meas tran vdout0_39ck72 FIND v(dout0_39) AT=365.025n

* CHECK dout0_40 Vdout0_40ck72 = 0.9 time = 365
.meas tran vdout0_40ck72 FIND v(dout0_40) AT=365.025n

* CHECK dout0_41 Vdout0_41ck72 = 0 time = 365
.meas tran vdout0_41ck72 FIND v(dout0_41) AT=365.025n

* CHECK dout0_42 Vdout0_42ck72 = 0 time = 365
.meas tran vdout0_42ck72 FIND v(dout0_42) AT=365.025n

* CHECK dout0_43 Vdout0_43ck72 = 0.9 time = 365
.meas tran vdout0_43ck72 FIND v(dout0_43) AT=365.025n

* CHECK dout0_44 Vdout0_44ck72 = 0 time = 365
.meas tran vdout0_44ck72 FIND v(dout0_44) AT=365.025n

* CHECK dout0_45 Vdout0_45ck72 = 0.9 time = 365
.meas tran vdout0_45ck72 FIND v(dout0_45) AT=365.025n

* CHECK dout0_46 Vdout0_46ck72 = 0 time = 365
.meas tran vdout0_46ck72 FIND v(dout0_46) AT=365.025n

* CHECK dout0_47 Vdout0_47ck72 = 0 time = 365
.meas tran vdout0_47ck72 FIND v(dout0_47) AT=365.025n

* CHECK dout0_48 Vdout0_48ck72 = 0 time = 365
.meas tran vdout0_48ck72 FIND v(dout0_48) AT=365.025n

* CHECK dout0_49 Vdout0_49ck72 = 0 time = 365
.meas tran vdout0_49ck72 FIND v(dout0_49) AT=365.025n

* CHECK dout0_50 Vdout0_50ck72 = 0 time = 365
.meas tran vdout0_50ck72 FIND v(dout0_50) AT=365.025n

* CHECK dout0_51 Vdout0_51ck72 = 0.9 time = 365
.meas tran vdout0_51ck72 FIND v(dout0_51) AT=365.025n

* CHECK dout0_52 Vdout0_52ck72 = 0.9 time = 365
.meas tran vdout0_52ck72 FIND v(dout0_52) AT=365.025n

* CHECK dout0_53 Vdout0_53ck72 = 0 time = 365
.meas tran vdout0_53ck72 FIND v(dout0_53) AT=365.025n

* CHECK dout0_54 Vdout0_54ck72 = 0.9 time = 365
.meas tran vdout0_54ck72 FIND v(dout0_54) AT=365.025n

* CHECK dout0_55 Vdout0_55ck72 = 0 time = 365
.meas tran vdout0_55ck72 FIND v(dout0_55) AT=365.025n

* CHECK dout0_56 Vdout0_56ck72 = 0 time = 365
.meas tran vdout0_56ck72 FIND v(dout0_56) AT=365.025n

* CHECK dout0_57 Vdout0_57ck72 = 0.9 time = 365
.meas tran vdout0_57ck72 FIND v(dout0_57) AT=365.025n

* CHECK dout0_58 Vdout0_58ck72 = 0.9 time = 365
.meas tran vdout0_58ck72 FIND v(dout0_58) AT=365.025n

* CHECK dout0_59 Vdout0_59ck72 = 0.9 time = 365
.meas tran vdout0_59ck72 FIND v(dout0_59) AT=365.025n

* CHECK dout0_60 Vdout0_60ck72 = 0.9 time = 365
.meas tran vdout0_60ck72 FIND v(dout0_60) AT=365.025n

* CHECK dout0_61 Vdout0_61ck72 = 0 time = 365
.meas tran vdout0_61ck72 FIND v(dout0_61) AT=365.025n

* CHECK dout0_62 Vdout0_62ck72 = 0.9 time = 365
.meas tran vdout0_62ck72 FIND v(dout0_62) AT=365.025n

* CHECK dout0_63 Vdout0_63ck72 = 0 time = 365
.meas tran vdout0_63ck72 FIND v(dout0_63) AT=365.025n

* CHECK dout0_64 Vdout0_64ck72 = 0.9 time = 365
.meas tran vdout0_64ck72 FIND v(dout0_64) AT=365.025n

* CHECK dout0_65 Vdout0_65ck72 = 0.9 time = 365
.meas tran vdout0_65ck72 FIND v(dout0_65) AT=365.025n

* CHECK dout0_66 Vdout0_66ck72 = 0.9 time = 365
.meas tran vdout0_66ck72 FIND v(dout0_66) AT=365.025n

* CHECK dout0_67 Vdout0_67ck72 = 0.9 time = 365
.meas tran vdout0_67ck72 FIND v(dout0_67) AT=365.025n

* CHECK dout0_68 Vdout0_68ck72 = 0.9 time = 365
.meas tran vdout0_68ck72 FIND v(dout0_68) AT=365.025n

* CHECK dout0_69 Vdout0_69ck72 = 0.9 time = 365
.meas tran vdout0_69ck72 FIND v(dout0_69) AT=365.025n

* CHECK dout0_70 Vdout0_70ck72 = 0 time = 365
.meas tran vdout0_70ck72 FIND v(dout0_70) AT=365.025n

* CHECK dout0_71 Vdout0_71ck72 = 0 time = 365
.meas tran vdout0_71ck72 FIND v(dout0_71) AT=365.025n

* CHECK dout0_72 Vdout0_72ck72 = 0 time = 365
.meas tran vdout0_72ck72 FIND v(dout0_72) AT=365.025n

* CHECK dout0_73 Vdout0_73ck72 = 0.9 time = 365
.meas tran vdout0_73ck72 FIND v(dout0_73) AT=365.025n

* CHECK dout0_74 Vdout0_74ck72 = 0 time = 365
.meas tran vdout0_74ck72 FIND v(dout0_74) AT=365.025n

* CHECK dout0_75 Vdout0_75ck72 = 0 time = 365
.meas tran vdout0_75ck72 FIND v(dout0_75) AT=365.025n

* CHECK dout0_76 Vdout0_76ck72 = 0 time = 365
.meas tran vdout0_76ck72 FIND v(dout0_76) AT=365.025n

* CHECK dout0_77 Vdout0_77ck72 = 0.9 time = 365
.meas tran vdout0_77ck72 FIND v(dout0_77) AT=365.025n

* CHECK dout0_78 Vdout0_78ck72 = 0.9 time = 365
.meas tran vdout0_78ck72 FIND v(dout0_78) AT=365.025n

* CHECK dout0_79 Vdout0_79ck72 = 0 time = 365
.meas tran vdout0_79ck72 FIND v(dout0_79) AT=365.025n

* CHECK dout0_0 Vdout0_0ck73 = 0.9 time = 370
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=370.025n

* CHECK dout0_1 Vdout0_1ck73 = 0 time = 370
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=370.025n

* CHECK dout0_2 Vdout0_2ck73 = 0.9 time = 370
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=370.025n

* CHECK dout0_3 Vdout0_3ck73 = 0.9 time = 370
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=370.025n

* CHECK dout0_4 Vdout0_4ck73 = 0 time = 370
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=370.025n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 370
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=370.025n

* CHECK dout0_6 Vdout0_6ck73 = 0.9 time = 370
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=370.025n

* CHECK dout0_7 Vdout0_7ck73 = 0.9 time = 370
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=370.025n

* CHECK dout0_8 Vdout0_8ck73 = 0.9 time = 370
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=370.025n

* CHECK dout0_9 Vdout0_9ck73 = 0.9 time = 370
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=370.025n

* CHECK dout0_10 Vdout0_10ck73 = 0 time = 370
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=370.025n

* CHECK dout0_11 Vdout0_11ck73 = 0.9 time = 370
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=370.025n

* CHECK dout0_12 Vdout0_12ck73 = 0.9 time = 370
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=370.025n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 370
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=370.025n

* CHECK dout0_14 Vdout0_14ck73 = 0.9 time = 370
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=370.025n

* CHECK dout0_15 Vdout0_15ck73 = 0.9 time = 370
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=370.025n

* CHECK dout0_16 Vdout0_16ck73 = 0.9 time = 370
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=370.025n

* CHECK dout0_17 Vdout0_17ck73 = 0 time = 370
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=370.025n

* CHECK dout0_18 Vdout0_18ck73 = 0.9 time = 370
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=370.025n

* CHECK dout0_19 Vdout0_19ck73 = 0.9 time = 370
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=370.025n

* CHECK dout0_20 Vdout0_20ck73 = 0.9 time = 370
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=370.025n

* CHECK dout0_21 Vdout0_21ck73 = 0.9 time = 370
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=370.025n

* CHECK dout0_22 Vdout0_22ck73 = 0.9 time = 370
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=370.025n

* CHECK dout0_23 Vdout0_23ck73 = 0 time = 370
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=370.025n

* CHECK dout0_24 Vdout0_24ck73 = 0.9 time = 370
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=370.025n

* CHECK dout0_25 Vdout0_25ck73 = 0.9 time = 370
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=370.025n

* CHECK dout0_26 Vdout0_26ck73 = 0.9 time = 370
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=370.025n

* CHECK dout0_27 Vdout0_27ck73 = 0 time = 370
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=370.025n

* CHECK dout0_28 Vdout0_28ck73 = 0.9 time = 370
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=370.025n

* CHECK dout0_29 Vdout0_29ck73 = 0 time = 370
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=370.025n

* CHECK dout0_30 Vdout0_30ck73 = 0 time = 370
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=370.025n

* CHECK dout0_31 Vdout0_31ck73 = 0.9 time = 370
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=370.025n

* CHECK dout0_32 Vdout0_32ck73 = 0.9 time = 370
.meas tran vdout0_32ck73 FIND v(dout0_32) AT=370.025n

* CHECK dout0_33 Vdout0_33ck73 = 0.9 time = 370
.meas tran vdout0_33ck73 FIND v(dout0_33) AT=370.025n

* CHECK dout0_34 Vdout0_34ck73 = 0 time = 370
.meas tran vdout0_34ck73 FIND v(dout0_34) AT=370.025n

* CHECK dout0_35 Vdout0_35ck73 = 0.9 time = 370
.meas tran vdout0_35ck73 FIND v(dout0_35) AT=370.025n

* CHECK dout0_36 Vdout0_36ck73 = 0.9 time = 370
.meas tran vdout0_36ck73 FIND v(dout0_36) AT=370.025n

* CHECK dout0_37 Vdout0_37ck73 = 0 time = 370
.meas tran vdout0_37ck73 FIND v(dout0_37) AT=370.025n

* CHECK dout0_38 Vdout0_38ck73 = 0 time = 370
.meas tran vdout0_38ck73 FIND v(dout0_38) AT=370.025n

* CHECK dout0_39 Vdout0_39ck73 = 0.9 time = 370
.meas tran vdout0_39ck73 FIND v(dout0_39) AT=370.025n

* CHECK dout0_40 Vdout0_40ck73 = 0.9 time = 370
.meas tran vdout0_40ck73 FIND v(dout0_40) AT=370.025n

* CHECK dout0_41 Vdout0_41ck73 = 0 time = 370
.meas tran vdout0_41ck73 FIND v(dout0_41) AT=370.025n

* CHECK dout0_42 Vdout0_42ck73 = 0 time = 370
.meas tran vdout0_42ck73 FIND v(dout0_42) AT=370.025n

* CHECK dout0_43 Vdout0_43ck73 = 0 time = 370
.meas tran vdout0_43ck73 FIND v(dout0_43) AT=370.025n

* CHECK dout0_44 Vdout0_44ck73 = 0 time = 370
.meas tran vdout0_44ck73 FIND v(dout0_44) AT=370.025n

* CHECK dout0_45 Vdout0_45ck73 = 0.9 time = 370
.meas tran vdout0_45ck73 FIND v(dout0_45) AT=370.025n

* CHECK dout0_46 Vdout0_46ck73 = 0.9 time = 370
.meas tran vdout0_46ck73 FIND v(dout0_46) AT=370.025n

* CHECK dout0_47 Vdout0_47ck73 = 0 time = 370
.meas tran vdout0_47ck73 FIND v(dout0_47) AT=370.025n

* CHECK dout0_48 Vdout0_48ck73 = 0 time = 370
.meas tran vdout0_48ck73 FIND v(dout0_48) AT=370.025n

* CHECK dout0_49 Vdout0_49ck73 = 0 time = 370
.meas tran vdout0_49ck73 FIND v(dout0_49) AT=370.025n

* CHECK dout0_50 Vdout0_50ck73 = 0 time = 370
.meas tran vdout0_50ck73 FIND v(dout0_50) AT=370.025n

* CHECK dout0_51 Vdout0_51ck73 = 0.9 time = 370
.meas tran vdout0_51ck73 FIND v(dout0_51) AT=370.025n

* CHECK dout0_52 Vdout0_52ck73 = 0 time = 370
.meas tran vdout0_52ck73 FIND v(dout0_52) AT=370.025n

* CHECK dout0_53 Vdout0_53ck73 = 0 time = 370
.meas tran vdout0_53ck73 FIND v(dout0_53) AT=370.025n

* CHECK dout0_54 Vdout0_54ck73 = 0.9 time = 370
.meas tran vdout0_54ck73 FIND v(dout0_54) AT=370.025n

* CHECK dout0_55 Vdout0_55ck73 = 0.9 time = 370
.meas tran vdout0_55ck73 FIND v(dout0_55) AT=370.025n

* CHECK dout0_56 Vdout0_56ck73 = 0.9 time = 370
.meas tran vdout0_56ck73 FIND v(dout0_56) AT=370.025n

* CHECK dout0_57 Vdout0_57ck73 = 0 time = 370
.meas tran vdout0_57ck73 FIND v(dout0_57) AT=370.025n

* CHECK dout0_58 Vdout0_58ck73 = 0 time = 370
.meas tran vdout0_58ck73 FIND v(dout0_58) AT=370.025n

* CHECK dout0_59 Vdout0_59ck73 = 0 time = 370
.meas tran vdout0_59ck73 FIND v(dout0_59) AT=370.025n

* CHECK dout0_60 Vdout0_60ck73 = 0 time = 370
.meas tran vdout0_60ck73 FIND v(dout0_60) AT=370.025n

* CHECK dout0_61 Vdout0_61ck73 = 0.9 time = 370
.meas tran vdout0_61ck73 FIND v(dout0_61) AT=370.025n

* CHECK dout0_62 Vdout0_62ck73 = 0 time = 370
.meas tran vdout0_62ck73 FIND v(dout0_62) AT=370.025n

* CHECK dout0_63 Vdout0_63ck73 = 0.9 time = 370
.meas tran vdout0_63ck73 FIND v(dout0_63) AT=370.025n

* CHECK dout0_64 Vdout0_64ck73 = 0.9 time = 370
.meas tran vdout0_64ck73 FIND v(dout0_64) AT=370.025n

* CHECK dout0_65 Vdout0_65ck73 = 0.9 time = 370
.meas tran vdout0_65ck73 FIND v(dout0_65) AT=370.025n

* CHECK dout0_66 Vdout0_66ck73 = 0.9 time = 370
.meas tran vdout0_66ck73 FIND v(dout0_66) AT=370.025n

* CHECK dout0_67 Vdout0_67ck73 = 0 time = 370
.meas tran vdout0_67ck73 FIND v(dout0_67) AT=370.025n

* CHECK dout0_68 Vdout0_68ck73 = 0.9 time = 370
.meas tran vdout0_68ck73 FIND v(dout0_68) AT=370.025n

* CHECK dout0_69 Vdout0_69ck73 = 0.9 time = 370
.meas tran vdout0_69ck73 FIND v(dout0_69) AT=370.025n

* CHECK dout0_70 Vdout0_70ck73 = 0.9 time = 370
.meas tran vdout0_70ck73 FIND v(dout0_70) AT=370.025n

* CHECK dout0_71 Vdout0_71ck73 = 0 time = 370
.meas tran vdout0_71ck73 FIND v(dout0_71) AT=370.025n

* CHECK dout0_72 Vdout0_72ck73 = 0 time = 370
.meas tran vdout0_72ck73 FIND v(dout0_72) AT=370.025n

* CHECK dout0_73 Vdout0_73ck73 = 0 time = 370
.meas tran vdout0_73ck73 FIND v(dout0_73) AT=370.025n

* CHECK dout0_74 Vdout0_74ck73 = 0.9 time = 370
.meas tran vdout0_74ck73 FIND v(dout0_74) AT=370.025n

* CHECK dout0_75 Vdout0_75ck73 = 0.9 time = 370
.meas tran vdout0_75ck73 FIND v(dout0_75) AT=370.025n

* CHECK dout0_76 Vdout0_76ck73 = 0.9 time = 370
.meas tran vdout0_76ck73 FIND v(dout0_76) AT=370.025n

* CHECK dout0_77 Vdout0_77ck73 = 0.9 time = 370
.meas tran vdout0_77ck73 FIND v(dout0_77) AT=370.025n

* CHECK dout0_78 Vdout0_78ck73 = 0 time = 370
.meas tran vdout0_78ck73 FIND v(dout0_78) AT=370.025n

* CHECK dout0_79 Vdout0_79ck73 = 0 time = 370
.meas tran vdout0_79ck73 FIND v(dout0_79) AT=370.025n

* CHECK dout0_0 Vdout0_0ck75 = 0 time = 380
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=380.025n

* CHECK dout0_1 Vdout0_1ck75 = 0.9 time = 380
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=380.025n

* CHECK dout0_2 Vdout0_2ck75 = 0 time = 380
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=380.025n

* CHECK dout0_3 Vdout0_3ck75 = 0.9 time = 380
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=380.025n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 380
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=380.025n

* CHECK dout0_5 Vdout0_5ck75 = 0 time = 380
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=380.025n

* CHECK dout0_6 Vdout0_6ck75 = 0.9 time = 380
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=380.025n

* CHECK dout0_7 Vdout0_7ck75 = 0.9 time = 380
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=380.025n

* CHECK dout0_8 Vdout0_8ck75 = 0.9 time = 380
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=380.025n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 380
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=380.025n

* CHECK dout0_10 Vdout0_10ck75 = 0 time = 380
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=380.025n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 380
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=380.025n

* CHECK dout0_12 Vdout0_12ck75 = 0 time = 380
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=380.025n

* CHECK dout0_13 Vdout0_13ck75 = 0.9 time = 380
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=380.025n

* CHECK dout0_14 Vdout0_14ck75 = 0.9 time = 380
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=380.025n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 380
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=380.025n

* CHECK dout0_16 Vdout0_16ck75 = 0.9 time = 380
.meas tran vdout0_16ck75 FIND v(dout0_16) AT=380.025n

* CHECK dout0_17 Vdout0_17ck75 = 0.9 time = 380
.meas tran vdout0_17ck75 FIND v(dout0_17) AT=380.025n

* CHECK dout0_18 Vdout0_18ck75 = 0.9 time = 380
.meas tran vdout0_18ck75 FIND v(dout0_18) AT=380.025n

* CHECK dout0_19 Vdout0_19ck75 = 0.9 time = 380
.meas tran vdout0_19ck75 FIND v(dout0_19) AT=380.025n

* CHECK dout0_20 Vdout0_20ck75 = 0.9 time = 380
.meas tran vdout0_20ck75 FIND v(dout0_20) AT=380.025n

* CHECK dout0_21 Vdout0_21ck75 = 0.9 time = 380
.meas tran vdout0_21ck75 FIND v(dout0_21) AT=380.025n

* CHECK dout0_22 Vdout0_22ck75 = 0 time = 380
.meas tran vdout0_22ck75 FIND v(dout0_22) AT=380.025n

* CHECK dout0_23 Vdout0_23ck75 = 0 time = 380
.meas tran vdout0_23ck75 FIND v(dout0_23) AT=380.025n

* CHECK dout0_24 Vdout0_24ck75 = 0.9 time = 380
.meas tran vdout0_24ck75 FIND v(dout0_24) AT=380.025n

* CHECK dout0_25 Vdout0_25ck75 = 0 time = 380
.meas tran vdout0_25ck75 FIND v(dout0_25) AT=380.025n

* CHECK dout0_26 Vdout0_26ck75 = 0 time = 380
.meas tran vdout0_26ck75 FIND v(dout0_26) AT=380.025n

* CHECK dout0_27 Vdout0_27ck75 = 0.9 time = 380
.meas tran vdout0_27ck75 FIND v(dout0_27) AT=380.025n

* CHECK dout0_28 Vdout0_28ck75 = 0 time = 380
.meas tran vdout0_28ck75 FIND v(dout0_28) AT=380.025n

* CHECK dout0_29 Vdout0_29ck75 = 0.9 time = 380
.meas tran vdout0_29ck75 FIND v(dout0_29) AT=380.025n

* CHECK dout0_30 Vdout0_30ck75 = 0 time = 380
.meas tran vdout0_30ck75 FIND v(dout0_30) AT=380.025n

* CHECK dout0_31 Vdout0_31ck75 = 0 time = 380
.meas tran vdout0_31ck75 FIND v(dout0_31) AT=380.025n

* CHECK dout0_32 Vdout0_32ck75 = 0 time = 380
.meas tran vdout0_32ck75 FIND v(dout0_32) AT=380.025n

* CHECK dout0_33 Vdout0_33ck75 = 0 time = 380
.meas tran vdout0_33ck75 FIND v(dout0_33) AT=380.025n

* CHECK dout0_34 Vdout0_34ck75 = 0 time = 380
.meas tran vdout0_34ck75 FIND v(dout0_34) AT=380.025n

* CHECK dout0_35 Vdout0_35ck75 = 0.9 time = 380
.meas tran vdout0_35ck75 FIND v(dout0_35) AT=380.025n

* CHECK dout0_36 Vdout0_36ck75 = 0.9 time = 380
.meas tran vdout0_36ck75 FIND v(dout0_36) AT=380.025n

* CHECK dout0_37 Vdout0_37ck75 = 0 time = 380
.meas tran vdout0_37ck75 FIND v(dout0_37) AT=380.025n

* CHECK dout0_38 Vdout0_38ck75 = 0.9 time = 380
.meas tran vdout0_38ck75 FIND v(dout0_38) AT=380.025n

* CHECK dout0_39 Vdout0_39ck75 = 0.9 time = 380
.meas tran vdout0_39ck75 FIND v(dout0_39) AT=380.025n

* CHECK dout0_40 Vdout0_40ck75 = 0.9 time = 380
.meas tran vdout0_40ck75 FIND v(dout0_40) AT=380.025n

* CHECK dout0_41 Vdout0_41ck75 = 0 time = 380
.meas tran vdout0_41ck75 FIND v(dout0_41) AT=380.025n

* CHECK dout0_42 Vdout0_42ck75 = 0 time = 380
.meas tran vdout0_42ck75 FIND v(dout0_42) AT=380.025n

* CHECK dout0_43 Vdout0_43ck75 = 0.9 time = 380
.meas tran vdout0_43ck75 FIND v(dout0_43) AT=380.025n

* CHECK dout0_44 Vdout0_44ck75 = 0 time = 380
.meas tran vdout0_44ck75 FIND v(dout0_44) AT=380.025n

* CHECK dout0_45 Vdout0_45ck75 = 0.9 time = 380
.meas tran vdout0_45ck75 FIND v(dout0_45) AT=380.025n

* CHECK dout0_46 Vdout0_46ck75 = 0 time = 380
.meas tran vdout0_46ck75 FIND v(dout0_46) AT=380.025n

* CHECK dout0_47 Vdout0_47ck75 = 0 time = 380
.meas tran vdout0_47ck75 FIND v(dout0_47) AT=380.025n

* CHECK dout0_48 Vdout0_48ck75 = 0 time = 380
.meas tran vdout0_48ck75 FIND v(dout0_48) AT=380.025n

* CHECK dout0_49 Vdout0_49ck75 = 0 time = 380
.meas tran vdout0_49ck75 FIND v(dout0_49) AT=380.025n

* CHECK dout0_50 Vdout0_50ck75 = 0 time = 380
.meas tran vdout0_50ck75 FIND v(dout0_50) AT=380.025n

* CHECK dout0_51 Vdout0_51ck75 = 0.9 time = 380
.meas tran vdout0_51ck75 FIND v(dout0_51) AT=380.025n

* CHECK dout0_52 Vdout0_52ck75 = 0.9 time = 380
.meas tran vdout0_52ck75 FIND v(dout0_52) AT=380.025n

* CHECK dout0_53 Vdout0_53ck75 = 0 time = 380
.meas tran vdout0_53ck75 FIND v(dout0_53) AT=380.025n

* CHECK dout0_54 Vdout0_54ck75 = 0.9 time = 380
.meas tran vdout0_54ck75 FIND v(dout0_54) AT=380.025n

* CHECK dout0_55 Vdout0_55ck75 = 0 time = 380
.meas tran vdout0_55ck75 FIND v(dout0_55) AT=380.025n

* CHECK dout0_56 Vdout0_56ck75 = 0 time = 380
.meas tran vdout0_56ck75 FIND v(dout0_56) AT=380.025n

* CHECK dout0_57 Vdout0_57ck75 = 0.9 time = 380
.meas tran vdout0_57ck75 FIND v(dout0_57) AT=380.025n

* CHECK dout0_58 Vdout0_58ck75 = 0.9 time = 380
.meas tran vdout0_58ck75 FIND v(dout0_58) AT=380.025n

* CHECK dout0_59 Vdout0_59ck75 = 0.9 time = 380
.meas tran vdout0_59ck75 FIND v(dout0_59) AT=380.025n

* CHECK dout0_60 Vdout0_60ck75 = 0.9 time = 380
.meas tran vdout0_60ck75 FIND v(dout0_60) AT=380.025n

* CHECK dout0_61 Vdout0_61ck75 = 0 time = 380
.meas tran vdout0_61ck75 FIND v(dout0_61) AT=380.025n

* CHECK dout0_62 Vdout0_62ck75 = 0.9 time = 380
.meas tran vdout0_62ck75 FIND v(dout0_62) AT=380.025n

* CHECK dout0_63 Vdout0_63ck75 = 0 time = 380
.meas tran vdout0_63ck75 FIND v(dout0_63) AT=380.025n

* CHECK dout0_64 Vdout0_64ck75 = 0.9 time = 380
.meas tran vdout0_64ck75 FIND v(dout0_64) AT=380.025n

* CHECK dout0_65 Vdout0_65ck75 = 0.9 time = 380
.meas tran vdout0_65ck75 FIND v(dout0_65) AT=380.025n

* CHECK dout0_66 Vdout0_66ck75 = 0.9 time = 380
.meas tran vdout0_66ck75 FIND v(dout0_66) AT=380.025n

* CHECK dout0_67 Vdout0_67ck75 = 0.9 time = 380
.meas tran vdout0_67ck75 FIND v(dout0_67) AT=380.025n

* CHECK dout0_68 Vdout0_68ck75 = 0.9 time = 380
.meas tran vdout0_68ck75 FIND v(dout0_68) AT=380.025n

* CHECK dout0_69 Vdout0_69ck75 = 0.9 time = 380
.meas tran vdout0_69ck75 FIND v(dout0_69) AT=380.025n

* CHECK dout0_70 Vdout0_70ck75 = 0 time = 380
.meas tran vdout0_70ck75 FIND v(dout0_70) AT=380.025n

* CHECK dout0_71 Vdout0_71ck75 = 0 time = 380
.meas tran vdout0_71ck75 FIND v(dout0_71) AT=380.025n

* CHECK dout0_72 Vdout0_72ck75 = 0 time = 380
.meas tran vdout0_72ck75 FIND v(dout0_72) AT=380.025n

* CHECK dout0_73 Vdout0_73ck75 = 0.9 time = 380
.meas tran vdout0_73ck75 FIND v(dout0_73) AT=380.025n

* CHECK dout0_74 Vdout0_74ck75 = 0 time = 380
.meas tran vdout0_74ck75 FIND v(dout0_74) AT=380.025n

* CHECK dout0_75 Vdout0_75ck75 = 0 time = 380
.meas tran vdout0_75ck75 FIND v(dout0_75) AT=380.025n

* CHECK dout0_76 Vdout0_76ck75 = 0 time = 380
.meas tran vdout0_76ck75 FIND v(dout0_76) AT=380.025n

* CHECK dout0_77 Vdout0_77ck75 = 0.9 time = 380
.meas tran vdout0_77ck75 FIND v(dout0_77) AT=380.025n

* CHECK dout0_78 Vdout0_78ck75 = 0.9 time = 380
.meas tran vdout0_78ck75 FIND v(dout0_78) AT=380.025n

* CHECK dout0_79 Vdout0_79ck75 = 0 time = 380
.meas tran vdout0_79ck75 FIND v(dout0_79) AT=380.025n

* CHECK dout0_0 Vdout0_0ck76 = 0.9 time = 385
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=385.025n

* CHECK dout0_1 Vdout0_1ck76 = 0.9 time = 385
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=385.025n

* CHECK dout0_2 Vdout0_2ck76 = 0.9 time = 385
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=385.025n

* CHECK dout0_3 Vdout0_3ck76 = 0.9 time = 385
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=385.025n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 385
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=385.025n

* CHECK dout0_5 Vdout0_5ck76 = 0 time = 385
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=385.025n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 385
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=385.025n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 385
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=385.025n

* CHECK dout0_8 Vdout0_8ck76 = 0 time = 385
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=385.025n

* CHECK dout0_9 Vdout0_9ck76 = 0 time = 385
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=385.025n

* CHECK dout0_10 Vdout0_10ck76 = 0.9 time = 385
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=385.025n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 385
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=385.025n

* CHECK dout0_12 Vdout0_12ck76 = 0.9 time = 385
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=385.025n

* CHECK dout0_13 Vdout0_13ck76 = 0 time = 385
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=385.025n

* CHECK dout0_14 Vdout0_14ck76 = 0 time = 385
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=385.025n

* CHECK dout0_15 Vdout0_15ck76 = 0 time = 385
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=385.025n

* CHECK dout0_16 Vdout0_16ck76 = 0.9 time = 385
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=385.025n

* CHECK dout0_17 Vdout0_17ck76 = 0.9 time = 385
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=385.025n

* CHECK dout0_18 Vdout0_18ck76 = 0 time = 385
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=385.025n

* CHECK dout0_19 Vdout0_19ck76 = 0.9 time = 385
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=385.025n

* CHECK dout0_20 Vdout0_20ck76 = 0.9 time = 385
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=385.025n

* CHECK dout0_21 Vdout0_21ck76 = 0 time = 385
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=385.025n

* CHECK dout0_22 Vdout0_22ck76 = 0 time = 385
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=385.025n

* CHECK dout0_23 Vdout0_23ck76 = 0 time = 385
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=385.025n

* CHECK dout0_24 Vdout0_24ck76 = 0 time = 385
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=385.025n

* CHECK dout0_25 Vdout0_25ck76 = 0.9 time = 385
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=385.025n

* CHECK dout0_26 Vdout0_26ck76 = 0.9 time = 385
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=385.025n

* CHECK dout0_27 Vdout0_27ck76 = 0 time = 385
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=385.025n

* CHECK dout0_28 Vdout0_28ck76 = 0.9 time = 385
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=385.025n

* CHECK dout0_29 Vdout0_29ck76 = 0.9 time = 385
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=385.025n

* CHECK dout0_30 Vdout0_30ck76 = 0 time = 385
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=385.025n

* CHECK dout0_31 Vdout0_31ck76 = 0.9 time = 385
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=385.025n

* CHECK dout0_32 Vdout0_32ck76 = 0.9 time = 385
.meas tran vdout0_32ck76 FIND v(dout0_32) AT=385.025n

* CHECK dout0_33 Vdout0_33ck76 = 0.9 time = 385
.meas tran vdout0_33ck76 FIND v(dout0_33) AT=385.025n

* CHECK dout0_34 Vdout0_34ck76 = 0.9 time = 385
.meas tran vdout0_34ck76 FIND v(dout0_34) AT=385.025n

* CHECK dout0_35 Vdout0_35ck76 = 0 time = 385
.meas tran vdout0_35ck76 FIND v(dout0_35) AT=385.025n

* CHECK dout0_36 Vdout0_36ck76 = 0 time = 385
.meas tran vdout0_36ck76 FIND v(dout0_36) AT=385.025n

* CHECK dout0_37 Vdout0_37ck76 = 0 time = 385
.meas tran vdout0_37ck76 FIND v(dout0_37) AT=385.025n

* CHECK dout0_38 Vdout0_38ck76 = 0.9 time = 385
.meas tran vdout0_38ck76 FIND v(dout0_38) AT=385.025n

* CHECK dout0_39 Vdout0_39ck76 = 0.9 time = 385
.meas tran vdout0_39ck76 FIND v(dout0_39) AT=385.025n

* CHECK dout0_40 Vdout0_40ck76 = 0.9 time = 385
.meas tran vdout0_40ck76 FIND v(dout0_40) AT=385.025n

* CHECK dout0_41 Vdout0_41ck76 = 0.9 time = 385
.meas tran vdout0_41ck76 FIND v(dout0_41) AT=385.025n

* CHECK dout0_42 Vdout0_42ck76 = 0 time = 385
.meas tran vdout0_42ck76 FIND v(dout0_42) AT=385.025n

* CHECK dout0_43 Vdout0_43ck76 = 0 time = 385
.meas tran vdout0_43ck76 FIND v(dout0_43) AT=385.025n

* CHECK dout0_44 Vdout0_44ck76 = 0 time = 385
.meas tran vdout0_44ck76 FIND v(dout0_44) AT=385.025n

* CHECK dout0_45 Vdout0_45ck76 = 0.9 time = 385
.meas tran vdout0_45ck76 FIND v(dout0_45) AT=385.025n

* CHECK dout0_46 Vdout0_46ck76 = 0.9 time = 385
.meas tran vdout0_46ck76 FIND v(dout0_46) AT=385.025n

* CHECK dout0_47 Vdout0_47ck76 = 0 time = 385
.meas tran vdout0_47ck76 FIND v(dout0_47) AT=385.025n

* CHECK dout0_48 Vdout0_48ck76 = 0.9 time = 385
.meas tran vdout0_48ck76 FIND v(dout0_48) AT=385.025n

* CHECK dout0_49 Vdout0_49ck76 = 0.9 time = 385
.meas tran vdout0_49ck76 FIND v(dout0_49) AT=385.025n

* CHECK dout0_50 Vdout0_50ck76 = 0.9 time = 385
.meas tran vdout0_50ck76 FIND v(dout0_50) AT=385.025n

* CHECK dout0_51 Vdout0_51ck76 = 0.9 time = 385
.meas tran vdout0_51ck76 FIND v(dout0_51) AT=385.025n

* CHECK dout0_52 Vdout0_52ck76 = 0 time = 385
.meas tran vdout0_52ck76 FIND v(dout0_52) AT=385.025n

* CHECK dout0_53 Vdout0_53ck76 = 0.9 time = 385
.meas tran vdout0_53ck76 FIND v(dout0_53) AT=385.025n

* CHECK dout0_54 Vdout0_54ck76 = 0.9 time = 385
.meas tran vdout0_54ck76 FIND v(dout0_54) AT=385.025n

* CHECK dout0_55 Vdout0_55ck76 = 0 time = 385
.meas tran vdout0_55ck76 FIND v(dout0_55) AT=385.025n

* CHECK dout0_56 Vdout0_56ck76 = 0.9 time = 385
.meas tran vdout0_56ck76 FIND v(dout0_56) AT=385.025n

* CHECK dout0_57 Vdout0_57ck76 = 0.9 time = 385
.meas tran vdout0_57ck76 FIND v(dout0_57) AT=385.025n

* CHECK dout0_58 Vdout0_58ck76 = 0.9 time = 385
.meas tran vdout0_58ck76 FIND v(dout0_58) AT=385.025n

* CHECK dout0_59 Vdout0_59ck76 = 0 time = 385
.meas tran vdout0_59ck76 FIND v(dout0_59) AT=385.025n

* CHECK dout0_60 Vdout0_60ck76 = 0.9 time = 385
.meas tran vdout0_60ck76 FIND v(dout0_60) AT=385.025n

* CHECK dout0_61 Vdout0_61ck76 = 0 time = 385
.meas tran vdout0_61ck76 FIND v(dout0_61) AT=385.025n

* CHECK dout0_62 Vdout0_62ck76 = 0.9 time = 385
.meas tran vdout0_62ck76 FIND v(dout0_62) AT=385.025n

* CHECK dout0_63 Vdout0_63ck76 = 0 time = 385
.meas tran vdout0_63ck76 FIND v(dout0_63) AT=385.025n

* CHECK dout0_64 Vdout0_64ck76 = 0 time = 385
.meas tran vdout0_64ck76 FIND v(dout0_64) AT=385.025n

* CHECK dout0_65 Vdout0_65ck76 = 0.9 time = 385
.meas tran vdout0_65ck76 FIND v(dout0_65) AT=385.025n

* CHECK dout0_66 Vdout0_66ck76 = 0.9 time = 385
.meas tran vdout0_66ck76 FIND v(dout0_66) AT=385.025n

* CHECK dout0_67 Vdout0_67ck76 = 0 time = 385
.meas tran vdout0_67ck76 FIND v(dout0_67) AT=385.025n

* CHECK dout0_68 Vdout0_68ck76 = 0 time = 385
.meas tran vdout0_68ck76 FIND v(dout0_68) AT=385.025n

* CHECK dout0_69 Vdout0_69ck76 = 0 time = 385
.meas tran vdout0_69ck76 FIND v(dout0_69) AT=385.025n

* CHECK dout0_70 Vdout0_70ck76 = 0.9 time = 385
.meas tran vdout0_70ck76 FIND v(dout0_70) AT=385.025n

* CHECK dout0_71 Vdout0_71ck76 = 0 time = 385
.meas tran vdout0_71ck76 FIND v(dout0_71) AT=385.025n

* CHECK dout0_72 Vdout0_72ck76 = 0 time = 385
.meas tran vdout0_72ck76 FIND v(dout0_72) AT=385.025n

* CHECK dout0_73 Vdout0_73ck76 = 0.9 time = 385
.meas tran vdout0_73ck76 FIND v(dout0_73) AT=385.025n

* CHECK dout0_74 Vdout0_74ck76 = 0 time = 385
.meas tran vdout0_74ck76 FIND v(dout0_74) AT=385.025n

* CHECK dout0_75 Vdout0_75ck76 = 0 time = 385
.meas tran vdout0_75ck76 FIND v(dout0_75) AT=385.025n

* CHECK dout0_76 Vdout0_76ck76 = 0.9 time = 385
.meas tran vdout0_76ck76 FIND v(dout0_76) AT=385.025n

* CHECK dout0_77 Vdout0_77ck76 = 0 time = 385
.meas tran vdout0_77ck76 FIND v(dout0_77) AT=385.025n

* CHECK dout0_78 Vdout0_78ck76 = 0 time = 385
.meas tran vdout0_78ck76 FIND v(dout0_78) AT=385.025n

* CHECK dout0_79 Vdout0_79ck76 = 0.9 time = 385
.meas tran vdout0_79ck76 FIND v(dout0_79) AT=385.025n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 0.9 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 0.9 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 0.9 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 0.9 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 0.9 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0.9 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 0.9 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0.9 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 0.9 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 0.9 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 0.9 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 0.9 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 0.9 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 0 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 0 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 0 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 0 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_32 Vdout0_32ck81 = 0.9 time = 410
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=410.025n

* CHECK dout0_33 Vdout0_33ck81 = 0.9 time = 410
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=410.025n

* CHECK dout0_34 Vdout0_34ck81 = 0 time = 410
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=410.025n

* CHECK dout0_35 Vdout0_35ck81 = 0.9 time = 410
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=410.025n

* CHECK dout0_36 Vdout0_36ck81 = 0.9 time = 410
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=410.025n

* CHECK dout0_37 Vdout0_37ck81 = 0 time = 410
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=410.025n

* CHECK dout0_38 Vdout0_38ck81 = 0 time = 410
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=410.025n

* CHECK dout0_39 Vdout0_39ck81 = 0 time = 410
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=410.025n

* CHECK dout0_40 Vdout0_40ck81 = 0 time = 410
.meas tran vdout0_40ck81 FIND v(dout0_40) AT=410.025n

* CHECK dout0_41 Vdout0_41ck81 = 0.9 time = 410
.meas tran vdout0_41ck81 FIND v(dout0_41) AT=410.025n

* CHECK dout0_42 Vdout0_42ck81 = 0 time = 410
.meas tran vdout0_42ck81 FIND v(dout0_42) AT=410.025n

* CHECK dout0_43 Vdout0_43ck81 = 0 time = 410
.meas tran vdout0_43ck81 FIND v(dout0_43) AT=410.025n

* CHECK dout0_44 Vdout0_44ck81 = 0 time = 410
.meas tran vdout0_44ck81 FIND v(dout0_44) AT=410.025n

* CHECK dout0_45 Vdout0_45ck81 = 0.9 time = 410
.meas tran vdout0_45ck81 FIND v(dout0_45) AT=410.025n

* CHECK dout0_46 Vdout0_46ck81 = 0 time = 410
.meas tran vdout0_46ck81 FIND v(dout0_46) AT=410.025n

* CHECK dout0_47 Vdout0_47ck81 = 0.9 time = 410
.meas tran vdout0_47ck81 FIND v(dout0_47) AT=410.025n

* CHECK dout0_48 Vdout0_48ck81 = 0 time = 410
.meas tran vdout0_48ck81 FIND v(dout0_48) AT=410.025n

* CHECK dout0_49 Vdout0_49ck81 = 0 time = 410
.meas tran vdout0_49ck81 FIND v(dout0_49) AT=410.025n

* CHECK dout0_50 Vdout0_50ck81 = 0.9 time = 410
.meas tran vdout0_50ck81 FIND v(dout0_50) AT=410.025n

* CHECK dout0_51 Vdout0_51ck81 = 0 time = 410
.meas tran vdout0_51ck81 FIND v(dout0_51) AT=410.025n

* CHECK dout0_52 Vdout0_52ck81 = 0.9 time = 410
.meas tran vdout0_52ck81 FIND v(dout0_52) AT=410.025n

* CHECK dout0_53 Vdout0_53ck81 = 0 time = 410
.meas tran vdout0_53ck81 FIND v(dout0_53) AT=410.025n

* CHECK dout0_54 Vdout0_54ck81 = 0 time = 410
.meas tran vdout0_54ck81 FIND v(dout0_54) AT=410.025n

* CHECK dout0_55 Vdout0_55ck81 = 0.9 time = 410
.meas tran vdout0_55ck81 FIND v(dout0_55) AT=410.025n

* CHECK dout0_56 Vdout0_56ck81 = 0.9 time = 410
.meas tran vdout0_56ck81 FIND v(dout0_56) AT=410.025n

* CHECK dout0_57 Vdout0_57ck81 = 0.9 time = 410
.meas tran vdout0_57ck81 FIND v(dout0_57) AT=410.025n

* CHECK dout0_58 Vdout0_58ck81 = 0.9 time = 410
.meas tran vdout0_58ck81 FIND v(dout0_58) AT=410.025n

* CHECK dout0_59 Vdout0_59ck81 = 0 time = 410
.meas tran vdout0_59ck81 FIND v(dout0_59) AT=410.025n

* CHECK dout0_60 Vdout0_60ck81 = 0 time = 410
.meas tran vdout0_60ck81 FIND v(dout0_60) AT=410.025n

* CHECK dout0_61 Vdout0_61ck81 = 0.9 time = 410
.meas tran vdout0_61ck81 FIND v(dout0_61) AT=410.025n

* CHECK dout0_62 Vdout0_62ck81 = 0.9 time = 410
.meas tran vdout0_62ck81 FIND v(dout0_62) AT=410.025n

* CHECK dout0_63 Vdout0_63ck81 = 0.9 time = 410
.meas tran vdout0_63ck81 FIND v(dout0_63) AT=410.025n

* CHECK dout0_64 Vdout0_64ck81 = 0.9 time = 410
.meas tran vdout0_64ck81 FIND v(dout0_64) AT=410.025n

* CHECK dout0_65 Vdout0_65ck81 = 0.9 time = 410
.meas tran vdout0_65ck81 FIND v(dout0_65) AT=410.025n

* CHECK dout0_66 Vdout0_66ck81 = 0 time = 410
.meas tran vdout0_66ck81 FIND v(dout0_66) AT=410.025n

* CHECK dout0_67 Vdout0_67ck81 = 0.9 time = 410
.meas tran vdout0_67ck81 FIND v(dout0_67) AT=410.025n

* CHECK dout0_68 Vdout0_68ck81 = 0 time = 410
.meas tran vdout0_68ck81 FIND v(dout0_68) AT=410.025n

* CHECK dout0_69 Vdout0_69ck81 = 0 time = 410
.meas tran vdout0_69ck81 FIND v(dout0_69) AT=410.025n

* CHECK dout0_70 Vdout0_70ck81 = 0.9 time = 410
.meas tran vdout0_70ck81 FIND v(dout0_70) AT=410.025n

* CHECK dout0_71 Vdout0_71ck81 = 0.9 time = 410
.meas tran vdout0_71ck81 FIND v(dout0_71) AT=410.025n

* CHECK dout0_72 Vdout0_72ck81 = 0 time = 410
.meas tran vdout0_72ck81 FIND v(dout0_72) AT=410.025n

* CHECK dout0_73 Vdout0_73ck81 = 0 time = 410
.meas tran vdout0_73ck81 FIND v(dout0_73) AT=410.025n

* CHECK dout0_74 Vdout0_74ck81 = 0 time = 410
.meas tran vdout0_74ck81 FIND v(dout0_74) AT=410.025n

* CHECK dout0_75 Vdout0_75ck81 = 0.9 time = 410
.meas tran vdout0_75ck81 FIND v(dout0_75) AT=410.025n

* CHECK dout0_76 Vdout0_76ck81 = 0 time = 410
.meas tran vdout0_76ck81 FIND v(dout0_76) AT=410.025n

* CHECK dout0_77 Vdout0_77ck81 = 0 time = 410
.meas tran vdout0_77ck81 FIND v(dout0_77) AT=410.025n

* CHECK dout0_78 Vdout0_78ck81 = 0.9 time = 410
.meas tran vdout0_78ck81 FIND v(dout0_78) AT=410.025n

* CHECK dout0_79 Vdout0_79ck81 = 0 time = 410
.meas tran vdout0_79ck81 FIND v(dout0_79) AT=410.025n

* CHECK dout0_0 Vdout0_0ck87 = 0.9 time = 440
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=440.025n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 440
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=440.025n

* CHECK dout0_2 Vdout0_2ck87 = 0.9 time = 440
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=440.025n

* CHECK dout0_3 Vdout0_3ck87 = 0.9 time = 440
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=440.025n

* CHECK dout0_4 Vdout0_4ck87 = 0 time = 440
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=440.025n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 440
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=440.025n

* CHECK dout0_6 Vdout0_6ck87 = 0.9 time = 440
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=440.025n

* CHECK dout0_7 Vdout0_7ck87 = 0.9 time = 440
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=440.025n

* CHECK dout0_8 Vdout0_8ck87 = 0.9 time = 440
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=440.025n

* CHECK dout0_9 Vdout0_9ck87 = 0.9 time = 440
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=440.025n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 440
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=440.025n

* CHECK dout0_11 Vdout0_11ck87 = 0.9 time = 440
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=440.025n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 440
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=440.025n

* CHECK dout0_13 Vdout0_13ck87 = 0.9 time = 440
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=440.025n

* CHECK dout0_14 Vdout0_14ck87 = 0.9 time = 440
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=440.025n

* CHECK dout0_15 Vdout0_15ck87 = 0.9 time = 440
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=440.025n

* CHECK dout0_16 Vdout0_16ck87 = 0 time = 440
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=440.025n

* CHECK dout0_17 Vdout0_17ck87 = 0 time = 440
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=440.025n

* CHECK dout0_18 Vdout0_18ck87 = 0 time = 440
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=440.025n

* CHECK dout0_19 Vdout0_19ck87 = 0 time = 440
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=440.025n

* CHECK dout0_20 Vdout0_20ck87 = 0 time = 440
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=440.025n

* CHECK dout0_21 Vdout0_21ck87 = 0 time = 440
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=440.025n

* CHECK dout0_22 Vdout0_22ck87 = 0.9 time = 440
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=440.025n

* CHECK dout0_23 Vdout0_23ck87 = 0 time = 440
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=440.025n

* CHECK dout0_24 Vdout0_24ck87 = 0.9 time = 440
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=440.025n

* CHECK dout0_25 Vdout0_25ck87 = 0.9 time = 440
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=440.025n

* CHECK dout0_26 Vdout0_26ck87 = 0.9 time = 440
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=440.025n

* CHECK dout0_27 Vdout0_27ck87 = 0 time = 440
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=440.025n

* CHECK dout0_28 Vdout0_28ck87 = 0.9 time = 440
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=440.025n

* CHECK dout0_29 Vdout0_29ck87 = 0.9 time = 440
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=440.025n

* CHECK dout0_30 Vdout0_30ck87 = 0 time = 440
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=440.025n

* CHECK dout0_31 Vdout0_31ck87 = 0.9 time = 440
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=440.025n

* CHECK dout0_32 Vdout0_32ck87 = 0 time = 440
.meas tran vdout0_32ck87 FIND v(dout0_32) AT=440.025n

* CHECK dout0_33 Vdout0_33ck87 = 0 time = 440
.meas tran vdout0_33ck87 FIND v(dout0_33) AT=440.025n

* CHECK dout0_34 Vdout0_34ck87 = 0.9 time = 440
.meas tran vdout0_34ck87 FIND v(dout0_34) AT=440.025n

* CHECK dout0_35 Vdout0_35ck87 = 0.9 time = 440
.meas tran vdout0_35ck87 FIND v(dout0_35) AT=440.025n

* CHECK dout0_36 Vdout0_36ck87 = 0 time = 440
.meas tran vdout0_36ck87 FIND v(dout0_36) AT=440.025n

* CHECK dout0_37 Vdout0_37ck87 = 0.9 time = 440
.meas tran vdout0_37ck87 FIND v(dout0_37) AT=440.025n

* CHECK dout0_38 Vdout0_38ck87 = 0.9 time = 440
.meas tran vdout0_38ck87 FIND v(dout0_38) AT=440.025n

* CHECK dout0_39 Vdout0_39ck87 = 0.9 time = 440
.meas tran vdout0_39ck87 FIND v(dout0_39) AT=440.025n

* CHECK dout0_40 Vdout0_40ck87 = 0.9 time = 440
.meas tran vdout0_40ck87 FIND v(dout0_40) AT=440.025n

* CHECK dout0_41 Vdout0_41ck87 = 0.9 time = 440
.meas tran vdout0_41ck87 FIND v(dout0_41) AT=440.025n

* CHECK dout0_42 Vdout0_42ck87 = 0 time = 440
.meas tran vdout0_42ck87 FIND v(dout0_42) AT=440.025n

* CHECK dout0_43 Vdout0_43ck87 = 0 time = 440
.meas tran vdout0_43ck87 FIND v(dout0_43) AT=440.025n

* CHECK dout0_44 Vdout0_44ck87 = 0 time = 440
.meas tran vdout0_44ck87 FIND v(dout0_44) AT=440.025n

* CHECK dout0_45 Vdout0_45ck87 = 0.9 time = 440
.meas tran vdout0_45ck87 FIND v(dout0_45) AT=440.025n

* CHECK dout0_46 Vdout0_46ck87 = 0.9 time = 440
.meas tran vdout0_46ck87 FIND v(dout0_46) AT=440.025n

* CHECK dout0_47 Vdout0_47ck87 = 0 time = 440
.meas tran vdout0_47ck87 FIND v(dout0_47) AT=440.025n

* CHECK dout0_48 Vdout0_48ck87 = 0 time = 440
.meas tran vdout0_48ck87 FIND v(dout0_48) AT=440.025n

* CHECK dout0_49 Vdout0_49ck87 = 0.9 time = 440
.meas tran vdout0_49ck87 FIND v(dout0_49) AT=440.025n

* CHECK dout0_50 Vdout0_50ck87 = 0.9 time = 440
.meas tran vdout0_50ck87 FIND v(dout0_50) AT=440.025n

* CHECK dout0_51 Vdout0_51ck87 = 0 time = 440
.meas tran vdout0_51ck87 FIND v(dout0_51) AT=440.025n

* CHECK dout0_52 Vdout0_52ck87 = 0 time = 440
.meas tran vdout0_52ck87 FIND v(dout0_52) AT=440.025n

* CHECK dout0_53 Vdout0_53ck87 = 0.9 time = 440
.meas tran vdout0_53ck87 FIND v(dout0_53) AT=440.025n

* CHECK dout0_54 Vdout0_54ck87 = 0.9 time = 440
.meas tran vdout0_54ck87 FIND v(dout0_54) AT=440.025n

* CHECK dout0_55 Vdout0_55ck87 = 0 time = 440
.meas tran vdout0_55ck87 FIND v(dout0_55) AT=440.025n

* CHECK dout0_56 Vdout0_56ck87 = 0.9 time = 440
.meas tran vdout0_56ck87 FIND v(dout0_56) AT=440.025n

* CHECK dout0_57 Vdout0_57ck87 = 0 time = 440
.meas tran vdout0_57ck87 FIND v(dout0_57) AT=440.025n

* CHECK dout0_58 Vdout0_58ck87 = 0 time = 440
.meas tran vdout0_58ck87 FIND v(dout0_58) AT=440.025n

* CHECK dout0_59 Vdout0_59ck87 = 0.9 time = 440
.meas tran vdout0_59ck87 FIND v(dout0_59) AT=440.025n

* CHECK dout0_60 Vdout0_60ck87 = 0.9 time = 440
.meas tran vdout0_60ck87 FIND v(dout0_60) AT=440.025n

* CHECK dout0_61 Vdout0_61ck87 = 0 time = 440
.meas tran vdout0_61ck87 FIND v(dout0_61) AT=440.025n

* CHECK dout0_62 Vdout0_62ck87 = 0 time = 440
.meas tran vdout0_62ck87 FIND v(dout0_62) AT=440.025n

* CHECK dout0_63 Vdout0_63ck87 = 0.9 time = 440
.meas tran vdout0_63ck87 FIND v(dout0_63) AT=440.025n

* CHECK dout0_64 Vdout0_64ck87 = 0.9 time = 440
.meas tran vdout0_64ck87 FIND v(dout0_64) AT=440.025n

* CHECK dout0_65 Vdout0_65ck87 = 0.9 time = 440
.meas tran vdout0_65ck87 FIND v(dout0_65) AT=440.025n

* CHECK dout0_66 Vdout0_66ck87 = 0 time = 440
.meas tran vdout0_66ck87 FIND v(dout0_66) AT=440.025n

* CHECK dout0_67 Vdout0_67ck87 = 0.9 time = 440
.meas tran vdout0_67ck87 FIND v(dout0_67) AT=440.025n

* CHECK dout0_68 Vdout0_68ck87 = 0.9 time = 440
.meas tran vdout0_68ck87 FIND v(dout0_68) AT=440.025n

* CHECK dout0_69 Vdout0_69ck87 = 0 time = 440
.meas tran vdout0_69ck87 FIND v(dout0_69) AT=440.025n

* CHECK dout0_70 Vdout0_70ck87 = 0.9 time = 440
.meas tran vdout0_70ck87 FIND v(dout0_70) AT=440.025n

* CHECK dout0_71 Vdout0_71ck87 = 0 time = 440
.meas tran vdout0_71ck87 FIND v(dout0_71) AT=440.025n

* CHECK dout0_72 Vdout0_72ck87 = 0.9 time = 440
.meas tran vdout0_72ck87 FIND v(dout0_72) AT=440.025n

* CHECK dout0_73 Vdout0_73ck87 = 0.9 time = 440
.meas tran vdout0_73ck87 FIND v(dout0_73) AT=440.025n

* CHECK dout0_74 Vdout0_74ck87 = 0.9 time = 440
.meas tran vdout0_74ck87 FIND v(dout0_74) AT=440.025n

* CHECK dout0_75 Vdout0_75ck87 = 0.9 time = 440
.meas tran vdout0_75ck87 FIND v(dout0_75) AT=440.025n

* CHECK dout0_76 Vdout0_76ck87 = 0.9 time = 440
.meas tran vdout0_76ck87 FIND v(dout0_76) AT=440.025n

* CHECK dout0_77 Vdout0_77ck87 = 0.9 time = 440
.meas tran vdout0_77ck87 FIND v(dout0_77) AT=440.025n

* CHECK dout0_78 Vdout0_78ck87 = 0.9 time = 440
.meas tran vdout0_78ck87 FIND v(dout0_78) AT=440.025n

* CHECK dout0_79 Vdout0_79ck87 = 0 time = 440
.meas tran vdout0_79ck87 FIND v(dout0_79) AT=440.025n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 475
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=475.025n

* CHECK dout0_1 Vdout0_1ck94 = 0 time = 475
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=475.025n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 475
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=475.025n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 475
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=475.025n

* CHECK dout0_4 Vdout0_4ck94 = 0 time = 475
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=475.025n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 475
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=475.025n

* CHECK dout0_6 Vdout0_6ck94 = 0.9 time = 475
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=475.025n

* CHECK dout0_7 Vdout0_7ck94 = 0.9 time = 475
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=475.025n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 475
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=475.025n

* CHECK dout0_9 Vdout0_9ck94 = 0 time = 475
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=475.025n

* CHECK dout0_10 Vdout0_10ck94 = 0 time = 475
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=475.025n

* CHECK dout0_11 Vdout0_11ck94 = 0.9 time = 475
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=475.025n

* CHECK dout0_12 Vdout0_12ck94 = 0.9 time = 475
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=475.025n

* CHECK dout0_13 Vdout0_13ck94 = 0.9 time = 475
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=475.025n

* CHECK dout0_14 Vdout0_14ck94 = 0 time = 475
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=475.025n

* CHECK dout0_15 Vdout0_15ck94 = 0.9 time = 475
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=475.025n

* CHECK dout0_16 Vdout0_16ck94 = 0.9 time = 475
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=475.025n

* CHECK dout0_17 Vdout0_17ck94 = 0.9 time = 475
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=475.025n

* CHECK dout0_18 Vdout0_18ck94 = 0.9 time = 475
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=475.025n

* CHECK dout0_19 Vdout0_19ck94 = 0.9 time = 475
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=475.025n

* CHECK dout0_20 Vdout0_20ck94 = 0 time = 475
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=475.025n

* CHECK dout0_21 Vdout0_21ck94 = 0 time = 475
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=475.025n

* CHECK dout0_22 Vdout0_22ck94 = 0.9 time = 475
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=475.025n

* CHECK dout0_23 Vdout0_23ck94 = 0 time = 475
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=475.025n

* CHECK dout0_24 Vdout0_24ck94 = 0.9 time = 475
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=475.025n

* CHECK dout0_25 Vdout0_25ck94 = 0.9 time = 475
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=475.025n

* CHECK dout0_26 Vdout0_26ck94 = 0.9 time = 475
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=475.025n

* CHECK dout0_27 Vdout0_27ck94 = 0 time = 475
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=475.025n

* CHECK dout0_28 Vdout0_28ck94 = 0 time = 475
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=475.025n

* CHECK dout0_29 Vdout0_29ck94 = 0 time = 475
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=475.025n

* CHECK dout0_30 Vdout0_30ck94 = 0.9 time = 475
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=475.025n

* CHECK dout0_31 Vdout0_31ck94 = 0.9 time = 475
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=475.025n

* CHECK dout0_32 Vdout0_32ck94 = 0 time = 475
.meas tran vdout0_32ck94 FIND v(dout0_32) AT=475.025n

* CHECK dout0_33 Vdout0_33ck94 = 0 time = 475
.meas tran vdout0_33ck94 FIND v(dout0_33) AT=475.025n

* CHECK dout0_34 Vdout0_34ck94 = 0.9 time = 475
.meas tran vdout0_34ck94 FIND v(dout0_34) AT=475.025n

* CHECK dout0_35 Vdout0_35ck94 = 0 time = 475
.meas tran vdout0_35ck94 FIND v(dout0_35) AT=475.025n

* CHECK dout0_36 Vdout0_36ck94 = 0 time = 475
.meas tran vdout0_36ck94 FIND v(dout0_36) AT=475.025n

* CHECK dout0_37 Vdout0_37ck94 = 0 time = 475
.meas tran vdout0_37ck94 FIND v(dout0_37) AT=475.025n

* CHECK dout0_38 Vdout0_38ck94 = 0 time = 475
.meas tran vdout0_38ck94 FIND v(dout0_38) AT=475.025n

* CHECK dout0_39 Vdout0_39ck94 = 0.9 time = 475
.meas tran vdout0_39ck94 FIND v(dout0_39) AT=475.025n

* CHECK dout0_40 Vdout0_40ck94 = 0 time = 475
.meas tran vdout0_40ck94 FIND v(dout0_40) AT=475.025n

* CHECK dout0_41 Vdout0_41ck94 = 0 time = 475
.meas tran vdout0_41ck94 FIND v(dout0_41) AT=475.025n

* CHECK dout0_42 Vdout0_42ck94 = 0.9 time = 475
.meas tran vdout0_42ck94 FIND v(dout0_42) AT=475.025n

* CHECK dout0_43 Vdout0_43ck94 = 0.9 time = 475
.meas tran vdout0_43ck94 FIND v(dout0_43) AT=475.025n

* CHECK dout0_44 Vdout0_44ck94 = 0.9 time = 475
.meas tran vdout0_44ck94 FIND v(dout0_44) AT=475.025n

* CHECK dout0_45 Vdout0_45ck94 = 0.9 time = 475
.meas tran vdout0_45ck94 FIND v(dout0_45) AT=475.025n

* CHECK dout0_46 Vdout0_46ck94 = 0.9 time = 475
.meas tran vdout0_46ck94 FIND v(dout0_46) AT=475.025n

* CHECK dout0_47 Vdout0_47ck94 = 0.9 time = 475
.meas tran vdout0_47ck94 FIND v(dout0_47) AT=475.025n

* CHECK dout0_48 Vdout0_48ck94 = 0 time = 475
.meas tran vdout0_48ck94 FIND v(dout0_48) AT=475.025n

* CHECK dout0_49 Vdout0_49ck94 = 0.9 time = 475
.meas tran vdout0_49ck94 FIND v(dout0_49) AT=475.025n

* CHECK dout0_50 Vdout0_50ck94 = 0 time = 475
.meas tran vdout0_50ck94 FIND v(dout0_50) AT=475.025n

* CHECK dout0_51 Vdout0_51ck94 = 0.9 time = 475
.meas tran vdout0_51ck94 FIND v(dout0_51) AT=475.025n

* CHECK dout0_52 Vdout0_52ck94 = 0.9 time = 475
.meas tran vdout0_52ck94 FIND v(dout0_52) AT=475.025n

* CHECK dout0_53 Vdout0_53ck94 = 0 time = 475
.meas tran vdout0_53ck94 FIND v(dout0_53) AT=475.025n

* CHECK dout0_54 Vdout0_54ck94 = 0 time = 475
.meas tran vdout0_54ck94 FIND v(dout0_54) AT=475.025n

* CHECK dout0_55 Vdout0_55ck94 = 0 time = 475
.meas tran vdout0_55ck94 FIND v(dout0_55) AT=475.025n

* CHECK dout0_56 Vdout0_56ck94 = 0.9 time = 475
.meas tran vdout0_56ck94 FIND v(dout0_56) AT=475.025n

* CHECK dout0_57 Vdout0_57ck94 = 0 time = 475
.meas tran vdout0_57ck94 FIND v(dout0_57) AT=475.025n

* CHECK dout0_58 Vdout0_58ck94 = 0 time = 475
.meas tran vdout0_58ck94 FIND v(dout0_58) AT=475.025n

* CHECK dout0_59 Vdout0_59ck94 = 0 time = 475
.meas tran vdout0_59ck94 FIND v(dout0_59) AT=475.025n

* CHECK dout0_60 Vdout0_60ck94 = 0 time = 475
.meas tran vdout0_60ck94 FIND v(dout0_60) AT=475.025n

* CHECK dout0_61 Vdout0_61ck94 = 0 time = 475
.meas tran vdout0_61ck94 FIND v(dout0_61) AT=475.025n

* CHECK dout0_62 Vdout0_62ck94 = 0.9 time = 475
.meas tran vdout0_62ck94 FIND v(dout0_62) AT=475.025n

* CHECK dout0_63 Vdout0_63ck94 = 0 time = 475
.meas tran vdout0_63ck94 FIND v(dout0_63) AT=475.025n

* CHECK dout0_64 Vdout0_64ck94 = 0.9 time = 475
.meas tran vdout0_64ck94 FIND v(dout0_64) AT=475.025n

* CHECK dout0_65 Vdout0_65ck94 = 0.9 time = 475
.meas tran vdout0_65ck94 FIND v(dout0_65) AT=475.025n

* CHECK dout0_66 Vdout0_66ck94 = 0.9 time = 475
.meas tran vdout0_66ck94 FIND v(dout0_66) AT=475.025n

* CHECK dout0_67 Vdout0_67ck94 = 0 time = 475
.meas tran vdout0_67ck94 FIND v(dout0_67) AT=475.025n

* CHECK dout0_68 Vdout0_68ck94 = 0.9 time = 475
.meas tran vdout0_68ck94 FIND v(dout0_68) AT=475.025n

* CHECK dout0_69 Vdout0_69ck94 = 0.9 time = 475
.meas tran vdout0_69ck94 FIND v(dout0_69) AT=475.025n

* CHECK dout0_70 Vdout0_70ck94 = 0 time = 475
.meas tran vdout0_70ck94 FIND v(dout0_70) AT=475.025n

* CHECK dout0_71 Vdout0_71ck94 = 0.9 time = 475
.meas tran vdout0_71ck94 FIND v(dout0_71) AT=475.025n

* CHECK dout0_72 Vdout0_72ck94 = 0 time = 475
.meas tran vdout0_72ck94 FIND v(dout0_72) AT=475.025n

* CHECK dout0_73 Vdout0_73ck94 = 0.9 time = 475
.meas tran vdout0_73ck94 FIND v(dout0_73) AT=475.025n

* CHECK dout0_74 Vdout0_74ck94 = 0 time = 475
.meas tran vdout0_74ck94 FIND v(dout0_74) AT=475.025n

* CHECK dout0_75 Vdout0_75ck94 = 0 time = 475
.meas tran vdout0_75ck94 FIND v(dout0_75) AT=475.025n

* CHECK dout0_76 Vdout0_76ck94 = 0 time = 475
.meas tran vdout0_76ck94 FIND v(dout0_76) AT=475.025n

* CHECK dout0_77 Vdout0_77ck94 = 0 time = 475
.meas tran vdout0_77ck94 FIND v(dout0_77) AT=475.025n

* CHECK dout0_78 Vdout0_78ck94 = 0 time = 475
.meas tran vdout0_78ck94 FIND v(dout0_78) AT=475.025n

* CHECK dout0_79 Vdout0_79ck94 = 0 time = 475
.meas tran vdout0_79ck94 FIND v(dout0_79) AT=475.025n

* CHECK dout0_0 Vdout0_0ck95 = 0 time = 480
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=480.025n

* CHECK dout0_1 Vdout0_1ck95 = 0.9 time = 480
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=480.025n

* CHECK dout0_2 Vdout0_2ck95 = 0.9 time = 480
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=480.025n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 480
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=480.025n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 480
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=480.025n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 480
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=480.025n

* CHECK dout0_6 Vdout0_6ck95 = 0.9 time = 480
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=480.025n

* CHECK dout0_7 Vdout0_7ck95 = 0.9 time = 480
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=480.025n

* CHECK dout0_8 Vdout0_8ck95 = 0.9 time = 480
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=480.025n

* CHECK dout0_9 Vdout0_9ck95 = 0.9 time = 480
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=480.025n

* CHECK dout0_10 Vdout0_10ck95 = 0.9 time = 480
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=480.025n

* CHECK dout0_11 Vdout0_11ck95 = 0.9 time = 480
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=480.025n

* CHECK dout0_12 Vdout0_12ck95 = 0.9 time = 480
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=480.025n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 480
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=480.025n

* CHECK dout0_14 Vdout0_14ck95 = 0.9 time = 480
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=480.025n

* CHECK dout0_15 Vdout0_15ck95 = 0.9 time = 480
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=480.025n

* CHECK dout0_16 Vdout0_16ck95 = 0.9 time = 480
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=480.025n

* CHECK dout0_17 Vdout0_17ck95 = 0 time = 480
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=480.025n

* CHECK dout0_18 Vdout0_18ck95 = 0.9 time = 480
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=480.025n

* CHECK dout0_19 Vdout0_19ck95 = 0 time = 480
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=480.025n

* CHECK dout0_20 Vdout0_20ck95 = 0 time = 480
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=480.025n

* CHECK dout0_21 Vdout0_21ck95 = 0.9 time = 480
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=480.025n

* CHECK dout0_22 Vdout0_22ck95 = 0.9 time = 480
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=480.025n

* CHECK dout0_23 Vdout0_23ck95 = 0 time = 480
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=480.025n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 480
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=480.025n

* CHECK dout0_25 Vdout0_25ck95 = 0.9 time = 480
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=480.025n

* CHECK dout0_26 Vdout0_26ck95 = 0.9 time = 480
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=480.025n

* CHECK dout0_27 Vdout0_27ck95 = 0.9 time = 480
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=480.025n

* CHECK dout0_28 Vdout0_28ck95 = 0.9 time = 480
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=480.025n

* CHECK dout0_29 Vdout0_29ck95 = 0 time = 480
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=480.025n

* CHECK dout0_30 Vdout0_30ck95 = 0 time = 480
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=480.025n

* CHECK dout0_31 Vdout0_31ck95 = 0.9 time = 480
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=480.025n

* CHECK dout0_32 Vdout0_32ck95 = 0 time = 480
.meas tran vdout0_32ck95 FIND v(dout0_32) AT=480.025n

* CHECK dout0_33 Vdout0_33ck95 = 0 time = 480
.meas tran vdout0_33ck95 FIND v(dout0_33) AT=480.025n

* CHECK dout0_34 Vdout0_34ck95 = 0 time = 480
.meas tran vdout0_34ck95 FIND v(dout0_34) AT=480.025n

* CHECK dout0_35 Vdout0_35ck95 = 0.9 time = 480
.meas tran vdout0_35ck95 FIND v(dout0_35) AT=480.025n

* CHECK dout0_36 Vdout0_36ck95 = 0 time = 480
.meas tran vdout0_36ck95 FIND v(dout0_36) AT=480.025n

* CHECK dout0_37 Vdout0_37ck95 = 0 time = 480
.meas tran vdout0_37ck95 FIND v(dout0_37) AT=480.025n

* CHECK dout0_38 Vdout0_38ck95 = 0.9 time = 480
.meas tran vdout0_38ck95 FIND v(dout0_38) AT=480.025n

* CHECK dout0_39 Vdout0_39ck95 = 0 time = 480
.meas tran vdout0_39ck95 FIND v(dout0_39) AT=480.025n

* CHECK dout0_40 Vdout0_40ck95 = 0 time = 480
.meas tran vdout0_40ck95 FIND v(dout0_40) AT=480.025n

* CHECK dout0_41 Vdout0_41ck95 = 0.9 time = 480
.meas tran vdout0_41ck95 FIND v(dout0_41) AT=480.025n

* CHECK dout0_42 Vdout0_42ck95 = 0 time = 480
.meas tran vdout0_42ck95 FIND v(dout0_42) AT=480.025n

* CHECK dout0_43 Vdout0_43ck95 = 0.9 time = 480
.meas tran vdout0_43ck95 FIND v(dout0_43) AT=480.025n

* CHECK dout0_44 Vdout0_44ck95 = 0 time = 480
.meas tran vdout0_44ck95 FIND v(dout0_44) AT=480.025n

* CHECK dout0_45 Vdout0_45ck95 = 0 time = 480
.meas tran vdout0_45ck95 FIND v(dout0_45) AT=480.025n

* CHECK dout0_46 Vdout0_46ck95 = 0.9 time = 480
.meas tran vdout0_46ck95 FIND v(dout0_46) AT=480.025n

* CHECK dout0_47 Vdout0_47ck95 = 0 time = 480
.meas tran vdout0_47ck95 FIND v(dout0_47) AT=480.025n

* CHECK dout0_48 Vdout0_48ck95 = 0 time = 480
.meas tran vdout0_48ck95 FIND v(dout0_48) AT=480.025n

* CHECK dout0_49 Vdout0_49ck95 = 0 time = 480
.meas tran vdout0_49ck95 FIND v(dout0_49) AT=480.025n

* CHECK dout0_50 Vdout0_50ck95 = 0.9 time = 480
.meas tran vdout0_50ck95 FIND v(dout0_50) AT=480.025n

* CHECK dout0_51 Vdout0_51ck95 = 0.9 time = 480
.meas tran vdout0_51ck95 FIND v(dout0_51) AT=480.025n

* CHECK dout0_52 Vdout0_52ck95 = 0 time = 480
.meas tran vdout0_52ck95 FIND v(dout0_52) AT=480.025n

* CHECK dout0_53 Vdout0_53ck95 = 0 time = 480
.meas tran vdout0_53ck95 FIND v(dout0_53) AT=480.025n

* CHECK dout0_54 Vdout0_54ck95 = 0 time = 480
.meas tran vdout0_54ck95 FIND v(dout0_54) AT=480.025n

* CHECK dout0_55 Vdout0_55ck95 = 0.9 time = 480
.meas tran vdout0_55ck95 FIND v(dout0_55) AT=480.025n

* CHECK dout0_56 Vdout0_56ck95 = 0 time = 480
.meas tran vdout0_56ck95 FIND v(dout0_56) AT=480.025n

* CHECK dout0_57 Vdout0_57ck95 = 0.9 time = 480
.meas tran vdout0_57ck95 FIND v(dout0_57) AT=480.025n

* CHECK dout0_58 Vdout0_58ck95 = 0 time = 480
.meas tran vdout0_58ck95 FIND v(dout0_58) AT=480.025n

* CHECK dout0_59 Vdout0_59ck95 = 0 time = 480
.meas tran vdout0_59ck95 FIND v(dout0_59) AT=480.025n

* CHECK dout0_60 Vdout0_60ck95 = 0 time = 480
.meas tran vdout0_60ck95 FIND v(dout0_60) AT=480.025n

* CHECK dout0_61 Vdout0_61ck95 = 0 time = 480
.meas tran vdout0_61ck95 FIND v(dout0_61) AT=480.025n

* CHECK dout0_62 Vdout0_62ck95 = 0 time = 480
.meas tran vdout0_62ck95 FIND v(dout0_62) AT=480.025n

* CHECK dout0_63 Vdout0_63ck95 = 0 time = 480
.meas tran vdout0_63ck95 FIND v(dout0_63) AT=480.025n

* CHECK dout0_64 Vdout0_64ck95 = 0 time = 480
.meas tran vdout0_64ck95 FIND v(dout0_64) AT=480.025n

* CHECK dout0_65 Vdout0_65ck95 = 0.9 time = 480
.meas tran vdout0_65ck95 FIND v(dout0_65) AT=480.025n

* CHECK dout0_66 Vdout0_66ck95 = 0.9 time = 480
.meas tran vdout0_66ck95 FIND v(dout0_66) AT=480.025n

* CHECK dout0_67 Vdout0_67ck95 = 0 time = 480
.meas tran vdout0_67ck95 FIND v(dout0_67) AT=480.025n

* CHECK dout0_68 Vdout0_68ck95 = 0.9 time = 480
.meas tran vdout0_68ck95 FIND v(dout0_68) AT=480.025n

* CHECK dout0_69 Vdout0_69ck95 = 0.9 time = 480
.meas tran vdout0_69ck95 FIND v(dout0_69) AT=480.025n

* CHECK dout0_70 Vdout0_70ck95 = 0.9 time = 480
.meas tran vdout0_70ck95 FIND v(dout0_70) AT=480.025n

* CHECK dout0_71 Vdout0_71ck95 = 0 time = 480
.meas tran vdout0_71ck95 FIND v(dout0_71) AT=480.025n

* CHECK dout0_72 Vdout0_72ck95 = 0 time = 480
.meas tran vdout0_72ck95 FIND v(dout0_72) AT=480.025n

* CHECK dout0_73 Vdout0_73ck95 = 0 time = 480
.meas tran vdout0_73ck95 FIND v(dout0_73) AT=480.025n

* CHECK dout0_74 Vdout0_74ck95 = 0.9 time = 480
.meas tran vdout0_74ck95 FIND v(dout0_74) AT=480.025n

* CHECK dout0_75 Vdout0_75ck95 = 0 time = 480
.meas tran vdout0_75ck95 FIND v(dout0_75) AT=480.025n

* CHECK dout0_76 Vdout0_76ck95 = 0.9 time = 480
.meas tran vdout0_76ck95 FIND v(dout0_76) AT=480.025n

* CHECK dout0_77 Vdout0_77ck95 = 0 time = 480
.meas tran vdout0_77ck95 FIND v(dout0_77) AT=480.025n

* CHECK dout0_78 Vdout0_78ck95 = 0.9 time = 480
.meas tran vdout0_78ck95 FIND v(dout0_78) AT=480.025n

* CHECK dout0_79 Vdout0_79ck95 = 0.9 time = 480
.meas tran vdout0_79ck95 FIND v(dout0_79) AT=480.025n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 0.9 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 0.9 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 0.9 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 0.9 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0.9 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0.9 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0.9 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 0.9 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 0.9 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 0.9 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0.9 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 0.9 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 0 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 0.9 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 0 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 0.9 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 0.9 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 0.9 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0.9 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0.9 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 0.9 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 0.9 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_32 Vdout0_32ck96 = 0 time = 485
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=485.025n

* CHECK dout0_33 Vdout0_33ck96 = 0 time = 485
.meas tran vdout0_33ck96 FIND v(dout0_33) AT=485.025n

* CHECK dout0_34 Vdout0_34ck96 = 0 time = 485
.meas tran vdout0_34ck96 FIND v(dout0_34) AT=485.025n

* CHECK dout0_35 Vdout0_35ck96 = 0.9 time = 485
.meas tran vdout0_35ck96 FIND v(dout0_35) AT=485.025n

* CHECK dout0_36 Vdout0_36ck96 = 0 time = 485
.meas tran vdout0_36ck96 FIND v(dout0_36) AT=485.025n

* CHECK dout0_37 Vdout0_37ck96 = 0 time = 485
.meas tran vdout0_37ck96 FIND v(dout0_37) AT=485.025n

* CHECK dout0_38 Vdout0_38ck96 = 0.9 time = 485
.meas tran vdout0_38ck96 FIND v(dout0_38) AT=485.025n

* CHECK dout0_39 Vdout0_39ck96 = 0 time = 485
.meas tran vdout0_39ck96 FIND v(dout0_39) AT=485.025n

* CHECK dout0_40 Vdout0_40ck96 = 0 time = 485
.meas tran vdout0_40ck96 FIND v(dout0_40) AT=485.025n

* CHECK dout0_41 Vdout0_41ck96 = 0.9 time = 485
.meas tran vdout0_41ck96 FIND v(dout0_41) AT=485.025n

* CHECK dout0_42 Vdout0_42ck96 = 0 time = 485
.meas tran vdout0_42ck96 FIND v(dout0_42) AT=485.025n

* CHECK dout0_43 Vdout0_43ck96 = 0.9 time = 485
.meas tran vdout0_43ck96 FIND v(dout0_43) AT=485.025n

* CHECK dout0_44 Vdout0_44ck96 = 0 time = 485
.meas tran vdout0_44ck96 FIND v(dout0_44) AT=485.025n

* CHECK dout0_45 Vdout0_45ck96 = 0 time = 485
.meas tran vdout0_45ck96 FIND v(dout0_45) AT=485.025n

* CHECK dout0_46 Vdout0_46ck96 = 0.9 time = 485
.meas tran vdout0_46ck96 FIND v(dout0_46) AT=485.025n

* CHECK dout0_47 Vdout0_47ck96 = 0 time = 485
.meas tran vdout0_47ck96 FIND v(dout0_47) AT=485.025n

* CHECK dout0_48 Vdout0_48ck96 = 0 time = 485
.meas tran vdout0_48ck96 FIND v(dout0_48) AT=485.025n

* CHECK dout0_49 Vdout0_49ck96 = 0 time = 485
.meas tran vdout0_49ck96 FIND v(dout0_49) AT=485.025n

* CHECK dout0_50 Vdout0_50ck96 = 0.9 time = 485
.meas tran vdout0_50ck96 FIND v(dout0_50) AT=485.025n

* CHECK dout0_51 Vdout0_51ck96 = 0.9 time = 485
.meas tran vdout0_51ck96 FIND v(dout0_51) AT=485.025n

* CHECK dout0_52 Vdout0_52ck96 = 0 time = 485
.meas tran vdout0_52ck96 FIND v(dout0_52) AT=485.025n

* CHECK dout0_53 Vdout0_53ck96 = 0 time = 485
.meas tran vdout0_53ck96 FIND v(dout0_53) AT=485.025n

* CHECK dout0_54 Vdout0_54ck96 = 0 time = 485
.meas tran vdout0_54ck96 FIND v(dout0_54) AT=485.025n

* CHECK dout0_55 Vdout0_55ck96 = 0.9 time = 485
.meas tran vdout0_55ck96 FIND v(dout0_55) AT=485.025n

* CHECK dout0_56 Vdout0_56ck96 = 0 time = 485
.meas tran vdout0_56ck96 FIND v(dout0_56) AT=485.025n

* CHECK dout0_57 Vdout0_57ck96 = 0.9 time = 485
.meas tran vdout0_57ck96 FIND v(dout0_57) AT=485.025n

* CHECK dout0_58 Vdout0_58ck96 = 0 time = 485
.meas tran vdout0_58ck96 FIND v(dout0_58) AT=485.025n

* CHECK dout0_59 Vdout0_59ck96 = 0 time = 485
.meas tran vdout0_59ck96 FIND v(dout0_59) AT=485.025n

* CHECK dout0_60 Vdout0_60ck96 = 0 time = 485
.meas tran vdout0_60ck96 FIND v(dout0_60) AT=485.025n

* CHECK dout0_61 Vdout0_61ck96 = 0 time = 485
.meas tran vdout0_61ck96 FIND v(dout0_61) AT=485.025n

* CHECK dout0_62 Vdout0_62ck96 = 0 time = 485
.meas tran vdout0_62ck96 FIND v(dout0_62) AT=485.025n

* CHECK dout0_63 Vdout0_63ck96 = 0 time = 485
.meas tran vdout0_63ck96 FIND v(dout0_63) AT=485.025n

* CHECK dout0_64 Vdout0_64ck96 = 0 time = 485
.meas tran vdout0_64ck96 FIND v(dout0_64) AT=485.025n

* CHECK dout0_65 Vdout0_65ck96 = 0.9 time = 485
.meas tran vdout0_65ck96 FIND v(dout0_65) AT=485.025n

* CHECK dout0_66 Vdout0_66ck96 = 0.9 time = 485
.meas tran vdout0_66ck96 FIND v(dout0_66) AT=485.025n

* CHECK dout0_67 Vdout0_67ck96 = 0 time = 485
.meas tran vdout0_67ck96 FIND v(dout0_67) AT=485.025n

* CHECK dout0_68 Vdout0_68ck96 = 0.9 time = 485
.meas tran vdout0_68ck96 FIND v(dout0_68) AT=485.025n

* CHECK dout0_69 Vdout0_69ck96 = 0.9 time = 485
.meas tran vdout0_69ck96 FIND v(dout0_69) AT=485.025n

* CHECK dout0_70 Vdout0_70ck96 = 0.9 time = 485
.meas tran vdout0_70ck96 FIND v(dout0_70) AT=485.025n

* CHECK dout0_71 Vdout0_71ck96 = 0 time = 485
.meas tran vdout0_71ck96 FIND v(dout0_71) AT=485.025n

* CHECK dout0_72 Vdout0_72ck96 = 0 time = 485
.meas tran vdout0_72ck96 FIND v(dout0_72) AT=485.025n

* CHECK dout0_73 Vdout0_73ck96 = 0 time = 485
.meas tran vdout0_73ck96 FIND v(dout0_73) AT=485.025n

* CHECK dout0_74 Vdout0_74ck96 = 0.9 time = 485
.meas tran vdout0_74ck96 FIND v(dout0_74) AT=485.025n

* CHECK dout0_75 Vdout0_75ck96 = 0 time = 485
.meas tran vdout0_75ck96 FIND v(dout0_75) AT=485.025n

* CHECK dout0_76 Vdout0_76ck96 = 0.9 time = 485
.meas tran vdout0_76ck96 FIND v(dout0_76) AT=485.025n

* CHECK dout0_77 Vdout0_77ck96 = 0 time = 485
.meas tran vdout0_77ck96 FIND v(dout0_77) AT=485.025n

* CHECK dout0_78 Vdout0_78ck96 = 0.9 time = 485
.meas tran vdout0_78ck96 FIND v(dout0_78) AT=485.025n

* CHECK dout0_79 Vdout0_79ck96 = 0.9 time = 485
.meas tran vdout0_79ck96 FIND v(dout0_79) AT=485.025n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 490
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=490.025n

* CHECK dout0_1 Vdout0_1ck97 = 0.9 time = 490
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=490.025n

* CHECK dout0_2 Vdout0_2ck97 = 0.9 time = 490
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=490.025n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 490
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=490.025n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 490
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=490.025n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 490
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=490.025n

* CHECK dout0_6 Vdout0_6ck97 = 0.9 time = 490
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=490.025n

* CHECK dout0_7 Vdout0_7ck97 = 0.9 time = 490
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=490.025n

* CHECK dout0_8 Vdout0_8ck97 = 0.9 time = 490
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=490.025n

* CHECK dout0_9 Vdout0_9ck97 = 0.9 time = 490
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=490.025n

* CHECK dout0_10 Vdout0_10ck97 = 0.9 time = 490
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=490.025n

* CHECK dout0_11 Vdout0_11ck97 = 0.9 time = 490
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=490.025n

* CHECK dout0_12 Vdout0_12ck97 = 0.9 time = 490
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=490.025n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 490
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=490.025n

* CHECK dout0_14 Vdout0_14ck97 = 0.9 time = 490
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=490.025n

* CHECK dout0_15 Vdout0_15ck97 = 0.9 time = 490
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=490.025n

* CHECK dout0_16 Vdout0_16ck97 = 0.9 time = 490
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=490.025n

* CHECK dout0_17 Vdout0_17ck97 = 0 time = 490
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=490.025n

* CHECK dout0_18 Vdout0_18ck97 = 0.9 time = 490
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=490.025n

* CHECK dout0_19 Vdout0_19ck97 = 0 time = 490
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=490.025n

* CHECK dout0_20 Vdout0_20ck97 = 0 time = 490
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=490.025n

* CHECK dout0_21 Vdout0_21ck97 = 0.9 time = 490
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=490.025n

* CHECK dout0_22 Vdout0_22ck97 = 0.9 time = 490
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=490.025n

* CHECK dout0_23 Vdout0_23ck97 = 0 time = 490
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=490.025n

* CHECK dout0_24 Vdout0_24ck97 = 0 time = 490
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=490.025n

* CHECK dout0_25 Vdout0_25ck97 = 0.9 time = 490
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=490.025n

* CHECK dout0_26 Vdout0_26ck97 = 0.9 time = 490
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=490.025n

* CHECK dout0_27 Vdout0_27ck97 = 0.9 time = 490
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=490.025n

* CHECK dout0_28 Vdout0_28ck97 = 0.9 time = 490
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=490.025n

* CHECK dout0_29 Vdout0_29ck97 = 0 time = 490
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=490.025n

* CHECK dout0_30 Vdout0_30ck97 = 0 time = 490
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=490.025n

* CHECK dout0_31 Vdout0_31ck97 = 0.9 time = 490
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=490.025n

* CHECK dout0_32 Vdout0_32ck97 = 0 time = 490
.meas tran vdout0_32ck97 FIND v(dout0_32) AT=490.025n

* CHECK dout0_33 Vdout0_33ck97 = 0 time = 490
.meas tran vdout0_33ck97 FIND v(dout0_33) AT=490.025n

* CHECK dout0_34 Vdout0_34ck97 = 0 time = 490
.meas tran vdout0_34ck97 FIND v(dout0_34) AT=490.025n

* CHECK dout0_35 Vdout0_35ck97 = 0.9 time = 490
.meas tran vdout0_35ck97 FIND v(dout0_35) AT=490.025n

* CHECK dout0_36 Vdout0_36ck97 = 0 time = 490
.meas tran vdout0_36ck97 FIND v(dout0_36) AT=490.025n

* CHECK dout0_37 Vdout0_37ck97 = 0 time = 490
.meas tran vdout0_37ck97 FIND v(dout0_37) AT=490.025n

* CHECK dout0_38 Vdout0_38ck97 = 0.9 time = 490
.meas tran vdout0_38ck97 FIND v(dout0_38) AT=490.025n

* CHECK dout0_39 Vdout0_39ck97 = 0 time = 490
.meas tran vdout0_39ck97 FIND v(dout0_39) AT=490.025n

* CHECK dout0_40 Vdout0_40ck97 = 0 time = 490
.meas tran vdout0_40ck97 FIND v(dout0_40) AT=490.025n

* CHECK dout0_41 Vdout0_41ck97 = 0.9 time = 490
.meas tran vdout0_41ck97 FIND v(dout0_41) AT=490.025n

* CHECK dout0_42 Vdout0_42ck97 = 0 time = 490
.meas tran vdout0_42ck97 FIND v(dout0_42) AT=490.025n

* CHECK dout0_43 Vdout0_43ck97 = 0.9 time = 490
.meas tran vdout0_43ck97 FIND v(dout0_43) AT=490.025n

* CHECK dout0_44 Vdout0_44ck97 = 0 time = 490
.meas tran vdout0_44ck97 FIND v(dout0_44) AT=490.025n

* CHECK dout0_45 Vdout0_45ck97 = 0 time = 490
.meas tran vdout0_45ck97 FIND v(dout0_45) AT=490.025n

* CHECK dout0_46 Vdout0_46ck97 = 0.9 time = 490
.meas tran vdout0_46ck97 FIND v(dout0_46) AT=490.025n

* CHECK dout0_47 Vdout0_47ck97 = 0 time = 490
.meas tran vdout0_47ck97 FIND v(dout0_47) AT=490.025n

* CHECK dout0_48 Vdout0_48ck97 = 0 time = 490
.meas tran vdout0_48ck97 FIND v(dout0_48) AT=490.025n

* CHECK dout0_49 Vdout0_49ck97 = 0 time = 490
.meas tran vdout0_49ck97 FIND v(dout0_49) AT=490.025n

* CHECK dout0_50 Vdout0_50ck97 = 0.9 time = 490
.meas tran vdout0_50ck97 FIND v(dout0_50) AT=490.025n

* CHECK dout0_51 Vdout0_51ck97 = 0.9 time = 490
.meas tran vdout0_51ck97 FIND v(dout0_51) AT=490.025n

* CHECK dout0_52 Vdout0_52ck97 = 0 time = 490
.meas tran vdout0_52ck97 FIND v(dout0_52) AT=490.025n

* CHECK dout0_53 Vdout0_53ck97 = 0 time = 490
.meas tran vdout0_53ck97 FIND v(dout0_53) AT=490.025n

* CHECK dout0_54 Vdout0_54ck97 = 0 time = 490
.meas tran vdout0_54ck97 FIND v(dout0_54) AT=490.025n

* CHECK dout0_55 Vdout0_55ck97 = 0.9 time = 490
.meas tran vdout0_55ck97 FIND v(dout0_55) AT=490.025n

* CHECK dout0_56 Vdout0_56ck97 = 0 time = 490
.meas tran vdout0_56ck97 FIND v(dout0_56) AT=490.025n

* CHECK dout0_57 Vdout0_57ck97 = 0.9 time = 490
.meas tran vdout0_57ck97 FIND v(dout0_57) AT=490.025n

* CHECK dout0_58 Vdout0_58ck97 = 0 time = 490
.meas tran vdout0_58ck97 FIND v(dout0_58) AT=490.025n

* CHECK dout0_59 Vdout0_59ck97 = 0 time = 490
.meas tran vdout0_59ck97 FIND v(dout0_59) AT=490.025n

* CHECK dout0_60 Vdout0_60ck97 = 0 time = 490
.meas tran vdout0_60ck97 FIND v(dout0_60) AT=490.025n

* CHECK dout0_61 Vdout0_61ck97 = 0 time = 490
.meas tran vdout0_61ck97 FIND v(dout0_61) AT=490.025n

* CHECK dout0_62 Vdout0_62ck97 = 0 time = 490
.meas tran vdout0_62ck97 FIND v(dout0_62) AT=490.025n

* CHECK dout0_63 Vdout0_63ck97 = 0 time = 490
.meas tran vdout0_63ck97 FIND v(dout0_63) AT=490.025n

* CHECK dout0_64 Vdout0_64ck97 = 0 time = 490
.meas tran vdout0_64ck97 FIND v(dout0_64) AT=490.025n

* CHECK dout0_65 Vdout0_65ck97 = 0.9 time = 490
.meas tran vdout0_65ck97 FIND v(dout0_65) AT=490.025n

* CHECK dout0_66 Vdout0_66ck97 = 0.9 time = 490
.meas tran vdout0_66ck97 FIND v(dout0_66) AT=490.025n

* CHECK dout0_67 Vdout0_67ck97 = 0 time = 490
.meas tran vdout0_67ck97 FIND v(dout0_67) AT=490.025n

* CHECK dout0_68 Vdout0_68ck97 = 0.9 time = 490
.meas tran vdout0_68ck97 FIND v(dout0_68) AT=490.025n

* CHECK dout0_69 Vdout0_69ck97 = 0.9 time = 490
.meas tran vdout0_69ck97 FIND v(dout0_69) AT=490.025n

* CHECK dout0_70 Vdout0_70ck97 = 0.9 time = 490
.meas tran vdout0_70ck97 FIND v(dout0_70) AT=490.025n

* CHECK dout0_71 Vdout0_71ck97 = 0 time = 490
.meas tran vdout0_71ck97 FIND v(dout0_71) AT=490.025n

* CHECK dout0_72 Vdout0_72ck97 = 0 time = 490
.meas tran vdout0_72ck97 FIND v(dout0_72) AT=490.025n

* CHECK dout0_73 Vdout0_73ck97 = 0 time = 490
.meas tran vdout0_73ck97 FIND v(dout0_73) AT=490.025n

* CHECK dout0_74 Vdout0_74ck97 = 0.9 time = 490
.meas tran vdout0_74ck97 FIND v(dout0_74) AT=490.025n

* CHECK dout0_75 Vdout0_75ck97 = 0 time = 490
.meas tran vdout0_75ck97 FIND v(dout0_75) AT=490.025n

* CHECK dout0_76 Vdout0_76ck97 = 0.9 time = 490
.meas tran vdout0_76ck97 FIND v(dout0_76) AT=490.025n

* CHECK dout0_77 Vdout0_77ck97 = 0 time = 490
.meas tran vdout0_77ck97 FIND v(dout0_77) AT=490.025n

* CHECK dout0_78 Vdout0_78ck97 = 0.9 time = 490
.meas tran vdout0_78ck97 FIND v(dout0_78) AT=490.025n

* CHECK dout0_79 Vdout0_79ck97 = 0.9 time = 490
.meas tran vdout0_79ck97 FIND v(dout0_79) AT=490.025n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 500
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=500.025n

* CHECK dout0_1 Vdout0_1ck99 = 0.9 time = 500
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=500.025n

* CHECK dout0_2 Vdout0_2ck99 = 0.9 time = 500
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=500.025n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 500
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=500.025n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 500
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=500.025n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 500
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=500.025n

* CHECK dout0_6 Vdout0_6ck99 = 0.9 time = 500
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=500.025n

* CHECK dout0_7 Vdout0_7ck99 = 0.9 time = 500
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=500.025n

* CHECK dout0_8 Vdout0_8ck99 = 0.9 time = 500
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=500.025n

* CHECK dout0_9 Vdout0_9ck99 = 0.9 time = 500
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=500.025n

* CHECK dout0_10 Vdout0_10ck99 = 0.9 time = 500
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=500.025n

* CHECK dout0_11 Vdout0_11ck99 = 0.9 time = 500
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=500.025n

* CHECK dout0_12 Vdout0_12ck99 = 0.9 time = 500
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=500.025n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 500
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=500.025n

* CHECK dout0_14 Vdout0_14ck99 = 0.9 time = 500
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=500.025n

* CHECK dout0_15 Vdout0_15ck99 = 0.9 time = 500
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=500.025n

* CHECK dout0_16 Vdout0_16ck99 = 0.9 time = 500
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=500.025n

* CHECK dout0_17 Vdout0_17ck99 = 0 time = 500
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=500.025n

* CHECK dout0_18 Vdout0_18ck99 = 0.9 time = 500
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=500.025n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 500
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=500.025n

* CHECK dout0_20 Vdout0_20ck99 = 0 time = 500
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=500.025n

* CHECK dout0_21 Vdout0_21ck99 = 0.9 time = 500
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=500.025n

* CHECK dout0_22 Vdout0_22ck99 = 0.9 time = 500
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=500.025n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 500
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=500.025n

* CHECK dout0_24 Vdout0_24ck99 = 0 time = 500
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=500.025n

* CHECK dout0_25 Vdout0_25ck99 = 0.9 time = 500
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=500.025n

* CHECK dout0_26 Vdout0_26ck99 = 0.9 time = 500
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=500.025n

* CHECK dout0_27 Vdout0_27ck99 = 0.9 time = 500
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=500.025n

* CHECK dout0_28 Vdout0_28ck99 = 0.9 time = 500
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=500.025n

* CHECK dout0_29 Vdout0_29ck99 = 0 time = 500
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=500.025n

* CHECK dout0_30 Vdout0_30ck99 = 0 time = 500
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=500.025n

* CHECK dout0_31 Vdout0_31ck99 = 0.9 time = 500
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=500.025n

* CHECK dout0_32 Vdout0_32ck99 = 0 time = 500
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=500.025n

* CHECK dout0_33 Vdout0_33ck99 = 0 time = 500
.meas tran vdout0_33ck99 FIND v(dout0_33) AT=500.025n

* CHECK dout0_34 Vdout0_34ck99 = 0 time = 500
.meas tran vdout0_34ck99 FIND v(dout0_34) AT=500.025n

* CHECK dout0_35 Vdout0_35ck99 = 0.9 time = 500
.meas tran vdout0_35ck99 FIND v(dout0_35) AT=500.025n

* CHECK dout0_36 Vdout0_36ck99 = 0 time = 500
.meas tran vdout0_36ck99 FIND v(dout0_36) AT=500.025n

* CHECK dout0_37 Vdout0_37ck99 = 0 time = 500
.meas tran vdout0_37ck99 FIND v(dout0_37) AT=500.025n

* CHECK dout0_38 Vdout0_38ck99 = 0.9 time = 500
.meas tran vdout0_38ck99 FIND v(dout0_38) AT=500.025n

* CHECK dout0_39 Vdout0_39ck99 = 0 time = 500
.meas tran vdout0_39ck99 FIND v(dout0_39) AT=500.025n

* CHECK dout0_40 Vdout0_40ck99 = 0 time = 500
.meas tran vdout0_40ck99 FIND v(dout0_40) AT=500.025n

* CHECK dout0_41 Vdout0_41ck99 = 0.9 time = 500
.meas tran vdout0_41ck99 FIND v(dout0_41) AT=500.025n

* CHECK dout0_42 Vdout0_42ck99 = 0 time = 500
.meas tran vdout0_42ck99 FIND v(dout0_42) AT=500.025n

* CHECK dout0_43 Vdout0_43ck99 = 0.9 time = 500
.meas tran vdout0_43ck99 FIND v(dout0_43) AT=500.025n

* CHECK dout0_44 Vdout0_44ck99 = 0 time = 500
.meas tran vdout0_44ck99 FIND v(dout0_44) AT=500.025n

* CHECK dout0_45 Vdout0_45ck99 = 0 time = 500
.meas tran vdout0_45ck99 FIND v(dout0_45) AT=500.025n

* CHECK dout0_46 Vdout0_46ck99 = 0.9 time = 500
.meas tran vdout0_46ck99 FIND v(dout0_46) AT=500.025n

* CHECK dout0_47 Vdout0_47ck99 = 0 time = 500
.meas tran vdout0_47ck99 FIND v(dout0_47) AT=500.025n

* CHECK dout0_48 Vdout0_48ck99 = 0 time = 500
.meas tran vdout0_48ck99 FIND v(dout0_48) AT=500.025n

* CHECK dout0_49 Vdout0_49ck99 = 0 time = 500
.meas tran vdout0_49ck99 FIND v(dout0_49) AT=500.025n

* CHECK dout0_50 Vdout0_50ck99 = 0.9 time = 500
.meas tran vdout0_50ck99 FIND v(dout0_50) AT=500.025n

* CHECK dout0_51 Vdout0_51ck99 = 0.9 time = 500
.meas tran vdout0_51ck99 FIND v(dout0_51) AT=500.025n

* CHECK dout0_52 Vdout0_52ck99 = 0 time = 500
.meas tran vdout0_52ck99 FIND v(dout0_52) AT=500.025n

* CHECK dout0_53 Vdout0_53ck99 = 0 time = 500
.meas tran vdout0_53ck99 FIND v(dout0_53) AT=500.025n

* CHECK dout0_54 Vdout0_54ck99 = 0 time = 500
.meas tran vdout0_54ck99 FIND v(dout0_54) AT=500.025n

* CHECK dout0_55 Vdout0_55ck99 = 0.9 time = 500
.meas tran vdout0_55ck99 FIND v(dout0_55) AT=500.025n

* CHECK dout0_56 Vdout0_56ck99 = 0 time = 500
.meas tran vdout0_56ck99 FIND v(dout0_56) AT=500.025n

* CHECK dout0_57 Vdout0_57ck99 = 0.9 time = 500
.meas tran vdout0_57ck99 FIND v(dout0_57) AT=500.025n

* CHECK dout0_58 Vdout0_58ck99 = 0 time = 500
.meas tran vdout0_58ck99 FIND v(dout0_58) AT=500.025n

* CHECK dout0_59 Vdout0_59ck99 = 0 time = 500
.meas tran vdout0_59ck99 FIND v(dout0_59) AT=500.025n

* CHECK dout0_60 Vdout0_60ck99 = 0 time = 500
.meas tran vdout0_60ck99 FIND v(dout0_60) AT=500.025n

* CHECK dout0_61 Vdout0_61ck99 = 0 time = 500
.meas tran vdout0_61ck99 FIND v(dout0_61) AT=500.025n

* CHECK dout0_62 Vdout0_62ck99 = 0 time = 500
.meas tran vdout0_62ck99 FIND v(dout0_62) AT=500.025n

* CHECK dout0_63 Vdout0_63ck99 = 0 time = 500
.meas tran vdout0_63ck99 FIND v(dout0_63) AT=500.025n

* CHECK dout0_64 Vdout0_64ck99 = 0 time = 500
.meas tran vdout0_64ck99 FIND v(dout0_64) AT=500.025n

* CHECK dout0_65 Vdout0_65ck99 = 0.9 time = 500
.meas tran vdout0_65ck99 FIND v(dout0_65) AT=500.025n

* CHECK dout0_66 Vdout0_66ck99 = 0.9 time = 500
.meas tran vdout0_66ck99 FIND v(dout0_66) AT=500.025n

* CHECK dout0_67 Vdout0_67ck99 = 0 time = 500
.meas tran vdout0_67ck99 FIND v(dout0_67) AT=500.025n

* CHECK dout0_68 Vdout0_68ck99 = 0.9 time = 500
.meas tran vdout0_68ck99 FIND v(dout0_68) AT=500.025n

* CHECK dout0_69 Vdout0_69ck99 = 0.9 time = 500
.meas tran vdout0_69ck99 FIND v(dout0_69) AT=500.025n

* CHECK dout0_70 Vdout0_70ck99 = 0.9 time = 500
.meas tran vdout0_70ck99 FIND v(dout0_70) AT=500.025n

* CHECK dout0_71 Vdout0_71ck99 = 0 time = 500
.meas tran vdout0_71ck99 FIND v(dout0_71) AT=500.025n

* CHECK dout0_72 Vdout0_72ck99 = 0 time = 500
.meas tran vdout0_72ck99 FIND v(dout0_72) AT=500.025n

* CHECK dout0_73 Vdout0_73ck99 = 0 time = 500
.meas tran vdout0_73ck99 FIND v(dout0_73) AT=500.025n

* CHECK dout0_74 Vdout0_74ck99 = 0.9 time = 500
.meas tran vdout0_74ck99 FIND v(dout0_74) AT=500.025n

* CHECK dout0_75 Vdout0_75ck99 = 0 time = 500
.meas tran vdout0_75ck99 FIND v(dout0_75) AT=500.025n

* CHECK dout0_76 Vdout0_76ck99 = 0.9 time = 500
.meas tran vdout0_76ck99 FIND v(dout0_76) AT=500.025n

* CHECK dout0_77 Vdout0_77ck99 = 0 time = 500
.meas tran vdout0_77ck99 FIND v(dout0_77) AT=500.025n

* CHECK dout0_78 Vdout0_78ck99 = 0.9 time = 500
.meas tran vdout0_78ck99 FIND v(dout0_78) AT=500.025n

* CHECK dout0_79 Vdout0_79ck99 = 0.9 time = 500
.meas tran vdout0_79ck99 FIND v(dout0_79) AT=500.025n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0.9 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0.9 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0.9 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 0.9 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 0.9 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0.9 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 0.9 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0.9 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0.9 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 0.9 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 0.9 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0.9 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0.9 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 0.9 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 0 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0.9 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0.9 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_32 Vdout0_32ck102 = 0 time = 515
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=515.025n

* CHECK dout0_33 Vdout0_33ck102 = 0 time = 515
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=515.025n

* CHECK dout0_34 Vdout0_34ck102 = 0.9 time = 515
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=515.025n

* CHECK dout0_35 Vdout0_35ck102 = 0 time = 515
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=515.025n

* CHECK dout0_36 Vdout0_36ck102 = 0 time = 515
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=515.025n

* CHECK dout0_37 Vdout0_37ck102 = 0 time = 515
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=515.025n

* CHECK dout0_38 Vdout0_38ck102 = 0 time = 515
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=515.025n

* CHECK dout0_39 Vdout0_39ck102 = 0.9 time = 515
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=515.025n

* CHECK dout0_40 Vdout0_40ck102 = 0 time = 515
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=515.025n

* CHECK dout0_41 Vdout0_41ck102 = 0 time = 515
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=515.025n

* CHECK dout0_42 Vdout0_42ck102 = 0.9 time = 515
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=515.025n

* CHECK dout0_43 Vdout0_43ck102 = 0.9 time = 515
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=515.025n

* CHECK dout0_44 Vdout0_44ck102 = 0.9 time = 515
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=515.025n

* CHECK dout0_45 Vdout0_45ck102 = 0.9 time = 515
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=515.025n

* CHECK dout0_46 Vdout0_46ck102 = 0.9 time = 515
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=515.025n

* CHECK dout0_47 Vdout0_47ck102 = 0.9 time = 515
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=515.025n

* CHECK dout0_48 Vdout0_48ck102 = 0 time = 515
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=515.025n

* CHECK dout0_49 Vdout0_49ck102 = 0.9 time = 515
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=515.025n

* CHECK dout0_50 Vdout0_50ck102 = 0 time = 515
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=515.025n

* CHECK dout0_51 Vdout0_51ck102 = 0.9 time = 515
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=515.025n

* CHECK dout0_52 Vdout0_52ck102 = 0.9 time = 515
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=515.025n

* CHECK dout0_53 Vdout0_53ck102 = 0 time = 515
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=515.025n

* CHECK dout0_54 Vdout0_54ck102 = 0 time = 515
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=515.025n

* CHECK dout0_55 Vdout0_55ck102 = 0 time = 515
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=515.025n

* CHECK dout0_56 Vdout0_56ck102 = 0.9 time = 515
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=515.025n

* CHECK dout0_57 Vdout0_57ck102 = 0 time = 515
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=515.025n

* CHECK dout0_58 Vdout0_58ck102 = 0 time = 515
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=515.025n

* CHECK dout0_59 Vdout0_59ck102 = 0 time = 515
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=515.025n

* CHECK dout0_60 Vdout0_60ck102 = 0 time = 515
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=515.025n

* CHECK dout0_61 Vdout0_61ck102 = 0 time = 515
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=515.025n

* CHECK dout0_62 Vdout0_62ck102 = 0.9 time = 515
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=515.025n

* CHECK dout0_63 Vdout0_63ck102 = 0 time = 515
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=515.025n

* CHECK dout0_64 Vdout0_64ck102 = 0.9 time = 515
.meas tran vdout0_64ck102 FIND v(dout0_64) AT=515.025n

* CHECK dout0_65 Vdout0_65ck102 = 0.9 time = 515
.meas tran vdout0_65ck102 FIND v(dout0_65) AT=515.025n

* CHECK dout0_66 Vdout0_66ck102 = 0.9 time = 515
.meas tran vdout0_66ck102 FIND v(dout0_66) AT=515.025n

* CHECK dout0_67 Vdout0_67ck102 = 0 time = 515
.meas tran vdout0_67ck102 FIND v(dout0_67) AT=515.025n

* CHECK dout0_68 Vdout0_68ck102 = 0.9 time = 515
.meas tran vdout0_68ck102 FIND v(dout0_68) AT=515.025n

* CHECK dout0_69 Vdout0_69ck102 = 0.9 time = 515
.meas tran vdout0_69ck102 FIND v(dout0_69) AT=515.025n

* CHECK dout0_70 Vdout0_70ck102 = 0 time = 515
.meas tran vdout0_70ck102 FIND v(dout0_70) AT=515.025n

* CHECK dout0_71 Vdout0_71ck102 = 0.9 time = 515
.meas tran vdout0_71ck102 FIND v(dout0_71) AT=515.025n

* CHECK dout0_72 Vdout0_72ck102 = 0 time = 515
.meas tran vdout0_72ck102 FIND v(dout0_72) AT=515.025n

* CHECK dout0_73 Vdout0_73ck102 = 0.9 time = 515
.meas tran vdout0_73ck102 FIND v(dout0_73) AT=515.025n

* CHECK dout0_74 Vdout0_74ck102 = 0 time = 515
.meas tran vdout0_74ck102 FIND v(dout0_74) AT=515.025n

* CHECK dout0_75 Vdout0_75ck102 = 0 time = 515
.meas tran vdout0_75ck102 FIND v(dout0_75) AT=515.025n

* CHECK dout0_76 Vdout0_76ck102 = 0 time = 515
.meas tran vdout0_76ck102 FIND v(dout0_76) AT=515.025n

* CHECK dout0_77 Vdout0_77ck102 = 0 time = 515
.meas tran vdout0_77ck102 FIND v(dout0_77) AT=515.025n

* CHECK dout0_78 Vdout0_78ck102 = 0 time = 515
.meas tran vdout0_78ck102 FIND v(dout0_78) AT=515.025n

* CHECK dout0_79 Vdout0_79ck102 = 0 time = 515
.meas tran vdout0_79ck102 FIND v(dout0_79) AT=515.025n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 530
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=530.025n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 530
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=530.025n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 530
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=530.025n

* CHECK dout0_3 Vdout0_3ck105 = 0 time = 530
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=530.025n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 530
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=530.025n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 530
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=530.025n

* CHECK dout0_6 Vdout0_6ck105 = 0.9 time = 530
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=530.025n

* CHECK dout0_7 Vdout0_7ck105 = 0.9 time = 530
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=530.025n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 530
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=530.025n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 530
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=530.025n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 530
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=530.025n

* CHECK dout0_11 Vdout0_11ck105 = 0.9 time = 530
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=530.025n

* CHECK dout0_12 Vdout0_12ck105 = 0.9 time = 530
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=530.025n

* CHECK dout0_13 Vdout0_13ck105 = 0.9 time = 530
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=530.025n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 530
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=530.025n

* CHECK dout0_15 Vdout0_15ck105 = 0.9 time = 530
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=530.025n

* CHECK dout0_16 Vdout0_16ck105 = 0.9 time = 530
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=530.025n

* CHECK dout0_17 Vdout0_17ck105 = 0.9 time = 530
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=530.025n

* CHECK dout0_18 Vdout0_18ck105 = 0.9 time = 530
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=530.025n

* CHECK dout0_19 Vdout0_19ck105 = 0.9 time = 530
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=530.025n

* CHECK dout0_20 Vdout0_20ck105 = 0 time = 530
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=530.025n

* CHECK dout0_21 Vdout0_21ck105 = 0 time = 530
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=530.025n

* CHECK dout0_22 Vdout0_22ck105 = 0.9 time = 530
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=530.025n

* CHECK dout0_23 Vdout0_23ck105 = 0 time = 530
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=530.025n

* CHECK dout0_24 Vdout0_24ck105 = 0.9 time = 530
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=530.025n

* CHECK dout0_25 Vdout0_25ck105 = 0.9 time = 530
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=530.025n

* CHECK dout0_26 Vdout0_26ck105 = 0.9 time = 530
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=530.025n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 530
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=530.025n

* CHECK dout0_28 Vdout0_28ck105 = 0 time = 530
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=530.025n

* CHECK dout0_29 Vdout0_29ck105 = 0 time = 530
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=530.025n

* CHECK dout0_30 Vdout0_30ck105 = 0.9 time = 530
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=530.025n

* CHECK dout0_31 Vdout0_31ck105 = 0.9 time = 530
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=530.025n

* CHECK dout0_32 Vdout0_32ck105 = 0 time = 530
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=530.025n

* CHECK dout0_33 Vdout0_33ck105 = 0 time = 530
.meas tran vdout0_33ck105 FIND v(dout0_33) AT=530.025n

* CHECK dout0_34 Vdout0_34ck105 = 0.9 time = 530
.meas tran vdout0_34ck105 FIND v(dout0_34) AT=530.025n

* CHECK dout0_35 Vdout0_35ck105 = 0 time = 530
.meas tran vdout0_35ck105 FIND v(dout0_35) AT=530.025n

* CHECK dout0_36 Vdout0_36ck105 = 0 time = 530
.meas tran vdout0_36ck105 FIND v(dout0_36) AT=530.025n

* CHECK dout0_37 Vdout0_37ck105 = 0 time = 530
.meas tran vdout0_37ck105 FIND v(dout0_37) AT=530.025n

* CHECK dout0_38 Vdout0_38ck105 = 0 time = 530
.meas tran vdout0_38ck105 FIND v(dout0_38) AT=530.025n

* CHECK dout0_39 Vdout0_39ck105 = 0.9 time = 530
.meas tran vdout0_39ck105 FIND v(dout0_39) AT=530.025n

* CHECK dout0_40 Vdout0_40ck105 = 0 time = 530
.meas tran vdout0_40ck105 FIND v(dout0_40) AT=530.025n

* CHECK dout0_41 Vdout0_41ck105 = 0 time = 530
.meas tran vdout0_41ck105 FIND v(dout0_41) AT=530.025n

* CHECK dout0_42 Vdout0_42ck105 = 0.9 time = 530
.meas tran vdout0_42ck105 FIND v(dout0_42) AT=530.025n

* CHECK dout0_43 Vdout0_43ck105 = 0.9 time = 530
.meas tran vdout0_43ck105 FIND v(dout0_43) AT=530.025n

* CHECK dout0_44 Vdout0_44ck105 = 0.9 time = 530
.meas tran vdout0_44ck105 FIND v(dout0_44) AT=530.025n

* CHECK dout0_45 Vdout0_45ck105 = 0.9 time = 530
.meas tran vdout0_45ck105 FIND v(dout0_45) AT=530.025n

* CHECK dout0_46 Vdout0_46ck105 = 0.9 time = 530
.meas tran vdout0_46ck105 FIND v(dout0_46) AT=530.025n

* CHECK dout0_47 Vdout0_47ck105 = 0.9 time = 530
.meas tran vdout0_47ck105 FIND v(dout0_47) AT=530.025n

* CHECK dout0_48 Vdout0_48ck105 = 0 time = 530
.meas tran vdout0_48ck105 FIND v(dout0_48) AT=530.025n

* CHECK dout0_49 Vdout0_49ck105 = 0.9 time = 530
.meas tran vdout0_49ck105 FIND v(dout0_49) AT=530.025n

* CHECK dout0_50 Vdout0_50ck105 = 0 time = 530
.meas tran vdout0_50ck105 FIND v(dout0_50) AT=530.025n

* CHECK dout0_51 Vdout0_51ck105 = 0.9 time = 530
.meas tran vdout0_51ck105 FIND v(dout0_51) AT=530.025n

* CHECK dout0_52 Vdout0_52ck105 = 0.9 time = 530
.meas tran vdout0_52ck105 FIND v(dout0_52) AT=530.025n

* CHECK dout0_53 Vdout0_53ck105 = 0 time = 530
.meas tran vdout0_53ck105 FIND v(dout0_53) AT=530.025n

* CHECK dout0_54 Vdout0_54ck105 = 0 time = 530
.meas tran vdout0_54ck105 FIND v(dout0_54) AT=530.025n

* CHECK dout0_55 Vdout0_55ck105 = 0 time = 530
.meas tran vdout0_55ck105 FIND v(dout0_55) AT=530.025n

* CHECK dout0_56 Vdout0_56ck105 = 0.9 time = 530
.meas tran vdout0_56ck105 FIND v(dout0_56) AT=530.025n

* CHECK dout0_57 Vdout0_57ck105 = 0 time = 530
.meas tran vdout0_57ck105 FIND v(dout0_57) AT=530.025n

* CHECK dout0_58 Vdout0_58ck105 = 0 time = 530
.meas tran vdout0_58ck105 FIND v(dout0_58) AT=530.025n

* CHECK dout0_59 Vdout0_59ck105 = 0 time = 530
.meas tran vdout0_59ck105 FIND v(dout0_59) AT=530.025n

* CHECK dout0_60 Vdout0_60ck105 = 0 time = 530
.meas tran vdout0_60ck105 FIND v(dout0_60) AT=530.025n

* CHECK dout0_61 Vdout0_61ck105 = 0 time = 530
.meas tran vdout0_61ck105 FIND v(dout0_61) AT=530.025n

* CHECK dout0_62 Vdout0_62ck105 = 0.9 time = 530
.meas tran vdout0_62ck105 FIND v(dout0_62) AT=530.025n

* CHECK dout0_63 Vdout0_63ck105 = 0 time = 530
.meas tran vdout0_63ck105 FIND v(dout0_63) AT=530.025n

* CHECK dout0_64 Vdout0_64ck105 = 0.9 time = 530
.meas tran vdout0_64ck105 FIND v(dout0_64) AT=530.025n

* CHECK dout0_65 Vdout0_65ck105 = 0.9 time = 530
.meas tran vdout0_65ck105 FIND v(dout0_65) AT=530.025n

* CHECK dout0_66 Vdout0_66ck105 = 0.9 time = 530
.meas tran vdout0_66ck105 FIND v(dout0_66) AT=530.025n

* CHECK dout0_67 Vdout0_67ck105 = 0 time = 530
.meas tran vdout0_67ck105 FIND v(dout0_67) AT=530.025n

* CHECK dout0_68 Vdout0_68ck105 = 0.9 time = 530
.meas tran vdout0_68ck105 FIND v(dout0_68) AT=530.025n

* CHECK dout0_69 Vdout0_69ck105 = 0.9 time = 530
.meas tran vdout0_69ck105 FIND v(dout0_69) AT=530.025n

* CHECK dout0_70 Vdout0_70ck105 = 0 time = 530
.meas tran vdout0_70ck105 FIND v(dout0_70) AT=530.025n

* CHECK dout0_71 Vdout0_71ck105 = 0.9 time = 530
.meas tran vdout0_71ck105 FIND v(dout0_71) AT=530.025n

* CHECK dout0_72 Vdout0_72ck105 = 0 time = 530
.meas tran vdout0_72ck105 FIND v(dout0_72) AT=530.025n

* CHECK dout0_73 Vdout0_73ck105 = 0.9 time = 530
.meas tran vdout0_73ck105 FIND v(dout0_73) AT=530.025n

* CHECK dout0_74 Vdout0_74ck105 = 0 time = 530
.meas tran vdout0_74ck105 FIND v(dout0_74) AT=530.025n

* CHECK dout0_75 Vdout0_75ck105 = 0 time = 530
.meas tran vdout0_75ck105 FIND v(dout0_75) AT=530.025n

* CHECK dout0_76 Vdout0_76ck105 = 0 time = 530
.meas tran vdout0_76ck105 FIND v(dout0_76) AT=530.025n

* CHECK dout0_77 Vdout0_77ck105 = 0 time = 530
.meas tran vdout0_77ck105 FIND v(dout0_77) AT=530.025n

* CHECK dout0_78 Vdout0_78ck105 = 0 time = 530
.meas tran vdout0_78ck105 FIND v(dout0_78) AT=530.025n

* CHECK dout0_79 Vdout0_79ck105 = 0 time = 530
.meas tran vdout0_79ck105 FIND v(dout0_79) AT=530.025n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0.9 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0.9 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0.9 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 0.9 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0.9 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0.9 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 0.9 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0.9 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 0.9 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0.9 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0.9 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0.9 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 0.9 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0.9 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0.9 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0.9 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_32 Vdout0_32ck106 = 0 time = 535
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=535.025n

* CHECK dout0_33 Vdout0_33ck106 = 0 time = 535
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=535.025n

* CHECK dout0_34 Vdout0_34ck106 = 0.9 time = 535
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=535.025n

* CHECK dout0_35 Vdout0_35ck106 = 0 time = 535
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=535.025n

* CHECK dout0_36 Vdout0_36ck106 = 0 time = 535
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=535.025n

* CHECK dout0_37 Vdout0_37ck106 = 0 time = 535
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=535.025n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 535
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=535.025n

* CHECK dout0_39 Vdout0_39ck106 = 0.9 time = 535
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=535.025n

* CHECK dout0_40 Vdout0_40ck106 = 0 time = 535
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=535.025n

* CHECK dout0_41 Vdout0_41ck106 = 0 time = 535
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=535.025n

* CHECK dout0_42 Vdout0_42ck106 = 0.9 time = 535
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=535.025n

* CHECK dout0_43 Vdout0_43ck106 = 0.9 time = 535
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=535.025n

* CHECK dout0_44 Vdout0_44ck106 = 0.9 time = 535
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=535.025n

* CHECK dout0_45 Vdout0_45ck106 = 0.9 time = 535
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=535.025n

* CHECK dout0_46 Vdout0_46ck106 = 0.9 time = 535
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=535.025n

* CHECK dout0_47 Vdout0_47ck106 = 0.9 time = 535
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=535.025n

* CHECK dout0_48 Vdout0_48ck106 = 0 time = 535
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=535.025n

* CHECK dout0_49 Vdout0_49ck106 = 0.9 time = 535
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=535.025n

* CHECK dout0_50 Vdout0_50ck106 = 0 time = 535
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=535.025n

* CHECK dout0_51 Vdout0_51ck106 = 0.9 time = 535
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=535.025n

* CHECK dout0_52 Vdout0_52ck106 = 0.9 time = 535
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=535.025n

* CHECK dout0_53 Vdout0_53ck106 = 0 time = 535
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=535.025n

* CHECK dout0_54 Vdout0_54ck106 = 0 time = 535
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=535.025n

* CHECK dout0_55 Vdout0_55ck106 = 0 time = 535
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=535.025n

* CHECK dout0_56 Vdout0_56ck106 = 0.9 time = 535
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=535.025n

* CHECK dout0_57 Vdout0_57ck106 = 0 time = 535
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=535.025n

* CHECK dout0_58 Vdout0_58ck106 = 0 time = 535
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=535.025n

* CHECK dout0_59 Vdout0_59ck106 = 0 time = 535
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=535.025n

* CHECK dout0_60 Vdout0_60ck106 = 0 time = 535
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=535.025n

* CHECK dout0_61 Vdout0_61ck106 = 0 time = 535
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=535.025n

* CHECK dout0_62 Vdout0_62ck106 = 0.9 time = 535
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=535.025n

* CHECK dout0_63 Vdout0_63ck106 = 0 time = 535
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=535.025n

* CHECK dout0_64 Vdout0_64ck106 = 0.9 time = 535
.meas tran vdout0_64ck106 FIND v(dout0_64) AT=535.025n

* CHECK dout0_65 Vdout0_65ck106 = 0.9 time = 535
.meas tran vdout0_65ck106 FIND v(dout0_65) AT=535.025n

* CHECK dout0_66 Vdout0_66ck106 = 0.9 time = 535
.meas tran vdout0_66ck106 FIND v(dout0_66) AT=535.025n

* CHECK dout0_67 Vdout0_67ck106 = 0 time = 535
.meas tran vdout0_67ck106 FIND v(dout0_67) AT=535.025n

* CHECK dout0_68 Vdout0_68ck106 = 0.9 time = 535
.meas tran vdout0_68ck106 FIND v(dout0_68) AT=535.025n

* CHECK dout0_69 Vdout0_69ck106 = 0.9 time = 535
.meas tran vdout0_69ck106 FIND v(dout0_69) AT=535.025n

* CHECK dout0_70 Vdout0_70ck106 = 0 time = 535
.meas tran vdout0_70ck106 FIND v(dout0_70) AT=535.025n

* CHECK dout0_71 Vdout0_71ck106 = 0.9 time = 535
.meas tran vdout0_71ck106 FIND v(dout0_71) AT=535.025n

* CHECK dout0_72 Vdout0_72ck106 = 0 time = 535
.meas tran vdout0_72ck106 FIND v(dout0_72) AT=535.025n

* CHECK dout0_73 Vdout0_73ck106 = 0.9 time = 535
.meas tran vdout0_73ck106 FIND v(dout0_73) AT=535.025n

* CHECK dout0_74 Vdout0_74ck106 = 0 time = 535
.meas tran vdout0_74ck106 FIND v(dout0_74) AT=535.025n

* CHECK dout0_75 Vdout0_75ck106 = 0 time = 535
.meas tran vdout0_75ck106 FIND v(dout0_75) AT=535.025n

* CHECK dout0_76 Vdout0_76ck106 = 0 time = 535
.meas tran vdout0_76ck106 FIND v(dout0_76) AT=535.025n

* CHECK dout0_77 Vdout0_77ck106 = 0 time = 535
.meas tran vdout0_77ck106 FIND v(dout0_77) AT=535.025n

* CHECK dout0_78 Vdout0_78ck106 = 0 time = 535
.meas tran vdout0_78ck106 FIND v(dout0_78) AT=535.025n

* CHECK dout0_79 Vdout0_79ck106 = 0 time = 535
.meas tran vdout0_79ck106 FIND v(dout0_79) AT=535.025n

* CHECK dout0_0 Vdout0_0ck107 = 0 time = 540
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=540.025n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 540
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=540.025n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 540
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=540.025n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 540
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=540.025n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 540
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=540.025n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 540
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=540.025n

* CHECK dout0_6 Vdout0_6ck107 = 0.9 time = 540
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=540.025n

* CHECK dout0_7 Vdout0_7ck107 = 0.9 time = 540
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=540.025n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 540
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=540.025n

* CHECK dout0_9 Vdout0_9ck107 = 0 time = 540
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=540.025n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 540
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=540.025n

* CHECK dout0_11 Vdout0_11ck107 = 0.9 time = 540
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=540.025n

* CHECK dout0_12 Vdout0_12ck107 = 0.9 time = 540
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=540.025n

* CHECK dout0_13 Vdout0_13ck107 = 0.9 time = 540
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=540.025n

* CHECK dout0_14 Vdout0_14ck107 = 0 time = 540
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=540.025n

* CHECK dout0_15 Vdout0_15ck107 = 0.9 time = 540
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=540.025n

* CHECK dout0_16 Vdout0_16ck107 = 0.9 time = 540
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=540.025n

* CHECK dout0_17 Vdout0_17ck107 = 0.9 time = 540
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=540.025n

* CHECK dout0_18 Vdout0_18ck107 = 0.9 time = 540
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=540.025n

* CHECK dout0_19 Vdout0_19ck107 = 0.9 time = 540
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=540.025n

* CHECK dout0_20 Vdout0_20ck107 = 0 time = 540
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=540.025n

* CHECK dout0_21 Vdout0_21ck107 = 0 time = 540
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=540.025n

* CHECK dout0_22 Vdout0_22ck107 = 0.9 time = 540
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=540.025n

* CHECK dout0_23 Vdout0_23ck107 = 0 time = 540
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=540.025n

* CHECK dout0_24 Vdout0_24ck107 = 0.9 time = 540
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=540.025n

* CHECK dout0_25 Vdout0_25ck107 = 0.9 time = 540
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=540.025n

* CHECK dout0_26 Vdout0_26ck107 = 0.9 time = 540
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=540.025n

* CHECK dout0_27 Vdout0_27ck107 = 0 time = 540
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=540.025n

* CHECK dout0_28 Vdout0_28ck107 = 0 time = 540
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=540.025n

* CHECK dout0_29 Vdout0_29ck107 = 0 time = 540
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=540.025n

* CHECK dout0_30 Vdout0_30ck107 = 0.9 time = 540
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=540.025n

* CHECK dout0_31 Vdout0_31ck107 = 0.9 time = 540
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=540.025n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 540
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=540.025n

* CHECK dout0_33 Vdout0_33ck107 = 0 time = 540
.meas tran vdout0_33ck107 FIND v(dout0_33) AT=540.025n

* CHECK dout0_34 Vdout0_34ck107 = 0.9 time = 540
.meas tran vdout0_34ck107 FIND v(dout0_34) AT=540.025n

* CHECK dout0_35 Vdout0_35ck107 = 0 time = 540
.meas tran vdout0_35ck107 FIND v(dout0_35) AT=540.025n

* CHECK dout0_36 Vdout0_36ck107 = 0 time = 540
.meas tran vdout0_36ck107 FIND v(dout0_36) AT=540.025n

* CHECK dout0_37 Vdout0_37ck107 = 0 time = 540
.meas tran vdout0_37ck107 FIND v(dout0_37) AT=540.025n

* CHECK dout0_38 Vdout0_38ck107 = 0 time = 540
.meas tran vdout0_38ck107 FIND v(dout0_38) AT=540.025n

* CHECK dout0_39 Vdout0_39ck107 = 0.9 time = 540
.meas tran vdout0_39ck107 FIND v(dout0_39) AT=540.025n

* CHECK dout0_40 Vdout0_40ck107 = 0 time = 540
.meas tran vdout0_40ck107 FIND v(dout0_40) AT=540.025n

* CHECK dout0_41 Vdout0_41ck107 = 0 time = 540
.meas tran vdout0_41ck107 FIND v(dout0_41) AT=540.025n

* CHECK dout0_42 Vdout0_42ck107 = 0.9 time = 540
.meas tran vdout0_42ck107 FIND v(dout0_42) AT=540.025n

* CHECK dout0_43 Vdout0_43ck107 = 0.9 time = 540
.meas tran vdout0_43ck107 FIND v(dout0_43) AT=540.025n

* CHECK dout0_44 Vdout0_44ck107 = 0.9 time = 540
.meas tran vdout0_44ck107 FIND v(dout0_44) AT=540.025n

* CHECK dout0_45 Vdout0_45ck107 = 0.9 time = 540
.meas tran vdout0_45ck107 FIND v(dout0_45) AT=540.025n

* CHECK dout0_46 Vdout0_46ck107 = 0.9 time = 540
.meas tran vdout0_46ck107 FIND v(dout0_46) AT=540.025n

* CHECK dout0_47 Vdout0_47ck107 = 0.9 time = 540
.meas tran vdout0_47ck107 FIND v(dout0_47) AT=540.025n

* CHECK dout0_48 Vdout0_48ck107 = 0 time = 540
.meas tran vdout0_48ck107 FIND v(dout0_48) AT=540.025n

* CHECK dout0_49 Vdout0_49ck107 = 0.9 time = 540
.meas tran vdout0_49ck107 FIND v(dout0_49) AT=540.025n

* CHECK dout0_50 Vdout0_50ck107 = 0 time = 540
.meas tran vdout0_50ck107 FIND v(dout0_50) AT=540.025n

* CHECK dout0_51 Vdout0_51ck107 = 0.9 time = 540
.meas tran vdout0_51ck107 FIND v(dout0_51) AT=540.025n

* CHECK dout0_52 Vdout0_52ck107 = 0.9 time = 540
.meas tran vdout0_52ck107 FIND v(dout0_52) AT=540.025n

* CHECK dout0_53 Vdout0_53ck107 = 0 time = 540
.meas tran vdout0_53ck107 FIND v(dout0_53) AT=540.025n

* CHECK dout0_54 Vdout0_54ck107 = 0 time = 540
.meas tran vdout0_54ck107 FIND v(dout0_54) AT=540.025n

* CHECK dout0_55 Vdout0_55ck107 = 0 time = 540
.meas tran vdout0_55ck107 FIND v(dout0_55) AT=540.025n

* CHECK dout0_56 Vdout0_56ck107 = 0.9 time = 540
.meas tran vdout0_56ck107 FIND v(dout0_56) AT=540.025n

* CHECK dout0_57 Vdout0_57ck107 = 0 time = 540
.meas tran vdout0_57ck107 FIND v(dout0_57) AT=540.025n

* CHECK dout0_58 Vdout0_58ck107 = 0 time = 540
.meas tran vdout0_58ck107 FIND v(dout0_58) AT=540.025n

* CHECK dout0_59 Vdout0_59ck107 = 0 time = 540
.meas tran vdout0_59ck107 FIND v(dout0_59) AT=540.025n

* CHECK dout0_60 Vdout0_60ck107 = 0 time = 540
.meas tran vdout0_60ck107 FIND v(dout0_60) AT=540.025n

* CHECK dout0_61 Vdout0_61ck107 = 0 time = 540
.meas tran vdout0_61ck107 FIND v(dout0_61) AT=540.025n

* CHECK dout0_62 Vdout0_62ck107 = 0.9 time = 540
.meas tran vdout0_62ck107 FIND v(dout0_62) AT=540.025n

* CHECK dout0_63 Vdout0_63ck107 = 0 time = 540
.meas tran vdout0_63ck107 FIND v(dout0_63) AT=540.025n

* CHECK dout0_64 Vdout0_64ck107 = 0.9 time = 540
.meas tran vdout0_64ck107 FIND v(dout0_64) AT=540.025n

* CHECK dout0_65 Vdout0_65ck107 = 0.9 time = 540
.meas tran vdout0_65ck107 FIND v(dout0_65) AT=540.025n

* CHECK dout0_66 Vdout0_66ck107 = 0.9 time = 540
.meas tran vdout0_66ck107 FIND v(dout0_66) AT=540.025n

* CHECK dout0_67 Vdout0_67ck107 = 0 time = 540
.meas tran vdout0_67ck107 FIND v(dout0_67) AT=540.025n

* CHECK dout0_68 Vdout0_68ck107 = 0.9 time = 540
.meas tran vdout0_68ck107 FIND v(dout0_68) AT=540.025n

* CHECK dout0_69 Vdout0_69ck107 = 0.9 time = 540
.meas tran vdout0_69ck107 FIND v(dout0_69) AT=540.025n

* CHECK dout0_70 Vdout0_70ck107 = 0 time = 540
.meas tran vdout0_70ck107 FIND v(dout0_70) AT=540.025n

* CHECK dout0_71 Vdout0_71ck107 = 0.9 time = 540
.meas tran vdout0_71ck107 FIND v(dout0_71) AT=540.025n

* CHECK dout0_72 Vdout0_72ck107 = 0 time = 540
.meas tran vdout0_72ck107 FIND v(dout0_72) AT=540.025n

* CHECK dout0_73 Vdout0_73ck107 = 0.9 time = 540
.meas tran vdout0_73ck107 FIND v(dout0_73) AT=540.025n

* CHECK dout0_74 Vdout0_74ck107 = 0 time = 540
.meas tran vdout0_74ck107 FIND v(dout0_74) AT=540.025n

* CHECK dout0_75 Vdout0_75ck107 = 0 time = 540
.meas tran vdout0_75ck107 FIND v(dout0_75) AT=540.025n

* CHECK dout0_76 Vdout0_76ck107 = 0 time = 540
.meas tran vdout0_76ck107 FIND v(dout0_76) AT=540.025n

* CHECK dout0_77 Vdout0_77ck107 = 0 time = 540
.meas tran vdout0_77ck107 FIND v(dout0_77) AT=540.025n

* CHECK dout0_78 Vdout0_78ck107 = 0 time = 540
.meas tran vdout0_78ck107 FIND v(dout0_78) AT=540.025n

* CHECK dout0_79 Vdout0_79ck107 = 0 time = 540
.meas tran vdout0_79ck107 FIND v(dout0_79) AT=540.025n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 555
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=555.025n

* CHECK dout0_1 Vdout0_1ck110 = 0.9 time = 555
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=555.025n

* CHECK dout0_2 Vdout0_2ck110 = 0.9 time = 555
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=555.025n

* CHECK dout0_3 Vdout0_3ck110 = 0 time = 555
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=555.025n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 555
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=555.025n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 555
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=555.025n

* CHECK dout0_6 Vdout0_6ck110 = 0.9 time = 555
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=555.025n

* CHECK dout0_7 Vdout0_7ck110 = 0.9 time = 555
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=555.025n

* CHECK dout0_8 Vdout0_8ck110 = 0.9 time = 555
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=555.025n

* CHECK dout0_9 Vdout0_9ck110 = 0.9 time = 555
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=555.025n

* CHECK dout0_10 Vdout0_10ck110 = 0.9 time = 555
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=555.025n

* CHECK dout0_11 Vdout0_11ck110 = 0.9 time = 555
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=555.025n

* CHECK dout0_12 Vdout0_12ck110 = 0.9 time = 555
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=555.025n

* CHECK dout0_13 Vdout0_13ck110 = 0 time = 555
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=555.025n

* CHECK dout0_14 Vdout0_14ck110 = 0.9 time = 555
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=555.025n

* CHECK dout0_15 Vdout0_15ck110 = 0.9 time = 555
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=555.025n

* CHECK dout0_16 Vdout0_16ck110 = 0.9 time = 555
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=555.025n

* CHECK dout0_17 Vdout0_17ck110 = 0 time = 555
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=555.025n

* CHECK dout0_18 Vdout0_18ck110 = 0.9 time = 555
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=555.025n

* CHECK dout0_19 Vdout0_19ck110 = 0 time = 555
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=555.025n

* CHECK dout0_20 Vdout0_20ck110 = 0 time = 555
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=555.025n

* CHECK dout0_21 Vdout0_21ck110 = 0.9 time = 555
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=555.025n

* CHECK dout0_22 Vdout0_22ck110 = 0.9 time = 555
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=555.025n

* CHECK dout0_23 Vdout0_23ck110 = 0 time = 555
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=555.025n

* CHECK dout0_24 Vdout0_24ck110 = 0 time = 555
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=555.025n

* CHECK dout0_25 Vdout0_25ck110 = 0.9 time = 555
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=555.025n

* CHECK dout0_26 Vdout0_26ck110 = 0.9 time = 555
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=555.025n

* CHECK dout0_27 Vdout0_27ck110 = 0.9 time = 555
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=555.025n

* CHECK dout0_28 Vdout0_28ck110 = 0.9 time = 555
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=555.025n

* CHECK dout0_29 Vdout0_29ck110 = 0 time = 555
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=555.025n

* CHECK dout0_30 Vdout0_30ck110 = 0 time = 555
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=555.025n

* CHECK dout0_31 Vdout0_31ck110 = 0.9 time = 555
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=555.025n

* CHECK dout0_32 Vdout0_32ck110 = 0 time = 555
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=555.025n

* CHECK dout0_33 Vdout0_33ck110 = 0 time = 555
.meas tran vdout0_33ck110 FIND v(dout0_33) AT=555.025n

* CHECK dout0_34 Vdout0_34ck110 = 0 time = 555
.meas tran vdout0_34ck110 FIND v(dout0_34) AT=555.025n

* CHECK dout0_35 Vdout0_35ck110 = 0.9 time = 555
.meas tran vdout0_35ck110 FIND v(dout0_35) AT=555.025n

* CHECK dout0_36 Vdout0_36ck110 = 0 time = 555
.meas tran vdout0_36ck110 FIND v(dout0_36) AT=555.025n

* CHECK dout0_37 Vdout0_37ck110 = 0 time = 555
.meas tran vdout0_37ck110 FIND v(dout0_37) AT=555.025n

* CHECK dout0_38 Vdout0_38ck110 = 0.9 time = 555
.meas tran vdout0_38ck110 FIND v(dout0_38) AT=555.025n

* CHECK dout0_39 Vdout0_39ck110 = 0 time = 555
.meas tran vdout0_39ck110 FIND v(dout0_39) AT=555.025n

* CHECK dout0_40 Vdout0_40ck110 = 0 time = 555
.meas tran vdout0_40ck110 FIND v(dout0_40) AT=555.025n

* CHECK dout0_41 Vdout0_41ck110 = 0.9 time = 555
.meas tran vdout0_41ck110 FIND v(dout0_41) AT=555.025n

* CHECK dout0_42 Vdout0_42ck110 = 0 time = 555
.meas tran vdout0_42ck110 FIND v(dout0_42) AT=555.025n

* CHECK dout0_43 Vdout0_43ck110 = 0.9 time = 555
.meas tran vdout0_43ck110 FIND v(dout0_43) AT=555.025n

* CHECK dout0_44 Vdout0_44ck110 = 0 time = 555
.meas tran vdout0_44ck110 FIND v(dout0_44) AT=555.025n

* CHECK dout0_45 Vdout0_45ck110 = 0 time = 555
.meas tran vdout0_45ck110 FIND v(dout0_45) AT=555.025n

* CHECK dout0_46 Vdout0_46ck110 = 0.9 time = 555
.meas tran vdout0_46ck110 FIND v(dout0_46) AT=555.025n

* CHECK dout0_47 Vdout0_47ck110 = 0 time = 555
.meas tran vdout0_47ck110 FIND v(dout0_47) AT=555.025n

* CHECK dout0_48 Vdout0_48ck110 = 0 time = 555
.meas tran vdout0_48ck110 FIND v(dout0_48) AT=555.025n

* CHECK dout0_49 Vdout0_49ck110 = 0 time = 555
.meas tran vdout0_49ck110 FIND v(dout0_49) AT=555.025n

* CHECK dout0_50 Vdout0_50ck110 = 0.9 time = 555
.meas tran vdout0_50ck110 FIND v(dout0_50) AT=555.025n

* CHECK dout0_51 Vdout0_51ck110 = 0.9 time = 555
.meas tran vdout0_51ck110 FIND v(dout0_51) AT=555.025n

* CHECK dout0_52 Vdout0_52ck110 = 0 time = 555
.meas tran vdout0_52ck110 FIND v(dout0_52) AT=555.025n

* CHECK dout0_53 Vdout0_53ck110 = 0 time = 555
.meas tran vdout0_53ck110 FIND v(dout0_53) AT=555.025n

* CHECK dout0_54 Vdout0_54ck110 = 0 time = 555
.meas tran vdout0_54ck110 FIND v(dout0_54) AT=555.025n

* CHECK dout0_55 Vdout0_55ck110 = 0.9 time = 555
.meas tran vdout0_55ck110 FIND v(dout0_55) AT=555.025n

* CHECK dout0_56 Vdout0_56ck110 = 0 time = 555
.meas tran vdout0_56ck110 FIND v(dout0_56) AT=555.025n

* CHECK dout0_57 Vdout0_57ck110 = 0.9 time = 555
.meas tran vdout0_57ck110 FIND v(dout0_57) AT=555.025n

* CHECK dout0_58 Vdout0_58ck110 = 0 time = 555
.meas tran vdout0_58ck110 FIND v(dout0_58) AT=555.025n

* CHECK dout0_59 Vdout0_59ck110 = 0 time = 555
.meas tran vdout0_59ck110 FIND v(dout0_59) AT=555.025n

* CHECK dout0_60 Vdout0_60ck110 = 0 time = 555
.meas tran vdout0_60ck110 FIND v(dout0_60) AT=555.025n

* CHECK dout0_61 Vdout0_61ck110 = 0 time = 555
.meas tran vdout0_61ck110 FIND v(dout0_61) AT=555.025n

* CHECK dout0_62 Vdout0_62ck110 = 0 time = 555
.meas tran vdout0_62ck110 FIND v(dout0_62) AT=555.025n

* CHECK dout0_63 Vdout0_63ck110 = 0 time = 555
.meas tran vdout0_63ck110 FIND v(dout0_63) AT=555.025n

* CHECK dout0_64 Vdout0_64ck110 = 0 time = 555
.meas tran vdout0_64ck110 FIND v(dout0_64) AT=555.025n

* CHECK dout0_65 Vdout0_65ck110 = 0.9 time = 555
.meas tran vdout0_65ck110 FIND v(dout0_65) AT=555.025n

* CHECK dout0_66 Vdout0_66ck110 = 0.9 time = 555
.meas tran vdout0_66ck110 FIND v(dout0_66) AT=555.025n

* CHECK dout0_67 Vdout0_67ck110 = 0 time = 555
.meas tran vdout0_67ck110 FIND v(dout0_67) AT=555.025n

* CHECK dout0_68 Vdout0_68ck110 = 0.9 time = 555
.meas tran vdout0_68ck110 FIND v(dout0_68) AT=555.025n

* CHECK dout0_69 Vdout0_69ck110 = 0.9 time = 555
.meas tran vdout0_69ck110 FIND v(dout0_69) AT=555.025n

* CHECK dout0_70 Vdout0_70ck110 = 0.9 time = 555
.meas tran vdout0_70ck110 FIND v(dout0_70) AT=555.025n

* CHECK dout0_71 Vdout0_71ck110 = 0 time = 555
.meas tran vdout0_71ck110 FIND v(dout0_71) AT=555.025n

* CHECK dout0_72 Vdout0_72ck110 = 0 time = 555
.meas tran vdout0_72ck110 FIND v(dout0_72) AT=555.025n

* CHECK dout0_73 Vdout0_73ck110 = 0 time = 555
.meas tran vdout0_73ck110 FIND v(dout0_73) AT=555.025n

* CHECK dout0_74 Vdout0_74ck110 = 0.9 time = 555
.meas tran vdout0_74ck110 FIND v(dout0_74) AT=555.025n

* CHECK dout0_75 Vdout0_75ck110 = 0 time = 555
.meas tran vdout0_75ck110 FIND v(dout0_75) AT=555.025n

* CHECK dout0_76 Vdout0_76ck110 = 0.9 time = 555
.meas tran vdout0_76ck110 FIND v(dout0_76) AT=555.025n

* CHECK dout0_77 Vdout0_77ck110 = 0 time = 555
.meas tran vdout0_77ck110 FIND v(dout0_77) AT=555.025n

* CHECK dout0_78 Vdout0_78ck110 = 0.9 time = 555
.meas tran vdout0_78ck110 FIND v(dout0_78) AT=555.025n

* CHECK dout0_79 Vdout0_79ck110 = 0.9 time = 555
.meas tran vdout0_79ck110 FIND v(dout0_79) AT=555.025n

* CHECK dout0_0 Vdout0_0ck113 = 0.9 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 0.9 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0.9 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 0.9 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 0.9 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 0.9 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 0.9 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 0.9 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 0 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 0 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 0.9 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 0 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0.9 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 0 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 0.9 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 0 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 0 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 0 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 0.9 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_32 Vdout0_32ck113 = 0 time = 570
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=570.025n

* CHECK dout0_33 Vdout0_33ck113 = 0 time = 570
.meas tran vdout0_33ck113 FIND v(dout0_33) AT=570.025n

* CHECK dout0_34 Vdout0_34ck113 = 0 time = 570
.meas tran vdout0_34ck113 FIND v(dout0_34) AT=570.025n

* CHECK dout0_35 Vdout0_35ck113 = 0 time = 570
.meas tran vdout0_35ck113 FIND v(dout0_35) AT=570.025n

* CHECK dout0_36 Vdout0_36ck113 = 0.9 time = 570
.meas tran vdout0_36ck113 FIND v(dout0_36) AT=570.025n

* CHECK dout0_37 Vdout0_37ck113 = 0 time = 570
.meas tran vdout0_37ck113 FIND v(dout0_37) AT=570.025n

* CHECK dout0_38 Vdout0_38ck113 = 0.9 time = 570
.meas tran vdout0_38ck113 FIND v(dout0_38) AT=570.025n

* CHECK dout0_39 Vdout0_39ck113 = 0.9 time = 570
.meas tran vdout0_39ck113 FIND v(dout0_39) AT=570.025n

* CHECK dout0_40 Vdout0_40ck113 = 0 time = 570
.meas tran vdout0_40ck113 FIND v(dout0_40) AT=570.025n

* CHECK dout0_41 Vdout0_41ck113 = 0 time = 570
.meas tran vdout0_41ck113 FIND v(dout0_41) AT=570.025n

* CHECK dout0_42 Vdout0_42ck113 = 0 time = 570
.meas tran vdout0_42ck113 FIND v(dout0_42) AT=570.025n

* CHECK dout0_43 Vdout0_43ck113 = 0 time = 570
.meas tran vdout0_43ck113 FIND v(dout0_43) AT=570.025n

* CHECK dout0_44 Vdout0_44ck113 = 0.9 time = 570
.meas tran vdout0_44ck113 FIND v(dout0_44) AT=570.025n

* CHECK dout0_45 Vdout0_45ck113 = 0.9 time = 570
.meas tran vdout0_45ck113 FIND v(dout0_45) AT=570.025n

* CHECK dout0_46 Vdout0_46ck113 = 0 time = 570
.meas tran vdout0_46ck113 FIND v(dout0_46) AT=570.025n

* CHECK dout0_47 Vdout0_47ck113 = 0 time = 570
.meas tran vdout0_47ck113 FIND v(dout0_47) AT=570.025n

* CHECK dout0_48 Vdout0_48ck113 = 0 time = 570
.meas tran vdout0_48ck113 FIND v(dout0_48) AT=570.025n

* CHECK dout0_49 Vdout0_49ck113 = 0 time = 570
.meas tran vdout0_49ck113 FIND v(dout0_49) AT=570.025n

* CHECK dout0_50 Vdout0_50ck113 = 0.9 time = 570
.meas tran vdout0_50ck113 FIND v(dout0_50) AT=570.025n

* CHECK dout0_51 Vdout0_51ck113 = 0 time = 570
.meas tran vdout0_51ck113 FIND v(dout0_51) AT=570.025n

* CHECK dout0_52 Vdout0_52ck113 = 0.9 time = 570
.meas tran vdout0_52ck113 FIND v(dout0_52) AT=570.025n

* CHECK dout0_53 Vdout0_53ck113 = 0.9 time = 570
.meas tran vdout0_53ck113 FIND v(dout0_53) AT=570.025n

* CHECK dout0_54 Vdout0_54ck113 = 0 time = 570
.meas tran vdout0_54ck113 FIND v(dout0_54) AT=570.025n

* CHECK dout0_55 Vdout0_55ck113 = 0 time = 570
.meas tran vdout0_55ck113 FIND v(dout0_55) AT=570.025n

* CHECK dout0_56 Vdout0_56ck113 = 0 time = 570
.meas tran vdout0_56ck113 FIND v(dout0_56) AT=570.025n

* CHECK dout0_57 Vdout0_57ck113 = 0 time = 570
.meas tran vdout0_57ck113 FIND v(dout0_57) AT=570.025n

* CHECK dout0_58 Vdout0_58ck113 = 0 time = 570
.meas tran vdout0_58ck113 FIND v(dout0_58) AT=570.025n

* CHECK dout0_59 Vdout0_59ck113 = 0 time = 570
.meas tran vdout0_59ck113 FIND v(dout0_59) AT=570.025n

* CHECK dout0_60 Vdout0_60ck113 = 0.9 time = 570
.meas tran vdout0_60ck113 FIND v(dout0_60) AT=570.025n

* CHECK dout0_61 Vdout0_61ck113 = 0 time = 570
.meas tran vdout0_61ck113 FIND v(dout0_61) AT=570.025n

* CHECK dout0_62 Vdout0_62ck113 = 0.9 time = 570
.meas tran vdout0_62ck113 FIND v(dout0_62) AT=570.025n

* CHECK dout0_63 Vdout0_63ck113 = 0 time = 570
.meas tran vdout0_63ck113 FIND v(dout0_63) AT=570.025n

* CHECK dout0_64 Vdout0_64ck113 = 0.9 time = 570
.meas tran vdout0_64ck113 FIND v(dout0_64) AT=570.025n

* CHECK dout0_65 Vdout0_65ck113 = 0.9 time = 570
.meas tran vdout0_65ck113 FIND v(dout0_65) AT=570.025n

* CHECK dout0_66 Vdout0_66ck113 = 0.9 time = 570
.meas tran vdout0_66ck113 FIND v(dout0_66) AT=570.025n

* CHECK dout0_67 Vdout0_67ck113 = 0 time = 570
.meas tran vdout0_67ck113 FIND v(dout0_67) AT=570.025n

* CHECK dout0_68 Vdout0_68ck113 = 0.9 time = 570
.meas tran vdout0_68ck113 FIND v(dout0_68) AT=570.025n

* CHECK dout0_69 Vdout0_69ck113 = 0.9 time = 570
.meas tran vdout0_69ck113 FIND v(dout0_69) AT=570.025n

* CHECK dout0_70 Vdout0_70ck113 = 0.9 time = 570
.meas tran vdout0_70ck113 FIND v(dout0_70) AT=570.025n

* CHECK dout0_71 Vdout0_71ck113 = 0.9 time = 570
.meas tran vdout0_71ck113 FIND v(dout0_71) AT=570.025n

* CHECK dout0_72 Vdout0_72ck113 = 0 time = 570
.meas tran vdout0_72ck113 FIND v(dout0_72) AT=570.025n

* CHECK dout0_73 Vdout0_73ck113 = 0 time = 570
.meas tran vdout0_73ck113 FIND v(dout0_73) AT=570.025n

* CHECK dout0_74 Vdout0_74ck113 = 0 time = 570
.meas tran vdout0_74ck113 FIND v(dout0_74) AT=570.025n

* CHECK dout0_75 Vdout0_75ck113 = 0 time = 570
.meas tran vdout0_75ck113 FIND v(dout0_75) AT=570.025n

* CHECK dout0_76 Vdout0_76ck113 = 0.9 time = 570
.meas tran vdout0_76ck113 FIND v(dout0_76) AT=570.025n

* CHECK dout0_77 Vdout0_77ck113 = 0 time = 570
.meas tran vdout0_77ck113 FIND v(dout0_77) AT=570.025n

* CHECK dout0_78 Vdout0_78ck113 = 0.9 time = 570
.meas tran vdout0_78ck113 FIND v(dout0_78) AT=570.025n

* CHECK dout0_79 Vdout0_79ck113 = 0 time = 570
.meas tran vdout0_79ck113 FIND v(dout0_79) AT=570.025n

* CHECK dout0_0 Vdout0_0ck119 = 0.9 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0.9 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0.9 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 0.9 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0.9 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0.9 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0.9 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0.9 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0.9 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 0.9 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0.9 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0.9 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0.9 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0.9 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 0 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 0.9 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0.9 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_32 Vdout0_32ck119 = 0.9 time = 600
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=600.025n

* CHECK dout0_33 Vdout0_33ck119 = 0.9 time = 600
.meas tran vdout0_33ck119 FIND v(dout0_33) AT=600.025n

* CHECK dout0_34 Vdout0_34ck119 = 0.9 time = 600
.meas tran vdout0_34ck119 FIND v(dout0_34) AT=600.025n

* CHECK dout0_35 Vdout0_35ck119 = 0.9 time = 600
.meas tran vdout0_35ck119 FIND v(dout0_35) AT=600.025n

* CHECK dout0_36 Vdout0_36ck119 = 0.9 time = 600
.meas tran vdout0_36ck119 FIND v(dout0_36) AT=600.025n

* CHECK dout0_37 Vdout0_37ck119 = 0 time = 600
.meas tran vdout0_37ck119 FIND v(dout0_37) AT=600.025n

* CHECK dout0_38 Vdout0_38ck119 = 0 time = 600
.meas tran vdout0_38ck119 FIND v(dout0_38) AT=600.025n

* CHECK dout0_39 Vdout0_39ck119 = 0.9 time = 600
.meas tran vdout0_39ck119 FIND v(dout0_39) AT=600.025n

* CHECK dout0_40 Vdout0_40ck119 = 0 time = 600
.meas tran vdout0_40ck119 FIND v(dout0_40) AT=600.025n

* CHECK dout0_41 Vdout0_41ck119 = 0 time = 600
.meas tran vdout0_41ck119 FIND v(dout0_41) AT=600.025n

* CHECK dout0_42 Vdout0_42ck119 = 0 time = 600
.meas tran vdout0_42ck119 FIND v(dout0_42) AT=600.025n

* CHECK dout0_43 Vdout0_43ck119 = 0 time = 600
.meas tran vdout0_43ck119 FIND v(dout0_43) AT=600.025n

* CHECK dout0_44 Vdout0_44ck119 = 0 time = 600
.meas tran vdout0_44ck119 FIND v(dout0_44) AT=600.025n

* CHECK dout0_45 Vdout0_45ck119 = 0 time = 600
.meas tran vdout0_45ck119 FIND v(dout0_45) AT=600.025n

* CHECK dout0_46 Vdout0_46ck119 = 0 time = 600
.meas tran vdout0_46ck119 FIND v(dout0_46) AT=600.025n

* CHECK dout0_47 Vdout0_47ck119 = 0.9 time = 600
.meas tran vdout0_47ck119 FIND v(dout0_47) AT=600.025n

* CHECK dout0_48 Vdout0_48ck119 = 0.9 time = 600
.meas tran vdout0_48ck119 FIND v(dout0_48) AT=600.025n

* CHECK dout0_49 Vdout0_49ck119 = 0 time = 600
.meas tran vdout0_49ck119 FIND v(dout0_49) AT=600.025n

* CHECK dout0_50 Vdout0_50ck119 = 0 time = 600
.meas tran vdout0_50ck119 FIND v(dout0_50) AT=600.025n

* CHECK dout0_51 Vdout0_51ck119 = 0.9 time = 600
.meas tran vdout0_51ck119 FIND v(dout0_51) AT=600.025n

* CHECK dout0_52 Vdout0_52ck119 = 0 time = 600
.meas tran vdout0_52ck119 FIND v(dout0_52) AT=600.025n

* CHECK dout0_53 Vdout0_53ck119 = 0.9 time = 600
.meas tran vdout0_53ck119 FIND v(dout0_53) AT=600.025n

* CHECK dout0_54 Vdout0_54ck119 = 0.9 time = 600
.meas tran vdout0_54ck119 FIND v(dout0_54) AT=600.025n

* CHECK dout0_55 Vdout0_55ck119 = 0 time = 600
.meas tran vdout0_55ck119 FIND v(dout0_55) AT=600.025n

* CHECK dout0_56 Vdout0_56ck119 = 0 time = 600
.meas tran vdout0_56ck119 FIND v(dout0_56) AT=600.025n

* CHECK dout0_57 Vdout0_57ck119 = 0 time = 600
.meas tran vdout0_57ck119 FIND v(dout0_57) AT=600.025n

* CHECK dout0_58 Vdout0_58ck119 = 0.9 time = 600
.meas tran vdout0_58ck119 FIND v(dout0_58) AT=600.025n

* CHECK dout0_59 Vdout0_59ck119 = 0 time = 600
.meas tran vdout0_59ck119 FIND v(dout0_59) AT=600.025n

* CHECK dout0_60 Vdout0_60ck119 = 0 time = 600
.meas tran vdout0_60ck119 FIND v(dout0_60) AT=600.025n

* CHECK dout0_61 Vdout0_61ck119 = 0 time = 600
.meas tran vdout0_61ck119 FIND v(dout0_61) AT=600.025n

* CHECK dout0_62 Vdout0_62ck119 = 0 time = 600
.meas tran vdout0_62ck119 FIND v(dout0_62) AT=600.025n

* CHECK dout0_63 Vdout0_63ck119 = 0 time = 600
.meas tran vdout0_63ck119 FIND v(dout0_63) AT=600.025n

* CHECK dout0_64 Vdout0_64ck119 = 0.9 time = 600
.meas tran vdout0_64ck119 FIND v(dout0_64) AT=600.025n

* CHECK dout0_65 Vdout0_65ck119 = 0.9 time = 600
.meas tran vdout0_65ck119 FIND v(dout0_65) AT=600.025n

* CHECK dout0_66 Vdout0_66ck119 = 0.9 time = 600
.meas tran vdout0_66ck119 FIND v(dout0_66) AT=600.025n

* CHECK dout0_67 Vdout0_67ck119 = 0.9 time = 600
.meas tran vdout0_67ck119 FIND v(dout0_67) AT=600.025n

* CHECK dout0_68 Vdout0_68ck119 = 0.9 time = 600
.meas tran vdout0_68ck119 FIND v(dout0_68) AT=600.025n

* CHECK dout0_69 Vdout0_69ck119 = 0 time = 600
.meas tran vdout0_69ck119 FIND v(dout0_69) AT=600.025n

* CHECK dout0_70 Vdout0_70ck119 = 0.9 time = 600
.meas tran vdout0_70ck119 FIND v(dout0_70) AT=600.025n

* CHECK dout0_71 Vdout0_71ck119 = 0.9 time = 600
.meas tran vdout0_71ck119 FIND v(dout0_71) AT=600.025n

* CHECK dout0_72 Vdout0_72ck119 = 0 time = 600
.meas tran vdout0_72ck119 FIND v(dout0_72) AT=600.025n

* CHECK dout0_73 Vdout0_73ck119 = 0.9 time = 600
.meas tran vdout0_73ck119 FIND v(dout0_73) AT=600.025n

* CHECK dout0_74 Vdout0_74ck119 = 0.9 time = 600
.meas tran vdout0_74ck119 FIND v(dout0_74) AT=600.025n

* CHECK dout0_75 Vdout0_75ck119 = 0 time = 600
.meas tran vdout0_75ck119 FIND v(dout0_75) AT=600.025n

* CHECK dout0_76 Vdout0_76ck119 = 0.9 time = 600
.meas tran vdout0_76ck119 FIND v(dout0_76) AT=600.025n

* CHECK dout0_77 Vdout0_77ck119 = 0 time = 600
.meas tran vdout0_77ck119 FIND v(dout0_77) AT=600.025n

* CHECK dout0_78 Vdout0_78ck119 = 0.9 time = 600
.meas tran vdout0_78ck119 FIND v(dout0_78) AT=600.025n

* CHECK dout0_79 Vdout0_79ck119 = 0 time = 600
.meas tran vdout0_79ck119 FIND v(dout0_79) AT=600.025n

* CHECK dout0_0 Vdout0_0ck120 = 0.9 time = 605
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=605.025n

* CHECK dout0_1 Vdout0_1ck120 = 0.9 time = 605
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=605.025n

* CHECK dout0_2 Vdout0_2ck120 = 0 time = 605
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=605.025n

* CHECK dout0_3 Vdout0_3ck120 = 0.9 time = 605
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=605.025n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 605
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=605.025n

* CHECK dout0_5 Vdout0_5ck120 = 0 time = 605
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=605.025n

* CHECK dout0_6 Vdout0_6ck120 = 0.9 time = 605
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=605.025n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 605
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=605.025n

* CHECK dout0_8 Vdout0_8ck120 = 0.9 time = 605
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=605.025n

* CHECK dout0_9 Vdout0_9ck120 = 0.9 time = 605
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=605.025n

* CHECK dout0_10 Vdout0_10ck120 = 0.9 time = 605
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=605.025n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 605
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=605.025n

* CHECK dout0_12 Vdout0_12ck120 = 0.9 time = 605
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=605.025n

* CHECK dout0_13 Vdout0_13ck120 = 0.9 time = 605
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=605.025n

* CHECK dout0_14 Vdout0_14ck120 = 0 time = 605
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=605.025n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 605
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=605.025n

* CHECK dout0_16 Vdout0_16ck120 = 0.9 time = 605
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=605.025n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 605
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=605.025n

* CHECK dout0_18 Vdout0_18ck120 = 0.9 time = 605
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=605.025n

* CHECK dout0_19 Vdout0_19ck120 = 0.9 time = 605
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=605.025n

* CHECK dout0_20 Vdout0_20ck120 = 0.9 time = 605
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=605.025n

* CHECK dout0_21 Vdout0_21ck120 = 0.9 time = 605
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=605.025n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 605
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=605.025n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 605
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=605.025n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 605
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=605.025n

* CHECK dout0_25 Vdout0_25ck120 = 0 time = 605
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=605.025n

* CHECK dout0_26 Vdout0_26ck120 = 0 time = 605
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=605.025n

* CHECK dout0_27 Vdout0_27ck120 = 0.9 time = 605
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=605.025n

* CHECK dout0_28 Vdout0_28ck120 = 0 time = 605
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=605.025n

* CHECK dout0_29 Vdout0_29ck120 = 0.9 time = 605
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=605.025n

* CHECK dout0_30 Vdout0_30ck120 = 0 time = 605
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=605.025n

* CHECK dout0_31 Vdout0_31ck120 = 0 time = 605
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=605.025n

* CHECK dout0_32 Vdout0_32ck120 = 0.9 time = 605
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=605.025n

* CHECK dout0_33 Vdout0_33ck120 = 0.9 time = 605
.meas tran vdout0_33ck120 FIND v(dout0_33) AT=605.025n

* CHECK dout0_34 Vdout0_34ck120 = 0.9 time = 605
.meas tran vdout0_34ck120 FIND v(dout0_34) AT=605.025n

* CHECK dout0_35 Vdout0_35ck120 = 0.9 time = 605
.meas tran vdout0_35ck120 FIND v(dout0_35) AT=605.025n

* CHECK dout0_36 Vdout0_36ck120 = 0.9 time = 605
.meas tran vdout0_36ck120 FIND v(dout0_36) AT=605.025n

* CHECK dout0_37 Vdout0_37ck120 = 0 time = 605
.meas tran vdout0_37ck120 FIND v(dout0_37) AT=605.025n

* CHECK dout0_38 Vdout0_38ck120 = 0 time = 605
.meas tran vdout0_38ck120 FIND v(dout0_38) AT=605.025n

* CHECK dout0_39 Vdout0_39ck120 = 0.9 time = 605
.meas tran vdout0_39ck120 FIND v(dout0_39) AT=605.025n

* CHECK dout0_40 Vdout0_40ck120 = 0 time = 605
.meas tran vdout0_40ck120 FIND v(dout0_40) AT=605.025n

* CHECK dout0_41 Vdout0_41ck120 = 0 time = 605
.meas tran vdout0_41ck120 FIND v(dout0_41) AT=605.025n

* CHECK dout0_42 Vdout0_42ck120 = 0 time = 605
.meas tran vdout0_42ck120 FIND v(dout0_42) AT=605.025n

* CHECK dout0_43 Vdout0_43ck120 = 0 time = 605
.meas tran vdout0_43ck120 FIND v(dout0_43) AT=605.025n

* CHECK dout0_44 Vdout0_44ck120 = 0 time = 605
.meas tran vdout0_44ck120 FIND v(dout0_44) AT=605.025n

* CHECK dout0_45 Vdout0_45ck120 = 0 time = 605
.meas tran vdout0_45ck120 FIND v(dout0_45) AT=605.025n

* CHECK dout0_46 Vdout0_46ck120 = 0 time = 605
.meas tran vdout0_46ck120 FIND v(dout0_46) AT=605.025n

* CHECK dout0_47 Vdout0_47ck120 = 0.9 time = 605
.meas tran vdout0_47ck120 FIND v(dout0_47) AT=605.025n

* CHECK dout0_48 Vdout0_48ck120 = 0.9 time = 605
.meas tran vdout0_48ck120 FIND v(dout0_48) AT=605.025n

* CHECK dout0_49 Vdout0_49ck120 = 0 time = 605
.meas tran vdout0_49ck120 FIND v(dout0_49) AT=605.025n

* CHECK dout0_50 Vdout0_50ck120 = 0 time = 605
.meas tran vdout0_50ck120 FIND v(dout0_50) AT=605.025n

* CHECK dout0_51 Vdout0_51ck120 = 0.9 time = 605
.meas tran vdout0_51ck120 FIND v(dout0_51) AT=605.025n

* CHECK dout0_52 Vdout0_52ck120 = 0 time = 605
.meas tran vdout0_52ck120 FIND v(dout0_52) AT=605.025n

* CHECK dout0_53 Vdout0_53ck120 = 0.9 time = 605
.meas tran vdout0_53ck120 FIND v(dout0_53) AT=605.025n

* CHECK dout0_54 Vdout0_54ck120 = 0.9 time = 605
.meas tran vdout0_54ck120 FIND v(dout0_54) AT=605.025n

* CHECK dout0_55 Vdout0_55ck120 = 0 time = 605
.meas tran vdout0_55ck120 FIND v(dout0_55) AT=605.025n

* CHECK dout0_56 Vdout0_56ck120 = 0 time = 605
.meas tran vdout0_56ck120 FIND v(dout0_56) AT=605.025n

* CHECK dout0_57 Vdout0_57ck120 = 0 time = 605
.meas tran vdout0_57ck120 FIND v(dout0_57) AT=605.025n

* CHECK dout0_58 Vdout0_58ck120 = 0.9 time = 605
.meas tran vdout0_58ck120 FIND v(dout0_58) AT=605.025n

* CHECK dout0_59 Vdout0_59ck120 = 0 time = 605
.meas tran vdout0_59ck120 FIND v(dout0_59) AT=605.025n

* CHECK dout0_60 Vdout0_60ck120 = 0 time = 605
.meas tran vdout0_60ck120 FIND v(dout0_60) AT=605.025n

* CHECK dout0_61 Vdout0_61ck120 = 0 time = 605
.meas tran vdout0_61ck120 FIND v(dout0_61) AT=605.025n

* CHECK dout0_62 Vdout0_62ck120 = 0 time = 605
.meas tran vdout0_62ck120 FIND v(dout0_62) AT=605.025n

* CHECK dout0_63 Vdout0_63ck120 = 0 time = 605
.meas tran vdout0_63ck120 FIND v(dout0_63) AT=605.025n

* CHECK dout0_64 Vdout0_64ck120 = 0.9 time = 605
.meas tran vdout0_64ck120 FIND v(dout0_64) AT=605.025n

* CHECK dout0_65 Vdout0_65ck120 = 0.9 time = 605
.meas tran vdout0_65ck120 FIND v(dout0_65) AT=605.025n

* CHECK dout0_66 Vdout0_66ck120 = 0.9 time = 605
.meas tran vdout0_66ck120 FIND v(dout0_66) AT=605.025n

* CHECK dout0_67 Vdout0_67ck120 = 0.9 time = 605
.meas tran vdout0_67ck120 FIND v(dout0_67) AT=605.025n

* CHECK dout0_68 Vdout0_68ck120 = 0.9 time = 605
.meas tran vdout0_68ck120 FIND v(dout0_68) AT=605.025n

* CHECK dout0_69 Vdout0_69ck120 = 0 time = 605
.meas tran vdout0_69ck120 FIND v(dout0_69) AT=605.025n

* CHECK dout0_70 Vdout0_70ck120 = 0.9 time = 605
.meas tran vdout0_70ck120 FIND v(dout0_70) AT=605.025n

* CHECK dout0_71 Vdout0_71ck120 = 0.9 time = 605
.meas tran vdout0_71ck120 FIND v(dout0_71) AT=605.025n

* CHECK dout0_72 Vdout0_72ck120 = 0 time = 605
.meas tran vdout0_72ck120 FIND v(dout0_72) AT=605.025n

* CHECK dout0_73 Vdout0_73ck120 = 0.9 time = 605
.meas tran vdout0_73ck120 FIND v(dout0_73) AT=605.025n

* CHECK dout0_74 Vdout0_74ck120 = 0.9 time = 605
.meas tran vdout0_74ck120 FIND v(dout0_74) AT=605.025n

* CHECK dout0_75 Vdout0_75ck120 = 0 time = 605
.meas tran vdout0_75ck120 FIND v(dout0_75) AT=605.025n

* CHECK dout0_76 Vdout0_76ck120 = 0.9 time = 605
.meas tran vdout0_76ck120 FIND v(dout0_76) AT=605.025n

* CHECK dout0_77 Vdout0_77ck120 = 0 time = 605
.meas tran vdout0_77ck120 FIND v(dout0_77) AT=605.025n

* CHECK dout0_78 Vdout0_78ck120 = 0.9 time = 605
.meas tran vdout0_78ck120 FIND v(dout0_78) AT=605.025n

* CHECK dout0_79 Vdout0_79ck120 = 0 time = 605
.meas tran vdout0_79ck120 FIND v(dout0_79) AT=605.025n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 0.9 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 0.9 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 0.9 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 0 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 0.9 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0.9 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 0.9 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 0.9 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 0.9 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 0.9 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 0 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0.9 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 0.9 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0.9 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0.9 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0.9 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 0.9 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 0.9 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 0.9 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 0 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0.9 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 0 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_32 Vdout0_32ck123 = 0 time = 620
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=620.025n

* CHECK dout0_33 Vdout0_33ck123 = 0.9 time = 620
.meas tran vdout0_33ck123 FIND v(dout0_33) AT=620.025n

* CHECK dout0_34 Vdout0_34ck123 = 0 time = 620
.meas tran vdout0_34ck123 FIND v(dout0_34) AT=620.025n

* CHECK dout0_35 Vdout0_35ck123 = 0.9 time = 620
.meas tran vdout0_35ck123 FIND v(dout0_35) AT=620.025n

* CHECK dout0_36 Vdout0_36ck123 = 0.9 time = 620
.meas tran vdout0_36ck123 FIND v(dout0_36) AT=620.025n

* CHECK dout0_37 Vdout0_37ck123 = 0.9 time = 620
.meas tran vdout0_37ck123 FIND v(dout0_37) AT=620.025n

* CHECK dout0_38 Vdout0_38ck123 = 0.9 time = 620
.meas tran vdout0_38ck123 FIND v(dout0_38) AT=620.025n

* CHECK dout0_39 Vdout0_39ck123 = 0.9 time = 620
.meas tran vdout0_39ck123 FIND v(dout0_39) AT=620.025n

* CHECK dout0_40 Vdout0_40ck123 = 0 time = 620
.meas tran vdout0_40ck123 FIND v(dout0_40) AT=620.025n

* CHECK dout0_41 Vdout0_41ck123 = 0 time = 620
.meas tran vdout0_41ck123 FIND v(dout0_41) AT=620.025n

* CHECK dout0_42 Vdout0_42ck123 = 0 time = 620
.meas tran vdout0_42ck123 FIND v(dout0_42) AT=620.025n

* CHECK dout0_43 Vdout0_43ck123 = 0.9 time = 620
.meas tran vdout0_43ck123 FIND v(dout0_43) AT=620.025n

* CHECK dout0_44 Vdout0_44ck123 = 0.9 time = 620
.meas tran vdout0_44ck123 FIND v(dout0_44) AT=620.025n

* CHECK dout0_45 Vdout0_45ck123 = 0 time = 620
.meas tran vdout0_45ck123 FIND v(dout0_45) AT=620.025n

* CHECK dout0_46 Vdout0_46ck123 = 0.9 time = 620
.meas tran vdout0_46ck123 FIND v(dout0_46) AT=620.025n

* CHECK dout0_47 Vdout0_47ck123 = 0.9 time = 620
.meas tran vdout0_47ck123 FIND v(dout0_47) AT=620.025n

* CHECK dout0_48 Vdout0_48ck123 = 0 time = 620
.meas tran vdout0_48ck123 FIND v(dout0_48) AT=620.025n

* CHECK dout0_49 Vdout0_49ck123 = 0.9 time = 620
.meas tran vdout0_49ck123 FIND v(dout0_49) AT=620.025n

* CHECK dout0_50 Vdout0_50ck123 = 0 time = 620
.meas tran vdout0_50ck123 FIND v(dout0_50) AT=620.025n

* CHECK dout0_51 Vdout0_51ck123 = 0 time = 620
.meas tran vdout0_51ck123 FIND v(dout0_51) AT=620.025n

* CHECK dout0_52 Vdout0_52ck123 = 0 time = 620
.meas tran vdout0_52ck123 FIND v(dout0_52) AT=620.025n

* CHECK dout0_53 Vdout0_53ck123 = 0 time = 620
.meas tran vdout0_53ck123 FIND v(dout0_53) AT=620.025n

* CHECK dout0_54 Vdout0_54ck123 = 0 time = 620
.meas tran vdout0_54ck123 FIND v(dout0_54) AT=620.025n

* CHECK dout0_55 Vdout0_55ck123 = 0.9 time = 620
.meas tran vdout0_55ck123 FIND v(dout0_55) AT=620.025n

* CHECK dout0_56 Vdout0_56ck123 = 0.9 time = 620
.meas tran vdout0_56ck123 FIND v(dout0_56) AT=620.025n

* CHECK dout0_57 Vdout0_57ck123 = 0 time = 620
.meas tran vdout0_57ck123 FIND v(dout0_57) AT=620.025n

* CHECK dout0_58 Vdout0_58ck123 = 0.9 time = 620
.meas tran vdout0_58ck123 FIND v(dout0_58) AT=620.025n

* CHECK dout0_59 Vdout0_59ck123 = 0.9 time = 620
.meas tran vdout0_59ck123 FIND v(dout0_59) AT=620.025n

* CHECK dout0_60 Vdout0_60ck123 = 0.9 time = 620
.meas tran vdout0_60ck123 FIND v(dout0_60) AT=620.025n

* CHECK dout0_61 Vdout0_61ck123 = 0.9 time = 620
.meas tran vdout0_61ck123 FIND v(dout0_61) AT=620.025n

* CHECK dout0_62 Vdout0_62ck123 = 0.9 time = 620
.meas tran vdout0_62ck123 FIND v(dout0_62) AT=620.025n

* CHECK dout0_63 Vdout0_63ck123 = 0.9 time = 620
.meas tran vdout0_63ck123 FIND v(dout0_63) AT=620.025n

* CHECK dout0_64 Vdout0_64ck123 = 0 time = 620
.meas tran vdout0_64ck123 FIND v(dout0_64) AT=620.025n

* CHECK dout0_65 Vdout0_65ck123 = 0 time = 620
.meas tran vdout0_65ck123 FIND v(dout0_65) AT=620.025n

* CHECK dout0_66 Vdout0_66ck123 = 0 time = 620
.meas tran vdout0_66ck123 FIND v(dout0_66) AT=620.025n

* CHECK dout0_67 Vdout0_67ck123 = 0 time = 620
.meas tran vdout0_67ck123 FIND v(dout0_67) AT=620.025n

* CHECK dout0_68 Vdout0_68ck123 = 0.9 time = 620
.meas tran vdout0_68ck123 FIND v(dout0_68) AT=620.025n

* CHECK dout0_69 Vdout0_69ck123 = 0.9 time = 620
.meas tran vdout0_69ck123 FIND v(dout0_69) AT=620.025n

* CHECK dout0_70 Vdout0_70ck123 = 0.9 time = 620
.meas tran vdout0_70ck123 FIND v(dout0_70) AT=620.025n

* CHECK dout0_71 Vdout0_71ck123 = 0 time = 620
.meas tran vdout0_71ck123 FIND v(dout0_71) AT=620.025n

* CHECK dout0_72 Vdout0_72ck123 = 0 time = 620
.meas tran vdout0_72ck123 FIND v(dout0_72) AT=620.025n

* CHECK dout0_73 Vdout0_73ck123 = 0.9 time = 620
.meas tran vdout0_73ck123 FIND v(dout0_73) AT=620.025n

* CHECK dout0_74 Vdout0_74ck123 = 0.9 time = 620
.meas tran vdout0_74ck123 FIND v(dout0_74) AT=620.025n

* CHECK dout0_75 Vdout0_75ck123 = 0 time = 620
.meas tran vdout0_75ck123 FIND v(dout0_75) AT=620.025n

* CHECK dout0_76 Vdout0_76ck123 = 0.9 time = 620
.meas tran vdout0_76ck123 FIND v(dout0_76) AT=620.025n

* CHECK dout0_77 Vdout0_77ck123 = 0 time = 620
.meas tran vdout0_77ck123 FIND v(dout0_77) AT=620.025n

* CHECK dout0_78 Vdout0_78ck123 = 0.9 time = 620
.meas tran vdout0_78ck123 FIND v(dout0_78) AT=620.025n

* CHECK dout0_79 Vdout0_79ck123 = 0 time = 620
.meas tran vdout0_79ck123 FIND v(dout0_79) AT=620.025n

* CHECK dout0_0 Vdout0_0ck131 = 0.9 time = 660
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=660.025n

* CHECK dout0_1 Vdout0_1ck131 = 0.9 time = 660
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=660.025n

* CHECK dout0_2 Vdout0_2ck131 = 0 time = 660
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=660.025n

* CHECK dout0_3 Vdout0_3ck131 = 0 time = 660
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=660.025n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 660
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=660.025n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 660
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=660.025n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 660
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=660.025n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 660
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=660.025n

* CHECK dout0_8 Vdout0_8ck131 = 0.9 time = 660
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=660.025n

* CHECK dout0_9 Vdout0_9ck131 = 0 time = 660
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=660.025n

* CHECK dout0_10 Vdout0_10ck131 = 0 time = 660
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=660.025n

* CHECK dout0_11 Vdout0_11ck131 = 0.9 time = 660
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=660.025n

* CHECK dout0_12 Vdout0_12ck131 = 0.9 time = 660
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=660.025n

* CHECK dout0_13 Vdout0_13ck131 = 0 time = 660
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=660.025n

* CHECK dout0_14 Vdout0_14ck131 = 0 time = 660
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=660.025n

* CHECK dout0_15 Vdout0_15ck131 = 0.9 time = 660
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=660.025n

* CHECK dout0_16 Vdout0_16ck131 = 0.9 time = 660
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=660.025n

* CHECK dout0_17 Vdout0_17ck131 = 0 time = 660
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=660.025n

* CHECK dout0_18 Vdout0_18ck131 = 0 time = 660
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=660.025n

* CHECK dout0_19 Vdout0_19ck131 = 0.9 time = 660
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=660.025n

* CHECK dout0_20 Vdout0_20ck131 = 0.9 time = 660
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=660.025n

* CHECK dout0_21 Vdout0_21ck131 = 0.9 time = 660
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=660.025n

* CHECK dout0_22 Vdout0_22ck131 = 0 time = 660
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=660.025n

* CHECK dout0_23 Vdout0_23ck131 = 0.9 time = 660
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=660.025n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 660
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=660.025n

* CHECK dout0_25 Vdout0_25ck131 = 0.9 time = 660
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=660.025n

* CHECK dout0_26 Vdout0_26ck131 = 0.9 time = 660
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=660.025n

* CHECK dout0_27 Vdout0_27ck131 = 0.9 time = 660
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=660.025n

* CHECK dout0_28 Vdout0_28ck131 = 0.9 time = 660
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=660.025n

* CHECK dout0_29 Vdout0_29ck131 = 0 time = 660
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=660.025n

* CHECK dout0_30 Vdout0_30ck131 = 0.9 time = 660
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=660.025n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 660
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=660.025n

* CHECK dout0_32 Vdout0_32ck131 = 0 time = 660
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=660.025n

* CHECK dout0_33 Vdout0_33ck131 = 0.9 time = 660
.meas tran vdout0_33ck131 FIND v(dout0_33) AT=660.025n

* CHECK dout0_34 Vdout0_34ck131 = 0 time = 660
.meas tran vdout0_34ck131 FIND v(dout0_34) AT=660.025n

* CHECK dout0_35 Vdout0_35ck131 = 0.9 time = 660
.meas tran vdout0_35ck131 FIND v(dout0_35) AT=660.025n

* CHECK dout0_36 Vdout0_36ck131 = 0.9 time = 660
.meas tran vdout0_36ck131 FIND v(dout0_36) AT=660.025n

* CHECK dout0_37 Vdout0_37ck131 = 0.9 time = 660
.meas tran vdout0_37ck131 FIND v(dout0_37) AT=660.025n

* CHECK dout0_38 Vdout0_38ck131 = 0.9 time = 660
.meas tran vdout0_38ck131 FIND v(dout0_38) AT=660.025n

* CHECK dout0_39 Vdout0_39ck131 = 0.9 time = 660
.meas tran vdout0_39ck131 FIND v(dout0_39) AT=660.025n

* CHECK dout0_40 Vdout0_40ck131 = 0 time = 660
.meas tran vdout0_40ck131 FIND v(dout0_40) AT=660.025n

* CHECK dout0_41 Vdout0_41ck131 = 0 time = 660
.meas tran vdout0_41ck131 FIND v(dout0_41) AT=660.025n

* CHECK dout0_42 Vdout0_42ck131 = 0.9 time = 660
.meas tran vdout0_42ck131 FIND v(dout0_42) AT=660.025n

* CHECK dout0_43 Vdout0_43ck131 = 0 time = 660
.meas tran vdout0_43ck131 FIND v(dout0_43) AT=660.025n

* CHECK dout0_44 Vdout0_44ck131 = 0.9 time = 660
.meas tran vdout0_44ck131 FIND v(dout0_44) AT=660.025n

* CHECK dout0_45 Vdout0_45ck131 = 0 time = 660
.meas tran vdout0_45ck131 FIND v(dout0_45) AT=660.025n

* CHECK dout0_46 Vdout0_46ck131 = 0 time = 660
.meas tran vdout0_46ck131 FIND v(dout0_46) AT=660.025n

* CHECK dout0_47 Vdout0_47ck131 = 0.9 time = 660
.meas tran vdout0_47ck131 FIND v(dout0_47) AT=660.025n

* CHECK dout0_48 Vdout0_48ck131 = 0 time = 660
.meas tran vdout0_48ck131 FIND v(dout0_48) AT=660.025n

* CHECK dout0_49 Vdout0_49ck131 = 0 time = 660
.meas tran vdout0_49ck131 FIND v(dout0_49) AT=660.025n

* CHECK dout0_50 Vdout0_50ck131 = 0.9 time = 660
.meas tran vdout0_50ck131 FIND v(dout0_50) AT=660.025n

* CHECK dout0_51 Vdout0_51ck131 = 0 time = 660
.meas tran vdout0_51ck131 FIND v(dout0_51) AT=660.025n

* CHECK dout0_52 Vdout0_52ck131 = 0 time = 660
.meas tran vdout0_52ck131 FIND v(dout0_52) AT=660.025n

* CHECK dout0_53 Vdout0_53ck131 = 0.9 time = 660
.meas tran vdout0_53ck131 FIND v(dout0_53) AT=660.025n

* CHECK dout0_54 Vdout0_54ck131 = 0 time = 660
.meas tran vdout0_54ck131 FIND v(dout0_54) AT=660.025n

* CHECK dout0_55 Vdout0_55ck131 = 0 time = 660
.meas tran vdout0_55ck131 FIND v(dout0_55) AT=660.025n

* CHECK dout0_56 Vdout0_56ck131 = 0 time = 660
.meas tran vdout0_56ck131 FIND v(dout0_56) AT=660.025n

* CHECK dout0_57 Vdout0_57ck131 = 0 time = 660
.meas tran vdout0_57ck131 FIND v(dout0_57) AT=660.025n

* CHECK dout0_58 Vdout0_58ck131 = 0 time = 660
.meas tran vdout0_58ck131 FIND v(dout0_58) AT=660.025n

* CHECK dout0_59 Vdout0_59ck131 = 0.9 time = 660
.meas tran vdout0_59ck131 FIND v(dout0_59) AT=660.025n

* CHECK dout0_60 Vdout0_60ck131 = 0.9 time = 660
.meas tran vdout0_60ck131 FIND v(dout0_60) AT=660.025n

* CHECK dout0_61 Vdout0_61ck131 = 0.9 time = 660
.meas tran vdout0_61ck131 FIND v(dout0_61) AT=660.025n

* CHECK dout0_62 Vdout0_62ck131 = 0.9 time = 660
.meas tran vdout0_62ck131 FIND v(dout0_62) AT=660.025n

* CHECK dout0_63 Vdout0_63ck131 = 0.9 time = 660
.meas tran vdout0_63ck131 FIND v(dout0_63) AT=660.025n

* CHECK dout0_64 Vdout0_64ck131 = 0 time = 660
.meas tran vdout0_64ck131 FIND v(dout0_64) AT=660.025n

* CHECK dout0_65 Vdout0_65ck131 = 0 time = 660
.meas tran vdout0_65ck131 FIND v(dout0_65) AT=660.025n

* CHECK dout0_66 Vdout0_66ck131 = 0 time = 660
.meas tran vdout0_66ck131 FIND v(dout0_66) AT=660.025n

* CHECK dout0_67 Vdout0_67ck131 = 0 time = 660
.meas tran vdout0_67ck131 FIND v(dout0_67) AT=660.025n

* CHECK dout0_68 Vdout0_68ck131 = 0.9 time = 660
.meas tran vdout0_68ck131 FIND v(dout0_68) AT=660.025n

* CHECK dout0_69 Vdout0_69ck131 = 0.9 time = 660
.meas tran vdout0_69ck131 FIND v(dout0_69) AT=660.025n

* CHECK dout0_70 Vdout0_70ck131 = 0.9 time = 660
.meas tran vdout0_70ck131 FIND v(dout0_70) AT=660.025n

* CHECK dout0_71 Vdout0_71ck131 = 0 time = 660
.meas tran vdout0_71ck131 FIND v(dout0_71) AT=660.025n

* CHECK dout0_72 Vdout0_72ck131 = 0 time = 660
.meas tran vdout0_72ck131 FIND v(dout0_72) AT=660.025n

* CHECK dout0_73 Vdout0_73ck131 = 0.9 time = 660
.meas tran vdout0_73ck131 FIND v(dout0_73) AT=660.025n

* CHECK dout0_74 Vdout0_74ck131 = 0.9 time = 660
.meas tran vdout0_74ck131 FIND v(dout0_74) AT=660.025n

* CHECK dout0_75 Vdout0_75ck131 = 0 time = 660
.meas tran vdout0_75ck131 FIND v(dout0_75) AT=660.025n

* CHECK dout0_76 Vdout0_76ck131 = 0.9 time = 660
.meas tran vdout0_76ck131 FIND v(dout0_76) AT=660.025n

* CHECK dout0_77 Vdout0_77ck131 = 0 time = 660
.meas tran vdout0_77ck131 FIND v(dout0_77) AT=660.025n

* CHECK dout0_78 Vdout0_78ck131 = 0.9 time = 660
.meas tran vdout0_78ck131 FIND v(dout0_78) AT=660.025n

* CHECK dout0_79 Vdout0_79ck131 = 0 time = 660
.meas tran vdout0_79ck131 FIND v(dout0_79) AT=660.025n

* CHECK dout0_0 Vdout0_0ck135 = 0.9 time = 680
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=680.025n

* CHECK dout0_1 Vdout0_1ck135 = 0.9 time = 680
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=680.025n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 680
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=680.025n

* CHECK dout0_3 Vdout0_3ck135 = 0 time = 680
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=680.025n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 680
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=680.025n

* CHECK dout0_5 Vdout0_5ck135 = 0 time = 680
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=680.025n

* CHECK dout0_6 Vdout0_6ck135 = 0 time = 680
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=680.025n

* CHECK dout0_7 Vdout0_7ck135 = 0 time = 680
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=680.025n

* CHECK dout0_8 Vdout0_8ck135 = 0.9 time = 680
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=680.025n

* CHECK dout0_9 Vdout0_9ck135 = 0 time = 680
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=680.025n

* CHECK dout0_10 Vdout0_10ck135 = 0 time = 680
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=680.025n

* CHECK dout0_11 Vdout0_11ck135 = 0.9 time = 680
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=680.025n

* CHECK dout0_12 Vdout0_12ck135 = 0.9 time = 680
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=680.025n

* CHECK dout0_13 Vdout0_13ck135 = 0 time = 680
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=680.025n

* CHECK dout0_14 Vdout0_14ck135 = 0 time = 680
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=680.025n

* CHECK dout0_15 Vdout0_15ck135 = 0.9 time = 680
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=680.025n

* CHECK dout0_16 Vdout0_16ck135 = 0.9 time = 680
.meas tran vdout0_16ck135 FIND v(dout0_16) AT=680.025n

* CHECK dout0_17 Vdout0_17ck135 = 0 time = 680
.meas tran vdout0_17ck135 FIND v(dout0_17) AT=680.025n

* CHECK dout0_18 Vdout0_18ck135 = 0 time = 680
.meas tran vdout0_18ck135 FIND v(dout0_18) AT=680.025n

* CHECK dout0_19 Vdout0_19ck135 = 0.9 time = 680
.meas tran vdout0_19ck135 FIND v(dout0_19) AT=680.025n

* CHECK dout0_20 Vdout0_20ck135 = 0.9 time = 680
.meas tran vdout0_20ck135 FIND v(dout0_20) AT=680.025n

* CHECK dout0_21 Vdout0_21ck135 = 0.9 time = 680
.meas tran vdout0_21ck135 FIND v(dout0_21) AT=680.025n

* CHECK dout0_22 Vdout0_22ck135 = 0 time = 680
.meas tran vdout0_22ck135 FIND v(dout0_22) AT=680.025n

* CHECK dout0_23 Vdout0_23ck135 = 0.9 time = 680
.meas tran vdout0_23ck135 FIND v(dout0_23) AT=680.025n

* CHECK dout0_24 Vdout0_24ck135 = 0 time = 680
.meas tran vdout0_24ck135 FIND v(dout0_24) AT=680.025n

* CHECK dout0_25 Vdout0_25ck135 = 0.9 time = 680
.meas tran vdout0_25ck135 FIND v(dout0_25) AT=680.025n

* CHECK dout0_26 Vdout0_26ck135 = 0.9 time = 680
.meas tran vdout0_26ck135 FIND v(dout0_26) AT=680.025n

* CHECK dout0_27 Vdout0_27ck135 = 0.9 time = 680
.meas tran vdout0_27ck135 FIND v(dout0_27) AT=680.025n

* CHECK dout0_28 Vdout0_28ck135 = 0.9 time = 680
.meas tran vdout0_28ck135 FIND v(dout0_28) AT=680.025n

* CHECK dout0_29 Vdout0_29ck135 = 0 time = 680
.meas tran vdout0_29ck135 FIND v(dout0_29) AT=680.025n

* CHECK dout0_30 Vdout0_30ck135 = 0.9 time = 680
.meas tran vdout0_30ck135 FIND v(dout0_30) AT=680.025n

* CHECK dout0_31 Vdout0_31ck135 = 0 time = 680
.meas tran vdout0_31ck135 FIND v(dout0_31) AT=680.025n

* CHECK dout0_32 Vdout0_32ck135 = 0 time = 680
.meas tran vdout0_32ck135 FIND v(dout0_32) AT=680.025n

* CHECK dout0_33 Vdout0_33ck135 = 0.9 time = 680
.meas tran vdout0_33ck135 FIND v(dout0_33) AT=680.025n

* CHECK dout0_34 Vdout0_34ck135 = 0 time = 680
.meas tran vdout0_34ck135 FIND v(dout0_34) AT=680.025n

* CHECK dout0_35 Vdout0_35ck135 = 0.9 time = 680
.meas tran vdout0_35ck135 FIND v(dout0_35) AT=680.025n

* CHECK dout0_36 Vdout0_36ck135 = 0.9 time = 680
.meas tran vdout0_36ck135 FIND v(dout0_36) AT=680.025n

* CHECK dout0_37 Vdout0_37ck135 = 0.9 time = 680
.meas tran vdout0_37ck135 FIND v(dout0_37) AT=680.025n

* CHECK dout0_38 Vdout0_38ck135 = 0.9 time = 680
.meas tran vdout0_38ck135 FIND v(dout0_38) AT=680.025n

* CHECK dout0_39 Vdout0_39ck135 = 0.9 time = 680
.meas tran vdout0_39ck135 FIND v(dout0_39) AT=680.025n

* CHECK dout0_40 Vdout0_40ck135 = 0 time = 680
.meas tran vdout0_40ck135 FIND v(dout0_40) AT=680.025n

* CHECK dout0_41 Vdout0_41ck135 = 0 time = 680
.meas tran vdout0_41ck135 FIND v(dout0_41) AT=680.025n

* CHECK dout0_42 Vdout0_42ck135 = 0.9 time = 680
.meas tran vdout0_42ck135 FIND v(dout0_42) AT=680.025n

* CHECK dout0_43 Vdout0_43ck135 = 0 time = 680
.meas tran vdout0_43ck135 FIND v(dout0_43) AT=680.025n

* CHECK dout0_44 Vdout0_44ck135 = 0.9 time = 680
.meas tran vdout0_44ck135 FIND v(dout0_44) AT=680.025n

* CHECK dout0_45 Vdout0_45ck135 = 0 time = 680
.meas tran vdout0_45ck135 FIND v(dout0_45) AT=680.025n

* CHECK dout0_46 Vdout0_46ck135 = 0 time = 680
.meas tran vdout0_46ck135 FIND v(dout0_46) AT=680.025n

* CHECK dout0_47 Vdout0_47ck135 = 0.9 time = 680
.meas tran vdout0_47ck135 FIND v(dout0_47) AT=680.025n

* CHECK dout0_48 Vdout0_48ck135 = 0 time = 680
.meas tran vdout0_48ck135 FIND v(dout0_48) AT=680.025n

* CHECK dout0_49 Vdout0_49ck135 = 0 time = 680
.meas tran vdout0_49ck135 FIND v(dout0_49) AT=680.025n

* CHECK dout0_50 Vdout0_50ck135 = 0.9 time = 680
.meas tran vdout0_50ck135 FIND v(dout0_50) AT=680.025n

* CHECK dout0_51 Vdout0_51ck135 = 0 time = 680
.meas tran vdout0_51ck135 FIND v(dout0_51) AT=680.025n

* CHECK dout0_52 Vdout0_52ck135 = 0 time = 680
.meas tran vdout0_52ck135 FIND v(dout0_52) AT=680.025n

* CHECK dout0_53 Vdout0_53ck135 = 0.9 time = 680
.meas tran vdout0_53ck135 FIND v(dout0_53) AT=680.025n

* CHECK dout0_54 Vdout0_54ck135 = 0 time = 680
.meas tran vdout0_54ck135 FIND v(dout0_54) AT=680.025n

* CHECK dout0_55 Vdout0_55ck135 = 0 time = 680
.meas tran vdout0_55ck135 FIND v(dout0_55) AT=680.025n

* CHECK dout0_56 Vdout0_56ck135 = 0 time = 680
.meas tran vdout0_56ck135 FIND v(dout0_56) AT=680.025n

* CHECK dout0_57 Vdout0_57ck135 = 0 time = 680
.meas tran vdout0_57ck135 FIND v(dout0_57) AT=680.025n

* CHECK dout0_58 Vdout0_58ck135 = 0 time = 680
.meas tran vdout0_58ck135 FIND v(dout0_58) AT=680.025n

* CHECK dout0_59 Vdout0_59ck135 = 0.9 time = 680
.meas tran vdout0_59ck135 FIND v(dout0_59) AT=680.025n

* CHECK dout0_60 Vdout0_60ck135 = 0.9 time = 680
.meas tran vdout0_60ck135 FIND v(dout0_60) AT=680.025n

* CHECK dout0_61 Vdout0_61ck135 = 0.9 time = 680
.meas tran vdout0_61ck135 FIND v(dout0_61) AT=680.025n

* CHECK dout0_62 Vdout0_62ck135 = 0.9 time = 680
.meas tran vdout0_62ck135 FIND v(dout0_62) AT=680.025n

* CHECK dout0_63 Vdout0_63ck135 = 0.9 time = 680
.meas tran vdout0_63ck135 FIND v(dout0_63) AT=680.025n

* CHECK dout0_64 Vdout0_64ck135 = 0 time = 680
.meas tran vdout0_64ck135 FIND v(dout0_64) AT=680.025n

* CHECK dout0_65 Vdout0_65ck135 = 0 time = 680
.meas tran vdout0_65ck135 FIND v(dout0_65) AT=680.025n

* CHECK dout0_66 Vdout0_66ck135 = 0 time = 680
.meas tran vdout0_66ck135 FIND v(dout0_66) AT=680.025n

* CHECK dout0_67 Vdout0_67ck135 = 0 time = 680
.meas tran vdout0_67ck135 FIND v(dout0_67) AT=680.025n

* CHECK dout0_68 Vdout0_68ck135 = 0.9 time = 680
.meas tran vdout0_68ck135 FIND v(dout0_68) AT=680.025n

* CHECK dout0_69 Vdout0_69ck135 = 0.9 time = 680
.meas tran vdout0_69ck135 FIND v(dout0_69) AT=680.025n

* CHECK dout0_70 Vdout0_70ck135 = 0.9 time = 680
.meas tran vdout0_70ck135 FIND v(dout0_70) AT=680.025n

* CHECK dout0_71 Vdout0_71ck135 = 0 time = 680
.meas tran vdout0_71ck135 FIND v(dout0_71) AT=680.025n

* CHECK dout0_72 Vdout0_72ck135 = 0 time = 680
.meas tran vdout0_72ck135 FIND v(dout0_72) AT=680.025n

* CHECK dout0_73 Vdout0_73ck135 = 0.9 time = 680
.meas tran vdout0_73ck135 FIND v(dout0_73) AT=680.025n

* CHECK dout0_74 Vdout0_74ck135 = 0.9 time = 680
.meas tran vdout0_74ck135 FIND v(dout0_74) AT=680.025n

* CHECK dout0_75 Vdout0_75ck135 = 0 time = 680
.meas tran vdout0_75ck135 FIND v(dout0_75) AT=680.025n

* CHECK dout0_76 Vdout0_76ck135 = 0.9 time = 680
.meas tran vdout0_76ck135 FIND v(dout0_76) AT=680.025n

* CHECK dout0_77 Vdout0_77ck135 = 0 time = 680
.meas tran vdout0_77ck135 FIND v(dout0_77) AT=680.025n

* CHECK dout0_78 Vdout0_78ck135 = 0.9 time = 680
.meas tran vdout0_78ck135 FIND v(dout0_78) AT=680.025n

* CHECK dout0_79 Vdout0_79ck135 = 0 time = 680
.meas tran vdout0_79ck135 FIND v(dout0_79) AT=680.025n

* CHECK dout0_0 Vdout0_0ck138 = 0.9 time = 695
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=695.025n

* CHECK dout0_1 Vdout0_1ck138 = 0 time = 695
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=695.025n

* CHECK dout0_2 Vdout0_2ck138 = 0.9 time = 695
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=695.025n

* CHECK dout0_3 Vdout0_3ck138 = 0.9 time = 695
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=695.025n

* CHECK dout0_4 Vdout0_4ck138 = 0.9 time = 695
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=695.025n

* CHECK dout0_5 Vdout0_5ck138 = 0.9 time = 695
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=695.025n

* CHECK dout0_6 Vdout0_6ck138 = 0.9 time = 695
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=695.025n

* CHECK dout0_7 Vdout0_7ck138 = 0.9 time = 695
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=695.025n

* CHECK dout0_8 Vdout0_8ck138 = 0 time = 695
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=695.025n

* CHECK dout0_9 Vdout0_9ck138 = 0.9 time = 695
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=695.025n

* CHECK dout0_10 Vdout0_10ck138 = 0.9 time = 695
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=695.025n

* CHECK dout0_11 Vdout0_11ck138 = 0.9 time = 695
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=695.025n

* CHECK dout0_12 Vdout0_12ck138 = 0.9 time = 695
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=695.025n

* CHECK dout0_13 Vdout0_13ck138 = 0.9 time = 695
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=695.025n

* CHECK dout0_14 Vdout0_14ck138 = 0.9 time = 695
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=695.025n

* CHECK dout0_15 Vdout0_15ck138 = 0 time = 695
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=695.025n

* CHECK dout0_16 Vdout0_16ck138 = 0.9 time = 695
.meas tran vdout0_16ck138 FIND v(dout0_16) AT=695.025n

* CHECK dout0_17 Vdout0_17ck138 = 0.9 time = 695
.meas tran vdout0_17ck138 FIND v(dout0_17) AT=695.025n

* CHECK dout0_18 Vdout0_18ck138 = 0.9 time = 695
.meas tran vdout0_18ck138 FIND v(dout0_18) AT=695.025n

* CHECK dout0_19 Vdout0_19ck138 = 0.9 time = 695
.meas tran vdout0_19ck138 FIND v(dout0_19) AT=695.025n

* CHECK dout0_20 Vdout0_20ck138 = 0.9 time = 695
.meas tran vdout0_20ck138 FIND v(dout0_20) AT=695.025n

* CHECK dout0_21 Vdout0_21ck138 = 0 time = 695
.meas tran vdout0_21ck138 FIND v(dout0_21) AT=695.025n

* CHECK dout0_22 Vdout0_22ck138 = 0 time = 695
.meas tran vdout0_22ck138 FIND v(dout0_22) AT=695.025n

* CHECK dout0_23 Vdout0_23ck138 = 0 time = 695
.meas tran vdout0_23ck138 FIND v(dout0_23) AT=695.025n

* CHECK dout0_24 Vdout0_24ck138 = 0.9 time = 695
.meas tran vdout0_24ck138 FIND v(dout0_24) AT=695.025n

* CHECK dout0_25 Vdout0_25ck138 = 0.9 time = 695
.meas tran vdout0_25ck138 FIND v(dout0_25) AT=695.025n

* CHECK dout0_26 Vdout0_26ck138 = 0 time = 695
.meas tran vdout0_26ck138 FIND v(dout0_26) AT=695.025n

* CHECK dout0_27 Vdout0_27ck138 = 0.9 time = 695
.meas tran vdout0_27ck138 FIND v(dout0_27) AT=695.025n

* CHECK dout0_28 Vdout0_28ck138 = 0 time = 695
.meas tran vdout0_28ck138 FIND v(dout0_28) AT=695.025n

* CHECK dout0_29 Vdout0_29ck138 = 0 time = 695
.meas tran vdout0_29ck138 FIND v(dout0_29) AT=695.025n

* CHECK dout0_30 Vdout0_30ck138 = 0 time = 695
.meas tran vdout0_30ck138 FIND v(dout0_30) AT=695.025n

* CHECK dout0_31 Vdout0_31ck138 = 0 time = 695
.meas tran vdout0_31ck138 FIND v(dout0_31) AT=695.025n

* CHECK dout0_32 Vdout0_32ck138 = 0 time = 695
.meas tran vdout0_32ck138 FIND v(dout0_32) AT=695.025n

* CHECK dout0_33 Vdout0_33ck138 = 0 time = 695
.meas tran vdout0_33ck138 FIND v(dout0_33) AT=695.025n

* CHECK dout0_34 Vdout0_34ck138 = 0 time = 695
.meas tran vdout0_34ck138 FIND v(dout0_34) AT=695.025n

* CHECK dout0_35 Vdout0_35ck138 = 0 time = 695
.meas tran vdout0_35ck138 FIND v(dout0_35) AT=695.025n

* CHECK dout0_36 Vdout0_36ck138 = 0.9 time = 695
.meas tran vdout0_36ck138 FIND v(dout0_36) AT=695.025n

* CHECK dout0_37 Vdout0_37ck138 = 0.9 time = 695
.meas tran vdout0_37ck138 FIND v(dout0_37) AT=695.025n

* CHECK dout0_38 Vdout0_38ck138 = 0.9 time = 695
.meas tran vdout0_38ck138 FIND v(dout0_38) AT=695.025n

* CHECK dout0_39 Vdout0_39ck138 = 0.9 time = 695
.meas tran vdout0_39ck138 FIND v(dout0_39) AT=695.025n

* CHECK dout0_40 Vdout0_40ck138 = 0.9 time = 695
.meas tran vdout0_40ck138 FIND v(dout0_40) AT=695.025n

* CHECK dout0_41 Vdout0_41ck138 = 0 time = 695
.meas tran vdout0_41ck138 FIND v(dout0_41) AT=695.025n

* CHECK dout0_42 Vdout0_42ck138 = 0.9 time = 695
.meas tran vdout0_42ck138 FIND v(dout0_42) AT=695.025n

* CHECK dout0_43 Vdout0_43ck138 = 0.9 time = 695
.meas tran vdout0_43ck138 FIND v(dout0_43) AT=695.025n

* CHECK dout0_44 Vdout0_44ck138 = 0 time = 695
.meas tran vdout0_44ck138 FIND v(dout0_44) AT=695.025n

* CHECK dout0_45 Vdout0_45ck138 = 0 time = 695
.meas tran vdout0_45ck138 FIND v(dout0_45) AT=695.025n

* CHECK dout0_46 Vdout0_46ck138 = 0 time = 695
.meas tran vdout0_46ck138 FIND v(dout0_46) AT=695.025n

* CHECK dout0_47 Vdout0_47ck138 = 0.9 time = 695
.meas tran vdout0_47ck138 FIND v(dout0_47) AT=695.025n

* CHECK dout0_48 Vdout0_48ck138 = 0 time = 695
.meas tran vdout0_48ck138 FIND v(dout0_48) AT=695.025n

* CHECK dout0_49 Vdout0_49ck138 = 0.9 time = 695
.meas tran vdout0_49ck138 FIND v(dout0_49) AT=695.025n

* CHECK dout0_50 Vdout0_50ck138 = 0 time = 695
.meas tran vdout0_50ck138 FIND v(dout0_50) AT=695.025n

* CHECK dout0_51 Vdout0_51ck138 = 0.9 time = 695
.meas tran vdout0_51ck138 FIND v(dout0_51) AT=695.025n

* CHECK dout0_52 Vdout0_52ck138 = 0.9 time = 695
.meas tran vdout0_52ck138 FIND v(dout0_52) AT=695.025n

* CHECK dout0_53 Vdout0_53ck138 = 0 time = 695
.meas tran vdout0_53ck138 FIND v(dout0_53) AT=695.025n

* CHECK dout0_54 Vdout0_54ck138 = 0.9 time = 695
.meas tran vdout0_54ck138 FIND v(dout0_54) AT=695.025n

* CHECK dout0_55 Vdout0_55ck138 = 0 time = 695
.meas tran vdout0_55ck138 FIND v(dout0_55) AT=695.025n

* CHECK dout0_56 Vdout0_56ck138 = 0 time = 695
.meas tran vdout0_56ck138 FIND v(dout0_56) AT=695.025n

* CHECK dout0_57 Vdout0_57ck138 = 0 time = 695
.meas tran vdout0_57ck138 FIND v(dout0_57) AT=695.025n

* CHECK dout0_58 Vdout0_58ck138 = 0.9 time = 695
.meas tran vdout0_58ck138 FIND v(dout0_58) AT=695.025n

* CHECK dout0_59 Vdout0_59ck138 = 0 time = 695
.meas tran vdout0_59ck138 FIND v(dout0_59) AT=695.025n

* CHECK dout0_60 Vdout0_60ck138 = 0.9 time = 695
.meas tran vdout0_60ck138 FIND v(dout0_60) AT=695.025n

* CHECK dout0_61 Vdout0_61ck138 = 0.9 time = 695
.meas tran vdout0_61ck138 FIND v(dout0_61) AT=695.025n

* CHECK dout0_62 Vdout0_62ck138 = 0 time = 695
.meas tran vdout0_62ck138 FIND v(dout0_62) AT=695.025n

* CHECK dout0_63 Vdout0_63ck138 = 0 time = 695
.meas tran vdout0_63ck138 FIND v(dout0_63) AT=695.025n

* CHECK dout0_64 Vdout0_64ck138 = 0 time = 695
.meas tran vdout0_64ck138 FIND v(dout0_64) AT=695.025n

* CHECK dout0_65 Vdout0_65ck138 = 0.9 time = 695
.meas tran vdout0_65ck138 FIND v(dout0_65) AT=695.025n

* CHECK dout0_66 Vdout0_66ck138 = 0 time = 695
.meas tran vdout0_66ck138 FIND v(dout0_66) AT=695.025n

* CHECK dout0_67 Vdout0_67ck138 = 0.9 time = 695
.meas tran vdout0_67ck138 FIND v(dout0_67) AT=695.025n

* CHECK dout0_68 Vdout0_68ck138 = 0.9 time = 695
.meas tran vdout0_68ck138 FIND v(dout0_68) AT=695.025n

* CHECK dout0_69 Vdout0_69ck138 = 0.9 time = 695
.meas tran vdout0_69ck138 FIND v(dout0_69) AT=695.025n

* CHECK dout0_70 Vdout0_70ck138 = 0.9 time = 695
.meas tran vdout0_70ck138 FIND v(dout0_70) AT=695.025n

* CHECK dout0_71 Vdout0_71ck138 = 0.9 time = 695
.meas tran vdout0_71ck138 FIND v(dout0_71) AT=695.025n

* CHECK dout0_72 Vdout0_72ck138 = 0.9 time = 695
.meas tran vdout0_72ck138 FIND v(dout0_72) AT=695.025n

* CHECK dout0_73 Vdout0_73ck138 = 0 time = 695
.meas tran vdout0_73ck138 FIND v(dout0_73) AT=695.025n

* CHECK dout0_74 Vdout0_74ck138 = 0 time = 695
.meas tran vdout0_74ck138 FIND v(dout0_74) AT=695.025n

* CHECK dout0_75 Vdout0_75ck138 = 0.9 time = 695
.meas tran vdout0_75ck138 FIND v(dout0_75) AT=695.025n

* CHECK dout0_76 Vdout0_76ck138 = 0.9 time = 695
.meas tran vdout0_76ck138 FIND v(dout0_76) AT=695.025n

* CHECK dout0_77 Vdout0_77ck138 = 0 time = 695
.meas tran vdout0_77ck138 FIND v(dout0_77) AT=695.025n

* CHECK dout0_78 Vdout0_78ck138 = 0 time = 695
.meas tran vdout0_78ck138 FIND v(dout0_78) AT=695.025n

* CHECK dout0_79 Vdout0_79ck138 = 0.9 time = 695
.meas tran vdout0_79ck138 FIND v(dout0_79) AT=695.025n

* CHECK dout0_0 Vdout0_0ck139 = 0.9 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 0.9 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 0.9 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 0 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0.9 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 0.9 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0.9 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 0.9 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 0 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0.9 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0.9 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0.9 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0.9 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 0.9 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 0.9 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 0.9 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0.9 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0.9 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_32 Vdout0_32ck139 = 0 time = 700
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=700.025n

* CHECK dout0_33 Vdout0_33ck139 = 0.9 time = 700
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=700.025n

* CHECK dout0_34 Vdout0_34ck139 = 0 time = 700
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=700.025n

* CHECK dout0_35 Vdout0_35ck139 = 0.9 time = 700
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=700.025n

* CHECK dout0_36 Vdout0_36ck139 = 0.9 time = 700
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=700.025n

* CHECK dout0_37 Vdout0_37ck139 = 0.9 time = 700
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=700.025n

* CHECK dout0_38 Vdout0_38ck139 = 0.9 time = 700
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=700.025n

* CHECK dout0_39 Vdout0_39ck139 = 0.9 time = 700
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=700.025n

* CHECK dout0_40 Vdout0_40ck139 = 0 time = 700
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=700.025n

* CHECK dout0_41 Vdout0_41ck139 = 0 time = 700
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=700.025n

* CHECK dout0_42 Vdout0_42ck139 = 0.9 time = 700
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=700.025n

* CHECK dout0_43 Vdout0_43ck139 = 0 time = 700
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=700.025n

* CHECK dout0_44 Vdout0_44ck139 = 0.9 time = 700
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=700.025n

* CHECK dout0_45 Vdout0_45ck139 = 0 time = 700
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=700.025n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 700
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=700.025n

* CHECK dout0_47 Vdout0_47ck139 = 0.9 time = 700
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=700.025n

* CHECK dout0_48 Vdout0_48ck139 = 0 time = 700
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=700.025n

* CHECK dout0_49 Vdout0_49ck139 = 0 time = 700
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=700.025n

* CHECK dout0_50 Vdout0_50ck139 = 0.9 time = 700
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=700.025n

* CHECK dout0_51 Vdout0_51ck139 = 0 time = 700
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=700.025n

* CHECK dout0_52 Vdout0_52ck139 = 0 time = 700
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=700.025n

* CHECK dout0_53 Vdout0_53ck139 = 0.9 time = 700
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=700.025n

* CHECK dout0_54 Vdout0_54ck139 = 0 time = 700
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=700.025n

* CHECK dout0_55 Vdout0_55ck139 = 0 time = 700
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=700.025n

* CHECK dout0_56 Vdout0_56ck139 = 0 time = 700
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=700.025n

* CHECK dout0_57 Vdout0_57ck139 = 0 time = 700
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=700.025n

* CHECK dout0_58 Vdout0_58ck139 = 0 time = 700
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=700.025n

* CHECK dout0_59 Vdout0_59ck139 = 0.9 time = 700
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=700.025n

* CHECK dout0_60 Vdout0_60ck139 = 0.9 time = 700
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=700.025n

* CHECK dout0_61 Vdout0_61ck139 = 0.9 time = 700
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=700.025n

* CHECK dout0_62 Vdout0_62ck139 = 0.9 time = 700
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=700.025n

* CHECK dout0_63 Vdout0_63ck139 = 0.9 time = 700
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=700.025n

* CHECK dout0_64 Vdout0_64ck139 = 0 time = 700
.meas tran vdout0_64ck139 FIND v(dout0_64) AT=700.025n

* CHECK dout0_65 Vdout0_65ck139 = 0 time = 700
.meas tran vdout0_65ck139 FIND v(dout0_65) AT=700.025n

* CHECK dout0_66 Vdout0_66ck139 = 0 time = 700
.meas tran vdout0_66ck139 FIND v(dout0_66) AT=700.025n

* CHECK dout0_67 Vdout0_67ck139 = 0 time = 700
.meas tran vdout0_67ck139 FIND v(dout0_67) AT=700.025n

* CHECK dout0_68 Vdout0_68ck139 = 0.9 time = 700
.meas tran vdout0_68ck139 FIND v(dout0_68) AT=700.025n

* CHECK dout0_69 Vdout0_69ck139 = 0.9 time = 700
.meas tran vdout0_69ck139 FIND v(dout0_69) AT=700.025n

* CHECK dout0_70 Vdout0_70ck139 = 0.9 time = 700
.meas tran vdout0_70ck139 FIND v(dout0_70) AT=700.025n

* CHECK dout0_71 Vdout0_71ck139 = 0 time = 700
.meas tran vdout0_71ck139 FIND v(dout0_71) AT=700.025n

* CHECK dout0_72 Vdout0_72ck139 = 0 time = 700
.meas tran vdout0_72ck139 FIND v(dout0_72) AT=700.025n

* CHECK dout0_73 Vdout0_73ck139 = 0.9 time = 700
.meas tran vdout0_73ck139 FIND v(dout0_73) AT=700.025n

* CHECK dout0_74 Vdout0_74ck139 = 0.9 time = 700
.meas tran vdout0_74ck139 FIND v(dout0_74) AT=700.025n

* CHECK dout0_75 Vdout0_75ck139 = 0 time = 700
.meas tran vdout0_75ck139 FIND v(dout0_75) AT=700.025n

* CHECK dout0_76 Vdout0_76ck139 = 0.9 time = 700
.meas tran vdout0_76ck139 FIND v(dout0_76) AT=700.025n

* CHECK dout0_77 Vdout0_77ck139 = 0 time = 700
.meas tran vdout0_77ck139 FIND v(dout0_77) AT=700.025n

* CHECK dout0_78 Vdout0_78ck139 = 0.9 time = 700
.meas tran vdout0_78ck139 FIND v(dout0_78) AT=700.025n

* CHECK dout0_79 Vdout0_79ck139 = 0 time = 700
.meas tran vdout0_79ck139 FIND v(dout0_79) AT=700.025n

* CHECK dout0_0 Vdout0_0ck140 = 0.9 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 0.9 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 0 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 0 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 0.9 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 0 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 0.9 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 0.9 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 0 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 0.9 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0.9 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0.9 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0.9 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 0.9 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 0 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 0.9 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 0 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 0.9 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 0.9 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 0.9 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 0.9 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 0 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 0.9 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 0 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_32 Vdout0_32ck140 = 0 time = 705
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=705.025n

* CHECK dout0_33 Vdout0_33ck140 = 0.9 time = 705
.meas tran vdout0_33ck140 FIND v(dout0_33) AT=705.025n

* CHECK dout0_34 Vdout0_34ck140 = 0 time = 705
.meas tran vdout0_34ck140 FIND v(dout0_34) AT=705.025n

* CHECK dout0_35 Vdout0_35ck140 = 0.9 time = 705
.meas tran vdout0_35ck140 FIND v(dout0_35) AT=705.025n

* CHECK dout0_36 Vdout0_36ck140 = 0.9 time = 705
.meas tran vdout0_36ck140 FIND v(dout0_36) AT=705.025n

* CHECK dout0_37 Vdout0_37ck140 = 0.9 time = 705
.meas tran vdout0_37ck140 FIND v(dout0_37) AT=705.025n

* CHECK dout0_38 Vdout0_38ck140 = 0.9 time = 705
.meas tran vdout0_38ck140 FIND v(dout0_38) AT=705.025n

* CHECK dout0_39 Vdout0_39ck140 = 0.9 time = 705
.meas tran vdout0_39ck140 FIND v(dout0_39) AT=705.025n

* CHECK dout0_40 Vdout0_40ck140 = 0 time = 705
.meas tran vdout0_40ck140 FIND v(dout0_40) AT=705.025n

* CHECK dout0_41 Vdout0_41ck140 = 0 time = 705
.meas tran vdout0_41ck140 FIND v(dout0_41) AT=705.025n

* CHECK dout0_42 Vdout0_42ck140 = 0.9 time = 705
.meas tran vdout0_42ck140 FIND v(dout0_42) AT=705.025n

* CHECK dout0_43 Vdout0_43ck140 = 0 time = 705
.meas tran vdout0_43ck140 FIND v(dout0_43) AT=705.025n

* CHECK dout0_44 Vdout0_44ck140 = 0.9 time = 705
.meas tran vdout0_44ck140 FIND v(dout0_44) AT=705.025n

* CHECK dout0_45 Vdout0_45ck140 = 0 time = 705
.meas tran vdout0_45ck140 FIND v(dout0_45) AT=705.025n

* CHECK dout0_46 Vdout0_46ck140 = 0 time = 705
.meas tran vdout0_46ck140 FIND v(dout0_46) AT=705.025n

* CHECK dout0_47 Vdout0_47ck140 = 0.9 time = 705
.meas tran vdout0_47ck140 FIND v(dout0_47) AT=705.025n

* CHECK dout0_48 Vdout0_48ck140 = 0 time = 705
.meas tran vdout0_48ck140 FIND v(dout0_48) AT=705.025n

* CHECK dout0_49 Vdout0_49ck140 = 0 time = 705
.meas tran vdout0_49ck140 FIND v(dout0_49) AT=705.025n

* CHECK dout0_50 Vdout0_50ck140 = 0.9 time = 705
.meas tran vdout0_50ck140 FIND v(dout0_50) AT=705.025n

* CHECK dout0_51 Vdout0_51ck140 = 0 time = 705
.meas tran vdout0_51ck140 FIND v(dout0_51) AT=705.025n

* CHECK dout0_52 Vdout0_52ck140 = 0 time = 705
.meas tran vdout0_52ck140 FIND v(dout0_52) AT=705.025n

* CHECK dout0_53 Vdout0_53ck140 = 0.9 time = 705
.meas tran vdout0_53ck140 FIND v(dout0_53) AT=705.025n

* CHECK dout0_54 Vdout0_54ck140 = 0 time = 705
.meas tran vdout0_54ck140 FIND v(dout0_54) AT=705.025n

* CHECK dout0_55 Vdout0_55ck140 = 0 time = 705
.meas tran vdout0_55ck140 FIND v(dout0_55) AT=705.025n

* CHECK dout0_56 Vdout0_56ck140 = 0 time = 705
.meas tran vdout0_56ck140 FIND v(dout0_56) AT=705.025n

* CHECK dout0_57 Vdout0_57ck140 = 0 time = 705
.meas tran vdout0_57ck140 FIND v(dout0_57) AT=705.025n

* CHECK dout0_58 Vdout0_58ck140 = 0 time = 705
.meas tran vdout0_58ck140 FIND v(dout0_58) AT=705.025n

* CHECK dout0_59 Vdout0_59ck140 = 0.9 time = 705
.meas tran vdout0_59ck140 FIND v(dout0_59) AT=705.025n

* CHECK dout0_60 Vdout0_60ck140 = 0.9 time = 705
.meas tran vdout0_60ck140 FIND v(dout0_60) AT=705.025n

* CHECK dout0_61 Vdout0_61ck140 = 0.9 time = 705
.meas tran vdout0_61ck140 FIND v(dout0_61) AT=705.025n

* CHECK dout0_62 Vdout0_62ck140 = 0.9 time = 705
.meas tran vdout0_62ck140 FIND v(dout0_62) AT=705.025n

* CHECK dout0_63 Vdout0_63ck140 = 0.9 time = 705
.meas tran vdout0_63ck140 FIND v(dout0_63) AT=705.025n

* CHECK dout0_64 Vdout0_64ck140 = 0 time = 705
.meas tran vdout0_64ck140 FIND v(dout0_64) AT=705.025n

* CHECK dout0_65 Vdout0_65ck140 = 0 time = 705
.meas tran vdout0_65ck140 FIND v(dout0_65) AT=705.025n

* CHECK dout0_66 Vdout0_66ck140 = 0 time = 705
.meas tran vdout0_66ck140 FIND v(dout0_66) AT=705.025n

* CHECK dout0_67 Vdout0_67ck140 = 0 time = 705
.meas tran vdout0_67ck140 FIND v(dout0_67) AT=705.025n

* CHECK dout0_68 Vdout0_68ck140 = 0.9 time = 705
.meas tran vdout0_68ck140 FIND v(dout0_68) AT=705.025n

* CHECK dout0_69 Vdout0_69ck140 = 0.9 time = 705
.meas tran vdout0_69ck140 FIND v(dout0_69) AT=705.025n

* CHECK dout0_70 Vdout0_70ck140 = 0.9 time = 705
.meas tran vdout0_70ck140 FIND v(dout0_70) AT=705.025n

* CHECK dout0_71 Vdout0_71ck140 = 0 time = 705
.meas tran vdout0_71ck140 FIND v(dout0_71) AT=705.025n

* CHECK dout0_72 Vdout0_72ck140 = 0 time = 705
.meas tran vdout0_72ck140 FIND v(dout0_72) AT=705.025n

* CHECK dout0_73 Vdout0_73ck140 = 0.9 time = 705
.meas tran vdout0_73ck140 FIND v(dout0_73) AT=705.025n

* CHECK dout0_74 Vdout0_74ck140 = 0.9 time = 705
.meas tran vdout0_74ck140 FIND v(dout0_74) AT=705.025n

* CHECK dout0_75 Vdout0_75ck140 = 0 time = 705
.meas tran vdout0_75ck140 FIND v(dout0_75) AT=705.025n

* CHECK dout0_76 Vdout0_76ck140 = 0.9 time = 705
.meas tran vdout0_76ck140 FIND v(dout0_76) AT=705.025n

* CHECK dout0_77 Vdout0_77ck140 = 0 time = 705
.meas tran vdout0_77ck140 FIND v(dout0_77) AT=705.025n

* CHECK dout0_78 Vdout0_78ck140 = 0.9 time = 705
.meas tran vdout0_78ck140 FIND v(dout0_78) AT=705.025n

* CHECK dout0_79 Vdout0_79ck140 = 0 time = 705
.meas tran vdout0_79ck140 FIND v(dout0_79) AT=705.025n

* CHECK dout0_0 Vdout0_0ck141 = 0.9 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 0.9 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0.9 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 0.9 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 0.9 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 0 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 0.9 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 0.9 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 0 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 0.9 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 0.9 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 0.9 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 0 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 0.9 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 0 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 0.9 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0.9 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 0.9 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0.9 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 0 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0.9 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 0 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_32 Vdout0_32ck141 = 0 time = 710
.meas tran vdout0_32ck141 FIND v(dout0_32) AT=710.025n

* CHECK dout0_33 Vdout0_33ck141 = 0.9 time = 710
.meas tran vdout0_33ck141 FIND v(dout0_33) AT=710.025n

* CHECK dout0_34 Vdout0_34ck141 = 0 time = 710
.meas tran vdout0_34ck141 FIND v(dout0_34) AT=710.025n

* CHECK dout0_35 Vdout0_35ck141 = 0.9 time = 710
.meas tran vdout0_35ck141 FIND v(dout0_35) AT=710.025n

* CHECK dout0_36 Vdout0_36ck141 = 0.9 time = 710
.meas tran vdout0_36ck141 FIND v(dout0_36) AT=710.025n

* CHECK dout0_37 Vdout0_37ck141 = 0.9 time = 710
.meas tran vdout0_37ck141 FIND v(dout0_37) AT=710.025n

* CHECK dout0_38 Vdout0_38ck141 = 0.9 time = 710
.meas tran vdout0_38ck141 FIND v(dout0_38) AT=710.025n

* CHECK dout0_39 Vdout0_39ck141 = 0.9 time = 710
.meas tran vdout0_39ck141 FIND v(dout0_39) AT=710.025n

* CHECK dout0_40 Vdout0_40ck141 = 0 time = 710
.meas tran vdout0_40ck141 FIND v(dout0_40) AT=710.025n

* CHECK dout0_41 Vdout0_41ck141 = 0 time = 710
.meas tran vdout0_41ck141 FIND v(dout0_41) AT=710.025n

* CHECK dout0_42 Vdout0_42ck141 = 0.9 time = 710
.meas tran vdout0_42ck141 FIND v(dout0_42) AT=710.025n

* CHECK dout0_43 Vdout0_43ck141 = 0 time = 710
.meas tran vdout0_43ck141 FIND v(dout0_43) AT=710.025n

* CHECK dout0_44 Vdout0_44ck141 = 0.9 time = 710
.meas tran vdout0_44ck141 FIND v(dout0_44) AT=710.025n

* CHECK dout0_45 Vdout0_45ck141 = 0 time = 710
.meas tran vdout0_45ck141 FIND v(dout0_45) AT=710.025n

* CHECK dout0_46 Vdout0_46ck141 = 0 time = 710
.meas tran vdout0_46ck141 FIND v(dout0_46) AT=710.025n

* CHECK dout0_47 Vdout0_47ck141 = 0.9 time = 710
.meas tran vdout0_47ck141 FIND v(dout0_47) AT=710.025n

* CHECK dout0_48 Vdout0_48ck141 = 0 time = 710
.meas tran vdout0_48ck141 FIND v(dout0_48) AT=710.025n

* CHECK dout0_49 Vdout0_49ck141 = 0 time = 710
.meas tran vdout0_49ck141 FIND v(dout0_49) AT=710.025n

* CHECK dout0_50 Vdout0_50ck141 = 0.9 time = 710
.meas tran vdout0_50ck141 FIND v(dout0_50) AT=710.025n

* CHECK dout0_51 Vdout0_51ck141 = 0 time = 710
.meas tran vdout0_51ck141 FIND v(dout0_51) AT=710.025n

* CHECK dout0_52 Vdout0_52ck141 = 0 time = 710
.meas tran vdout0_52ck141 FIND v(dout0_52) AT=710.025n

* CHECK dout0_53 Vdout0_53ck141 = 0.9 time = 710
.meas tran vdout0_53ck141 FIND v(dout0_53) AT=710.025n

* CHECK dout0_54 Vdout0_54ck141 = 0 time = 710
.meas tran vdout0_54ck141 FIND v(dout0_54) AT=710.025n

* CHECK dout0_55 Vdout0_55ck141 = 0 time = 710
.meas tran vdout0_55ck141 FIND v(dout0_55) AT=710.025n

* CHECK dout0_56 Vdout0_56ck141 = 0 time = 710
.meas tran vdout0_56ck141 FIND v(dout0_56) AT=710.025n

* CHECK dout0_57 Vdout0_57ck141 = 0 time = 710
.meas tran vdout0_57ck141 FIND v(dout0_57) AT=710.025n

* CHECK dout0_58 Vdout0_58ck141 = 0 time = 710
.meas tran vdout0_58ck141 FIND v(dout0_58) AT=710.025n

* CHECK dout0_59 Vdout0_59ck141 = 0.9 time = 710
.meas tran vdout0_59ck141 FIND v(dout0_59) AT=710.025n

* CHECK dout0_60 Vdout0_60ck141 = 0.9 time = 710
.meas tran vdout0_60ck141 FIND v(dout0_60) AT=710.025n

* CHECK dout0_61 Vdout0_61ck141 = 0.9 time = 710
.meas tran vdout0_61ck141 FIND v(dout0_61) AT=710.025n

* CHECK dout0_62 Vdout0_62ck141 = 0.9 time = 710
.meas tran vdout0_62ck141 FIND v(dout0_62) AT=710.025n

* CHECK dout0_63 Vdout0_63ck141 = 0.9 time = 710
.meas tran vdout0_63ck141 FIND v(dout0_63) AT=710.025n

* CHECK dout0_64 Vdout0_64ck141 = 0 time = 710
.meas tran vdout0_64ck141 FIND v(dout0_64) AT=710.025n

* CHECK dout0_65 Vdout0_65ck141 = 0 time = 710
.meas tran vdout0_65ck141 FIND v(dout0_65) AT=710.025n

* CHECK dout0_66 Vdout0_66ck141 = 0 time = 710
.meas tran vdout0_66ck141 FIND v(dout0_66) AT=710.025n

* CHECK dout0_67 Vdout0_67ck141 = 0 time = 710
.meas tran vdout0_67ck141 FIND v(dout0_67) AT=710.025n

* CHECK dout0_68 Vdout0_68ck141 = 0.9 time = 710
.meas tran vdout0_68ck141 FIND v(dout0_68) AT=710.025n

* CHECK dout0_69 Vdout0_69ck141 = 0.9 time = 710
.meas tran vdout0_69ck141 FIND v(dout0_69) AT=710.025n

* CHECK dout0_70 Vdout0_70ck141 = 0.9 time = 710
.meas tran vdout0_70ck141 FIND v(dout0_70) AT=710.025n

* CHECK dout0_71 Vdout0_71ck141 = 0 time = 710
.meas tran vdout0_71ck141 FIND v(dout0_71) AT=710.025n

* CHECK dout0_72 Vdout0_72ck141 = 0 time = 710
.meas tran vdout0_72ck141 FIND v(dout0_72) AT=710.025n

* CHECK dout0_73 Vdout0_73ck141 = 0.9 time = 710
.meas tran vdout0_73ck141 FIND v(dout0_73) AT=710.025n

* CHECK dout0_74 Vdout0_74ck141 = 0.9 time = 710
.meas tran vdout0_74ck141 FIND v(dout0_74) AT=710.025n

* CHECK dout0_75 Vdout0_75ck141 = 0 time = 710
.meas tran vdout0_75ck141 FIND v(dout0_75) AT=710.025n

* CHECK dout0_76 Vdout0_76ck141 = 0.9 time = 710
.meas tran vdout0_76ck141 FIND v(dout0_76) AT=710.025n

* CHECK dout0_77 Vdout0_77ck141 = 0 time = 710
.meas tran vdout0_77ck141 FIND v(dout0_77) AT=710.025n

* CHECK dout0_78 Vdout0_78ck141 = 0.9 time = 710
.meas tran vdout0_78ck141 FIND v(dout0_78) AT=710.025n

* CHECK dout0_79 Vdout0_79ck141 = 0 time = 710
.meas tran vdout0_79ck141 FIND v(dout0_79) AT=710.025n

* CHECK dout0_0 Vdout0_0ck144 = 0 time = 725
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=725.025n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 725
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=725.025n

* CHECK dout0_2 Vdout0_2ck144 = 0 time = 725
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=725.025n

* CHECK dout0_3 Vdout0_3ck144 = 0.9 time = 725
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=725.025n

* CHECK dout0_4 Vdout0_4ck144 = 0.9 time = 725
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=725.025n

* CHECK dout0_5 Vdout0_5ck144 = 0.9 time = 725
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=725.025n

* CHECK dout0_6 Vdout0_6ck144 = 0.9 time = 725
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=725.025n

* CHECK dout0_7 Vdout0_7ck144 = 0 time = 725
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=725.025n

* CHECK dout0_8 Vdout0_8ck144 = 0 time = 725
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=725.025n

* CHECK dout0_9 Vdout0_9ck144 = 0.9 time = 725
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=725.025n

* CHECK dout0_10 Vdout0_10ck144 = 0 time = 725
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=725.025n

* CHECK dout0_11 Vdout0_11ck144 = 0 time = 725
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=725.025n

* CHECK dout0_12 Vdout0_12ck144 = 0.9 time = 725
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=725.025n

* CHECK dout0_13 Vdout0_13ck144 = 0.9 time = 725
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=725.025n

* CHECK dout0_14 Vdout0_14ck144 = 0 time = 725
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=725.025n

* CHECK dout0_15 Vdout0_15ck144 = 0 time = 725
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=725.025n

* CHECK dout0_16 Vdout0_16ck144 = 0 time = 725
.meas tran vdout0_16ck144 FIND v(dout0_16) AT=725.025n

* CHECK dout0_17 Vdout0_17ck144 = 0.9 time = 725
.meas tran vdout0_17ck144 FIND v(dout0_17) AT=725.025n

* CHECK dout0_18 Vdout0_18ck144 = 0 time = 725
.meas tran vdout0_18ck144 FIND v(dout0_18) AT=725.025n

* CHECK dout0_19 Vdout0_19ck144 = 0.9 time = 725
.meas tran vdout0_19ck144 FIND v(dout0_19) AT=725.025n

* CHECK dout0_20 Vdout0_20ck144 = 0 time = 725
.meas tran vdout0_20ck144 FIND v(dout0_20) AT=725.025n

* CHECK dout0_21 Vdout0_21ck144 = 0.9 time = 725
.meas tran vdout0_21ck144 FIND v(dout0_21) AT=725.025n

* CHECK dout0_22 Vdout0_22ck144 = 0.9 time = 725
.meas tran vdout0_22ck144 FIND v(dout0_22) AT=725.025n

* CHECK dout0_23 Vdout0_23ck144 = 0.9 time = 725
.meas tran vdout0_23ck144 FIND v(dout0_23) AT=725.025n

* CHECK dout0_24 Vdout0_24ck144 = 0 time = 725
.meas tran vdout0_24ck144 FIND v(dout0_24) AT=725.025n

* CHECK dout0_25 Vdout0_25ck144 = 0 time = 725
.meas tran vdout0_25ck144 FIND v(dout0_25) AT=725.025n

* CHECK dout0_26 Vdout0_26ck144 = 0 time = 725
.meas tran vdout0_26ck144 FIND v(dout0_26) AT=725.025n

* CHECK dout0_27 Vdout0_27ck144 = 0.9 time = 725
.meas tran vdout0_27ck144 FIND v(dout0_27) AT=725.025n

* CHECK dout0_28 Vdout0_28ck144 = 0.9 time = 725
.meas tran vdout0_28ck144 FIND v(dout0_28) AT=725.025n

* CHECK dout0_29 Vdout0_29ck144 = 0.9 time = 725
.meas tran vdout0_29ck144 FIND v(dout0_29) AT=725.025n

* CHECK dout0_30 Vdout0_30ck144 = 0 time = 725
.meas tran vdout0_30ck144 FIND v(dout0_30) AT=725.025n

* CHECK dout0_31 Vdout0_31ck144 = 0.9 time = 725
.meas tran vdout0_31ck144 FIND v(dout0_31) AT=725.025n

* CHECK dout0_32 Vdout0_32ck144 = 0.9 time = 725
.meas tran vdout0_32ck144 FIND v(dout0_32) AT=725.025n

* CHECK dout0_33 Vdout0_33ck144 = 0.9 time = 725
.meas tran vdout0_33ck144 FIND v(dout0_33) AT=725.025n

* CHECK dout0_34 Vdout0_34ck144 = 0.9 time = 725
.meas tran vdout0_34ck144 FIND v(dout0_34) AT=725.025n

* CHECK dout0_35 Vdout0_35ck144 = 0 time = 725
.meas tran vdout0_35ck144 FIND v(dout0_35) AT=725.025n

* CHECK dout0_36 Vdout0_36ck144 = 0.9 time = 725
.meas tran vdout0_36ck144 FIND v(dout0_36) AT=725.025n

* CHECK dout0_37 Vdout0_37ck144 = 0 time = 725
.meas tran vdout0_37ck144 FIND v(dout0_37) AT=725.025n

* CHECK dout0_38 Vdout0_38ck144 = 0.9 time = 725
.meas tran vdout0_38ck144 FIND v(dout0_38) AT=725.025n

* CHECK dout0_39 Vdout0_39ck144 = 0 time = 725
.meas tran vdout0_39ck144 FIND v(dout0_39) AT=725.025n

* CHECK dout0_40 Vdout0_40ck144 = 0.9 time = 725
.meas tran vdout0_40ck144 FIND v(dout0_40) AT=725.025n

* CHECK dout0_41 Vdout0_41ck144 = 0 time = 725
.meas tran vdout0_41ck144 FIND v(dout0_41) AT=725.025n

* CHECK dout0_42 Vdout0_42ck144 = 0.9 time = 725
.meas tran vdout0_42ck144 FIND v(dout0_42) AT=725.025n

* CHECK dout0_43 Vdout0_43ck144 = 0 time = 725
.meas tran vdout0_43ck144 FIND v(dout0_43) AT=725.025n

* CHECK dout0_44 Vdout0_44ck144 = 0.9 time = 725
.meas tran vdout0_44ck144 FIND v(dout0_44) AT=725.025n

* CHECK dout0_45 Vdout0_45ck144 = 0.9 time = 725
.meas tran vdout0_45ck144 FIND v(dout0_45) AT=725.025n

* CHECK dout0_46 Vdout0_46ck144 = 0 time = 725
.meas tran vdout0_46ck144 FIND v(dout0_46) AT=725.025n

* CHECK dout0_47 Vdout0_47ck144 = 0.9 time = 725
.meas tran vdout0_47ck144 FIND v(dout0_47) AT=725.025n

* CHECK dout0_48 Vdout0_48ck144 = 0.9 time = 725
.meas tran vdout0_48ck144 FIND v(dout0_48) AT=725.025n

* CHECK dout0_49 Vdout0_49ck144 = 0 time = 725
.meas tran vdout0_49ck144 FIND v(dout0_49) AT=725.025n

* CHECK dout0_50 Vdout0_50ck144 = 0 time = 725
.meas tran vdout0_50ck144 FIND v(dout0_50) AT=725.025n

* CHECK dout0_51 Vdout0_51ck144 = 0 time = 725
.meas tran vdout0_51ck144 FIND v(dout0_51) AT=725.025n

* CHECK dout0_52 Vdout0_52ck144 = 0 time = 725
.meas tran vdout0_52ck144 FIND v(dout0_52) AT=725.025n

* CHECK dout0_53 Vdout0_53ck144 = 0 time = 725
.meas tran vdout0_53ck144 FIND v(dout0_53) AT=725.025n

* CHECK dout0_54 Vdout0_54ck144 = 0 time = 725
.meas tran vdout0_54ck144 FIND v(dout0_54) AT=725.025n

* CHECK dout0_55 Vdout0_55ck144 = 0 time = 725
.meas tran vdout0_55ck144 FIND v(dout0_55) AT=725.025n

* CHECK dout0_56 Vdout0_56ck144 = 0 time = 725
.meas tran vdout0_56ck144 FIND v(dout0_56) AT=725.025n

* CHECK dout0_57 Vdout0_57ck144 = 0 time = 725
.meas tran vdout0_57ck144 FIND v(dout0_57) AT=725.025n

* CHECK dout0_58 Vdout0_58ck144 = 0 time = 725
.meas tran vdout0_58ck144 FIND v(dout0_58) AT=725.025n

* CHECK dout0_59 Vdout0_59ck144 = 0 time = 725
.meas tran vdout0_59ck144 FIND v(dout0_59) AT=725.025n

* CHECK dout0_60 Vdout0_60ck144 = 0 time = 725
.meas tran vdout0_60ck144 FIND v(dout0_60) AT=725.025n

* CHECK dout0_61 Vdout0_61ck144 = 0.9 time = 725
.meas tran vdout0_61ck144 FIND v(dout0_61) AT=725.025n

* CHECK dout0_62 Vdout0_62ck144 = 0.9 time = 725
.meas tran vdout0_62ck144 FIND v(dout0_62) AT=725.025n

* CHECK dout0_63 Vdout0_63ck144 = 0.9 time = 725
.meas tran vdout0_63ck144 FIND v(dout0_63) AT=725.025n

* CHECK dout0_64 Vdout0_64ck144 = 0.9 time = 725
.meas tran vdout0_64ck144 FIND v(dout0_64) AT=725.025n

* CHECK dout0_65 Vdout0_65ck144 = 0.9 time = 725
.meas tran vdout0_65ck144 FIND v(dout0_65) AT=725.025n

* CHECK dout0_66 Vdout0_66ck144 = 0 time = 725
.meas tran vdout0_66ck144 FIND v(dout0_66) AT=725.025n

* CHECK dout0_67 Vdout0_67ck144 = 0 time = 725
.meas tran vdout0_67ck144 FIND v(dout0_67) AT=725.025n

* CHECK dout0_68 Vdout0_68ck144 = 0.9 time = 725
.meas tran vdout0_68ck144 FIND v(dout0_68) AT=725.025n

* CHECK dout0_69 Vdout0_69ck144 = 0 time = 725
.meas tran vdout0_69ck144 FIND v(dout0_69) AT=725.025n

* CHECK dout0_70 Vdout0_70ck144 = 0.9 time = 725
.meas tran vdout0_70ck144 FIND v(dout0_70) AT=725.025n

* CHECK dout0_71 Vdout0_71ck144 = 0.9 time = 725
.meas tran vdout0_71ck144 FIND v(dout0_71) AT=725.025n

* CHECK dout0_72 Vdout0_72ck144 = 0.9 time = 725
.meas tran vdout0_72ck144 FIND v(dout0_72) AT=725.025n

* CHECK dout0_73 Vdout0_73ck144 = 0.9 time = 725
.meas tran vdout0_73ck144 FIND v(dout0_73) AT=725.025n

* CHECK dout0_74 Vdout0_74ck144 = 0.9 time = 725
.meas tran vdout0_74ck144 FIND v(dout0_74) AT=725.025n

* CHECK dout0_75 Vdout0_75ck144 = 0 time = 725
.meas tran vdout0_75ck144 FIND v(dout0_75) AT=725.025n

* CHECK dout0_76 Vdout0_76ck144 = 0.9 time = 725
.meas tran vdout0_76ck144 FIND v(dout0_76) AT=725.025n

* CHECK dout0_77 Vdout0_77ck144 = 0.9 time = 725
.meas tran vdout0_77ck144 FIND v(dout0_77) AT=725.025n

* CHECK dout0_78 Vdout0_78ck144 = 0.9 time = 725
.meas tran vdout0_78ck144 FIND v(dout0_78) AT=725.025n

* CHECK dout0_79 Vdout0_79ck144 = 0 time = 725
.meas tran vdout0_79ck144 FIND v(dout0_79) AT=725.025n

* CHECK dout0_0 Vdout0_0ck145 = 0.9 time = 730
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=730.025n

* CHECK dout0_1 Vdout0_1ck145 = 0.9 time = 730
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=730.025n

* CHECK dout0_2 Vdout0_2ck145 = 0 time = 730
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=730.025n

* CHECK dout0_3 Vdout0_3ck145 = 0 time = 730
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=730.025n

* CHECK dout0_4 Vdout0_4ck145 = 0 time = 730
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=730.025n

* CHECK dout0_5 Vdout0_5ck145 = 0 time = 730
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=730.025n

* CHECK dout0_6 Vdout0_6ck145 = 0 time = 730
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=730.025n

* CHECK dout0_7 Vdout0_7ck145 = 0 time = 730
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=730.025n

* CHECK dout0_8 Vdout0_8ck145 = 0.9 time = 730
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=730.025n

* CHECK dout0_9 Vdout0_9ck145 = 0 time = 730
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=730.025n

* CHECK dout0_10 Vdout0_10ck145 = 0 time = 730
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=730.025n

* CHECK dout0_11 Vdout0_11ck145 = 0.9 time = 730
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=730.025n

* CHECK dout0_12 Vdout0_12ck145 = 0.9 time = 730
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=730.025n

* CHECK dout0_13 Vdout0_13ck145 = 0 time = 730
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=730.025n

* CHECK dout0_14 Vdout0_14ck145 = 0 time = 730
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=730.025n

* CHECK dout0_15 Vdout0_15ck145 = 0.9 time = 730
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=730.025n

* CHECK dout0_16 Vdout0_16ck145 = 0.9 time = 730
.meas tran vdout0_16ck145 FIND v(dout0_16) AT=730.025n

* CHECK dout0_17 Vdout0_17ck145 = 0 time = 730
.meas tran vdout0_17ck145 FIND v(dout0_17) AT=730.025n

* CHECK dout0_18 Vdout0_18ck145 = 0 time = 730
.meas tran vdout0_18ck145 FIND v(dout0_18) AT=730.025n

* CHECK dout0_19 Vdout0_19ck145 = 0.9 time = 730
.meas tran vdout0_19ck145 FIND v(dout0_19) AT=730.025n

* CHECK dout0_20 Vdout0_20ck145 = 0.9 time = 730
.meas tran vdout0_20ck145 FIND v(dout0_20) AT=730.025n

* CHECK dout0_21 Vdout0_21ck145 = 0.9 time = 730
.meas tran vdout0_21ck145 FIND v(dout0_21) AT=730.025n

* CHECK dout0_22 Vdout0_22ck145 = 0 time = 730
.meas tran vdout0_22ck145 FIND v(dout0_22) AT=730.025n

* CHECK dout0_23 Vdout0_23ck145 = 0.9 time = 730
.meas tran vdout0_23ck145 FIND v(dout0_23) AT=730.025n

* CHECK dout0_24 Vdout0_24ck145 = 0 time = 730
.meas tran vdout0_24ck145 FIND v(dout0_24) AT=730.025n

* CHECK dout0_25 Vdout0_25ck145 = 0.9 time = 730
.meas tran vdout0_25ck145 FIND v(dout0_25) AT=730.025n

* CHECK dout0_26 Vdout0_26ck145 = 0.9 time = 730
.meas tran vdout0_26ck145 FIND v(dout0_26) AT=730.025n

* CHECK dout0_27 Vdout0_27ck145 = 0.9 time = 730
.meas tran vdout0_27ck145 FIND v(dout0_27) AT=730.025n

* CHECK dout0_28 Vdout0_28ck145 = 0.9 time = 730
.meas tran vdout0_28ck145 FIND v(dout0_28) AT=730.025n

* CHECK dout0_29 Vdout0_29ck145 = 0 time = 730
.meas tran vdout0_29ck145 FIND v(dout0_29) AT=730.025n

* CHECK dout0_30 Vdout0_30ck145 = 0.9 time = 730
.meas tran vdout0_30ck145 FIND v(dout0_30) AT=730.025n

* CHECK dout0_31 Vdout0_31ck145 = 0 time = 730
.meas tran vdout0_31ck145 FIND v(dout0_31) AT=730.025n

* CHECK dout0_32 Vdout0_32ck145 = 0 time = 730
.meas tran vdout0_32ck145 FIND v(dout0_32) AT=730.025n

* CHECK dout0_33 Vdout0_33ck145 = 0.9 time = 730
.meas tran vdout0_33ck145 FIND v(dout0_33) AT=730.025n

* CHECK dout0_34 Vdout0_34ck145 = 0 time = 730
.meas tran vdout0_34ck145 FIND v(dout0_34) AT=730.025n

* CHECK dout0_35 Vdout0_35ck145 = 0.9 time = 730
.meas tran vdout0_35ck145 FIND v(dout0_35) AT=730.025n

* CHECK dout0_36 Vdout0_36ck145 = 0.9 time = 730
.meas tran vdout0_36ck145 FIND v(dout0_36) AT=730.025n

* CHECK dout0_37 Vdout0_37ck145 = 0.9 time = 730
.meas tran vdout0_37ck145 FIND v(dout0_37) AT=730.025n

* CHECK dout0_38 Vdout0_38ck145 = 0.9 time = 730
.meas tran vdout0_38ck145 FIND v(dout0_38) AT=730.025n

* CHECK dout0_39 Vdout0_39ck145 = 0.9 time = 730
.meas tran vdout0_39ck145 FIND v(dout0_39) AT=730.025n

* CHECK dout0_40 Vdout0_40ck145 = 0 time = 730
.meas tran vdout0_40ck145 FIND v(dout0_40) AT=730.025n

* CHECK dout0_41 Vdout0_41ck145 = 0 time = 730
.meas tran vdout0_41ck145 FIND v(dout0_41) AT=730.025n

* CHECK dout0_42 Vdout0_42ck145 = 0.9 time = 730
.meas tran vdout0_42ck145 FIND v(dout0_42) AT=730.025n

* CHECK dout0_43 Vdout0_43ck145 = 0 time = 730
.meas tran vdout0_43ck145 FIND v(dout0_43) AT=730.025n

* CHECK dout0_44 Vdout0_44ck145 = 0.9 time = 730
.meas tran vdout0_44ck145 FIND v(dout0_44) AT=730.025n

* CHECK dout0_45 Vdout0_45ck145 = 0 time = 730
.meas tran vdout0_45ck145 FIND v(dout0_45) AT=730.025n

* CHECK dout0_46 Vdout0_46ck145 = 0 time = 730
.meas tran vdout0_46ck145 FIND v(dout0_46) AT=730.025n

* CHECK dout0_47 Vdout0_47ck145 = 0.9 time = 730
.meas tran vdout0_47ck145 FIND v(dout0_47) AT=730.025n

* CHECK dout0_48 Vdout0_48ck145 = 0 time = 730
.meas tran vdout0_48ck145 FIND v(dout0_48) AT=730.025n

* CHECK dout0_49 Vdout0_49ck145 = 0 time = 730
.meas tran vdout0_49ck145 FIND v(dout0_49) AT=730.025n

* CHECK dout0_50 Vdout0_50ck145 = 0.9 time = 730
.meas tran vdout0_50ck145 FIND v(dout0_50) AT=730.025n

* CHECK dout0_51 Vdout0_51ck145 = 0 time = 730
.meas tran vdout0_51ck145 FIND v(dout0_51) AT=730.025n

* CHECK dout0_52 Vdout0_52ck145 = 0 time = 730
.meas tran vdout0_52ck145 FIND v(dout0_52) AT=730.025n

* CHECK dout0_53 Vdout0_53ck145 = 0.9 time = 730
.meas tran vdout0_53ck145 FIND v(dout0_53) AT=730.025n

* CHECK dout0_54 Vdout0_54ck145 = 0 time = 730
.meas tran vdout0_54ck145 FIND v(dout0_54) AT=730.025n

* CHECK dout0_55 Vdout0_55ck145 = 0 time = 730
.meas tran vdout0_55ck145 FIND v(dout0_55) AT=730.025n

* CHECK dout0_56 Vdout0_56ck145 = 0 time = 730
.meas tran vdout0_56ck145 FIND v(dout0_56) AT=730.025n

* CHECK dout0_57 Vdout0_57ck145 = 0 time = 730
.meas tran vdout0_57ck145 FIND v(dout0_57) AT=730.025n

* CHECK dout0_58 Vdout0_58ck145 = 0 time = 730
.meas tran vdout0_58ck145 FIND v(dout0_58) AT=730.025n

* CHECK dout0_59 Vdout0_59ck145 = 0.9 time = 730
.meas tran vdout0_59ck145 FIND v(dout0_59) AT=730.025n

* CHECK dout0_60 Vdout0_60ck145 = 0.9 time = 730
.meas tran vdout0_60ck145 FIND v(dout0_60) AT=730.025n

* CHECK dout0_61 Vdout0_61ck145 = 0.9 time = 730
.meas tran vdout0_61ck145 FIND v(dout0_61) AT=730.025n

* CHECK dout0_62 Vdout0_62ck145 = 0.9 time = 730
.meas tran vdout0_62ck145 FIND v(dout0_62) AT=730.025n

* CHECK dout0_63 Vdout0_63ck145 = 0.9 time = 730
.meas tran vdout0_63ck145 FIND v(dout0_63) AT=730.025n

* CHECK dout0_64 Vdout0_64ck145 = 0 time = 730
.meas tran vdout0_64ck145 FIND v(dout0_64) AT=730.025n

* CHECK dout0_65 Vdout0_65ck145 = 0 time = 730
.meas tran vdout0_65ck145 FIND v(dout0_65) AT=730.025n

* CHECK dout0_66 Vdout0_66ck145 = 0 time = 730
.meas tran vdout0_66ck145 FIND v(dout0_66) AT=730.025n

* CHECK dout0_67 Vdout0_67ck145 = 0 time = 730
.meas tran vdout0_67ck145 FIND v(dout0_67) AT=730.025n

* CHECK dout0_68 Vdout0_68ck145 = 0.9 time = 730
.meas tran vdout0_68ck145 FIND v(dout0_68) AT=730.025n

* CHECK dout0_69 Vdout0_69ck145 = 0.9 time = 730
.meas tran vdout0_69ck145 FIND v(dout0_69) AT=730.025n

* CHECK dout0_70 Vdout0_70ck145 = 0.9 time = 730
.meas tran vdout0_70ck145 FIND v(dout0_70) AT=730.025n

* CHECK dout0_71 Vdout0_71ck145 = 0 time = 730
.meas tran vdout0_71ck145 FIND v(dout0_71) AT=730.025n

* CHECK dout0_72 Vdout0_72ck145 = 0 time = 730
.meas tran vdout0_72ck145 FIND v(dout0_72) AT=730.025n

* CHECK dout0_73 Vdout0_73ck145 = 0.9 time = 730
.meas tran vdout0_73ck145 FIND v(dout0_73) AT=730.025n

* CHECK dout0_74 Vdout0_74ck145 = 0.9 time = 730
.meas tran vdout0_74ck145 FIND v(dout0_74) AT=730.025n

* CHECK dout0_75 Vdout0_75ck145 = 0 time = 730
.meas tran vdout0_75ck145 FIND v(dout0_75) AT=730.025n

* CHECK dout0_76 Vdout0_76ck145 = 0.9 time = 730
.meas tran vdout0_76ck145 FIND v(dout0_76) AT=730.025n

* CHECK dout0_77 Vdout0_77ck145 = 0 time = 730
.meas tran vdout0_77ck145 FIND v(dout0_77) AT=730.025n

* CHECK dout0_78 Vdout0_78ck145 = 0.9 time = 730
.meas tran vdout0_78ck145 FIND v(dout0_78) AT=730.025n

* CHECK dout0_79 Vdout0_79ck145 = 0 time = 730
.meas tran vdout0_79ck145 FIND v(dout0_79) AT=730.025n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 760
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=760.025n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 760
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=760.025n

* CHECK dout0_2 Vdout0_2ck151 = 0.9 time = 760
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=760.025n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 760
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=760.025n

* CHECK dout0_4 Vdout0_4ck151 = 0.9 time = 760
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=760.025n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 760
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=760.025n

* CHECK dout0_6 Vdout0_6ck151 = 0.9 time = 760
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=760.025n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 760
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=760.025n

* CHECK dout0_8 Vdout0_8ck151 = 0.9 time = 760
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=760.025n

* CHECK dout0_9 Vdout0_9ck151 = 0 time = 760
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=760.025n

* CHECK dout0_10 Vdout0_10ck151 = 0.9 time = 760
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=760.025n

* CHECK dout0_11 Vdout0_11ck151 = 0.9 time = 760
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=760.025n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 760
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=760.025n

* CHECK dout0_13 Vdout0_13ck151 = 0 time = 760
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=760.025n

* CHECK dout0_14 Vdout0_14ck151 = 0 time = 760
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=760.025n

* CHECK dout0_15 Vdout0_15ck151 = 0 time = 760
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=760.025n

* CHECK dout0_16 Vdout0_16ck151 = 0.9 time = 760
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=760.025n

* CHECK dout0_17 Vdout0_17ck151 = 0.9 time = 760
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=760.025n

* CHECK dout0_18 Vdout0_18ck151 = 0.9 time = 760
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=760.025n

* CHECK dout0_19 Vdout0_19ck151 = 0.9 time = 760
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=760.025n

* CHECK dout0_20 Vdout0_20ck151 = 0.9 time = 760
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=760.025n

* CHECK dout0_21 Vdout0_21ck151 = 0 time = 760
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=760.025n

* CHECK dout0_22 Vdout0_22ck151 = 0.9 time = 760
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=760.025n

* CHECK dout0_23 Vdout0_23ck151 = 0 time = 760
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=760.025n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 760
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=760.025n

* CHECK dout0_25 Vdout0_25ck151 = 0 time = 760
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=760.025n

* CHECK dout0_26 Vdout0_26ck151 = 0 time = 760
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=760.025n

* CHECK dout0_27 Vdout0_27ck151 = 0.9 time = 760
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=760.025n

* CHECK dout0_28 Vdout0_28ck151 = 0.9 time = 760
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=760.025n

* CHECK dout0_29 Vdout0_29ck151 = 0.9 time = 760
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=760.025n

* CHECK dout0_30 Vdout0_30ck151 = 0.9 time = 760
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=760.025n

* CHECK dout0_31 Vdout0_31ck151 = 0.9 time = 760
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=760.025n

* CHECK dout0_32 Vdout0_32ck151 = 0.9 time = 760
.meas tran vdout0_32ck151 FIND v(dout0_32) AT=760.025n

* CHECK dout0_33 Vdout0_33ck151 = 0 time = 760
.meas tran vdout0_33ck151 FIND v(dout0_33) AT=760.025n

* CHECK dout0_34 Vdout0_34ck151 = 0.9 time = 760
.meas tran vdout0_34ck151 FIND v(dout0_34) AT=760.025n

* CHECK dout0_35 Vdout0_35ck151 = 0.9 time = 760
.meas tran vdout0_35ck151 FIND v(dout0_35) AT=760.025n

* CHECK dout0_36 Vdout0_36ck151 = 0 time = 760
.meas tran vdout0_36ck151 FIND v(dout0_36) AT=760.025n

* CHECK dout0_37 Vdout0_37ck151 = 0.9 time = 760
.meas tran vdout0_37ck151 FIND v(dout0_37) AT=760.025n

* CHECK dout0_38 Vdout0_38ck151 = 0 time = 760
.meas tran vdout0_38ck151 FIND v(dout0_38) AT=760.025n

* CHECK dout0_39 Vdout0_39ck151 = 0.9 time = 760
.meas tran vdout0_39ck151 FIND v(dout0_39) AT=760.025n

* CHECK dout0_40 Vdout0_40ck151 = 0 time = 760
.meas tran vdout0_40ck151 FIND v(dout0_40) AT=760.025n

* CHECK dout0_41 Vdout0_41ck151 = 0.9 time = 760
.meas tran vdout0_41ck151 FIND v(dout0_41) AT=760.025n

* CHECK dout0_42 Vdout0_42ck151 = 0 time = 760
.meas tran vdout0_42ck151 FIND v(dout0_42) AT=760.025n

* CHECK dout0_43 Vdout0_43ck151 = 0 time = 760
.meas tran vdout0_43ck151 FIND v(dout0_43) AT=760.025n

* CHECK dout0_44 Vdout0_44ck151 = 0 time = 760
.meas tran vdout0_44ck151 FIND v(dout0_44) AT=760.025n

* CHECK dout0_45 Vdout0_45ck151 = 0.9 time = 760
.meas tran vdout0_45ck151 FIND v(dout0_45) AT=760.025n

* CHECK dout0_46 Vdout0_46ck151 = 0.9 time = 760
.meas tran vdout0_46ck151 FIND v(dout0_46) AT=760.025n

* CHECK dout0_47 Vdout0_47ck151 = 0.9 time = 760
.meas tran vdout0_47ck151 FIND v(dout0_47) AT=760.025n

* CHECK dout0_48 Vdout0_48ck151 = 0.9 time = 760
.meas tran vdout0_48ck151 FIND v(dout0_48) AT=760.025n

* CHECK dout0_49 Vdout0_49ck151 = 0.9 time = 760
.meas tran vdout0_49ck151 FIND v(dout0_49) AT=760.025n

* CHECK dout0_50 Vdout0_50ck151 = 0.9 time = 760
.meas tran vdout0_50ck151 FIND v(dout0_50) AT=760.025n

* CHECK dout0_51 Vdout0_51ck151 = 0.9 time = 760
.meas tran vdout0_51ck151 FIND v(dout0_51) AT=760.025n

* CHECK dout0_52 Vdout0_52ck151 = 0 time = 760
.meas tran vdout0_52ck151 FIND v(dout0_52) AT=760.025n

* CHECK dout0_53 Vdout0_53ck151 = 0 time = 760
.meas tran vdout0_53ck151 FIND v(dout0_53) AT=760.025n

* CHECK dout0_54 Vdout0_54ck151 = 0 time = 760
.meas tran vdout0_54ck151 FIND v(dout0_54) AT=760.025n

* CHECK dout0_55 Vdout0_55ck151 = 0.9 time = 760
.meas tran vdout0_55ck151 FIND v(dout0_55) AT=760.025n

* CHECK dout0_56 Vdout0_56ck151 = 0.9 time = 760
.meas tran vdout0_56ck151 FIND v(dout0_56) AT=760.025n

* CHECK dout0_57 Vdout0_57ck151 = 0 time = 760
.meas tran vdout0_57ck151 FIND v(dout0_57) AT=760.025n

* CHECK dout0_58 Vdout0_58ck151 = 0 time = 760
.meas tran vdout0_58ck151 FIND v(dout0_58) AT=760.025n

* CHECK dout0_59 Vdout0_59ck151 = 0 time = 760
.meas tran vdout0_59ck151 FIND v(dout0_59) AT=760.025n

* CHECK dout0_60 Vdout0_60ck151 = 0.9 time = 760
.meas tran vdout0_60ck151 FIND v(dout0_60) AT=760.025n

* CHECK dout0_61 Vdout0_61ck151 = 0 time = 760
.meas tran vdout0_61ck151 FIND v(dout0_61) AT=760.025n

* CHECK dout0_62 Vdout0_62ck151 = 0.9 time = 760
.meas tran vdout0_62ck151 FIND v(dout0_62) AT=760.025n

* CHECK dout0_63 Vdout0_63ck151 = 0.9 time = 760
.meas tran vdout0_63ck151 FIND v(dout0_63) AT=760.025n

* CHECK dout0_64 Vdout0_64ck151 = 0 time = 760
.meas tran vdout0_64ck151 FIND v(dout0_64) AT=760.025n

* CHECK dout0_65 Vdout0_65ck151 = 0 time = 760
.meas tran vdout0_65ck151 FIND v(dout0_65) AT=760.025n

* CHECK dout0_66 Vdout0_66ck151 = 0.9 time = 760
.meas tran vdout0_66ck151 FIND v(dout0_66) AT=760.025n

* CHECK dout0_67 Vdout0_67ck151 = 0.9 time = 760
.meas tran vdout0_67ck151 FIND v(dout0_67) AT=760.025n

* CHECK dout0_68 Vdout0_68ck151 = 0.9 time = 760
.meas tran vdout0_68ck151 FIND v(dout0_68) AT=760.025n

* CHECK dout0_69 Vdout0_69ck151 = 0 time = 760
.meas tran vdout0_69ck151 FIND v(dout0_69) AT=760.025n

* CHECK dout0_70 Vdout0_70ck151 = 0 time = 760
.meas tran vdout0_70ck151 FIND v(dout0_70) AT=760.025n

* CHECK dout0_71 Vdout0_71ck151 = 0 time = 760
.meas tran vdout0_71ck151 FIND v(dout0_71) AT=760.025n

* CHECK dout0_72 Vdout0_72ck151 = 0.9 time = 760
.meas tran vdout0_72ck151 FIND v(dout0_72) AT=760.025n

* CHECK dout0_73 Vdout0_73ck151 = 0.9 time = 760
.meas tran vdout0_73ck151 FIND v(dout0_73) AT=760.025n

* CHECK dout0_74 Vdout0_74ck151 = 0 time = 760
.meas tran vdout0_74ck151 FIND v(dout0_74) AT=760.025n

* CHECK dout0_75 Vdout0_75ck151 = 0 time = 760
.meas tran vdout0_75ck151 FIND v(dout0_75) AT=760.025n

* CHECK dout0_76 Vdout0_76ck151 = 0.9 time = 760
.meas tran vdout0_76ck151 FIND v(dout0_76) AT=760.025n

* CHECK dout0_77 Vdout0_77ck151 = 0.9 time = 760
.meas tran vdout0_77ck151 FIND v(dout0_77) AT=760.025n

* CHECK dout0_78 Vdout0_78ck151 = 0 time = 760
.meas tran vdout0_78ck151 FIND v(dout0_78) AT=760.025n

* CHECK dout0_79 Vdout0_79ck151 = 0 time = 760
.meas tran vdout0_79ck151 FIND v(dout0_79) AT=760.025n

* CHECK dout0_0 Vdout0_0ck153 = 0.9 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0.9 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 0.9 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 0 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 0.9 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 0.9 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0.9 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 0.9 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 0.9 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 0.9 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 0.9 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 0 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 0.9 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0.9 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 0.9 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0.9 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0.9 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0.9 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 0 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 0.9 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 0 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0.9 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 0.9 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 0.9 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_32 Vdout0_32ck153 = 0 time = 770
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=770.025n

* CHECK dout0_33 Vdout0_33ck153 = 0.9 time = 770
.meas tran vdout0_33ck153 FIND v(dout0_33) AT=770.025n

* CHECK dout0_34 Vdout0_34ck153 = 0 time = 770
.meas tran vdout0_34ck153 FIND v(dout0_34) AT=770.025n

* CHECK dout0_35 Vdout0_35ck153 = 0.9 time = 770
.meas tran vdout0_35ck153 FIND v(dout0_35) AT=770.025n

* CHECK dout0_36 Vdout0_36ck153 = 0 time = 770
.meas tran vdout0_36ck153 FIND v(dout0_36) AT=770.025n

* CHECK dout0_37 Vdout0_37ck153 = 0.9 time = 770
.meas tran vdout0_37ck153 FIND v(dout0_37) AT=770.025n

* CHECK dout0_38 Vdout0_38ck153 = 0.9 time = 770
.meas tran vdout0_38ck153 FIND v(dout0_38) AT=770.025n

* CHECK dout0_39 Vdout0_39ck153 = 0 time = 770
.meas tran vdout0_39ck153 FIND v(dout0_39) AT=770.025n

* CHECK dout0_40 Vdout0_40ck153 = 0.9 time = 770
.meas tran vdout0_40ck153 FIND v(dout0_40) AT=770.025n

* CHECK dout0_41 Vdout0_41ck153 = 0 time = 770
.meas tran vdout0_41ck153 FIND v(dout0_41) AT=770.025n

* CHECK dout0_42 Vdout0_42ck153 = 0 time = 770
.meas tran vdout0_42ck153 FIND v(dout0_42) AT=770.025n

* CHECK dout0_43 Vdout0_43ck153 = 0 time = 770
.meas tran vdout0_43ck153 FIND v(dout0_43) AT=770.025n

* CHECK dout0_44 Vdout0_44ck153 = 0.9 time = 770
.meas tran vdout0_44ck153 FIND v(dout0_44) AT=770.025n

* CHECK dout0_45 Vdout0_45ck153 = 0.9 time = 770
.meas tran vdout0_45ck153 FIND v(dout0_45) AT=770.025n

* CHECK dout0_46 Vdout0_46ck153 = 0 time = 770
.meas tran vdout0_46ck153 FIND v(dout0_46) AT=770.025n

* CHECK dout0_47 Vdout0_47ck153 = 0 time = 770
.meas tran vdout0_47ck153 FIND v(dout0_47) AT=770.025n

* CHECK dout0_48 Vdout0_48ck153 = 0.9 time = 770
.meas tran vdout0_48ck153 FIND v(dout0_48) AT=770.025n

* CHECK dout0_49 Vdout0_49ck153 = 0 time = 770
.meas tran vdout0_49ck153 FIND v(dout0_49) AT=770.025n

* CHECK dout0_50 Vdout0_50ck153 = 0 time = 770
.meas tran vdout0_50ck153 FIND v(dout0_50) AT=770.025n

* CHECK dout0_51 Vdout0_51ck153 = 0 time = 770
.meas tran vdout0_51ck153 FIND v(dout0_51) AT=770.025n

* CHECK dout0_52 Vdout0_52ck153 = 0.9 time = 770
.meas tran vdout0_52ck153 FIND v(dout0_52) AT=770.025n

* CHECK dout0_53 Vdout0_53ck153 = 0.9 time = 770
.meas tran vdout0_53ck153 FIND v(dout0_53) AT=770.025n

* CHECK dout0_54 Vdout0_54ck153 = 0 time = 770
.meas tran vdout0_54ck153 FIND v(dout0_54) AT=770.025n

* CHECK dout0_55 Vdout0_55ck153 = 0 time = 770
.meas tran vdout0_55ck153 FIND v(dout0_55) AT=770.025n

* CHECK dout0_56 Vdout0_56ck153 = 0.9 time = 770
.meas tran vdout0_56ck153 FIND v(dout0_56) AT=770.025n

* CHECK dout0_57 Vdout0_57ck153 = 0.9 time = 770
.meas tran vdout0_57ck153 FIND v(dout0_57) AT=770.025n

* CHECK dout0_58 Vdout0_58ck153 = 0 time = 770
.meas tran vdout0_58ck153 FIND v(dout0_58) AT=770.025n

* CHECK dout0_59 Vdout0_59ck153 = 0.9 time = 770
.meas tran vdout0_59ck153 FIND v(dout0_59) AT=770.025n

* CHECK dout0_60 Vdout0_60ck153 = 0.9 time = 770
.meas tran vdout0_60ck153 FIND v(dout0_60) AT=770.025n

* CHECK dout0_61 Vdout0_61ck153 = 0 time = 770
.meas tran vdout0_61ck153 FIND v(dout0_61) AT=770.025n

* CHECK dout0_62 Vdout0_62ck153 = 0 time = 770
.meas tran vdout0_62ck153 FIND v(dout0_62) AT=770.025n

* CHECK dout0_63 Vdout0_63ck153 = 0.9 time = 770
.meas tran vdout0_63ck153 FIND v(dout0_63) AT=770.025n

* CHECK dout0_64 Vdout0_64ck153 = 0.9 time = 770
.meas tran vdout0_64ck153 FIND v(dout0_64) AT=770.025n

* CHECK dout0_65 Vdout0_65ck153 = 0.9 time = 770
.meas tran vdout0_65ck153 FIND v(dout0_65) AT=770.025n

* CHECK dout0_66 Vdout0_66ck153 = 0.9 time = 770
.meas tran vdout0_66ck153 FIND v(dout0_66) AT=770.025n

* CHECK dout0_67 Vdout0_67ck153 = 0 time = 770
.meas tran vdout0_67ck153 FIND v(dout0_67) AT=770.025n

* CHECK dout0_68 Vdout0_68ck153 = 0 time = 770
.meas tran vdout0_68ck153 FIND v(dout0_68) AT=770.025n

* CHECK dout0_69 Vdout0_69ck153 = 0 time = 770
.meas tran vdout0_69ck153 FIND v(dout0_69) AT=770.025n

* CHECK dout0_70 Vdout0_70ck153 = 0 time = 770
.meas tran vdout0_70ck153 FIND v(dout0_70) AT=770.025n

* CHECK dout0_71 Vdout0_71ck153 = 0.9 time = 770
.meas tran vdout0_71ck153 FIND v(dout0_71) AT=770.025n

* CHECK dout0_72 Vdout0_72ck153 = 0 time = 770
.meas tran vdout0_72ck153 FIND v(dout0_72) AT=770.025n

* CHECK dout0_73 Vdout0_73ck153 = 0.9 time = 770
.meas tran vdout0_73ck153 FIND v(dout0_73) AT=770.025n

* CHECK dout0_74 Vdout0_74ck153 = 0.9 time = 770
.meas tran vdout0_74ck153 FIND v(dout0_74) AT=770.025n

* CHECK dout0_75 Vdout0_75ck153 = 0 time = 770
.meas tran vdout0_75ck153 FIND v(dout0_75) AT=770.025n

* CHECK dout0_76 Vdout0_76ck153 = 0.9 time = 770
.meas tran vdout0_76ck153 FIND v(dout0_76) AT=770.025n

* CHECK dout0_77 Vdout0_77ck153 = 0.9 time = 770
.meas tran vdout0_77ck153 FIND v(dout0_77) AT=770.025n

* CHECK dout0_78 Vdout0_78ck153 = 0 time = 770
.meas tran vdout0_78ck153 FIND v(dout0_78) AT=770.025n

* CHECK dout0_79 Vdout0_79ck153 = 0.9 time = 770
.meas tran vdout0_79ck153 FIND v(dout0_79) AT=770.025n

* CHECK dout0_0 Vdout0_0ck156 = 0 time = 785
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=785.025n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 785
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=785.025n

* CHECK dout0_2 Vdout0_2ck156 = 0.9 time = 785
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=785.025n

* CHECK dout0_3 Vdout0_3ck156 = 0 time = 785
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=785.025n

* CHECK dout0_4 Vdout0_4ck156 = 0.9 time = 785
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=785.025n

* CHECK dout0_5 Vdout0_5ck156 = 0.9 time = 785
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=785.025n

* CHECK dout0_6 Vdout0_6ck156 = 0 time = 785
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=785.025n

* CHECK dout0_7 Vdout0_7ck156 = 0 time = 785
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=785.025n

* CHECK dout0_8 Vdout0_8ck156 = 0.9 time = 785
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=785.025n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 785
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=785.025n

* CHECK dout0_10 Vdout0_10ck156 = 0 time = 785
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=785.025n

* CHECK dout0_11 Vdout0_11ck156 = 0.9 time = 785
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=785.025n

* CHECK dout0_12 Vdout0_12ck156 = 0 time = 785
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=785.025n

* CHECK dout0_13 Vdout0_13ck156 = 0 time = 785
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=785.025n

* CHECK dout0_14 Vdout0_14ck156 = 0 time = 785
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=785.025n

* CHECK dout0_15 Vdout0_15ck156 = 0.9 time = 785
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=785.025n

* CHECK dout0_16 Vdout0_16ck156 = 0 time = 785
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=785.025n

* CHECK dout0_17 Vdout0_17ck156 = 0.9 time = 785
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=785.025n

* CHECK dout0_18 Vdout0_18ck156 = 0 time = 785
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=785.025n

* CHECK dout0_19 Vdout0_19ck156 = 0 time = 785
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=785.025n

* CHECK dout0_20 Vdout0_20ck156 = 0 time = 785
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=785.025n

* CHECK dout0_21 Vdout0_21ck156 = 0 time = 785
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=785.025n

* CHECK dout0_22 Vdout0_22ck156 = 0.9 time = 785
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=785.025n

* CHECK dout0_23 Vdout0_23ck156 = 0 time = 785
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=785.025n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 785
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=785.025n

* CHECK dout0_25 Vdout0_25ck156 = 0 time = 785
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=785.025n

* CHECK dout0_26 Vdout0_26ck156 = 0.9 time = 785
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=785.025n

* CHECK dout0_27 Vdout0_27ck156 = 0 time = 785
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=785.025n

* CHECK dout0_28 Vdout0_28ck156 = 0.9 time = 785
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=785.025n

* CHECK dout0_29 Vdout0_29ck156 = 0 time = 785
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=785.025n

* CHECK dout0_30 Vdout0_30ck156 = 0.9 time = 785
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=785.025n

* CHECK dout0_31 Vdout0_31ck156 = 0.9 time = 785
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=785.025n

* CHECK dout0_32 Vdout0_32ck156 = 0 time = 785
.meas tran vdout0_32ck156 FIND v(dout0_32) AT=785.025n

* CHECK dout0_33 Vdout0_33ck156 = 0 time = 785
.meas tran vdout0_33ck156 FIND v(dout0_33) AT=785.025n

* CHECK dout0_34 Vdout0_34ck156 = 0.9 time = 785
.meas tran vdout0_34ck156 FIND v(dout0_34) AT=785.025n

* CHECK dout0_35 Vdout0_35ck156 = 0 time = 785
.meas tran vdout0_35ck156 FIND v(dout0_35) AT=785.025n

* CHECK dout0_36 Vdout0_36ck156 = 0 time = 785
.meas tran vdout0_36ck156 FIND v(dout0_36) AT=785.025n

* CHECK dout0_37 Vdout0_37ck156 = 0 time = 785
.meas tran vdout0_37ck156 FIND v(dout0_37) AT=785.025n

* CHECK dout0_38 Vdout0_38ck156 = 0.9 time = 785
.meas tran vdout0_38ck156 FIND v(dout0_38) AT=785.025n

* CHECK dout0_39 Vdout0_39ck156 = 0 time = 785
.meas tran vdout0_39ck156 FIND v(dout0_39) AT=785.025n

* CHECK dout0_40 Vdout0_40ck156 = 0 time = 785
.meas tran vdout0_40ck156 FIND v(dout0_40) AT=785.025n

* CHECK dout0_41 Vdout0_41ck156 = 0.9 time = 785
.meas tran vdout0_41ck156 FIND v(dout0_41) AT=785.025n

* CHECK dout0_42 Vdout0_42ck156 = 0 time = 785
.meas tran vdout0_42ck156 FIND v(dout0_42) AT=785.025n

* CHECK dout0_43 Vdout0_43ck156 = 0.9 time = 785
.meas tran vdout0_43ck156 FIND v(dout0_43) AT=785.025n

* CHECK dout0_44 Vdout0_44ck156 = 0 time = 785
.meas tran vdout0_44ck156 FIND v(dout0_44) AT=785.025n

* CHECK dout0_45 Vdout0_45ck156 = 0.9 time = 785
.meas tran vdout0_45ck156 FIND v(dout0_45) AT=785.025n

* CHECK dout0_46 Vdout0_46ck156 = 0.9 time = 785
.meas tran vdout0_46ck156 FIND v(dout0_46) AT=785.025n

* CHECK dout0_47 Vdout0_47ck156 = 0 time = 785
.meas tran vdout0_47ck156 FIND v(dout0_47) AT=785.025n

* CHECK dout0_48 Vdout0_48ck156 = 0.9 time = 785
.meas tran vdout0_48ck156 FIND v(dout0_48) AT=785.025n

* CHECK dout0_49 Vdout0_49ck156 = 0 time = 785
.meas tran vdout0_49ck156 FIND v(dout0_49) AT=785.025n

* CHECK dout0_50 Vdout0_50ck156 = 0 time = 785
.meas tran vdout0_50ck156 FIND v(dout0_50) AT=785.025n

* CHECK dout0_51 Vdout0_51ck156 = 0 time = 785
.meas tran vdout0_51ck156 FIND v(dout0_51) AT=785.025n

* CHECK dout0_52 Vdout0_52ck156 = 0 time = 785
.meas tran vdout0_52ck156 FIND v(dout0_52) AT=785.025n

* CHECK dout0_53 Vdout0_53ck156 = 0.9 time = 785
.meas tran vdout0_53ck156 FIND v(dout0_53) AT=785.025n

* CHECK dout0_54 Vdout0_54ck156 = 0 time = 785
.meas tran vdout0_54ck156 FIND v(dout0_54) AT=785.025n

* CHECK dout0_55 Vdout0_55ck156 = 0 time = 785
.meas tran vdout0_55ck156 FIND v(dout0_55) AT=785.025n

* CHECK dout0_56 Vdout0_56ck156 = 0.9 time = 785
.meas tran vdout0_56ck156 FIND v(dout0_56) AT=785.025n

* CHECK dout0_57 Vdout0_57ck156 = 0 time = 785
.meas tran vdout0_57ck156 FIND v(dout0_57) AT=785.025n

* CHECK dout0_58 Vdout0_58ck156 = 0.9 time = 785
.meas tran vdout0_58ck156 FIND v(dout0_58) AT=785.025n

* CHECK dout0_59 Vdout0_59ck156 = 0 time = 785
.meas tran vdout0_59ck156 FIND v(dout0_59) AT=785.025n

* CHECK dout0_60 Vdout0_60ck156 = 0 time = 785
.meas tran vdout0_60ck156 FIND v(dout0_60) AT=785.025n

* CHECK dout0_61 Vdout0_61ck156 = 0 time = 785
.meas tran vdout0_61ck156 FIND v(dout0_61) AT=785.025n

* CHECK dout0_62 Vdout0_62ck156 = 0.9 time = 785
.meas tran vdout0_62ck156 FIND v(dout0_62) AT=785.025n

* CHECK dout0_63 Vdout0_63ck156 = 0.9 time = 785
.meas tran vdout0_63ck156 FIND v(dout0_63) AT=785.025n

* CHECK dout0_64 Vdout0_64ck156 = 0.9 time = 785
.meas tran vdout0_64ck156 FIND v(dout0_64) AT=785.025n

* CHECK dout0_65 Vdout0_65ck156 = 0.9 time = 785
.meas tran vdout0_65ck156 FIND v(dout0_65) AT=785.025n

* CHECK dout0_66 Vdout0_66ck156 = 0 time = 785
.meas tran vdout0_66ck156 FIND v(dout0_66) AT=785.025n

* CHECK dout0_67 Vdout0_67ck156 = 0 time = 785
.meas tran vdout0_67ck156 FIND v(dout0_67) AT=785.025n

* CHECK dout0_68 Vdout0_68ck156 = 0 time = 785
.meas tran vdout0_68ck156 FIND v(dout0_68) AT=785.025n

* CHECK dout0_69 Vdout0_69ck156 = 0.9 time = 785
.meas tran vdout0_69ck156 FIND v(dout0_69) AT=785.025n

* CHECK dout0_70 Vdout0_70ck156 = 0.9 time = 785
.meas tran vdout0_70ck156 FIND v(dout0_70) AT=785.025n

* CHECK dout0_71 Vdout0_71ck156 = 0.9 time = 785
.meas tran vdout0_71ck156 FIND v(dout0_71) AT=785.025n

* CHECK dout0_72 Vdout0_72ck156 = 0 time = 785
.meas tran vdout0_72ck156 FIND v(dout0_72) AT=785.025n

* CHECK dout0_73 Vdout0_73ck156 = 0 time = 785
.meas tran vdout0_73ck156 FIND v(dout0_73) AT=785.025n

* CHECK dout0_74 Vdout0_74ck156 = 0.9 time = 785
.meas tran vdout0_74ck156 FIND v(dout0_74) AT=785.025n

* CHECK dout0_75 Vdout0_75ck156 = 0.9 time = 785
.meas tran vdout0_75ck156 FIND v(dout0_75) AT=785.025n

* CHECK dout0_76 Vdout0_76ck156 = 0.9 time = 785
.meas tran vdout0_76ck156 FIND v(dout0_76) AT=785.025n

* CHECK dout0_77 Vdout0_77ck156 = 0.9 time = 785
.meas tran vdout0_77ck156 FIND v(dout0_77) AT=785.025n

* CHECK dout0_78 Vdout0_78ck156 = 0 time = 785
.meas tran vdout0_78ck156 FIND v(dout0_78) AT=785.025n

* CHECK dout0_79 Vdout0_79ck156 = 0.9 time = 785
.meas tran vdout0_79ck156 FIND v(dout0_79) AT=785.025n

* CHECK dout0_0 Vdout0_0ck160 = 0.9 time = 805
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=805.025n

* CHECK dout0_1 Vdout0_1ck160 = 0.9 time = 805
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=805.025n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 805
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=805.025n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 805
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=805.025n

* CHECK dout0_4 Vdout0_4ck160 = 0.9 time = 805
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=805.025n

* CHECK dout0_5 Vdout0_5ck160 = 0.9 time = 805
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=805.025n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 805
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=805.025n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 805
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=805.025n

* CHECK dout0_8 Vdout0_8ck160 = 0.9 time = 805
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=805.025n

* CHECK dout0_9 Vdout0_9ck160 = 0.9 time = 805
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=805.025n

* CHECK dout0_10 Vdout0_10ck160 = 0.9 time = 805
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=805.025n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 805
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=805.025n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 805
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=805.025n

* CHECK dout0_13 Vdout0_13ck160 = 0.9 time = 805
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=805.025n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 805
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=805.025n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 805
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=805.025n

* CHECK dout0_16 Vdout0_16ck160 = 0.9 time = 805
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=805.025n

* CHECK dout0_17 Vdout0_17ck160 = 0.9 time = 805
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=805.025n

* CHECK dout0_18 Vdout0_18ck160 = 0.9 time = 805
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=805.025n

* CHECK dout0_19 Vdout0_19ck160 = 0.9 time = 805
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=805.025n

* CHECK dout0_20 Vdout0_20ck160 = 0 time = 805
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=805.025n

* CHECK dout0_21 Vdout0_21ck160 = 0.9 time = 805
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=805.025n

* CHECK dout0_22 Vdout0_22ck160 = 0.9 time = 805
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=805.025n

* CHECK dout0_23 Vdout0_23ck160 = 0.9 time = 805
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=805.025n

* CHECK dout0_24 Vdout0_24ck160 = 0 time = 805
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=805.025n

* CHECK dout0_25 Vdout0_25ck160 = 0.9 time = 805
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=805.025n

* CHECK dout0_26 Vdout0_26ck160 = 0.9 time = 805
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=805.025n

* CHECK dout0_27 Vdout0_27ck160 = 0.9 time = 805
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=805.025n

* CHECK dout0_28 Vdout0_28ck160 = 0 time = 805
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=805.025n

* CHECK dout0_29 Vdout0_29ck160 = 0 time = 805
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=805.025n

* CHECK dout0_30 Vdout0_30ck160 = 0.9 time = 805
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=805.025n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 805
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=805.025n

* CHECK dout0_32 Vdout0_32ck160 = 0.9 time = 805
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=805.025n

* CHECK dout0_33 Vdout0_33ck160 = 0 time = 805
.meas tran vdout0_33ck160 FIND v(dout0_33) AT=805.025n

* CHECK dout0_34 Vdout0_34ck160 = 0.9 time = 805
.meas tran vdout0_34ck160 FIND v(dout0_34) AT=805.025n

* CHECK dout0_35 Vdout0_35ck160 = 0.9 time = 805
.meas tran vdout0_35ck160 FIND v(dout0_35) AT=805.025n

* CHECK dout0_36 Vdout0_36ck160 = 0 time = 805
.meas tran vdout0_36ck160 FIND v(dout0_36) AT=805.025n

* CHECK dout0_37 Vdout0_37ck160 = 0.9 time = 805
.meas tran vdout0_37ck160 FIND v(dout0_37) AT=805.025n

* CHECK dout0_38 Vdout0_38ck160 = 0.9 time = 805
.meas tran vdout0_38ck160 FIND v(dout0_38) AT=805.025n

* CHECK dout0_39 Vdout0_39ck160 = 0 time = 805
.meas tran vdout0_39ck160 FIND v(dout0_39) AT=805.025n

* CHECK dout0_40 Vdout0_40ck160 = 0 time = 805
.meas tran vdout0_40ck160 FIND v(dout0_40) AT=805.025n

* CHECK dout0_41 Vdout0_41ck160 = 0 time = 805
.meas tran vdout0_41ck160 FIND v(dout0_41) AT=805.025n

* CHECK dout0_42 Vdout0_42ck160 = 0 time = 805
.meas tran vdout0_42ck160 FIND v(dout0_42) AT=805.025n

* CHECK dout0_43 Vdout0_43ck160 = 0 time = 805
.meas tran vdout0_43ck160 FIND v(dout0_43) AT=805.025n

* CHECK dout0_44 Vdout0_44ck160 = 0 time = 805
.meas tran vdout0_44ck160 FIND v(dout0_44) AT=805.025n

* CHECK dout0_45 Vdout0_45ck160 = 0 time = 805
.meas tran vdout0_45ck160 FIND v(dout0_45) AT=805.025n

* CHECK dout0_46 Vdout0_46ck160 = 0.9 time = 805
.meas tran vdout0_46ck160 FIND v(dout0_46) AT=805.025n

* CHECK dout0_47 Vdout0_47ck160 = 0.9 time = 805
.meas tran vdout0_47ck160 FIND v(dout0_47) AT=805.025n

* CHECK dout0_48 Vdout0_48ck160 = 0.9 time = 805
.meas tran vdout0_48ck160 FIND v(dout0_48) AT=805.025n

* CHECK dout0_49 Vdout0_49ck160 = 0.9 time = 805
.meas tran vdout0_49ck160 FIND v(dout0_49) AT=805.025n

* CHECK dout0_50 Vdout0_50ck160 = 0.9 time = 805
.meas tran vdout0_50ck160 FIND v(dout0_50) AT=805.025n

* CHECK dout0_51 Vdout0_51ck160 = 0.9 time = 805
.meas tran vdout0_51ck160 FIND v(dout0_51) AT=805.025n

* CHECK dout0_52 Vdout0_52ck160 = 0 time = 805
.meas tran vdout0_52ck160 FIND v(dout0_52) AT=805.025n

* CHECK dout0_53 Vdout0_53ck160 = 0 time = 805
.meas tran vdout0_53ck160 FIND v(dout0_53) AT=805.025n

* CHECK dout0_54 Vdout0_54ck160 = 0 time = 805
.meas tran vdout0_54ck160 FIND v(dout0_54) AT=805.025n

* CHECK dout0_55 Vdout0_55ck160 = 0.9 time = 805
.meas tran vdout0_55ck160 FIND v(dout0_55) AT=805.025n

* CHECK dout0_56 Vdout0_56ck160 = 0.9 time = 805
.meas tran vdout0_56ck160 FIND v(dout0_56) AT=805.025n

* CHECK dout0_57 Vdout0_57ck160 = 0.9 time = 805
.meas tran vdout0_57ck160 FIND v(dout0_57) AT=805.025n

* CHECK dout0_58 Vdout0_58ck160 = 0 time = 805
.meas tran vdout0_58ck160 FIND v(dout0_58) AT=805.025n

* CHECK dout0_59 Vdout0_59ck160 = 0.9 time = 805
.meas tran vdout0_59ck160 FIND v(dout0_59) AT=805.025n

* CHECK dout0_60 Vdout0_60ck160 = 0 time = 805
.meas tran vdout0_60ck160 FIND v(dout0_60) AT=805.025n

* CHECK dout0_61 Vdout0_61ck160 = 0 time = 805
.meas tran vdout0_61ck160 FIND v(dout0_61) AT=805.025n

* CHECK dout0_62 Vdout0_62ck160 = 0.9 time = 805
.meas tran vdout0_62ck160 FIND v(dout0_62) AT=805.025n

* CHECK dout0_63 Vdout0_63ck160 = 0.9 time = 805
.meas tran vdout0_63ck160 FIND v(dout0_63) AT=805.025n

* CHECK dout0_64 Vdout0_64ck160 = 0 time = 805
.meas tran vdout0_64ck160 FIND v(dout0_64) AT=805.025n

* CHECK dout0_65 Vdout0_65ck160 = 0 time = 805
.meas tran vdout0_65ck160 FIND v(dout0_65) AT=805.025n

* CHECK dout0_66 Vdout0_66ck160 = 0.9 time = 805
.meas tran vdout0_66ck160 FIND v(dout0_66) AT=805.025n

* CHECK dout0_67 Vdout0_67ck160 = 0 time = 805
.meas tran vdout0_67ck160 FIND v(dout0_67) AT=805.025n

* CHECK dout0_68 Vdout0_68ck160 = 0.9 time = 805
.meas tran vdout0_68ck160 FIND v(dout0_68) AT=805.025n

* CHECK dout0_69 Vdout0_69ck160 = 0.9 time = 805
.meas tran vdout0_69ck160 FIND v(dout0_69) AT=805.025n

* CHECK dout0_70 Vdout0_70ck160 = 0.9 time = 805
.meas tran vdout0_70ck160 FIND v(dout0_70) AT=805.025n

* CHECK dout0_71 Vdout0_71ck160 = 0.9 time = 805
.meas tran vdout0_71ck160 FIND v(dout0_71) AT=805.025n

* CHECK dout0_72 Vdout0_72ck160 = 0.9 time = 805
.meas tran vdout0_72ck160 FIND v(dout0_72) AT=805.025n

* CHECK dout0_73 Vdout0_73ck160 = 0.9 time = 805
.meas tran vdout0_73ck160 FIND v(dout0_73) AT=805.025n

* CHECK dout0_74 Vdout0_74ck160 = 0.9 time = 805
.meas tran vdout0_74ck160 FIND v(dout0_74) AT=805.025n

* CHECK dout0_75 Vdout0_75ck160 = 0 time = 805
.meas tran vdout0_75ck160 FIND v(dout0_75) AT=805.025n

* CHECK dout0_76 Vdout0_76ck160 = 0 time = 805
.meas tran vdout0_76ck160 FIND v(dout0_76) AT=805.025n

* CHECK dout0_77 Vdout0_77ck160 = 0.9 time = 805
.meas tran vdout0_77ck160 FIND v(dout0_77) AT=805.025n

* CHECK dout0_78 Vdout0_78ck160 = 0.9 time = 805
.meas tran vdout0_78ck160 FIND v(dout0_78) AT=805.025n

* CHECK dout0_79 Vdout0_79ck160 = 0 time = 805
.meas tran vdout0_79ck160 FIND v(dout0_79) AT=805.025n

* CHECK dout0_0 Vdout0_0ck161 = 0.9 time = 810
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=810.025n

* CHECK dout0_1 Vdout0_1ck161 = 0.9 time = 810
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=810.025n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 810
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=810.025n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 810
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=810.025n

* CHECK dout0_4 Vdout0_4ck161 = 0.9 time = 810
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=810.025n

* CHECK dout0_5 Vdout0_5ck161 = 0.9 time = 810
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=810.025n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 810
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=810.025n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 810
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=810.025n

* CHECK dout0_8 Vdout0_8ck161 = 0.9 time = 810
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=810.025n

* CHECK dout0_9 Vdout0_9ck161 = 0.9 time = 810
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=810.025n

* CHECK dout0_10 Vdout0_10ck161 = 0.9 time = 810
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=810.025n

* CHECK dout0_11 Vdout0_11ck161 = 0 time = 810
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=810.025n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 810
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=810.025n

* CHECK dout0_13 Vdout0_13ck161 = 0.9 time = 810
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=810.025n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 810
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=810.025n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 810
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=810.025n

* CHECK dout0_16 Vdout0_16ck161 = 0.9 time = 810
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=810.025n

* CHECK dout0_17 Vdout0_17ck161 = 0.9 time = 810
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=810.025n

* CHECK dout0_18 Vdout0_18ck161 = 0.9 time = 810
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=810.025n

* CHECK dout0_19 Vdout0_19ck161 = 0.9 time = 810
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=810.025n

* CHECK dout0_20 Vdout0_20ck161 = 0 time = 810
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=810.025n

* CHECK dout0_21 Vdout0_21ck161 = 0.9 time = 810
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=810.025n

* CHECK dout0_22 Vdout0_22ck161 = 0.9 time = 810
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=810.025n

* CHECK dout0_23 Vdout0_23ck161 = 0.9 time = 810
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=810.025n

* CHECK dout0_24 Vdout0_24ck161 = 0 time = 810
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=810.025n

* CHECK dout0_25 Vdout0_25ck161 = 0.9 time = 810
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=810.025n

* CHECK dout0_26 Vdout0_26ck161 = 0.9 time = 810
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=810.025n

* CHECK dout0_27 Vdout0_27ck161 = 0.9 time = 810
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=810.025n

* CHECK dout0_28 Vdout0_28ck161 = 0 time = 810
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=810.025n

* CHECK dout0_29 Vdout0_29ck161 = 0 time = 810
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=810.025n

* CHECK dout0_30 Vdout0_30ck161 = 0.9 time = 810
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=810.025n

* CHECK dout0_31 Vdout0_31ck161 = 0 time = 810
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=810.025n

* CHECK dout0_32 Vdout0_32ck161 = 0.9 time = 810
.meas tran vdout0_32ck161 FIND v(dout0_32) AT=810.025n

* CHECK dout0_33 Vdout0_33ck161 = 0 time = 810
.meas tran vdout0_33ck161 FIND v(dout0_33) AT=810.025n

* CHECK dout0_34 Vdout0_34ck161 = 0.9 time = 810
.meas tran vdout0_34ck161 FIND v(dout0_34) AT=810.025n

* CHECK dout0_35 Vdout0_35ck161 = 0.9 time = 810
.meas tran vdout0_35ck161 FIND v(dout0_35) AT=810.025n

* CHECK dout0_36 Vdout0_36ck161 = 0 time = 810
.meas tran vdout0_36ck161 FIND v(dout0_36) AT=810.025n

* CHECK dout0_37 Vdout0_37ck161 = 0.9 time = 810
.meas tran vdout0_37ck161 FIND v(dout0_37) AT=810.025n

* CHECK dout0_38 Vdout0_38ck161 = 0.9 time = 810
.meas tran vdout0_38ck161 FIND v(dout0_38) AT=810.025n

* CHECK dout0_39 Vdout0_39ck161 = 0 time = 810
.meas tran vdout0_39ck161 FIND v(dout0_39) AT=810.025n

* CHECK dout0_40 Vdout0_40ck161 = 0 time = 810
.meas tran vdout0_40ck161 FIND v(dout0_40) AT=810.025n

* CHECK dout0_41 Vdout0_41ck161 = 0 time = 810
.meas tran vdout0_41ck161 FIND v(dout0_41) AT=810.025n

* CHECK dout0_42 Vdout0_42ck161 = 0 time = 810
.meas tran vdout0_42ck161 FIND v(dout0_42) AT=810.025n

* CHECK dout0_43 Vdout0_43ck161 = 0 time = 810
.meas tran vdout0_43ck161 FIND v(dout0_43) AT=810.025n

* CHECK dout0_44 Vdout0_44ck161 = 0 time = 810
.meas tran vdout0_44ck161 FIND v(dout0_44) AT=810.025n

* CHECK dout0_45 Vdout0_45ck161 = 0 time = 810
.meas tran vdout0_45ck161 FIND v(dout0_45) AT=810.025n

* CHECK dout0_46 Vdout0_46ck161 = 0.9 time = 810
.meas tran vdout0_46ck161 FIND v(dout0_46) AT=810.025n

* CHECK dout0_47 Vdout0_47ck161 = 0.9 time = 810
.meas tran vdout0_47ck161 FIND v(dout0_47) AT=810.025n

* CHECK dout0_48 Vdout0_48ck161 = 0.9 time = 810
.meas tran vdout0_48ck161 FIND v(dout0_48) AT=810.025n

* CHECK dout0_49 Vdout0_49ck161 = 0.9 time = 810
.meas tran vdout0_49ck161 FIND v(dout0_49) AT=810.025n

* CHECK dout0_50 Vdout0_50ck161 = 0.9 time = 810
.meas tran vdout0_50ck161 FIND v(dout0_50) AT=810.025n

* CHECK dout0_51 Vdout0_51ck161 = 0.9 time = 810
.meas tran vdout0_51ck161 FIND v(dout0_51) AT=810.025n

* CHECK dout0_52 Vdout0_52ck161 = 0 time = 810
.meas tran vdout0_52ck161 FIND v(dout0_52) AT=810.025n

* CHECK dout0_53 Vdout0_53ck161 = 0 time = 810
.meas tran vdout0_53ck161 FIND v(dout0_53) AT=810.025n

* CHECK dout0_54 Vdout0_54ck161 = 0 time = 810
.meas tran vdout0_54ck161 FIND v(dout0_54) AT=810.025n

* CHECK dout0_55 Vdout0_55ck161 = 0.9 time = 810
.meas tran vdout0_55ck161 FIND v(dout0_55) AT=810.025n

* CHECK dout0_56 Vdout0_56ck161 = 0.9 time = 810
.meas tran vdout0_56ck161 FIND v(dout0_56) AT=810.025n

* CHECK dout0_57 Vdout0_57ck161 = 0.9 time = 810
.meas tran vdout0_57ck161 FIND v(dout0_57) AT=810.025n

* CHECK dout0_58 Vdout0_58ck161 = 0 time = 810
.meas tran vdout0_58ck161 FIND v(dout0_58) AT=810.025n

* CHECK dout0_59 Vdout0_59ck161 = 0.9 time = 810
.meas tran vdout0_59ck161 FIND v(dout0_59) AT=810.025n

* CHECK dout0_60 Vdout0_60ck161 = 0 time = 810
.meas tran vdout0_60ck161 FIND v(dout0_60) AT=810.025n

* CHECK dout0_61 Vdout0_61ck161 = 0 time = 810
.meas tran vdout0_61ck161 FIND v(dout0_61) AT=810.025n

* CHECK dout0_62 Vdout0_62ck161 = 0.9 time = 810
.meas tran vdout0_62ck161 FIND v(dout0_62) AT=810.025n

* CHECK dout0_63 Vdout0_63ck161 = 0.9 time = 810
.meas tran vdout0_63ck161 FIND v(dout0_63) AT=810.025n

* CHECK dout0_64 Vdout0_64ck161 = 0 time = 810
.meas tran vdout0_64ck161 FIND v(dout0_64) AT=810.025n

* CHECK dout0_65 Vdout0_65ck161 = 0 time = 810
.meas tran vdout0_65ck161 FIND v(dout0_65) AT=810.025n

* CHECK dout0_66 Vdout0_66ck161 = 0.9 time = 810
.meas tran vdout0_66ck161 FIND v(dout0_66) AT=810.025n

* CHECK dout0_67 Vdout0_67ck161 = 0 time = 810
.meas tran vdout0_67ck161 FIND v(dout0_67) AT=810.025n

* CHECK dout0_68 Vdout0_68ck161 = 0.9 time = 810
.meas tran vdout0_68ck161 FIND v(dout0_68) AT=810.025n

* CHECK dout0_69 Vdout0_69ck161 = 0.9 time = 810
.meas tran vdout0_69ck161 FIND v(dout0_69) AT=810.025n

* CHECK dout0_70 Vdout0_70ck161 = 0.9 time = 810
.meas tran vdout0_70ck161 FIND v(dout0_70) AT=810.025n

* CHECK dout0_71 Vdout0_71ck161 = 0.9 time = 810
.meas tran vdout0_71ck161 FIND v(dout0_71) AT=810.025n

* CHECK dout0_72 Vdout0_72ck161 = 0.9 time = 810
.meas tran vdout0_72ck161 FIND v(dout0_72) AT=810.025n

* CHECK dout0_73 Vdout0_73ck161 = 0.9 time = 810
.meas tran vdout0_73ck161 FIND v(dout0_73) AT=810.025n

* CHECK dout0_74 Vdout0_74ck161 = 0.9 time = 810
.meas tran vdout0_74ck161 FIND v(dout0_74) AT=810.025n

* CHECK dout0_75 Vdout0_75ck161 = 0 time = 810
.meas tran vdout0_75ck161 FIND v(dout0_75) AT=810.025n

* CHECK dout0_76 Vdout0_76ck161 = 0 time = 810
.meas tran vdout0_76ck161 FIND v(dout0_76) AT=810.025n

* CHECK dout0_77 Vdout0_77ck161 = 0.9 time = 810
.meas tran vdout0_77ck161 FIND v(dout0_77) AT=810.025n

* CHECK dout0_78 Vdout0_78ck161 = 0.9 time = 810
.meas tran vdout0_78ck161 FIND v(dout0_78) AT=810.025n

* CHECK dout0_79 Vdout0_79ck161 = 0 time = 810
.meas tran vdout0_79ck161 FIND v(dout0_79) AT=810.025n

* CHECK dout0_0 Vdout0_0ck163 = 0 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0.9 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 0.9 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0.9 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0.9 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0.9 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 0.9 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0.9 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0.9 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0.9 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0.9 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 0 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0.9 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 0.9 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 0 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0.9 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0.9 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0.9 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0.9 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0.9 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 0.9 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0.9 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0.9 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 0.9 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_32 Vdout0_32ck163 = 0 time = 820
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=820.025n

* CHECK dout0_33 Vdout0_33ck163 = 0.9 time = 820
.meas tran vdout0_33ck163 FIND v(dout0_33) AT=820.025n

* CHECK dout0_34 Vdout0_34ck163 = 0 time = 820
.meas tran vdout0_34ck163 FIND v(dout0_34) AT=820.025n

* CHECK dout0_35 Vdout0_35ck163 = 0 time = 820
.meas tran vdout0_35ck163 FIND v(dout0_35) AT=820.025n

* CHECK dout0_36 Vdout0_36ck163 = 0 time = 820
.meas tran vdout0_36ck163 FIND v(dout0_36) AT=820.025n

* CHECK dout0_37 Vdout0_37ck163 = 0.9 time = 820
.meas tran vdout0_37ck163 FIND v(dout0_37) AT=820.025n

* CHECK dout0_38 Vdout0_38ck163 = 0.9 time = 820
.meas tran vdout0_38ck163 FIND v(dout0_38) AT=820.025n

* CHECK dout0_39 Vdout0_39ck163 = 0.9 time = 820
.meas tran vdout0_39ck163 FIND v(dout0_39) AT=820.025n

* CHECK dout0_40 Vdout0_40ck163 = 0 time = 820
.meas tran vdout0_40ck163 FIND v(dout0_40) AT=820.025n

* CHECK dout0_41 Vdout0_41ck163 = 0.9 time = 820
.meas tran vdout0_41ck163 FIND v(dout0_41) AT=820.025n

* CHECK dout0_42 Vdout0_42ck163 = 0 time = 820
.meas tran vdout0_42ck163 FIND v(dout0_42) AT=820.025n

* CHECK dout0_43 Vdout0_43ck163 = 0 time = 820
.meas tran vdout0_43ck163 FIND v(dout0_43) AT=820.025n

* CHECK dout0_44 Vdout0_44ck163 = 0.9 time = 820
.meas tran vdout0_44ck163 FIND v(dout0_44) AT=820.025n

* CHECK dout0_45 Vdout0_45ck163 = 0 time = 820
.meas tran vdout0_45ck163 FIND v(dout0_45) AT=820.025n

* CHECK dout0_46 Vdout0_46ck163 = 0.9 time = 820
.meas tran vdout0_46ck163 FIND v(dout0_46) AT=820.025n

* CHECK dout0_47 Vdout0_47ck163 = 0.9 time = 820
.meas tran vdout0_47ck163 FIND v(dout0_47) AT=820.025n

* CHECK dout0_48 Vdout0_48ck163 = 0.9 time = 820
.meas tran vdout0_48ck163 FIND v(dout0_48) AT=820.025n

* CHECK dout0_49 Vdout0_49ck163 = 0 time = 820
.meas tran vdout0_49ck163 FIND v(dout0_49) AT=820.025n

* CHECK dout0_50 Vdout0_50ck163 = 0.9 time = 820
.meas tran vdout0_50ck163 FIND v(dout0_50) AT=820.025n

* CHECK dout0_51 Vdout0_51ck163 = 0.9 time = 820
.meas tran vdout0_51ck163 FIND v(dout0_51) AT=820.025n

* CHECK dout0_52 Vdout0_52ck163 = 0.9 time = 820
.meas tran vdout0_52ck163 FIND v(dout0_52) AT=820.025n

* CHECK dout0_53 Vdout0_53ck163 = 0 time = 820
.meas tran vdout0_53ck163 FIND v(dout0_53) AT=820.025n

* CHECK dout0_54 Vdout0_54ck163 = 0.9 time = 820
.meas tran vdout0_54ck163 FIND v(dout0_54) AT=820.025n

* CHECK dout0_55 Vdout0_55ck163 = 0.9 time = 820
.meas tran vdout0_55ck163 FIND v(dout0_55) AT=820.025n

* CHECK dout0_56 Vdout0_56ck163 = 0.9 time = 820
.meas tran vdout0_56ck163 FIND v(dout0_56) AT=820.025n

* CHECK dout0_57 Vdout0_57ck163 = 0 time = 820
.meas tran vdout0_57ck163 FIND v(dout0_57) AT=820.025n

* CHECK dout0_58 Vdout0_58ck163 = 0 time = 820
.meas tran vdout0_58ck163 FIND v(dout0_58) AT=820.025n

* CHECK dout0_59 Vdout0_59ck163 = 0 time = 820
.meas tran vdout0_59ck163 FIND v(dout0_59) AT=820.025n

* CHECK dout0_60 Vdout0_60ck163 = 0.9 time = 820
.meas tran vdout0_60ck163 FIND v(dout0_60) AT=820.025n

* CHECK dout0_61 Vdout0_61ck163 = 0 time = 820
.meas tran vdout0_61ck163 FIND v(dout0_61) AT=820.025n

* CHECK dout0_62 Vdout0_62ck163 = 0 time = 820
.meas tran vdout0_62ck163 FIND v(dout0_62) AT=820.025n

* CHECK dout0_63 Vdout0_63ck163 = 0 time = 820
.meas tran vdout0_63ck163 FIND v(dout0_63) AT=820.025n

* CHECK dout0_64 Vdout0_64ck163 = 0.9 time = 820
.meas tran vdout0_64ck163 FIND v(dout0_64) AT=820.025n

* CHECK dout0_65 Vdout0_65ck163 = 0.9 time = 820
.meas tran vdout0_65ck163 FIND v(dout0_65) AT=820.025n

* CHECK dout0_66 Vdout0_66ck163 = 0.9 time = 820
.meas tran vdout0_66ck163 FIND v(dout0_66) AT=820.025n

* CHECK dout0_67 Vdout0_67ck163 = 0.9 time = 820
.meas tran vdout0_67ck163 FIND v(dout0_67) AT=820.025n

* CHECK dout0_68 Vdout0_68ck163 = 0 time = 820
.meas tran vdout0_68ck163 FIND v(dout0_68) AT=820.025n

* CHECK dout0_69 Vdout0_69ck163 = 0 time = 820
.meas tran vdout0_69ck163 FIND v(dout0_69) AT=820.025n

* CHECK dout0_70 Vdout0_70ck163 = 0 time = 820
.meas tran vdout0_70ck163 FIND v(dout0_70) AT=820.025n

* CHECK dout0_71 Vdout0_71ck163 = 0 time = 820
.meas tran vdout0_71ck163 FIND v(dout0_71) AT=820.025n

* CHECK dout0_72 Vdout0_72ck163 = 0 time = 820
.meas tran vdout0_72ck163 FIND v(dout0_72) AT=820.025n

* CHECK dout0_73 Vdout0_73ck163 = 0.9 time = 820
.meas tran vdout0_73ck163 FIND v(dout0_73) AT=820.025n

* CHECK dout0_74 Vdout0_74ck163 = 0 time = 820
.meas tran vdout0_74ck163 FIND v(dout0_74) AT=820.025n

* CHECK dout0_75 Vdout0_75ck163 = 0.9 time = 820
.meas tran vdout0_75ck163 FIND v(dout0_75) AT=820.025n

* CHECK dout0_76 Vdout0_76ck163 = 0.9 time = 820
.meas tran vdout0_76ck163 FIND v(dout0_76) AT=820.025n

* CHECK dout0_77 Vdout0_77ck163 = 0 time = 820
.meas tran vdout0_77ck163 FIND v(dout0_77) AT=820.025n

* CHECK dout0_78 Vdout0_78ck163 = 0.9 time = 820
.meas tran vdout0_78ck163 FIND v(dout0_78) AT=820.025n

* CHECK dout0_79 Vdout0_79ck163 = 0.9 time = 820
.meas tran vdout0_79ck163 FIND v(dout0_79) AT=820.025n

* CHECK dout0_0 Vdout0_0ck164 = 0 time = 825
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=825.025n

* CHECK dout0_1 Vdout0_1ck164 = 0.9 time = 825
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=825.025n

* CHECK dout0_2 Vdout0_2ck164 = 0.9 time = 825
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=825.025n

* CHECK dout0_3 Vdout0_3ck164 = 0.9 time = 825
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=825.025n

* CHECK dout0_4 Vdout0_4ck164 = 0.9 time = 825
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=825.025n

* CHECK dout0_5 Vdout0_5ck164 = 0.9 time = 825
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=825.025n

* CHECK dout0_6 Vdout0_6ck164 = 0.9 time = 825
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=825.025n

* CHECK dout0_7 Vdout0_7ck164 = 0.9 time = 825
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=825.025n

* CHECK dout0_8 Vdout0_8ck164 = 0 time = 825
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=825.025n

* CHECK dout0_9 Vdout0_9ck164 = 0.9 time = 825
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=825.025n

* CHECK dout0_10 Vdout0_10ck164 = 0.9 time = 825
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=825.025n

* CHECK dout0_11 Vdout0_11ck164 = 0.9 time = 825
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=825.025n

* CHECK dout0_12 Vdout0_12ck164 = 0 time = 825
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=825.025n

* CHECK dout0_13 Vdout0_13ck164 = 0 time = 825
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=825.025n

* CHECK dout0_14 Vdout0_14ck164 = 0 time = 825
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=825.025n

* CHECK dout0_15 Vdout0_15ck164 = 0 time = 825
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=825.025n

* CHECK dout0_16 Vdout0_16ck164 = 0.9 time = 825
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=825.025n

* CHECK dout0_17 Vdout0_17ck164 = 0.9 time = 825
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=825.025n

* CHECK dout0_18 Vdout0_18ck164 = 0 time = 825
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=825.025n

* CHECK dout0_19 Vdout0_19ck164 = 0 time = 825
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=825.025n

* CHECK dout0_20 Vdout0_20ck164 = 0.9 time = 825
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=825.025n

* CHECK dout0_21 Vdout0_21ck164 = 0.9 time = 825
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=825.025n

* CHECK dout0_22 Vdout0_22ck164 = 0.9 time = 825
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=825.025n

* CHECK dout0_23 Vdout0_23ck164 = 0 time = 825
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=825.025n

* CHECK dout0_24 Vdout0_24ck164 = 0 time = 825
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=825.025n

* CHECK dout0_25 Vdout0_25ck164 = 0.9 time = 825
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=825.025n

* CHECK dout0_26 Vdout0_26ck164 = 0 time = 825
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=825.025n

* CHECK dout0_27 Vdout0_27ck164 = 0.9 time = 825
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=825.025n

* CHECK dout0_28 Vdout0_28ck164 = 0.9 time = 825
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=825.025n

* CHECK dout0_29 Vdout0_29ck164 = 0.9 time = 825
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=825.025n

* CHECK dout0_30 Vdout0_30ck164 = 0.9 time = 825
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=825.025n

* CHECK dout0_31 Vdout0_31ck164 = 0.9 time = 825
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=825.025n

* CHECK dout0_32 Vdout0_32ck164 = 0 time = 825
.meas tran vdout0_32ck164 FIND v(dout0_32) AT=825.025n

* CHECK dout0_33 Vdout0_33ck164 = 0.9 time = 825
.meas tran vdout0_33ck164 FIND v(dout0_33) AT=825.025n

* CHECK dout0_34 Vdout0_34ck164 = 0 time = 825
.meas tran vdout0_34ck164 FIND v(dout0_34) AT=825.025n

* CHECK dout0_35 Vdout0_35ck164 = 0 time = 825
.meas tran vdout0_35ck164 FIND v(dout0_35) AT=825.025n

* CHECK dout0_36 Vdout0_36ck164 = 0 time = 825
.meas tran vdout0_36ck164 FIND v(dout0_36) AT=825.025n

* CHECK dout0_37 Vdout0_37ck164 = 0.9 time = 825
.meas tran vdout0_37ck164 FIND v(dout0_37) AT=825.025n

* CHECK dout0_38 Vdout0_38ck164 = 0.9 time = 825
.meas tran vdout0_38ck164 FIND v(dout0_38) AT=825.025n

* CHECK dout0_39 Vdout0_39ck164 = 0.9 time = 825
.meas tran vdout0_39ck164 FIND v(dout0_39) AT=825.025n

* CHECK dout0_40 Vdout0_40ck164 = 0 time = 825
.meas tran vdout0_40ck164 FIND v(dout0_40) AT=825.025n

* CHECK dout0_41 Vdout0_41ck164 = 0.9 time = 825
.meas tran vdout0_41ck164 FIND v(dout0_41) AT=825.025n

* CHECK dout0_42 Vdout0_42ck164 = 0 time = 825
.meas tran vdout0_42ck164 FIND v(dout0_42) AT=825.025n

* CHECK dout0_43 Vdout0_43ck164 = 0 time = 825
.meas tran vdout0_43ck164 FIND v(dout0_43) AT=825.025n

* CHECK dout0_44 Vdout0_44ck164 = 0.9 time = 825
.meas tran vdout0_44ck164 FIND v(dout0_44) AT=825.025n

* CHECK dout0_45 Vdout0_45ck164 = 0 time = 825
.meas tran vdout0_45ck164 FIND v(dout0_45) AT=825.025n

* CHECK dout0_46 Vdout0_46ck164 = 0.9 time = 825
.meas tran vdout0_46ck164 FIND v(dout0_46) AT=825.025n

* CHECK dout0_47 Vdout0_47ck164 = 0.9 time = 825
.meas tran vdout0_47ck164 FIND v(dout0_47) AT=825.025n

* CHECK dout0_48 Vdout0_48ck164 = 0.9 time = 825
.meas tran vdout0_48ck164 FIND v(dout0_48) AT=825.025n

* CHECK dout0_49 Vdout0_49ck164 = 0 time = 825
.meas tran vdout0_49ck164 FIND v(dout0_49) AT=825.025n

* CHECK dout0_50 Vdout0_50ck164 = 0.9 time = 825
.meas tran vdout0_50ck164 FIND v(dout0_50) AT=825.025n

* CHECK dout0_51 Vdout0_51ck164 = 0.9 time = 825
.meas tran vdout0_51ck164 FIND v(dout0_51) AT=825.025n

* CHECK dout0_52 Vdout0_52ck164 = 0.9 time = 825
.meas tran vdout0_52ck164 FIND v(dout0_52) AT=825.025n

* CHECK dout0_53 Vdout0_53ck164 = 0 time = 825
.meas tran vdout0_53ck164 FIND v(dout0_53) AT=825.025n

* CHECK dout0_54 Vdout0_54ck164 = 0.9 time = 825
.meas tran vdout0_54ck164 FIND v(dout0_54) AT=825.025n

* CHECK dout0_55 Vdout0_55ck164 = 0.9 time = 825
.meas tran vdout0_55ck164 FIND v(dout0_55) AT=825.025n

* CHECK dout0_56 Vdout0_56ck164 = 0.9 time = 825
.meas tran vdout0_56ck164 FIND v(dout0_56) AT=825.025n

* CHECK dout0_57 Vdout0_57ck164 = 0 time = 825
.meas tran vdout0_57ck164 FIND v(dout0_57) AT=825.025n

* CHECK dout0_58 Vdout0_58ck164 = 0 time = 825
.meas tran vdout0_58ck164 FIND v(dout0_58) AT=825.025n

* CHECK dout0_59 Vdout0_59ck164 = 0 time = 825
.meas tran vdout0_59ck164 FIND v(dout0_59) AT=825.025n

* CHECK dout0_60 Vdout0_60ck164 = 0.9 time = 825
.meas tran vdout0_60ck164 FIND v(dout0_60) AT=825.025n

* CHECK dout0_61 Vdout0_61ck164 = 0 time = 825
.meas tran vdout0_61ck164 FIND v(dout0_61) AT=825.025n

* CHECK dout0_62 Vdout0_62ck164 = 0 time = 825
.meas tran vdout0_62ck164 FIND v(dout0_62) AT=825.025n

* CHECK dout0_63 Vdout0_63ck164 = 0 time = 825
.meas tran vdout0_63ck164 FIND v(dout0_63) AT=825.025n

* CHECK dout0_64 Vdout0_64ck164 = 0.9 time = 825
.meas tran vdout0_64ck164 FIND v(dout0_64) AT=825.025n

* CHECK dout0_65 Vdout0_65ck164 = 0.9 time = 825
.meas tran vdout0_65ck164 FIND v(dout0_65) AT=825.025n

* CHECK dout0_66 Vdout0_66ck164 = 0.9 time = 825
.meas tran vdout0_66ck164 FIND v(dout0_66) AT=825.025n

* CHECK dout0_67 Vdout0_67ck164 = 0.9 time = 825
.meas tran vdout0_67ck164 FIND v(dout0_67) AT=825.025n

* CHECK dout0_68 Vdout0_68ck164 = 0 time = 825
.meas tran vdout0_68ck164 FIND v(dout0_68) AT=825.025n

* CHECK dout0_69 Vdout0_69ck164 = 0 time = 825
.meas tran vdout0_69ck164 FIND v(dout0_69) AT=825.025n

* CHECK dout0_70 Vdout0_70ck164 = 0 time = 825
.meas tran vdout0_70ck164 FIND v(dout0_70) AT=825.025n

* CHECK dout0_71 Vdout0_71ck164 = 0 time = 825
.meas tran vdout0_71ck164 FIND v(dout0_71) AT=825.025n

* CHECK dout0_72 Vdout0_72ck164 = 0 time = 825
.meas tran vdout0_72ck164 FIND v(dout0_72) AT=825.025n

* CHECK dout0_73 Vdout0_73ck164 = 0.9 time = 825
.meas tran vdout0_73ck164 FIND v(dout0_73) AT=825.025n

* CHECK dout0_74 Vdout0_74ck164 = 0 time = 825
.meas tran vdout0_74ck164 FIND v(dout0_74) AT=825.025n

* CHECK dout0_75 Vdout0_75ck164 = 0.9 time = 825
.meas tran vdout0_75ck164 FIND v(dout0_75) AT=825.025n

* CHECK dout0_76 Vdout0_76ck164 = 0.9 time = 825
.meas tran vdout0_76ck164 FIND v(dout0_76) AT=825.025n

* CHECK dout0_77 Vdout0_77ck164 = 0 time = 825
.meas tran vdout0_77ck164 FIND v(dout0_77) AT=825.025n

* CHECK dout0_78 Vdout0_78ck164 = 0.9 time = 825
.meas tran vdout0_78ck164 FIND v(dout0_78) AT=825.025n

* CHECK dout0_79 Vdout0_79ck164 = 0.9 time = 825
.meas tran vdout0_79ck164 FIND v(dout0_79) AT=825.025n

* CHECK dout0_0 Vdout0_0ck176 = 0.9 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 0.9 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 0.9 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 0.9 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 0.9 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 0.9 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0.9 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 0.9 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0.9 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 0.9 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 0 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 0.9 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 0 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 0 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 0 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0.9 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0.9 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 0.9 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 0.9 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0.9 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 0 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 0 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_32 Vdout0_32ck176 = 0.9 time = 885
.meas tran vdout0_32ck176 FIND v(dout0_32) AT=885.025n

* CHECK dout0_33 Vdout0_33ck176 = 0 time = 885
.meas tran vdout0_33ck176 FIND v(dout0_33) AT=885.025n

* CHECK dout0_34 Vdout0_34ck176 = 0 time = 885
.meas tran vdout0_34ck176 FIND v(dout0_34) AT=885.025n

* CHECK dout0_35 Vdout0_35ck176 = 0 time = 885
.meas tran vdout0_35ck176 FIND v(dout0_35) AT=885.025n

* CHECK dout0_36 Vdout0_36ck176 = 0 time = 885
.meas tran vdout0_36ck176 FIND v(dout0_36) AT=885.025n

* CHECK dout0_37 Vdout0_37ck176 = 0.9 time = 885
.meas tran vdout0_37ck176 FIND v(dout0_37) AT=885.025n

* CHECK dout0_38 Vdout0_38ck176 = 0.9 time = 885
.meas tran vdout0_38ck176 FIND v(dout0_38) AT=885.025n

* CHECK dout0_39 Vdout0_39ck176 = 0 time = 885
.meas tran vdout0_39ck176 FIND v(dout0_39) AT=885.025n

* CHECK dout0_40 Vdout0_40ck176 = 0 time = 885
.meas tran vdout0_40ck176 FIND v(dout0_40) AT=885.025n

* CHECK dout0_41 Vdout0_41ck176 = 0 time = 885
.meas tran vdout0_41ck176 FIND v(dout0_41) AT=885.025n

* CHECK dout0_42 Vdout0_42ck176 = 0 time = 885
.meas tran vdout0_42ck176 FIND v(dout0_42) AT=885.025n

* CHECK dout0_43 Vdout0_43ck176 = 0 time = 885
.meas tran vdout0_43ck176 FIND v(dout0_43) AT=885.025n

* CHECK dout0_44 Vdout0_44ck176 = 0.9 time = 885
.meas tran vdout0_44ck176 FIND v(dout0_44) AT=885.025n

* CHECK dout0_45 Vdout0_45ck176 = 0.9 time = 885
.meas tran vdout0_45ck176 FIND v(dout0_45) AT=885.025n

* CHECK dout0_46 Vdout0_46ck176 = 0.9 time = 885
.meas tran vdout0_46ck176 FIND v(dout0_46) AT=885.025n

* CHECK dout0_47 Vdout0_47ck176 = 0.9 time = 885
.meas tran vdout0_47ck176 FIND v(dout0_47) AT=885.025n

* CHECK dout0_48 Vdout0_48ck176 = 0.9 time = 885
.meas tran vdout0_48ck176 FIND v(dout0_48) AT=885.025n

* CHECK dout0_49 Vdout0_49ck176 = 0 time = 885
.meas tran vdout0_49ck176 FIND v(dout0_49) AT=885.025n

* CHECK dout0_50 Vdout0_50ck176 = 0 time = 885
.meas tran vdout0_50ck176 FIND v(dout0_50) AT=885.025n

* CHECK dout0_51 Vdout0_51ck176 = 0 time = 885
.meas tran vdout0_51ck176 FIND v(dout0_51) AT=885.025n

* CHECK dout0_52 Vdout0_52ck176 = 0 time = 885
.meas tran vdout0_52ck176 FIND v(dout0_52) AT=885.025n

* CHECK dout0_53 Vdout0_53ck176 = 0 time = 885
.meas tran vdout0_53ck176 FIND v(dout0_53) AT=885.025n

* CHECK dout0_54 Vdout0_54ck176 = 0.9 time = 885
.meas tran vdout0_54ck176 FIND v(dout0_54) AT=885.025n

* CHECK dout0_55 Vdout0_55ck176 = 0 time = 885
.meas tran vdout0_55ck176 FIND v(dout0_55) AT=885.025n

* CHECK dout0_56 Vdout0_56ck176 = 0 time = 885
.meas tran vdout0_56ck176 FIND v(dout0_56) AT=885.025n

* CHECK dout0_57 Vdout0_57ck176 = 0.9 time = 885
.meas tran vdout0_57ck176 FIND v(dout0_57) AT=885.025n

* CHECK dout0_58 Vdout0_58ck176 = 0 time = 885
.meas tran vdout0_58ck176 FIND v(dout0_58) AT=885.025n

* CHECK dout0_59 Vdout0_59ck176 = 0 time = 885
.meas tran vdout0_59ck176 FIND v(dout0_59) AT=885.025n

* CHECK dout0_60 Vdout0_60ck176 = 0 time = 885
.meas tran vdout0_60ck176 FIND v(dout0_60) AT=885.025n

* CHECK dout0_61 Vdout0_61ck176 = 0.9 time = 885
.meas tran vdout0_61ck176 FIND v(dout0_61) AT=885.025n

* CHECK dout0_62 Vdout0_62ck176 = 0.9 time = 885
.meas tran vdout0_62ck176 FIND v(dout0_62) AT=885.025n

* CHECK dout0_63 Vdout0_63ck176 = 0.9 time = 885
.meas tran vdout0_63ck176 FIND v(dout0_63) AT=885.025n

* CHECK dout0_64 Vdout0_64ck176 = 0 time = 885
.meas tran vdout0_64ck176 FIND v(dout0_64) AT=885.025n

* CHECK dout0_65 Vdout0_65ck176 = 0.9 time = 885
.meas tran vdout0_65ck176 FIND v(dout0_65) AT=885.025n

* CHECK dout0_66 Vdout0_66ck176 = 0 time = 885
.meas tran vdout0_66ck176 FIND v(dout0_66) AT=885.025n

* CHECK dout0_67 Vdout0_67ck176 = 0 time = 885
.meas tran vdout0_67ck176 FIND v(dout0_67) AT=885.025n

* CHECK dout0_68 Vdout0_68ck176 = 0.9 time = 885
.meas tran vdout0_68ck176 FIND v(dout0_68) AT=885.025n

* CHECK dout0_69 Vdout0_69ck176 = 0 time = 885
.meas tran vdout0_69ck176 FIND v(dout0_69) AT=885.025n

* CHECK dout0_70 Vdout0_70ck176 = 0 time = 885
.meas tran vdout0_70ck176 FIND v(dout0_70) AT=885.025n

* CHECK dout0_71 Vdout0_71ck176 = 0 time = 885
.meas tran vdout0_71ck176 FIND v(dout0_71) AT=885.025n

* CHECK dout0_72 Vdout0_72ck176 = 0.9 time = 885
.meas tran vdout0_72ck176 FIND v(dout0_72) AT=885.025n

* CHECK dout0_73 Vdout0_73ck176 = 0.9 time = 885
.meas tran vdout0_73ck176 FIND v(dout0_73) AT=885.025n

* CHECK dout0_74 Vdout0_74ck176 = 0 time = 885
.meas tran vdout0_74ck176 FIND v(dout0_74) AT=885.025n

* CHECK dout0_75 Vdout0_75ck176 = 0.9 time = 885
.meas tran vdout0_75ck176 FIND v(dout0_75) AT=885.025n

* CHECK dout0_76 Vdout0_76ck176 = 0.9 time = 885
.meas tran vdout0_76ck176 FIND v(dout0_76) AT=885.025n

* CHECK dout0_77 Vdout0_77ck176 = 0 time = 885
.meas tran vdout0_77ck176 FIND v(dout0_77) AT=885.025n

* CHECK dout0_78 Vdout0_78ck176 = 0 time = 885
.meas tran vdout0_78ck176 FIND v(dout0_78) AT=885.025n

* CHECK dout0_79 Vdout0_79ck176 = 0.9 time = 885
.meas tran vdout0_79ck176 FIND v(dout0_79) AT=885.025n

* CHECK dout0_0 Vdout0_0ck181 = 0.9 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0.9 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 0 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0.9 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 0.9 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 0 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0.9 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0.9 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 0.9 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0.9 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 0.9 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 0.9 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 0.9 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0.9 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 0.9 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 0 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 0 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 0.9 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 0.9 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0.9 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 0.9 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0.9 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0.9 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0.9 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_32 Vdout0_32ck181 = 0 time = 910
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=910.025n

* CHECK dout0_33 Vdout0_33ck181 = 0.9 time = 910
.meas tran vdout0_33ck181 FIND v(dout0_33) AT=910.025n

* CHECK dout0_34 Vdout0_34ck181 = 0.9 time = 910
.meas tran vdout0_34ck181 FIND v(dout0_34) AT=910.025n

* CHECK dout0_35 Vdout0_35ck181 = 0 time = 910
.meas tran vdout0_35ck181 FIND v(dout0_35) AT=910.025n

* CHECK dout0_36 Vdout0_36ck181 = 0.9 time = 910
.meas tran vdout0_36ck181 FIND v(dout0_36) AT=910.025n

* CHECK dout0_37 Vdout0_37ck181 = 0.9 time = 910
.meas tran vdout0_37ck181 FIND v(dout0_37) AT=910.025n

* CHECK dout0_38 Vdout0_38ck181 = 0 time = 910
.meas tran vdout0_38ck181 FIND v(dout0_38) AT=910.025n

* CHECK dout0_39 Vdout0_39ck181 = 0.9 time = 910
.meas tran vdout0_39ck181 FIND v(dout0_39) AT=910.025n

* CHECK dout0_40 Vdout0_40ck181 = 0 time = 910
.meas tran vdout0_40ck181 FIND v(dout0_40) AT=910.025n

* CHECK dout0_41 Vdout0_41ck181 = 0.9 time = 910
.meas tran vdout0_41ck181 FIND v(dout0_41) AT=910.025n

* CHECK dout0_42 Vdout0_42ck181 = 0 time = 910
.meas tran vdout0_42ck181 FIND v(dout0_42) AT=910.025n

* CHECK dout0_43 Vdout0_43ck181 = 0 time = 910
.meas tran vdout0_43ck181 FIND v(dout0_43) AT=910.025n

* CHECK dout0_44 Vdout0_44ck181 = 0.9 time = 910
.meas tran vdout0_44ck181 FIND v(dout0_44) AT=910.025n

* CHECK dout0_45 Vdout0_45ck181 = 0 time = 910
.meas tran vdout0_45ck181 FIND v(dout0_45) AT=910.025n

* CHECK dout0_46 Vdout0_46ck181 = 0.9 time = 910
.meas tran vdout0_46ck181 FIND v(dout0_46) AT=910.025n

* CHECK dout0_47 Vdout0_47ck181 = 0 time = 910
.meas tran vdout0_47ck181 FIND v(dout0_47) AT=910.025n

* CHECK dout0_48 Vdout0_48ck181 = 0.9 time = 910
.meas tran vdout0_48ck181 FIND v(dout0_48) AT=910.025n

* CHECK dout0_49 Vdout0_49ck181 = 0.9 time = 910
.meas tran vdout0_49ck181 FIND v(dout0_49) AT=910.025n

* CHECK dout0_50 Vdout0_50ck181 = 0 time = 910
.meas tran vdout0_50ck181 FIND v(dout0_50) AT=910.025n

* CHECK dout0_51 Vdout0_51ck181 = 0 time = 910
.meas tran vdout0_51ck181 FIND v(dout0_51) AT=910.025n

* CHECK dout0_52 Vdout0_52ck181 = 0 time = 910
.meas tran vdout0_52ck181 FIND v(dout0_52) AT=910.025n

* CHECK dout0_53 Vdout0_53ck181 = 0 time = 910
.meas tran vdout0_53ck181 FIND v(dout0_53) AT=910.025n

* CHECK dout0_54 Vdout0_54ck181 = 0 time = 910
.meas tran vdout0_54ck181 FIND v(dout0_54) AT=910.025n

* CHECK dout0_55 Vdout0_55ck181 = 0.9 time = 910
.meas tran vdout0_55ck181 FIND v(dout0_55) AT=910.025n

* CHECK dout0_56 Vdout0_56ck181 = 0.9 time = 910
.meas tran vdout0_56ck181 FIND v(dout0_56) AT=910.025n

* CHECK dout0_57 Vdout0_57ck181 = 0.9 time = 910
.meas tran vdout0_57ck181 FIND v(dout0_57) AT=910.025n

* CHECK dout0_58 Vdout0_58ck181 = 0 time = 910
.meas tran vdout0_58ck181 FIND v(dout0_58) AT=910.025n

* CHECK dout0_59 Vdout0_59ck181 = 0 time = 910
.meas tran vdout0_59ck181 FIND v(dout0_59) AT=910.025n

* CHECK dout0_60 Vdout0_60ck181 = 0.9 time = 910
.meas tran vdout0_60ck181 FIND v(dout0_60) AT=910.025n

* CHECK dout0_61 Vdout0_61ck181 = 0 time = 910
.meas tran vdout0_61ck181 FIND v(dout0_61) AT=910.025n

* CHECK dout0_62 Vdout0_62ck181 = 0.9 time = 910
.meas tran vdout0_62ck181 FIND v(dout0_62) AT=910.025n

* CHECK dout0_63 Vdout0_63ck181 = 0 time = 910
.meas tran vdout0_63ck181 FIND v(dout0_63) AT=910.025n

* CHECK dout0_64 Vdout0_64ck181 = 0 time = 910
.meas tran vdout0_64ck181 FIND v(dout0_64) AT=910.025n

* CHECK dout0_65 Vdout0_65ck181 = 0 time = 910
.meas tran vdout0_65ck181 FIND v(dout0_65) AT=910.025n

* CHECK dout0_66 Vdout0_66ck181 = 0.9 time = 910
.meas tran vdout0_66ck181 FIND v(dout0_66) AT=910.025n

* CHECK dout0_67 Vdout0_67ck181 = 0.9 time = 910
.meas tran vdout0_67ck181 FIND v(dout0_67) AT=910.025n

* CHECK dout0_68 Vdout0_68ck181 = 0 time = 910
.meas tran vdout0_68ck181 FIND v(dout0_68) AT=910.025n

* CHECK dout0_69 Vdout0_69ck181 = 0.9 time = 910
.meas tran vdout0_69ck181 FIND v(dout0_69) AT=910.025n

* CHECK dout0_70 Vdout0_70ck181 = 0.9 time = 910
.meas tran vdout0_70ck181 FIND v(dout0_70) AT=910.025n

* CHECK dout0_71 Vdout0_71ck181 = 0.9 time = 910
.meas tran vdout0_71ck181 FIND v(dout0_71) AT=910.025n

* CHECK dout0_72 Vdout0_72ck181 = 0.9 time = 910
.meas tran vdout0_72ck181 FIND v(dout0_72) AT=910.025n

* CHECK dout0_73 Vdout0_73ck181 = 0 time = 910
.meas tran vdout0_73ck181 FIND v(dout0_73) AT=910.025n

* CHECK dout0_74 Vdout0_74ck181 = 0 time = 910
.meas tran vdout0_74ck181 FIND v(dout0_74) AT=910.025n

* CHECK dout0_75 Vdout0_75ck181 = 0 time = 910
.meas tran vdout0_75ck181 FIND v(dout0_75) AT=910.025n

* CHECK dout0_76 Vdout0_76ck181 = 0.9 time = 910
.meas tran vdout0_76ck181 FIND v(dout0_76) AT=910.025n

* CHECK dout0_77 Vdout0_77ck181 = 0 time = 910
.meas tran vdout0_77ck181 FIND v(dout0_77) AT=910.025n

* CHECK dout0_78 Vdout0_78ck181 = 0.9 time = 910
.meas tran vdout0_78ck181 FIND v(dout0_78) AT=910.025n

* CHECK dout0_79 Vdout0_79ck181 = 0 time = 910
.meas tran vdout0_79ck181 FIND v(dout0_79) AT=910.025n

* CHECK dout0_0 Vdout0_0ck185 = 0.9 time = 930
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=930.025n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 930
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=930.025n

* CHECK dout0_2 Vdout0_2ck185 = 0 time = 930
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=930.025n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 930
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=930.025n

* CHECK dout0_4 Vdout0_4ck185 = 0 time = 930
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=930.025n

* CHECK dout0_5 Vdout0_5ck185 = 0.9 time = 930
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=930.025n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 930
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=930.025n

* CHECK dout0_7 Vdout0_7ck185 = 0.9 time = 930
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=930.025n

* CHECK dout0_8 Vdout0_8ck185 = 0.9 time = 930
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=930.025n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 930
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=930.025n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 930
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=930.025n

* CHECK dout0_11 Vdout0_11ck185 = 0.9 time = 930
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=930.025n

* CHECK dout0_12 Vdout0_12ck185 = 0.9 time = 930
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=930.025n

* CHECK dout0_13 Vdout0_13ck185 = 0 time = 930
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=930.025n

* CHECK dout0_14 Vdout0_14ck185 = 0.9 time = 930
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=930.025n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 930
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=930.025n

* CHECK dout0_16 Vdout0_16ck185 = 0 time = 930
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=930.025n

* CHECK dout0_17 Vdout0_17ck185 = 0 time = 930
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=930.025n

* CHECK dout0_18 Vdout0_18ck185 = 0 time = 930
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=930.025n

* CHECK dout0_19 Vdout0_19ck185 = 0.9 time = 930
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=930.025n

* CHECK dout0_20 Vdout0_20ck185 = 0 time = 930
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=930.025n

* CHECK dout0_21 Vdout0_21ck185 = 0.9 time = 930
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=930.025n

* CHECK dout0_22 Vdout0_22ck185 = 0.9 time = 930
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=930.025n

* CHECK dout0_23 Vdout0_23ck185 = 0.9 time = 930
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=930.025n

* CHECK dout0_24 Vdout0_24ck185 = 0.9 time = 930
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=930.025n

* CHECK dout0_25 Vdout0_25ck185 = 0 time = 930
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=930.025n

* CHECK dout0_26 Vdout0_26ck185 = 0.9 time = 930
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=930.025n

* CHECK dout0_27 Vdout0_27ck185 = 0 time = 930
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=930.025n

* CHECK dout0_28 Vdout0_28ck185 = 0 time = 930
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=930.025n

* CHECK dout0_29 Vdout0_29ck185 = 0 time = 930
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=930.025n

* CHECK dout0_30 Vdout0_30ck185 = 0.9 time = 930
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=930.025n

* CHECK dout0_31 Vdout0_31ck185 = 0 time = 930
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=930.025n

* CHECK dout0_32 Vdout0_32ck185 = 0.9 time = 930
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=930.025n

* CHECK dout0_33 Vdout0_33ck185 = 0 time = 930
.meas tran vdout0_33ck185 FIND v(dout0_33) AT=930.025n

* CHECK dout0_34 Vdout0_34ck185 = 0 time = 930
.meas tran vdout0_34ck185 FIND v(dout0_34) AT=930.025n

* CHECK dout0_35 Vdout0_35ck185 = 0.9 time = 930
.meas tran vdout0_35ck185 FIND v(dout0_35) AT=930.025n

* CHECK dout0_36 Vdout0_36ck185 = 0.9 time = 930
.meas tran vdout0_36ck185 FIND v(dout0_36) AT=930.025n

* CHECK dout0_37 Vdout0_37ck185 = 0.9 time = 930
.meas tran vdout0_37ck185 FIND v(dout0_37) AT=930.025n

* CHECK dout0_38 Vdout0_38ck185 = 0 time = 930
.meas tran vdout0_38ck185 FIND v(dout0_38) AT=930.025n

* CHECK dout0_39 Vdout0_39ck185 = 0 time = 930
.meas tran vdout0_39ck185 FIND v(dout0_39) AT=930.025n

* CHECK dout0_40 Vdout0_40ck185 = 0.9 time = 930
.meas tran vdout0_40ck185 FIND v(dout0_40) AT=930.025n

* CHECK dout0_41 Vdout0_41ck185 = 0 time = 930
.meas tran vdout0_41ck185 FIND v(dout0_41) AT=930.025n

* CHECK dout0_42 Vdout0_42ck185 = 0 time = 930
.meas tran vdout0_42ck185 FIND v(dout0_42) AT=930.025n

* CHECK dout0_43 Vdout0_43ck185 = 0.9 time = 930
.meas tran vdout0_43ck185 FIND v(dout0_43) AT=930.025n

* CHECK dout0_44 Vdout0_44ck185 = 0.9 time = 930
.meas tran vdout0_44ck185 FIND v(dout0_44) AT=930.025n

* CHECK dout0_45 Vdout0_45ck185 = 0.9 time = 930
.meas tran vdout0_45ck185 FIND v(dout0_45) AT=930.025n

* CHECK dout0_46 Vdout0_46ck185 = 0.9 time = 930
.meas tran vdout0_46ck185 FIND v(dout0_46) AT=930.025n

* CHECK dout0_47 Vdout0_47ck185 = 0.9 time = 930
.meas tran vdout0_47ck185 FIND v(dout0_47) AT=930.025n

* CHECK dout0_48 Vdout0_48ck185 = 0.9 time = 930
.meas tran vdout0_48ck185 FIND v(dout0_48) AT=930.025n

* CHECK dout0_49 Vdout0_49ck185 = 0.9 time = 930
.meas tran vdout0_49ck185 FIND v(dout0_49) AT=930.025n

* CHECK dout0_50 Vdout0_50ck185 = 0.9 time = 930
.meas tran vdout0_50ck185 FIND v(dout0_50) AT=930.025n

* CHECK dout0_51 Vdout0_51ck185 = 0.9 time = 930
.meas tran vdout0_51ck185 FIND v(dout0_51) AT=930.025n

* CHECK dout0_52 Vdout0_52ck185 = 0 time = 930
.meas tran vdout0_52ck185 FIND v(dout0_52) AT=930.025n

* CHECK dout0_53 Vdout0_53ck185 = 0 time = 930
.meas tran vdout0_53ck185 FIND v(dout0_53) AT=930.025n

* CHECK dout0_54 Vdout0_54ck185 = 0 time = 930
.meas tran vdout0_54ck185 FIND v(dout0_54) AT=930.025n

* CHECK dout0_55 Vdout0_55ck185 = 0 time = 930
.meas tran vdout0_55ck185 FIND v(dout0_55) AT=930.025n

* CHECK dout0_56 Vdout0_56ck185 = 0.9 time = 930
.meas tran vdout0_56ck185 FIND v(dout0_56) AT=930.025n

* CHECK dout0_57 Vdout0_57ck185 = 0.9 time = 930
.meas tran vdout0_57ck185 FIND v(dout0_57) AT=930.025n

* CHECK dout0_58 Vdout0_58ck185 = 0.9 time = 930
.meas tran vdout0_58ck185 FIND v(dout0_58) AT=930.025n

* CHECK dout0_59 Vdout0_59ck185 = 0 time = 930
.meas tran vdout0_59ck185 FIND v(dout0_59) AT=930.025n

* CHECK dout0_60 Vdout0_60ck185 = 0 time = 930
.meas tran vdout0_60ck185 FIND v(dout0_60) AT=930.025n

* CHECK dout0_61 Vdout0_61ck185 = 0 time = 930
.meas tran vdout0_61ck185 FIND v(dout0_61) AT=930.025n

* CHECK dout0_62 Vdout0_62ck185 = 0 time = 930
.meas tran vdout0_62ck185 FIND v(dout0_62) AT=930.025n

* CHECK dout0_63 Vdout0_63ck185 = 0 time = 930
.meas tran vdout0_63ck185 FIND v(dout0_63) AT=930.025n

* CHECK dout0_64 Vdout0_64ck185 = 0 time = 930
.meas tran vdout0_64ck185 FIND v(dout0_64) AT=930.025n

* CHECK dout0_65 Vdout0_65ck185 = 0 time = 930
.meas tran vdout0_65ck185 FIND v(dout0_65) AT=930.025n

* CHECK dout0_66 Vdout0_66ck185 = 0.9 time = 930
.meas tran vdout0_66ck185 FIND v(dout0_66) AT=930.025n

* CHECK dout0_67 Vdout0_67ck185 = 0.9 time = 930
.meas tran vdout0_67ck185 FIND v(dout0_67) AT=930.025n

* CHECK dout0_68 Vdout0_68ck185 = 0.9 time = 930
.meas tran vdout0_68ck185 FIND v(dout0_68) AT=930.025n

* CHECK dout0_69 Vdout0_69ck185 = 0 time = 930
.meas tran vdout0_69ck185 FIND v(dout0_69) AT=930.025n

* CHECK dout0_70 Vdout0_70ck185 = 0 time = 930
.meas tran vdout0_70ck185 FIND v(dout0_70) AT=930.025n

* CHECK dout0_71 Vdout0_71ck185 = 0.9 time = 930
.meas tran vdout0_71ck185 FIND v(dout0_71) AT=930.025n

* CHECK dout0_72 Vdout0_72ck185 = 0 time = 930
.meas tran vdout0_72ck185 FIND v(dout0_72) AT=930.025n

* CHECK dout0_73 Vdout0_73ck185 = 0 time = 930
.meas tran vdout0_73ck185 FIND v(dout0_73) AT=930.025n

* CHECK dout0_74 Vdout0_74ck185 = 0 time = 930
.meas tran vdout0_74ck185 FIND v(dout0_74) AT=930.025n

* CHECK dout0_75 Vdout0_75ck185 = 0 time = 930
.meas tran vdout0_75ck185 FIND v(dout0_75) AT=930.025n

* CHECK dout0_76 Vdout0_76ck185 = 0 time = 930
.meas tran vdout0_76ck185 FIND v(dout0_76) AT=930.025n

* CHECK dout0_77 Vdout0_77ck185 = 0 time = 930
.meas tran vdout0_77ck185 FIND v(dout0_77) AT=930.025n

* CHECK dout0_78 Vdout0_78ck185 = 0 time = 930
.meas tran vdout0_78ck185 FIND v(dout0_78) AT=930.025n

* CHECK dout0_79 Vdout0_79ck185 = 0 time = 930
.meas tran vdout0_79ck185 FIND v(dout0_79) AT=930.025n

* CHECK dout0_0 Vdout0_0ck187 = 0.9 time = 940
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=940.025n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 940
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=940.025n

* CHECK dout0_2 Vdout0_2ck187 = 0.9 time = 940
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=940.025n

* CHECK dout0_3 Vdout0_3ck187 = 0.9 time = 940
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=940.025n

* CHECK dout0_4 Vdout0_4ck187 = 0.9 time = 940
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=940.025n

* CHECK dout0_5 Vdout0_5ck187 = 0.9 time = 940
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=940.025n

* CHECK dout0_6 Vdout0_6ck187 = 0.9 time = 940
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=940.025n

* CHECK dout0_7 Vdout0_7ck187 = 0 time = 940
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=940.025n

* CHECK dout0_8 Vdout0_8ck187 = 0.9 time = 940
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=940.025n

* CHECK dout0_9 Vdout0_9ck187 = 0.9 time = 940
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=940.025n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 940
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=940.025n

* CHECK dout0_11 Vdout0_11ck187 = 0.9 time = 940
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=940.025n

* CHECK dout0_12 Vdout0_12ck187 = 0.9 time = 940
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=940.025n

* CHECK dout0_13 Vdout0_13ck187 = 0 time = 940
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=940.025n

* CHECK dout0_14 Vdout0_14ck187 = 0 time = 940
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=940.025n

* CHECK dout0_15 Vdout0_15ck187 = 0.9 time = 940
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=940.025n

* CHECK dout0_16 Vdout0_16ck187 = 0 time = 940
.meas tran vdout0_16ck187 FIND v(dout0_16) AT=940.025n

* CHECK dout0_17 Vdout0_17ck187 = 0.9 time = 940
.meas tran vdout0_17ck187 FIND v(dout0_17) AT=940.025n

* CHECK dout0_18 Vdout0_18ck187 = 0 time = 940
.meas tran vdout0_18ck187 FIND v(dout0_18) AT=940.025n

* CHECK dout0_19 Vdout0_19ck187 = 0 time = 940
.meas tran vdout0_19ck187 FIND v(dout0_19) AT=940.025n

* CHECK dout0_20 Vdout0_20ck187 = 0 time = 940
.meas tran vdout0_20ck187 FIND v(dout0_20) AT=940.025n

* CHECK dout0_21 Vdout0_21ck187 = 0.9 time = 940
.meas tran vdout0_21ck187 FIND v(dout0_21) AT=940.025n

* CHECK dout0_22 Vdout0_22ck187 = 0 time = 940
.meas tran vdout0_22ck187 FIND v(dout0_22) AT=940.025n

* CHECK dout0_23 Vdout0_23ck187 = 0 time = 940
.meas tran vdout0_23ck187 FIND v(dout0_23) AT=940.025n

* CHECK dout0_24 Vdout0_24ck187 = 0 time = 940
.meas tran vdout0_24ck187 FIND v(dout0_24) AT=940.025n

* CHECK dout0_25 Vdout0_25ck187 = 0.9 time = 940
.meas tran vdout0_25ck187 FIND v(dout0_25) AT=940.025n

* CHECK dout0_26 Vdout0_26ck187 = 0.9 time = 940
.meas tran vdout0_26ck187 FIND v(dout0_26) AT=940.025n

* CHECK dout0_27 Vdout0_27ck187 = 0 time = 940
.meas tran vdout0_27ck187 FIND v(dout0_27) AT=940.025n

* CHECK dout0_28 Vdout0_28ck187 = 0.9 time = 940
.meas tran vdout0_28ck187 FIND v(dout0_28) AT=940.025n

* CHECK dout0_29 Vdout0_29ck187 = 0 time = 940
.meas tran vdout0_29ck187 FIND v(dout0_29) AT=940.025n

* CHECK dout0_30 Vdout0_30ck187 = 0 time = 940
.meas tran vdout0_30ck187 FIND v(dout0_30) AT=940.025n

* CHECK dout0_31 Vdout0_31ck187 = 0 time = 940
.meas tran vdout0_31ck187 FIND v(dout0_31) AT=940.025n

* CHECK dout0_32 Vdout0_32ck187 = 0.9 time = 940
.meas tran vdout0_32ck187 FIND v(dout0_32) AT=940.025n

* CHECK dout0_33 Vdout0_33ck187 = 0.9 time = 940
.meas tran vdout0_33ck187 FIND v(dout0_33) AT=940.025n

* CHECK dout0_34 Vdout0_34ck187 = 0 time = 940
.meas tran vdout0_34ck187 FIND v(dout0_34) AT=940.025n

* CHECK dout0_35 Vdout0_35ck187 = 0 time = 940
.meas tran vdout0_35ck187 FIND v(dout0_35) AT=940.025n

* CHECK dout0_36 Vdout0_36ck187 = 0.9 time = 940
.meas tran vdout0_36ck187 FIND v(dout0_36) AT=940.025n

* CHECK dout0_37 Vdout0_37ck187 = 0 time = 940
.meas tran vdout0_37ck187 FIND v(dout0_37) AT=940.025n

* CHECK dout0_38 Vdout0_38ck187 = 0.9 time = 940
.meas tran vdout0_38ck187 FIND v(dout0_38) AT=940.025n

* CHECK dout0_39 Vdout0_39ck187 = 0.9 time = 940
.meas tran vdout0_39ck187 FIND v(dout0_39) AT=940.025n

* CHECK dout0_40 Vdout0_40ck187 = 0 time = 940
.meas tran vdout0_40ck187 FIND v(dout0_40) AT=940.025n

* CHECK dout0_41 Vdout0_41ck187 = 0 time = 940
.meas tran vdout0_41ck187 FIND v(dout0_41) AT=940.025n

* CHECK dout0_42 Vdout0_42ck187 = 0 time = 940
.meas tran vdout0_42ck187 FIND v(dout0_42) AT=940.025n

* CHECK dout0_43 Vdout0_43ck187 = 0.9 time = 940
.meas tran vdout0_43ck187 FIND v(dout0_43) AT=940.025n

* CHECK dout0_44 Vdout0_44ck187 = 0.9 time = 940
.meas tran vdout0_44ck187 FIND v(dout0_44) AT=940.025n

* CHECK dout0_45 Vdout0_45ck187 = 0.9 time = 940
.meas tran vdout0_45ck187 FIND v(dout0_45) AT=940.025n

* CHECK dout0_46 Vdout0_46ck187 = 0 time = 940
.meas tran vdout0_46ck187 FIND v(dout0_46) AT=940.025n

* CHECK dout0_47 Vdout0_47ck187 = 0.9 time = 940
.meas tran vdout0_47ck187 FIND v(dout0_47) AT=940.025n

* CHECK dout0_48 Vdout0_48ck187 = 0 time = 940
.meas tran vdout0_48ck187 FIND v(dout0_48) AT=940.025n

* CHECK dout0_49 Vdout0_49ck187 = 0 time = 940
.meas tran vdout0_49ck187 FIND v(dout0_49) AT=940.025n

* CHECK dout0_50 Vdout0_50ck187 = 0 time = 940
.meas tran vdout0_50ck187 FIND v(dout0_50) AT=940.025n

* CHECK dout0_51 Vdout0_51ck187 = 0 time = 940
.meas tran vdout0_51ck187 FIND v(dout0_51) AT=940.025n

* CHECK dout0_52 Vdout0_52ck187 = 0.9 time = 940
.meas tran vdout0_52ck187 FIND v(dout0_52) AT=940.025n

* CHECK dout0_53 Vdout0_53ck187 = 0.9 time = 940
.meas tran vdout0_53ck187 FIND v(dout0_53) AT=940.025n

* CHECK dout0_54 Vdout0_54ck187 = 0.9 time = 940
.meas tran vdout0_54ck187 FIND v(dout0_54) AT=940.025n

* CHECK dout0_55 Vdout0_55ck187 = 0 time = 940
.meas tran vdout0_55ck187 FIND v(dout0_55) AT=940.025n

* CHECK dout0_56 Vdout0_56ck187 = 0.9 time = 940
.meas tran vdout0_56ck187 FIND v(dout0_56) AT=940.025n

* CHECK dout0_57 Vdout0_57ck187 = 0 time = 940
.meas tran vdout0_57ck187 FIND v(dout0_57) AT=940.025n

* CHECK dout0_58 Vdout0_58ck187 = 0 time = 940
.meas tran vdout0_58ck187 FIND v(dout0_58) AT=940.025n

* CHECK dout0_59 Vdout0_59ck187 = 0 time = 940
.meas tran vdout0_59ck187 FIND v(dout0_59) AT=940.025n

* CHECK dout0_60 Vdout0_60ck187 = 0 time = 940
.meas tran vdout0_60ck187 FIND v(dout0_60) AT=940.025n

* CHECK dout0_61 Vdout0_61ck187 = 0.9 time = 940
.meas tran vdout0_61ck187 FIND v(dout0_61) AT=940.025n

* CHECK dout0_62 Vdout0_62ck187 = 0.9 time = 940
.meas tran vdout0_62ck187 FIND v(dout0_62) AT=940.025n

* CHECK dout0_63 Vdout0_63ck187 = 0 time = 940
.meas tran vdout0_63ck187 FIND v(dout0_63) AT=940.025n

* CHECK dout0_64 Vdout0_64ck187 = 0 time = 940
.meas tran vdout0_64ck187 FIND v(dout0_64) AT=940.025n

* CHECK dout0_65 Vdout0_65ck187 = 0.9 time = 940
.meas tran vdout0_65ck187 FIND v(dout0_65) AT=940.025n

* CHECK dout0_66 Vdout0_66ck187 = 0 time = 940
.meas tran vdout0_66ck187 FIND v(dout0_66) AT=940.025n

* CHECK dout0_67 Vdout0_67ck187 = 0.9 time = 940
.meas tran vdout0_67ck187 FIND v(dout0_67) AT=940.025n

* CHECK dout0_68 Vdout0_68ck187 = 0 time = 940
.meas tran vdout0_68ck187 FIND v(dout0_68) AT=940.025n

* CHECK dout0_69 Vdout0_69ck187 = 0.9 time = 940
.meas tran vdout0_69ck187 FIND v(dout0_69) AT=940.025n

* CHECK dout0_70 Vdout0_70ck187 = 0.9 time = 940
.meas tran vdout0_70ck187 FIND v(dout0_70) AT=940.025n

* CHECK dout0_71 Vdout0_71ck187 = 0.9 time = 940
.meas tran vdout0_71ck187 FIND v(dout0_71) AT=940.025n

* CHECK dout0_72 Vdout0_72ck187 = 0 time = 940
.meas tran vdout0_72ck187 FIND v(dout0_72) AT=940.025n

* CHECK dout0_73 Vdout0_73ck187 = 0 time = 940
.meas tran vdout0_73ck187 FIND v(dout0_73) AT=940.025n

* CHECK dout0_74 Vdout0_74ck187 = 0.9 time = 940
.meas tran vdout0_74ck187 FIND v(dout0_74) AT=940.025n

* CHECK dout0_75 Vdout0_75ck187 = 0 time = 940
.meas tran vdout0_75ck187 FIND v(dout0_75) AT=940.025n

* CHECK dout0_76 Vdout0_76ck187 = 0.9 time = 940
.meas tran vdout0_76ck187 FIND v(dout0_76) AT=940.025n

* CHECK dout0_77 Vdout0_77ck187 = 0.9 time = 940
.meas tran vdout0_77ck187 FIND v(dout0_77) AT=940.025n

* CHECK dout0_78 Vdout0_78ck187 = 0.9 time = 940
.meas tran vdout0_78ck187 FIND v(dout0_78) AT=940.025n

* CHECK dout0_79 Vdout0_79ck187 = 0 time = 940
.meas tran vdout0_79ck187 FIND v(dout0_79) AT=940.025n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 965
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=965.025n

* CHECK dout0_1 Vdout0_1ck192 = 0.9 time = 965
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=965.025n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 965
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=965.025n

* CHECK dout0_3 Vdout0_3ck192 = 0.9 time = 965
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=965.025n

* CHECK dout0_4 Vdout0_4ck192 = 0 time = 965
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=965.025n

* CHECK dout0_5 Vdout0_5ck192 = 0.9 time = 965
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=965.025n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 965
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=965.025n

* CHECK dout0_7 Vdout0_7ck192 = 0.9 time = 965
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=965.025n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 965
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=965.025n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 965
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=965.025n

* CHECK dout0_10 Vdout0_10ck192 = 0 time = 965
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=965.025n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 965
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=965.025n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 965
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=965.025n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 965
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=965.025n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 965
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=965.025n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 965
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=965.025n

* CHECK dout0_16 Vdout0_16ck192 = 0.9 time = 965
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=965.025n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 965
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=965.025n

* CHECK dout0_18 Vdout0_18ck192 = 0 time = 965
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=965.025n

* CHECK dout0_19 Vdout0_19ck192 = 0 time = 965
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=965.025n

* CHECK dout0_20 Vdout0_20ck192 = 0.9 time = 965
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=965.025n

* CHECK dout0_21 Vdout0_21ck192 = 0 time = 965
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=965.025n

* CHECK dout0_22 Vdout0_22ck192 = 0.9 time = 965
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=965.025n

* CHECK dout0_23 Vdout0_23ck192 = 0.9 time = 965
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=965.025n

* CHECK dout0_24 Vdout0_24ck192 = 0.9 time = 965
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=965.025n

* CHECK dout0_25 Vdout0_25ck192 = 0.9 time = 965
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=965.025n

* CHECK dout0_26 Vdout0_26ck192 = 0.9 time = 965
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=965.025n

* CHECK dout0_27 Vdout0_27ck192 = 0 time = 965
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=965.025n

* CHECK dout0_28 Vdout0_28ck192 = 0.9 time = 965
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=965.025n

* CHECK dout0_29 Vdout0_29ck192 = 0.9 time = 965
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=965.025n

* CHECK dout0_30 Vdout0_30ck192 = 0.9 time = 965
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=965.025n

* CHECK dout0_31 Vdout0_31ck192 = 0 time = 965
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=965.025n

* CHECK dout0_32 Vdout0_32ck192 = 0.9 time = 965
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=965.025n

* CHECK dout0_33 Vdout0_33ck192 = 0 time = 965
.meas tran vdout0_33ck192 FIND v(dout0_33) AT=965.025n

* CHECK dout0_34 Vdout0_34ck192 = 0.9 time = 965
.meas tran vdout0_34ck192 FIND v(dout0_34) AT=965.025n

* CHECK dout0_35 Vdout0_35ck192 = 0.9 time = 965
.meas tran vdout0_35ck192 FIND v(dout0_35) AT=965.025n

* CHECK dout0_36 Vdout0_36ck192 = 0 time = 965
.meas tran vdout0_36ck192 FIND v(dout0_36) AT=965.025n

* CHECK dout0_37 Vdout0_37ck192 = 0.9 time = 965
.meas tran vdout0_37ck192 FIND v(dout0_37) AT=965.025n

* CHECK dout0_38 Vdout0_38ck192 = 0 time = 965
.meas tran vdout0_38ck192 FIND v(dout0_38) AT=965.025n

* CHECK dout0_39 Vdout0_39ck192 = 0.9 time = 965
.meas tran vdout0_39ck192 FIND v(dout0_39) AT=965.025n

* CHECK dout0_40 Vdout0_40ck192 = 0.9 time = 965
.meas tran vdout0_40ck192 FIND v(dout0_40) AT=965.025n

* CHECK dout0_41 Vdout0_41ck192 = 0.9 time = 965
.meas tran vdout0_41ck192 FIND v(dout0_41) AT=965.025n

* CHECK dout0_42 Vdout0_42ck192 = 0 time = 965
.meas tran vdout0_42ck192 FIND v(dout0_42) AT=965.025n

* CHECK dout0_43 Vdout0_43ck192 = 0.9 time = 965
.meas tran vdout0_43ck192 FIND v(dout0_43) AT=965.025n

* CHECK dout0_44 Vdout0_44ck192 = 0 time = 965
.meas tran vdout0_44ck192 FIND v(dout0_44) AT=965.025n

* CHECK dout0_45 Vdout0_45ck192 = 0 time = 965
.meas tran vdout0_45ck192 FIND v(dout0_45) AT=965.025n

* CHECK dout0_46 Vdout0_46ck192 = 0.9 time = 965
.meas tran vdout0_46ck192 FIND v(dout0_46) AT=965.025n

* CHECK dout0_47 Vdout0_47ck192 = 0 time = 965
.meas tran vdout0_47ck192 FIND v(dout0_47) AT=965.025n

* CHECK dout0_48 Vdout0_48ck192 = 0.9 time = 965
.meas tran vdout0_48ck192 FIND v(dout0_48) AT=965.025n

* CHECK dout0_49 Vdout0_49ck192 = 0 time = 965
.meas tran vdout0_49ck192 FIND v(dout0_49) AT=965.025n

* CHECK dout0_50 Vdout0_50ck192 = 0 time = 965
.meas tran vdout0_50ck192 FIND v(dout0_50) AT=965.025n

* CHECK dout0_51 Vdout0_51ck192 = 0.9 time = 965
.meas tran vdout0_51ck192 FIND v(dout0_51) AT=965.025n

* CHECK dout0_52 Vdout0_52ck192 = 0 time = 965
.meas tran vdout0_52ck192 FIND v(dout0_52) AT=965.025n

* CHECK dout0_53 Vdout0_53ck192 = 0 time = 965
.meas tran vdout0_53ck192 FIND v(dout0_53) AT=965.025n

* CHECK dout0_54 Vdout0_54ck192 = 0 time = 965
.meas tran vdout0_54ck192 FIND v(dout0_54) AT=965.025n

* CHECK dout0_55 Vdout0_55ck192 = 0.9 time = 965
.meas tran vdout0_55ck192 FIND v(dout0_55) AT=965.025n

* CHECK dout0_56 Vdout0_56ck192 = 0.9 time = 965
.meas tran vdout0_56ck192 FIND v(dout0_56) AT=965.025n

* CHECK dout0_57 Vdout0_57ck192 = 0 time = 965
.meas tran vdout0_57ck192 FIND v(dout0_57) AT=965.025n

* CHECK dout0_58 Vdout0_58ck192 = 0.9 time = 965
.meas tran vdout0_58ck192 FIND v(dout0_58) AT=965.025n

* CHECK dout0_59 Vdout0_59ck192 = 0 time = 965
.meas tran vdout0_59ck192 FIND v(dout0_59) AT=965.025n

* CHECK dout0_60 Vdout0_60ck192 = 0 time = 965
.meas tran vdout0_60ck192 FIND v(dout0_60) AT=965.025n

* CHECK dout0_61 Vdout0_61ck192 = 0.9 time = 965
.meas tran vdout0_61ck192 FIND v(dout0_61) AT=965.025n

* CHECK dout0_62 Vdout0_62ck192 = 0.9 time = 965
.meas tran vdout0_62ck192 FIND v(dout0_62) AT=965.025n

* CHECK dout0_63 Vdout0_63ck192 = 0 time = 965
.meas tran vdout0_63ck192 FIND v(dout0_63) AT=965.025n

* CHECK dout0_64 Vdout0_64ck192 = 0.9 time = 965
.meas tran vdout0_64ck192 FIND v(dout0_64) AT=965.025n

* CHECK dout0_65 Vdout0_65ck192 = 0 time = 965
.meas tran vdout0_65ck192 FIND v(dout0_65) AT=965.025n

* CHECK dout0_66 Vdout0_66ck192 = 0.9 time = 965
.meas tran vdout0_66ck192 FIND v(dout0_66) AT=965.025n

* CHECK dout0_67 Vdout0_67ck192 = 0 time = 965
.meas tran vdout0_67ck192 FIND v(dout0_67) AT=965.025n

* CHECK dout0_68 Vdout0_68ck192 = 0.9 time = 965
.meas tran vdout0_68ck192 FIND v(dout0_68) AT=965.025n

* CHECK dout0_69 Vdout0_69ck192 = 0.9 time = 965
.meas tran vdout0_69ck192 FIND v(dout0_69) AT=965.025n

* CHECK dout0_70 Vdout0_70ck192 = 0 time = 965
.meas tran vdout0_70ck192 FIND v(dout0_70) AT=965.025n

* CHECK dout0_71 Vdout0_71ck192 = 0 time = 965
.meas tran vdout0_71ck192 FIND v(dout0_71) AT=965.025n

* CHECK dout0_72 Vdout0_72ck192 = 0.9 time = 965
.meas tran vdout0_72ck192 FIND v(dout0_72) AT=965.025n

* CHECK dout0_73 Vdout0_73ck192 = 0.9 time = 965
.meas tran vdout0_73ck192 FIND v(dout0_73) AT=965.025n

* CHECK dout0_74 Vdout0_74ck192 = 0.9 time = 965
.meas tran vdout0_74ck192 FIND v(dout0_74) AT=965.025n

* CHECK dout0_75 Vdout0_75ck192 = 0.9 time = 965
.meas tran vdout0_75ck192 FIND v(dout0_75) AT=965.025n

* CHECK dout0_76 Vdout0_76ck192 = 0 time = 965
.meas tran vdout0_76ck192 FIND v(dout0_76) AT=965.025n

* CHECK dout0_77 Vdout0_77ck192 = 0.9 time = 965
.meas tran vdout0_77ck192 FIND v(dout0_77) AT=965.025n

* CHECK dout0_78 Vdout0_78ck192 = 0.9 time = 965
.meas tran vdout0_78ck192 FIND v(dout0_78) AT=965.025n

* CHECK dout0_79 Vdout0_79ck192 = 0 time = 965
.meas tran vdout0_79ck192 FIND v(dout0_79) AT=965.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0.9 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0.9 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0.9 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0.9 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0.9 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0.9 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 0.9 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 0 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0.9 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0.9 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 0.9 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0.9 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0.9 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0.9 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0.9 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0.9 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0.9 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0.9 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_32 Vdout0_32ck193 = 0.9 time = 970
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=970.025n

* CHECK dout0_33 Vdout0_33ck193 = 0.9 time = 970
.meas tran vdout0_33ck193 FIND v(dout0_33) AT=970.025n

* CHECK dout0_34 Vdout0_34ck193 = 0 time = 970
.meas tran vdout0_34ck193 FIND v(dout0_34) AT=970.025n

* CHECK dout0_35 Vdout0_35ck193 = 0.9 time = 970
.meas tran vdout0_35ck193 FIND v(dout0_35) AT=970.025n

* CHECK dout0_36 Vdout0_36ck193 = 0.9 time = 970
.meas tran vdout0_36ck193 FIND v(dout0_36) AT=970.025n

* CHECK dout0_37 Vdout0_37ck193 = 0 time = 970
.meas tran vdout0_37ck193 FIND v(dout0_37) AT=970.025n

* CHECK dout0_38 Vdout0_38ck193 = 0.9 time = 970
.meas tran vdout0_38ck193 FIND v(dout0_38) AT=970.025n

* CHECK dout0_39 Vdout0_39ck193 = 0.9 time = 970
.meas tran vdout0_39ck193 FIND v(dout0_39) AT=970.025n

* CHECK dout0_40 Vdout0_40ck193 = 0.9 time = 970
.meas tran vdout0_40ck193 FIND v(dout0_40) AT=970.025n

* CHECK dout0_41 Vdout0_41ck193 = 0 time = 970
.meas tran vdout0_41ck193 FIND v(dout0_41) AT=970.025n

* CHECK dout0_42 Vdout0_42ck193 = 0.9 time = 970
.meas tran vdout0_42ck193 FIND v(dout0_42) AT=970.025n

* CHECK dout0_43 Vdout0_43ck193 = 0 time = 970
.meas tran vdout0_43ck193 FIND v(dout0_43) AT=970.025n

* CHECK dout0_44 Vdout0_44ck193 = 0 time = 970
.meas tran vdout0_44ck193 FIND v(dout0_44) AT=970.025n

* CHECK dout0_45 Vdout0_45ck193 = 0 time = 970
.meas tran vdout0_45ck193 FIND v(dout0_45) AT=970.025n

* CHECK dout0_46 Vdout0_46ck193 = 0.9 time = 970
.meas tran vdout0_46ck193 FIND v(dout0_46) AT=970.025n

* CHECK dout0_47 Vdout0_47ck193 = 0.9 time = 970
.meas tran vdout0_47ck193 FIND v(dout0_47) AT=970.025n

* CHECK dout0_48 Vdout0_48ck193 = 0 time = 970
.meas tran vdout0_48ck193 FIND v(dout0_48) AT=970.025n

* CHECK dout0_49 Vdout0_49ck193 = 0 time = 970
.meas tran vdout0_49ck193 FIND v(dout0_49) AT=970.025n

* CHECK dout0_50 Vdout0_50ck193 = 0.9 time = 970
.meas tran vdout0_50ck193 FIND v(dout0_50) AT=970.025n

* CHECK dout0_51 Vdout0_51ck193 = 0 time = 970
.meas tran vdout0_51ck193 FIND v(dout0_51) AT=970.025n

* CHECK dout0_52 Vdout0_52ck193 = 0.9 time = 970
.meas tran vdout0_52ck193 FIND v(dout0_52) AT=970.025n

* CHECK dout0_53 Vdout0_53ck193 = 0 time = 970
.meas tran vdout0_53ck193 FIND v(dout0_53) AT=970.025n

* CHECK dout0_54 Vdout0_54ck193 = 0.9 time = 970
.meas tran vdout0_54ck193 FIND v(dout0_54) AT=970.025n

* CHECK dout0_55 Vdout0_55ck193 = 0 time = 970
.meas tran vdout0_55ck193 FIND v(dout0_55) AT=970.025n

* CHECK dout0_56 Vdout0_56ck193 = 0.9 time = 970
.meas tran vdout0_56ck193 FIND v(dout0_56) AT=970.025n

* CHECK dout0_57 Vdout0_57ck193 = 0 time = 970
.meas tran vdout0_57ck193 FIND v(dout0_57) AT=970.025n

* CHECK dout0_58 Vdout0_58ck193 = 0.9 time = 970
.meas tran vdout0_58ck193 FIND v(dout0_58) AT=970.025n

* CHECK dout0_59 Vdout0_59ck193 = 0.9 time = 970
.meas tran vdout0_59ck193 FIND v(dout0_59) AT=970.025n

* CHECK dout0_60 Vdout0_60ck193 = 0 time = 970
.meas tran vdout0_60ck193 FIND v(dout0_60) AT=970.025n

* CHECK dout0_61 Vdout0_61ck193 = 0.9 time = 970
.meas tran vdout0_61ck193 FIND v(dout0_61) AT=970.025n

* CHECK dout0_62 Vdout0_62ck193 = 0 time = 970
.meas tran vdout0_62ck193 FIND v(dout0_62) AT=970.025n

* CHECK dout0_63 Vdout0_63ck193 = 0 time = 970
.meas tran vdout0_63ck193 FIND v(dout0_63) AT=970.025n

* CHECK dout0_64 Vdout0_64ck193 = 0.9 time = 970
.meas tran vdout0_64ck193 FIND v(dout0_64) AT=970.025n

* CHECK dout0_65 Vdout0_65ck193 = 0.9 time = 970
.meas tran vdout0_65ck193 FIND v(dout0_65) AT=970.025n

* CHECK dout0_66 Vdout0_66ck193 = 0 time = 970
.meas tran vdout0_66ck193 FIND v(dout0_66) AT=970.025n

* CHECK dout0_67 Vdout0_67ck193 = 0 time = 970
.meas tran vdout0_67ck193 FIND v(dout0_67) AT=970.025n

* CHECK dout0_68 Vdout0_68ck193 = 0.9 time = 970
.meas tran vdout0_68ck193 FIND v(dout0_68) AT=970.025n

* CHECK dout0_69 Vdout0_69ck193 = 0 time = 970
.meas tran vdout0_69ck193 FIND v(dout0_69) AT=970.025n

* CHECK dout0_70 Vdout0_70ck193 = 0.9 time = 970
.meas tran vdout0_70ck193 FIND v(dout0_70) AT=970.025n

* CHECK dout0_71 Vdout0_71ck193 = 0 time = 970
.meas tran vdout0_71ck193 FIND v(dout0_71) AT=970.025n

* CHECK dout0_72 Vdout0_72ck193 = 0 time = 970
.meas tran vdout0_72ck193 FIND v(dout0_72) AT=970.025n

* CHECK dout0_73 Vdout0_73ck193 = 0 time = 970
.meas tran vdout0_73ck193 FIND v(dout0_73) AT=970.025n

* CHECK dout0_74 Vdout0_74ck193 = 0.9 time = 970
.meas tran vdout0_74ck193 FIND v(dout0_74) AT=970.025n

* CHECK dout0_75 Vdout0_75ck193 = 0 time = 970
.meas tran vdout0_75ck193 FIND v(dout0_75) AT=970.025n

* CHECK dout0_76 Vdout0_76ck193 = 0 time = 970
.meas tran vdout0_76ck193 FIND v(dout0_76) AT=970.025n

* CHECK dout0_77 Vdout0_77ck193 = 0 time = 970
.meas tran vdout0_77ck193 FIND v(dout0_77) AT=970.025n

* CHECK dout0_78 Vdout0_78ck193 = 0 time = 970
.meas tran vdout0_78ck193 FIND v(dout0_78) AT=970.025n

* CHECK dout0_79 Vdout0_79ck193 = 0 time = 970
.meas tran vdout0_79ck193 FIND v(dout0_79) AT=970.025n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 980
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=980.025n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 980
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=980.025n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 980
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=980.025n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 980
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=980.025n

* CHECK dout0_4 Vdout0_4ck195 = 0.9 time = 980
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=980.025n

* CHECK dout0_5 Vdout0_5ck195 = 0.9 time = 980
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=980.025n

* CHECK dout0_6 Vdout0_6ck195 = 0.9 time = 980
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=980.025n

* CHECK dout0_7 Vdout0_7ck195 = 0.9 time = 980
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=980.025n

* CHECK dout0_8 Vdout0_8ck195 = 0.9 time = 980
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=980.025n

* CHECK dout0_9 Vdout0_9ck195 = 0.9 time = 980
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=980.025n

* CHECK dout0_10 Vdout0_10ck195 = 0.9 time = 980
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=980.025n

* CHECK dout0_11 Vdout0_11ck195 = 0 time = 980
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=980.025n

* CHECK dout0_12 Vdout0_12ck195 = 0 time = 980
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=980.025n

* CHECK dout0_13 Vdout0_13ck195 = 0.9 time = 980
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=980.025n

* CHECK dout0_14 Vdout0_14ck195 = 0.9 time = 980
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=980.025n

* CHECK dout0_15 Vdout0_15ck195 = 0 time = 980
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=980.025n

* CHECK dout0_16 Vdout0_16ck195 = 0 time = 980
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=980.025n

* CHECK dout0_17 Vdout0_17ck195 = 0 time = 980
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=980.025n

* CHECK dout0_18 Vdout0_18ck195 = 0.9 time = 980
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=980.025n

* CHECK dout0_19 Vdout0_19ck195 = 0 time = 980
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=980.025n

* CHECK dout0_20 Vdout0_20ck195 = 0.9 time = 980
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=980.025n

* CHECK dout0_21 Vdout0_21ck195 = 0.9 time = 980
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=980.025n

* CHECK dout0_22 Vdout0_22ck195 = 0 time = 980
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=980.025n

* CHECK dout0_23 Vdout0_23ck195 = 0.9 time = 980
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=980.025n

* CHECK dout0_24 Vdout0_24ck195 = 0.9 time = 980
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=980.025n

* CHECK dout0_25 Vdout0_25ck195 = 0.9 time = 980
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=980.025n

* CHECK dout0_26 Vdout0_26ck195 = 0.9 time = 980
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=980.025n

* CHECK dout0_27 Vdout0_27ck195 = 0 time = 980
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=980.025n

* CHECK dout0_28 Vdout0_28ck195 = 0 time = 980
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=980.025n

* CHECK dout0_29 Vdout0_29ck195 = 0 time = 980
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=980.025n

* CHECK dout0_30 Vdout0_30ck195 = 0 time = 980
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=980.025n

* CHECK dout0_31 Vdout0_31ck195 = 0.9 time = 980
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=980.025n

* CHECK dout0_32 Vdout0_32ck195 = 0.9 time = 980
.meas tran vdout0_32ck195 FIND v(dout0_32) AT=980.025n

* CHECK dout0_33 Vdout0_33ck195 = 0.9 time = 980
.meas tran vdout0_33ck195 FIND v(dout0_33) AT=980.025n

* CHECK dout0_34 Vdout0_34ck195 = 0 time = 980
.meas tran vdout0_34ck195 FIND v(dout0_34) AT=980.025n

* CHECK dout0_35 Vdout0_35ck195 = 0.9 time = 980
.meas tran vdout0_35ck195 FIND v(dout0_35) AT=980.025n

* CHECK dout0_36 Vdout0_36ck195 = 0.9 time = 980
.meas tran vdout0_36ck195 FIND v(dout0_36) AT=980.025n

* CHECK dout0_37 Vdout0_37ck195 = 0 time = 980
.meas tran vdout0_37ck195 FIND v(dout0_37) AT=980.025n

* CHECK dout0_38 Vdout0_38ck195 = 0.9 time = 980
.meas tran vdout0_38ck195 FIND v(dout0_38) AT=980.025n

* CHECK dout0_39 Vdout0_39ck195 = 0.9 time = 980
.meas tran vdout0_39ck195 FIND v(dout0_39) AT=980.025n

* CHECK dout0_40 Vdout0_40ck195 = 0.9 time = 980
.meas tran vdout0_40ck195 FIND v(dout0_40) AT=980.025n

* CHECK dout0_41 Vdout0_41ck195 = 0 time = 980
.meas tran vdout0_41ck195 FIND v(dout0_41) AT=980.025n

* CHECK dout0_42 Vdout0_42ck195 = 0.9 time = 980
.meas tran vdout0_42ck195 FIND v(dout0_42) AT=980.025n

* CHECK dout0_43 Vdout0_43ck195 = 0 time = 980
.meas tran vdout0_43ck195 FIND v(dout0_43) AT=980.025n

* CHECK dout0_44 Vdout0_44ck195 = 0 time = 980
.meas tran vdout0_44ck195 FIND v(dout0_44) AT=980.025n

* CHECK dout0_45 Vdout0_45ck195 = 0 time = 980
.meas tran vdout0_45ck195 FIND v(dout0_45) AT=980.025n

* CHECK dout0_46 Vdout0_46ck195 = 0.9 time = 980
.meas tran vdout0_46ck195 FIND v(dout0_46) AT=980.025n

* CHECK dout0_47 Vdout0_47ck195 = 0.9 time = 980
.meas tran vdout0_47ck195 FIND v(dout0_47) AT=980.025n

* CHECK dout0_48 Vdout0_48ck195 = 0 time = 980
.meas tran vdout0_48ck195 FIND v(dout0_48) AT=980.025n

* CHECK dout0_49 Vdout0_49ck195 = 0 time = 980
.meas tran vdout0_49ck195 FIND v(dout0_49) AT=980.025n

* CHECK dout0_50 Vdout0_50ck195 = 0.9 time = 980
.meas tran vdout0_50ck195 FIND v(dout0_50) AT=980.025n

* CHECK dout0_51 Vdout0_51ck195 = 0 time = 980
.meas tran vdout0_51ck195 FIND v(dout0_51) AT=980.025n

* CHECK dout0_52 Vdout0_52ck195 = 0.9 time = 980
.meas tran vdout0_52ck195 FIND v(dout0_52) AT=980.025n

* CHECK dout0_53 Vdout0_53ck195 = 0 time = 980
.meas tran vdout0_53ck195 FIND v(dout0_53) AT=980.025n

* CHECK dout0_54 Vdout0_54ck195 = 0.9 time = 980
.meas tran vdout0_54ck195 FIND v(dout0_54) AT=980.025n

* CHECK dout0_55 Vdout0_55ck195 = 0 time = 980
.meas tran vdout0_55ck195 FIND v(dout0_55) AT=980.025n

* CHECK dout0_56 Vdout0_56ck195 = 0.9 time = 980
.meas tran vdout0_56ck195 FIND v(dout0_56) AT=980.025n

* CHECK dout0_57 Vdout0_57ck195 = 0 time = 980
.meas tran vdout0_57ck195 FIND v(dout0_57) AT=980.025n

* CHECK dout0_58 Vdout0_58ck195 = 0.9 time = 980
.meas tran vdout0_58ck195 FIND v(dout0_58) AT=980.025n

* CHECK dout0_59 Vdout0_59ck195 = 0.9 time = 980
.meas tran vdout0_59ck195 FIND v(dout0_59) AT=980.025n

* CHECK dout0_60 Vdout0_60ck195 = 0 time = 980
.meas tran vdout0_60ck195 FIND v(dout0_60) AT=980.025n

* CHECK dout0_61 Vdout0_61ck195 = 0.9 time = 980
.meas tran vdout0_61ck195 FIND v(dout0_61) AT=980.025n

* CHECK dout0_62 Vdout0_62ck195 = 0 time = 980
.meas tran vdout0_62ck195 FIND v(dout0_62) AT=980.025n

* CHECK dout0_63 Vdout0_63ck195 = 0 time = 980
.meas tran vdout0_63ck195 FIND v(dout0_63) AT=980.025n

* CHECK dout0_64 Vdout0_64ck195 = 0.9 time = 980
.meas tran vdout0_64ck195 FIND v(dout0_64) AT=980.025n

* CHECK dout0_65 Vdout0_65ck195 = 0.9 time = 980
.meas tran vdout0_65ck195 FIND v(dout0_65) AT=980.025n

* CHECK dout0_66 Vdout0_66ck195 = 0 time = 980
.meas tran vdout0_66ck195 FIND v(dout0_66) AT=980.025n

* CHECK dout0_67 Vdout0_67ck195 = 0 time = 980
.meas tran vdout0_67ck195 FIND v(dout0_67) AT=980.025n

* CHECK dout0_68 Vdout0_68ck195 = 0.9 time = 980
.meas tran vdout0_68ck195 FIND v(dout0_68) AT=980.025n

* CHECK dout0_69 Vdout0_69ck195 = 0 time = 980
.meas tran vdout0_69ck195 FIND v(dout0_69) AT=980.025n

* CHECK dout0_70 Vdout0_70ck195 = 0.9 time = 980
.meas tran vdout0_70ck195 FIND v(dout0_70) AT=980.025n

* CHECK dout0_71 Vdout0_71ck195 = 0 time = 980
.meas tran vdout0_71ck195 FIND v(dout0_71) AT=980.025n

* CHECK dout0_72 Vdout0_72ck195 = 0 time = 980
.meas tran vdout0_72ck195 FIND v(dout0_72) AT=980.025n

* CHECK dout0_73 Vdout0_73ck195 = 0 time = 980
.meas tran vdout0_73ck195 FIND v(dout0_73) AT=980.025n

* CHECK dout0_74 Vdout0_74ck195 = 0.9 time = 980
.meas tran vdout0_74ck195 FIND v(dout0_74) AT=980.025n

* CHECK dout0_75 Vdout0_75ck195 = 0 time = 980
.meas tran vdout0_75ck195 FIND v(dout0_75) AT=980.025n

* CHECK dout0_76 Vdout0_76ck195 = 0 time = 980
.meas tran vdout0_76ck195 FIND v(dout0_76) AT=980.025n

* CHECK dout0_77 Vdout0_77ck195 = 0 time = 980
.meas tran vdout0_77ck195 FIND v(dout0_77) AT=980.025n

* CHECK dout0_78 Vdout0_78ck195 = 0 time = 980
.meas tran vdout0_78ck195 FIND v(dout0_78) AT=980.025n

* CHECK dout0_79 Vdout0_79ck195 = 0 time = 980
.meas tran vdout0_79ck195 FIND v(dout0_79) AT=980.025n

* CHECK dout0_0 Vdout0_0ck196 = 0 time = 985
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=985.025n

* CHECK dout0_1 Vdout0_1ck196 = 0 time = 985
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=985.025n

* CHECK dout0_2 Vdout0_2ck196 = 0 time = 985
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=985.025n

* CHECK dout0_3 Vdout0_3ck196 = 0 time = 985
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=985.025n

* CHECK dout0_4 Vdout0_4ck196 = 0.9 time = 985
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=985.025n

* CHECK dout0_5 Vdout0_5ck196 = 0.9 time = 985
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=985.025n

* CHECK dout0_6 Vdout0_6ck196 = 0.9 time = 985
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=985.025n

* CHECK dout0_7 Vdout0_7ck196 = 0.9 time = 985
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=985.025n

* CHECK dout0_8 Vdout0_8ck196 = 0.9 time = 985
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=985.025n

* CHECK dout0_9 Vdout0_9ck196 = 0.9 time = 985
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=985.025n

* CHECK dout0_10 Vdout0_10ck196 = 0.9 time = 985
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=985.025n

* CHECK dout0_11 Vdout0_11ck196 = 0 time = 985
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=985.025n

* CHECK dout0_12 Vdout0_12ck196 = 0 time = 985
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=985.025n

* CHECK dout0_13 Vdout0_13ck196 = 0.9 time = 985
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=985.025n

* CHECK dout0_14 Vdout0_14ck196 = 0.9 time = 985
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=985.025n

* CHECK dout0_15 Vdout0_15ck196 = 0 time = 985
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=985.025n

* CHECK dout0_16 Vdout0_16ck196 = 0 time = 985
.meas tran vdout0_16ck196 FIND v(dout0_16) AT=985.025n

* CHECK dout0_17 Vdout0_17ck196 = 0 time = 985
.meas tran vdout0_17ck196 FIND v(dout0_17) AT=985.025n

* CHECK dout0_18 Vdout0_18ck196 = 0.9 time = 985
.meas tran vdout0_18ck196 FIND v(dout0_18) AT=985.025n

* CHECK dout0_19 Vdout0_19ck196 = 0 time = 985
.meas tran vdout0_19ck196 FIND v(dout0_19) AT=985.025n

* CHECK dout0_20 Vdout0_20ck196 = 0.9 time = 985
.meas tran vdout0_20ck196 FIND v(dout0_20) AT=985.025n

* CHECK dout0_21 Vdout0_21ck196 = 0.9 time = 985
.meas tran vdout0_21ck196 FIND v(dout0_21) AT=985.025n

* CHECK dout0_22 Vdout0_22ck196 = 0 time = 985
.meas tran vdout0_22ck196 FIND v(dout0_22) AT=985.025n

* CHECK dout0_23 Vdout0_23ck196 = 0.9 time = 985
.meas tran vdout0_23ck196 FIND v(dout0_23) AT=985.025n

* CHECK dout0_24 Vdout0_24ck196 = 0.9 time = 985
.meas tran vdout0_24ck196 FIND v(dout0_24) AT=985.025n

* CHECK dout0_25 Vdout0_25ck196 = 0.9 time = 985
.meas tran vdout0_25ck196 FIND v(dout0_25) AT=985.025n

* CHECK dout0_26 Vdout0_26ck196 = 0.9 time = 985
.meas tran vdout0_26ck196 FIND v(dout0_26) AT=985.025n

* CHECK dout0_27 Vdout0_27ck196 = 0 time = 985
.meas tran vdout0_27ck196 FIND v(dout0_27) AT=985.025n

* CHECK dout0_28 Vdout0_28ck196 = 0 time = 985
.meas tran vdout0_28ck196 FIND v(dout0_28) AT=985.025n

* CHECK dout0_29 Vdout0_29ck196 = 0 time = 985
.meas tran vdout0_29ck196 FIND v(dout0_29) AT=985.025n

* CHECK dout0_30 Vdout0_30ck196 = 0 time = 985
.meas tran vdout0_30ck196 FIND v(dout0_30) AT=985.025n

* CHECK dout0_31 Vdout0_31ck196 = 0.9 time = 985
.meas tran vdout0_31ck196 FIND v(dout0_31) AT=985.025n

* CHECK dout0_32 Vdout0_32ck196 = 0.9 time = 985
.meas tran vdout0_32ck196 FIND v(dout0_32) AT=985.025n

* CHECK dout0_33 Vdout0_33ck196 = 0.9 time = 985
.meas tran vdout0_33ck196 FIND v(dout0_33) AT=985.025n

* CHECK dout0_34 Vdout0_34ck196 = 0 time = 985
.meas tran vdout0_34ck196 FIND v(dout0_34) AT=985.025n

* CHECK dout0_35 Vdout0_35ck196 = 0.9 time = 985
.meas tran vdout0_35ck196 FIND v(dout0_35) AT=985.025n

* CHECK dout0_36 Vdout0_36ck196 = 0.9 time = 985
.meas tran vdout0_36ck196 FIND v(dout0_36) AT=985.025n

* CHECK dout0_37 Vdout0_37ck196 = 0 time = 985
.meas tran vdout0_37ck196 FIND v(dout0_37) AT=985.025n

* CHECK dout0_38 Vdout0_38ck196 = 0.9 time = 985
.meas tran vdout0_38ck196 FIND v(dout0_38) AT=985.025n

* CHECK dout0_39 Vdout0_39ck196 = 0.9 time = 985
.meas tran vdout0_39ck196 FIND v(dout0_39) AT=985.025n

* CHECK dout0_40 Vdout0_40ck196 = 0.9 time = 985
.meas tran vdout0_40ck196 FIND v(dout0_40) AT=985.025n

* CHECK dout0_41 Vdout0_41ck196 = 0 time = 985
.meas tran vdout0_41ck196 FIND v(dout0_41) AT=985.025n

* CHECK dout0_42 Vdout0_42ck196 = 0.9 time = 985
.meas tran vdout0_42ck196 FIND v(dout0_42) AT=985.025n

* CHECK dout0_43 Vdout0_43ck196 = 0 time = 985
.meas tran vdout0_43ck196 FIND v(dout0_43) AT=985.025n

* CHECK dout0_44 Vdout0_44ck196 = 0 time = 985
.meas tran vdout0_44ck196 FIND v(dout0_44) AT=985.025n

* CHECK dout0_45 Vdout0_45ck196 = 0 time = 985
.meas tran vdout0_45ck196 FIND v(dout0_45) AT=985.025n

* CHECK dout0_46 Vdout0_46ck196 = 0.9 time = 985
.meas tran vdout0_46ck196 FIND v(dout0_46) AT=985.025n

* CHECK dout0_47 Vdout0_47ck196 = 0.9 time = 985
.meas tran vdout0_47ck196 FIND v(dout0_47) AT=985.025n

* CHECK dout0_48 Vdout0_48ck196 = 0 time = 985
.meas tran vdout0_48ck196 FIND v(dout0_48) AT=985.025n

* CHECK dout0_49 Vdout0_49ck196 = 0 time = 985
.meas tran vdout0_49ck196 FIND v(dout0_49) AT=985.025n

* CHECK dout0_50 Vdout0_50ck196 = 0.9 time = 985
.meas tran vdout0_50ck196 FIND v(dout0_50) AT=985.025n

* CHECK dout0_51 Vdout0_51ck196 = 0 time = 985
.meas tran vdout0_51ck196 FIND v(dout0_51) AT=985.025n

* CHECK dout0_52 Vdout0_52ck196 = 0.9 time = 985
.meas tran vdout0_52ck196 FIND v(dout0_52) AT=985.025n

* CHECK dout0_53 Vdout0_53ck196 = 0 time = 985
.meas tran vdout0_53ck196 FIND v(dout0_53) AT=985.025n

* CHECK dout0_54 Vdout0_54ck196 = 0.9 time = 985
.meas tran vdout0_54ck196 FIND v(dout0_54) AT=985.025n

* CHECK dout0_55 Vdout0_55ck196 = 0 time = 985
.meas tran vdout0_55ck196 FIND v(dout0_55) AT=985.025n

* CHECK dout0_56 Vdout0_56ck196 = 0.9 time = 985
.meas tran vdout0_56ck196 FIND v(dout0_56) AT=985.025n

* CHECK dout0_57 Vdout0_57ck196 = 0 time = 985
.meas tran vdout0_57ck196 FIND v(dout0_57) AT=985.025n

* CHECK dout0_58 Vdout0_58ck196 = 0.9 time = 985
.meas tran vdout0_58ck196 FIND v(dout0_58) AT=985.025n

* CHECK dout0_59 Vdout0_59ck196 = 0.9 time = 985
.meas tran vdout0_59ck196 FIND v(dout0_59) AT=985.025n

* CHECK dout0_60 Vdout0_60ck196 = 0 time = 985
.meas tran vdout0_60ck196 FIND v(dout0_60) AT=985.025n

* CHECK dout0_61 Vdout0_61ck196 = 0.9 time = 985
.meas tran vdout0_61ck196 FIND v(dout0_61) AT=985.025n

* CHECK dout0_62 Vdout0_62ck196 = 0 time = 985
.meas tran vdout0_62ck196 FIND v(dout0_62) AT=985.025n

* CHECK dout0_63 Vdout0_63ck196 = 0 time = 985
.meas tran vdout0_63ck196 FIND v(dout0_63) AT=985.025n

* CHECK dout0_64 Vdout0_64ck196 = 0.9 time = 985
.meas tran vdout0_64ck196 FIND v(dout0_64) AT=985.025n

* CHECK dout0_65 Vdout0_65ck196 = 0.9 time = 985
.meas tran vdout0_65ck196 FIND v(dout0_65) AT=985.025n

* CHECK dout0_66 Vdout0_66ck196 = 0 time = 985
.meas tran vdout0_66ck196 FIND v(dout0_66) AT=985.025n

* CHECK dout0_67 Vdout0_67ck196 = 0 time = 985
.meas tran vdout0_67ck196 FIND v(dout0_67) AT=985.025n

* CHECK dout0_68 Vdout0_68ck196 = 0.9 time = 985
.meas tran vdout0_68ck196 FIND v(dout0_68) AT=985.025n

* CHECK dout0_69 Vdout0_69ck196 = 0 time = 985
.meas tran vdout0_69ck196 FIND v(dout0_69) AT=985.025n

* CHECK dout0_70 Vdout0_70ck196 = 0.9 time = 985
.meas tran vdout0_70ck196 FIND v(dout0_70) AT=985.025n

* CHECK dout0_71 Vdout0_71ck196 = 0 time = 985
.meas tran vdout0_71ck196 FIND v(dout0_71) AT=985.025n

* CHECK dout0_72 Vdout0_72ck196 = 0 time = 985
.meas tran vdout0_72ck196 FIND v(dout0_72) AT=985.025n

* CHECK dout0_73 Vdout0_73ck196 = 0 time = 985
.meas tran vdout0_73ck196 FIND v(dout0_73) AT=985.025n

* CHECK dout0_74 Vdout0_74ck196 = 0.9 time = 985
.meas tran vdout0_74ck196 FIND v(dout0_74) AT=985.025n

* CHECK dout0_75 Vdout0_75ck196 = 0 time = 985
.meas tran vdout0_75ck196 FIND v(dout0_75) AT=985.025n

* CHECK dout0_76 Vdout0_76ck196 = 0 time = 985
.meas tran vdout0_76ck196 FIND v(dout0_76) AT=985.025n

* CHECK dout0_77 Vdout0_77ck196 = 0 time = 985
.meas tran vdout0_77ck196 FIND v(dout0_77) AT=985.025n

* CHECK dout0_78 Vdout0_78ck196 = 0 time = 985
.meas tran vdout0_78ck196 FIND v(dout0_78) AT=985.025n

* CHECK dout0_79 Vdout0_79ck196 = 0 time = 985
.meas tran vdout0_79ck196 FIND v(dout0_79) AT=985.025n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 990
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=990.025n

* CHECK dout0_1 Vdout0_1ck197 = 0.9 time = 990
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=990.025n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 990
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=990.025n

* CHECK dout0_3 Vdout0_3ck197 = 0.9 time = 990
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=990.025n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 990
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=990.025n

* CHECK dout0_5 Vdout0_5ck197 = 0.9 time = 990
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=990.025n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 990
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=990.025n

* CHECK dout0_7 Vdout0_7ck197 = 0.9 time = 990
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=990.025n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 990
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=990.025n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 990
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=990.025n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 990
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=990.025n

* CHECK dout0_11 Vdout0_11ck197 = 0 time = 990
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=990.025n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 990
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=990.025n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 990
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=990.025n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 990
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=990.025n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 990
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=990.025n

* CHECK dout0_16 Vdout0_16ck197 = 0.9 time = 990
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=990.025n

* CHECK dout0_17 Vdout0_17ck197 = 0 time = 990
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=990.025n

* CHECK dout0_18 Vdout0_18ck197 = 0 time = 990
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=990.025n

* CHECK dout0_19 Vdout0_19ck197 = 0 time = 990
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=990.025n

* CHECK dout0_20 Vdout0_20ck197 = 0.9 time = 990
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=990.025n

* CHECK dout0_21 Vdout0_21ck197 = 0 time = 990
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=990.025n

* CHECK dout0_22 Vdout0_22ck197 = 0.9 time = 990
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=990.025n

* CHECK dout0_23 Vdout0_23ck197 = 0.9 time = 990
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=990.025n

* CHECK dout0_24 Vdout0_24ck197 = 0.9 time = 990
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=990.025n

* CHECK dout0_25 Vdout0_25ck197 = 0.9 time = 990
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=990.025n

* CHECK dout0_26 Vdout0_26ck197 = 0.9 time = 990
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=990.025n

* CHECK dout0_27 Vdout0_27ck197 = 0 time = 990
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=990.025n

* CHECK dout0_28 Vdout0_28ck197 = 0.9 time = 990
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=990.025n

* CHECK dout0_29 Vdout0_29ck197 = 0.9 time = 990
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=990.025n

* CHECK dout0_30 Vdout0_30ck197 = 0.9 time = 990
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=990.025n

* CHECK dout0_31 Vdout0_31ck197 = 0 time = 990
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=990.025n

* CHECK dout0_32 Vdout0_32ck197 = 0.9 time = 990
.meas tran vdout0_32ck197 FIND v(dout0_32) AT=990.025n

* CHECK dout0_33 Vdout0_33ck197 = 0 time = 990
.meas tran vdout0_33ck197 FIND v(dout0_33) AT=990.025n

* CHECK dout0_34 Vdout0_34ck197 = 0.9 time = 990
.meas tran vdout0_34ck197 FIND v(dout0_34) AT=990.025n

* CHECK dout0_35 Vdout0_35ck197 = 0.9 time = 990
.meas tran vdout0_35ck197 FIND v(dout0_35) AT=990.025n

* CHECK dout0_36 Vdout0_36ck197 = 0 time = 990
.meas tran vdout0_36ck197 FIND v(dout0_36) AT=990.025n

* CHECK dout0_37 Vdout0_37ck197 = 0.9 time = 990
.meas tran vdout0_37ck197 FIND v(dout0_37) AT=990.025n

* CHECK dout0_38 Vdout0_38ck197 = 0 time = 990
.meas tran vdout0_38ck197 FIND v(dout0_38) AT=990.025n

* CHECK dout0_39 Vdout0_39ck197 = 0.9 time = 990
.meas tran vdout0_39ck197 FIND v(dout0_39) AT=990.025n

* CHECK dout0_40 Vdout0_40ck197 = 0.9 time = 990
.meas tran vdout0_40ck197 FIND v(dout0_40) AT=990.025n

* CHECK dout0_41 Vdout0_41ck197 = 0.9 time = 990
.meas tran vdout0_41ck197 FIND v(dout0_41) AT=990.025n

* CHECK dout0_42 Vdout0_42ck197 = 0 time = 990
.meas tran vdout0_42ck197 FIND v(dout0_42) AT=990.025n

* CHECK dout0_43 Vdout0_43ck197 = 0.9 time = 990
.meas tran vdout0_43ck197 FIND v(dout0_43) AT=990.025n

* CHECK dout0_44 Vdout0_44ck197 = 0 time = 990
.meas tran vdout0_44ck197 FIND v(dout0_44) AT=990.025n

* CHECK dout0_45 Vdout0_45ck197 = 0 time = 990
.meas tran vdout0_45ck197 FIND v(dout0_45) AT=990.025n

* CHECK dout0_46 Vdout0_46ck197 = 0.9 time = 990
.meas tran vdout0_46ck197 FIND v(dout0_46) AT=990.025n

* CHECK dout0_47 Vdout0_47ck197 = 0 time = 990
.meas tran vdout0_47ck197 FIND v(dout0_47) AT=990.025n

* CHECK dout0_48 Vdout0_48ck197 = 0.9 time = 990
.meas tran vdout0_48ck197 FIND v(dout0_48) AT=990.025n

* CHECK dout0_49 Vdout0_49ck197 = 0 time = 990
.meas tran vdout0_49ck197 FIND v(dout0_49) AT=990.025n

* CHECK dout0_50 Vdout0_50ck197 = 0 time = 990
.meas tran vdout0_50ck197 FIND v(dout0_50) AT=990.025n

* CHECK dout0_51 Vdout0_51ck197 = 0.9 time = 990
.meas tran vdout0_51ck197 FIND v(dout0_51) AT=990.025n

* CHECK dout0_52 Vdout0_52ck197 = 0 time = 990
.meas tran vdout0_52ck197 FIND v(dout0_52) AT=990.025n

* CHECK dout0_53 Vdout0_53ck197 = 0 time = 990
.meas tran vdout0_53ck197 FIND v(dout0_53) AT=990.025n

* CHECK dout0_54 Vdout0_54ck197 = 0 time = 990
.meas tran vdout0_54ck197 FIND v(dout0_54) AT=990.025n

* CHECK dout0_55 Vdout0_55ck197 = 0.9 time = 990
.meas tran vdout0_55ck197 FIND v(dout0_55) AT=990.025n

* CHECK dout0_56 Vdout0_56ck197 = 0.9 time = 990
.meas tran vdout0_56ck197 FIND v(dout0_56) AT=990.025n

* CHECK dout0_57 Vdout0_57ck197 = 0 time = 990
.meas tran vdout0_57ck197 FIND v(dout0_57) AT=990.025n

* CHECK dout0_58 Vdout0_58ck197 = 0.9 time = 990
.meas tran vdout0_58ck197 FIND v(dout0_58) AT=990.025n

* CHECK dout0_59 Vdout0_59ck197 = 0 time = 990
.meas tran vdout0_59ck197 FIND v(dout0_59) AT=990.025n

* CHECK dout0_60 Vdout0_60ck197 = 0 time = 990
.meas tran vdout0_60ck197 FIND v(dout0_60) AT=990.025n

* CHECK dout0_61 Vdout0_61ck197 = 0.9 time = 990
.meas tran vdout0_61ck197 FIND v(dout0_61) AT=990.025n

* CHECK dout0_62 Vdout0_62ck197 = 0.9 time = 990
.meas tran vdout0_62ck197 FIND v(dout0_62) AT=990.025n

* CHECK dout0_63 Vdout0_63ck197 = 0 time = 990
.meas tran vdout0_63ck197 FIND v(dout0_63) AT=990.025n

* CHECK dout0_64 Vdout0_64ck197 = 0.9 time = 990
.meas tran vdout0_64ck197 FIND v(dout0_64) AT=990.025n

* CHECK dout0_65 Vdout0_65ck197 = 0 time = 990
.meas tran vdout0_65ck197 FIND v(dout0_65) AT=990.025n

* CHECK dout0_66 Vdout0_66ck197 = 0.9 time = 990
.meas tran vdout0_66ck197 FIND v(dout0_66) AT=990.025n

* CHECK dout0_67 Vdout0_67ck197 = 0 time = 990
.meas tran vdout0_67ck197 FIND v(dout0_67) AT=990.025n

* CHECK dout0_68 Vdout0_68ck197 = 0.9 time = 990
.meas tran vdout0_68ck197 FIND v(dout0_68) AT=990.025n

* CHECK dout0_69 Vdout0_69ck197 = 0.9 time = 990
.meas tran vdout0_69ck197 FIND v(dout0_69) AT=990.025n

* CHECK dout0_70 Vdout0_70ck197 = 0 time = 990
.meas tran vdout0_70ck197 FIND v(dout0_70) AT=990.025n

* CHECK dout0_71 Vdout0_71ck197 = 0 time = 990
.meas tran vdout0_71ck197 FIND v(dout0_71) AT=990.025n

* CHECK dout0_72 Vdout0_72ck197 = 0.9 time = 990
.meas tran vdout0_72ck197 FIND v(dout0_72) AT=990.025n

* CHECK dout0_73 Vdout0_73ck197 = 0.9 time = 990
.meas tran vdout0_73ck197 FIND v(dout0_73) AT=990.025n

* CHECK dout0_74 Vdout0_74ck197 = 0.9 time = 990
.meas tran vdout0_74ck197 FIND v(dout0_74) AT=990.025n

* CHECK dout0_75 Vdout0_75ck197 = 0.9 time = 990
.meas tran vdout0_75ck197 FIND v(dout0_75) AT=990.025n

* CHECK dout0_76 Vdout0_76ck197 = 0 time = 990
.meas tran vdout0_76ck197 FIND v(dout0_76) AT=990.025n

* CHECK dout0_77 Vdout0_77ck197 = 0.9 time = 990
.meas tran vdout0_77ck197 FIND v(dout0_77) AT=990.025n

* CHECK dout0_78 Vdout0_78ck197 = 0.9 time = 990
.meas tran vdout0_78ck197 FIND v(dout0_78) AT=990.025n

* CHECK dout0_79 Vdout0_79ck197 = 0 time = 990
.meas tran vdout0_79ck197 FIND v(dout0_79) AT=990.025n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 1000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=1000.025n

* CHECK dout0_1 Vdout0_1ck199 = 0.9 time = 1000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=1000.025n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 1000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=1000.025n

* CHECK dout0_3 Vdout0_3ck199 = 0.9 time = 1000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=1000.025n

* CHECK dout0_4 Vdout0_4ck199 = 0.9 time = 1000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=1000.025n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 1000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=1000.025n

* CHECK dout0_6 Vdout0_6ck199 = 0.9 time = 1000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=1000.025n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 1000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=1000.025n

* CHECK dout0_8 Vdout0_8ck199 = 0 time = 1000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=1000.025n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 1000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=1000.025n

* CHECK dout0_10 Vdout0_10ck199 = 0 time = 1000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=1000.025n

* CHECK dout0_11 Vdout0_11ck199 = 0.9 time = 1000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=1000.025n

* CHECK dout0_12 Vdout0_12ck199 = 0 time = 1000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=1000.025n

* CHECK dout0_13 Vdout0_13ck199 = 0.9 time = 1000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=1000.025n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 1000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=1000.025n

* CHECK dout0_15 Vdout0_15ck199 = 0 time = 1000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=1000.025n

* CHECK dout0_16 Vdout0_16ck199 = 0.9 time = 1000
.meas tran vdout0_16ck199 FIND v(dout0_16) AT=1000.025n

* CHECK dout0_17 Vdout0_17ck199 = 0 time = 1000
.meas tran vdout0_17ck199 FIND v(dout0_17) AT=1000.025n

* CHECK dout0_18 Vdout0_18ck199 = 0 time = 1000
.meas tran vdout0_18ck199 FIND v(dout0_18) AT=1000.025n

* CHECK dout0_19 Vdout0_19ck199 = 0.9 time = 1000
.meas tran vdout0_19ck199 FIND v(dout0_19) AT=1000.025n

* CHECK dout0_20 Vdout0_20ck199 = 0 time = 1000
.meas tran vdout0_20ck199 FIND v(dout0_20) AT=1000.025n

* CHECK dout0_21 Vdout0_21ck199 = 0 time = 1000
.meas tran vdout0_21ck199 FIND v(dout0_21) AT=1000.025n

* CHECK dout0_22 Vdout0_22ck199 = 0 time = 1000
.meas tran vdout0_22ck199 FIND v(dout0_22) AT=1000.025n

* CHECK dout0_23 Vdout0_23ck199 = 0.9 time = 1000
.meas tran vdout0_23ck199 FIND v(dout0_23) AT=1000.025n

* CHECK dout0_24 Vdout0_24ck199 = 0 time = 1000
.meas tran vdout0_24ck199 FIND v(dout0_24) AT=1000.025n

* CHECK dout0_25 Vdout0_25ck199 = 0 time = 1000
.meas tran vdout0_25ck199 FIND v(dout0_25) AT=1000.025n

* CHECK dout0_26 Vdout0_26ck199 = 0.9 time = 1000
.meas tran vdout0_26ck199 FIND v(dout0_26) AT=1000.025n

* CHECK dout0_27 Vdout0_27ck199 = 0 time = 1000
.meas tran vdout0_27ck199 FIND v(dout0_27) AT=1000.025n

* CHECK dout0_28 Vdout0_28ck199 = 0.9 time = 1000
.meas tran vdout0_28ck199 FIND v(dout0_28) AT=1000.025n

* CHECK dout0_29 Vdout0_29ck199 = 0.9 time = 1000
.meas tran vdout0_29ck199 FIND v(dout0_29) AT=1000.025n

* CHECK dout0_30 Vdout0_30ck199 = 0 time = 1000
.meas tran vdout0_30ck199 FIND v(dout0_30) AT=1000.025n

* CHECK dout0_31 Vdout0_31ck199 = 0 time = 1000
.meas tran vdout0_31ck199 FIND v(dout0_31) AT=1000.025n

* CHECK dout0_32 Vdout0_32ck199 = 0 time = 1000
.meas tran vdout0_32ck199 FIND v(dout0_32) AT=1000.025n

* CHECK dout0_33 Vdout0_33ck199 = 0 time = 1000
.meas tran vdout0_33ck199 FIND v(dout0_33) AT=1000.025n

* CHECK dout0_34 Vdout0_34ck199 = 0 time = 1000
.meas tran vdout0_34ck199 FIND v(dout0_34) AT=1000.025n

* CHECK dout0_35 Vdout0_35ck199 = 0 time = 1000
.meas tran vdout0_35ck199 FIND v(dout0_35) AT=1000.025n

* CHECK dout0_36 Vdout0_36ck199 = 0.9 time = 1000
.meas tran vdout0_36ck199 FIND v(dout0_36) AT=1000.025n

* CHECK dout0_37 Vdout0_37ck199 = 0 time = 1000
.meas tran vdout0_37ck199 FIND v(dout0_37) AT=1000.025n

* CHECK dout0_38 Vdout0_38ck199 = 0 time = 1000
.meas tran vdout0_38ck199 FIND v(dout0_38) AT=1000.025n

* CHECK dout0_39 Vdout0_39ck199 = 0 time = 1000
.meas tran vdout0_39ck199 FIND v(dout0_39) AT=1000.025n

* CHECK dout0_40 Vdout0_40ck199 = 0 time = 1000
.meas tran vdout0_40ck199 FIND v(dout0_40) AT=1000.025n

* CHECK dout0_41 Vdout0_41ck199 = 0 time = 1000
.meas tran vdout0_41ck199 FIND v(dout0_41) AT=1000.025n

* CHECK dout0_42 Vdout0_42ck199 = 0.9 time = 1000
.meas tran vdout0_42ck199 FIND v(dout0_42) AT=1000.025n

* CHECK dout0_43 Vdout0_43ck199 = 0.9 time = 1000
.meas tran vdout0_43ck199 FIND v(dout0_43) AT=1000.025n

* CHECK dout0_44 Vdout0_44ck199 = 0.9 time = 1000
.meas tran vdout0_44ck199 FIND v(dout0_44) AT=1000.025n

* CHECK dout0_45 Vdout0_45ck199 = 0 time = 1000
.meas tran vdout0_45ck199 FIND v(dout0_45) AT=1000.025n

* CHECK dout0_46 Vdout0_46ck199 = 0 time = 1000
.meas tran vdout0_46ck199 FIND v(dout0_46) AT=1000.025n

* CHECK dout0_47 Vdout0_47ck199 = 0.9 time = 1000
.meas tran vdout0_47ck199 FIND v(dout0_47) AT=1000.025n

* CHECK dout0_48 Vdout0_48ck199 = 0.9 time = 1000
.meas tran vdout0_48ck199 FIND v(dout0_48) AT=1000.025n

* CHECK dout0_49 Vdout0_49ck199 = 0.9 time = 1000
.meas tran vdout0_49ck199 FIND v(dout0_49) AT=1000.025n

* CHECK dout0_50 Vdout0_50ck199 = 0 time = 1000
.meas tran vdout0_50ck199 FIND v(dout0_50) AT=1000.025n

* CHECK dout0_51 Vdout0_51ck199 = 0.9 time = 1000
.meas tran vdout0_51ck199 FIND v(dout0_51) AT=1000.025n

* CHECK dout0_52 Vdout0_52ck199 = 0 time = 1000
.meas tran vdout0_52ck199 FIND v(dout0_52) AT=1000.025n

* CHECK dout0_53 Vdout0_53ck199 = 0 time = 1000
.meas tran vdout0_53ck199 FIND v(dout0_53) AT=1000.025n

* CHECK dout0_54 Vdout0_54ck199 = 0 time = 1000
.meas tran vdout0_54ck199 FIND v(dout0_54) AT=1000.025n

* CHECK dout0_55 Vdout0_55ck199 = 0.9 time = 1000
.meas tran vdout0_55ck199 FIND v(dout0_55) AT=1000.025n

* CHECK dout0_56 Vdout0_56ck199 = 0.9 time = 1000
.meas tran vdout0_56ck199 FIND v(dout0_56) AT=1000.025n

* CHECK dout0_57 Vdout0_57ck199 = 0 time = 1000
.meas tran vdout0_57ck199 FIND v(dout0_57) AT=1000.025n

* CHECK dout0_58 Vdout0_58ck199 = 0 time = 1000
.meas tran vdout0_58ck199 FIND v(dout0_58) AT=1000.025n

* CHECK dout0_59 Vdout0_59ck199 = 0 time = 1000
.meas tran vdout0_59ck199 FIND v(dout0_59) AT=1000.025n

* CHECK dout0_60 Vdout0_60ck199 = 0 time = 1000
.meas tran vdout0_60ck199 FIND v(dout0_60) AT=1000.025n

* CHECK dout0_61 Vdout0_61ck199 = 0.9 time = 1000
.meas tran vdout0_61ck199 FIND v(dout0_61) AT=1000.025n

* CHECK dout0_62 Vdout0_62ck199 = 0.9 time = 1000
.meas tran vdout0_62ck199 FIND v(dout0_62) AT=1000.025n

* CHECK dout0_63 Vdout0_63ck199 = 0.9 time = 1000
.meas tran vdout0_63ck199 FIND v(dout0_63) AT=1000.025n

* CHECK dout0_64 Vdout0_64ck199 = 0.9 time = 1000
.meas tran vdout0_64ck199 FIND v(dout0_64) AT=1000.025n

* CHECK dout0_65 Vdout0_65ck199 = 0.9 time = 1000
.meas tran vdout0_65ck199 FIND v(dout0_65) AT=1000.025n

* CHECK dout0_66 Vdout0_66ck199 = 0 time = 1000
.meas tran vdout0_66ck199 FIND v(dout0_66) AT=1000.025n

* CHECK dout0_67 Vdout0_67ck199 = 0.9 time = 1000
.meas tran vdout0_67ck199 FIND v(dout0_67) AT=1000.025n

* CHECK dout0_68 Vdout0_68ck199 = 0.9 time = 1000
.meas tran vdout0_68ck199 FIND v(dout0_68) AT=1000.025n

* CHECK dout0_69 Vdout0_69ck199 = 0 time = 1000
.meas tran vdout0_69ck199 FIND v(dout0_69) AT=1000.025n

* CHECK dout0_70 Vdout0_70ck199 = 0 time = 1000
.meas tran vdout0_70ck199 FIND v(dout0_70) AT=1000.025n

* CHECK dout0_71 Vdout0_71ck199 = 0 time = 1000
.meas tran vdout0_71ck199 FIND v(dout0_71) AT=1000.025n

* CHECK dout0_72 Vdout0_72ck199 = 0 time = 1000
.meas tran vdout0_72ck199 FIND v(dout0_72) AT=1000.025n

* CHECK dout0_73 Vdout0_73ck199 = 0 time = 1000
.meas tran vdout0_73ck199 FIND v(dout0_73) AT=1000.025n

* CHECK dout0_74 Vdout0_74ck199 = 0 time = 1000
.meas tran vdout0_74ck199 FIND v(dout0_74) AT=1000.025n

* CHECK dout0_75 Vdout0_75ck199 = 0 time = 1000
.meas tran vdout0_75ck199 FIND v(dout0_75) AT=1000.025n

* CHECK dout0_76 Vdout0_76ck199 = 0 time = 1000
.meas tran vdout0_76ck199 FIND v(dout0_76) AT=1000.025n

* CHECK dout0_77 Vdout0_77ck199 = 0 time = 1000
.meas tran vdout0_77ck199 FIND v(dout0_77) AT=1000.025n

* CHECK dout0_78 Vdout0_78ck199 = 0 time = 1000
.meas tran vdout0_78ck199 FIND v(dout0_78) AT=1000.025n

* CHECK dout0_79 Vdout0_79ck199 = 0.9 time = 1000
.meas tran vdout0_79ck199 FIND v(dout0_79) AT=1000.025n

* CHECK dout0_0 Vdout0_0ck202 = 0 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 0.9 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 0.9 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 0.9 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 0.9 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0.9 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 0.9 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 0 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 0 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 0 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 0 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 0.9 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 0.9 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 0 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 0.9 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 0 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 0.9 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 0 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_32 Vdout0_32ck202 = 0 time = 1015
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=1015.025n

* CHECK dout0_33 Vdout0_33ck202 = 0 time = 1015
.meas tran vdout0_33ck202 FIND v(dout0_33) AT=1015.025n

* CHECK dout0_34 Vdout0_34ck202 = 0 time = 1015
.meas tran vdout0_34ck202 FIND v(dout0_34) AT=1015.025n

* CHECK dout0_35 Vdout0_35ck202 = 0.9 time = 1015
.meas tran vdout0_35ck202 FIND v(dout0_35) AT=1015.025n

* CHECK dout0_36 Vdout0_36ck202 = 0.9 time = 1015
.meas tran vdout0_36ck202 FIND v(dout0_36) AT=1015.025n

* CHECK dout0_37 Vdout0_37ck202 = 0 time = 1015
.meas tran vdout0_37ck202 FIND v(dout0_37) AT=1015.025n

* CHECK dout0_38 Vdout0_38ck202 = 0 time = 1015
.meas tran vdout0_38ck202 FIND v(dout0_38) AT=1015.025n

* CHECK dout0_39 Vdout0_39ck202 = 0 time = 1015
.meas tran vdout0_39ck202 FIND v(dout0_39) AT=1015.025n

* CHECK dout0_40 Vdout0_40ck202 = 0.9 time = 1015
.meas tran vdout0_40ck202 FIND v(dout0_40) AT=1015.025n

* CHECK dout0_41 Vdout0_41ck202 = 0.9 time = 1015
.meas tran vdout0_41ck202 FIND v(dout0_41) AT=1015.025n

* CHECK dout0_42 Vdout0_42ck202 = 0 time = 1015
.meas tran vdout0_42ck202 FIND v(dout0_42) AT=1015.025n

* CHECK dout0_43 Vdout0_43ck202 = 0 time = 1015
.meas tran vdout0_43ck202 FIND v(dout0_43) AT=1015.025n

* CHECK dout0_44 Vdout0_44ck202 = 0 time = 1015
.meas tran vdout0_44ck202 FIND v(dout0_44) AT=1015.025n

* CHECK dout0_45 Vdout0_45ck202 = 0 time = 1015
.meas tran vdout0_45ck202 FIND v(dout0_45) AT=1015.025n

* CHECK dout0_46 Vdout0_46ck202 = 0 time = 1015
.meas tran vdout0_46ck202 FIND v(dout0_46) AT=1015.025n

* CHECK dout0_47 Vdout0_47ck202 = 0 time = 1015
.meas tran vdout0_47ck202 FIND v(dout0_47) AT=1015.025n

* CHECK dout0_48 Vdout0_48ck202 = 0.9 time = 1015
.meas tran vdout0_48ck202 FIND v(dout0_48) AT=1015.025n

* CHECK dout0_49 Vdout0_49ck202 = 0 time = 1015
.meas tran vdout0_49ck202 FIND v(dout0_49) AT=1015.025n

* CHECK dout0_50 Vdout0_50ck202 = 0.9 time = 1015
.meas tran vdout0_50ck202 FIND v(dout0_50) AT=1015.025n

* CHECK dout0_51 Vdout0_51ck202 = 0.9 time = 1015
.meas tran vdout0_51ck202 FIND v(dout0_51) AT=1015.025n

* CHECK dout0_52 Vdout0_52ck202 = 0 time = 1015
.meas tran vdout0_52ck202 FIND v(dout0_52) AT=1015.025n

* CHECK dout0_53 Vdout0_53ck202 = 0.9 time = 1015
.meas tran vdout0_53ck202 FIND v(dout0_53) AT=1015.025n

* CHECK dout0_54 Vdout0_54ck202 = 0.9 time = 1015
.meas tran vdout0_54ck202 FIND v(dout0_54) AT=1015.025n

* CHECK dout0_55 Vdout0_55ck202 = 0 time = 1015
.meas tran vdout0_55ck202 FIND v(dout0_55) AT=1015.025n

* CHECK dout0_56 Vdout0_56ck202 = 0.9 time = 1015
.meas tran vdout0_56ck202 FIND v(dout0_56) AT=1015.025n

* CHECK dout0_57 Vdout0_57ck202 = 0.9 time = 1015
.meas tran vdout0_57ck202 FIND v(dout0_57) AT=1015.025n

* CHECK dout0_58 Vdout0_58ck202 = 0 time = 1015
.meas tran vdout0_58ck202 FIND v(dout0_58) AT=1015.025n

* CHECK dout0_59 Vdout0_59ck202 = 0.9 time = 1015
.meas tran vdout0_59ck202 FIND v(dout0_59) AT=1015.025n

* CHECK dout0_60 Vdout0_60ck202 = 0 time = 1015
.meas tran vdout0_60ck202 FIND v(dout0_60) AT=1015.025n

* CHECK dout0_61 Vdout0_61ck202 = 0.9 time = 1015
.meas tran vdout0_61ck202 FIND v(dout0_61) AT=1015.025n

* CHECK dout0_62 Vdout0_62ck202 = 0.9 time = 1015
.meas tran vdout0_62ck202 FIND v(dout0_62) AT=1015.025n

* CHECK dout0_63 Vdout0_63ck202 = 0.9 time = 1015
.meas tran vdout0_63ck202 FIND v(dout0_63) AT=1015.025n

* CHECK dout0_64 Vdout0_64ck202 = 0 time = 1015
.meas tran vdout0_64ck202 FIND v(dout0_64) AT=1015.025n

* CHECK dout0_65 Vdout0_65ck202 = 0.9 time = 1015
.meas tran vdout0_65ck202 FIND v(dout0_65) AT=1015.025n

* CHECK dout0_66 Vdout0_66ck202 = 0.9 time = 1015
.meas tran vdout0_66ck202 FIND v(dout0_66) AT=1015.025n

* CHECK dout0_67 Vdout0_67ck202 = 0 time = 1015
.meas tran vdout0_67ck202 FIND v(dout0_67) AT=1015.025n

* CHECK dout0_68 Vdout0_68ck202 = 0 time = 1015
.meas tran vdout0_68ck202 FIND v(dout0_68) AT=1015.025n

* CHECK dout0_69 Vdout0_69ck202 = 0.9 time = 1015
.meas tran vdout0_69ck202 FIND v(dout0_69) AT=1015.025n

* CHECK dout0_70 Vdout0_70ck202 = 0.9 time = 1015
.meas tran vdout0_70ck202 FIND v(dout0_70) AT=1015.025n

* CHECK dout0_71 Vdout0_71ck202 = 0.9 time = 1015
.meas tran vdout0_71ck202 FIND v(dout0_71) AT=1015.025n

* CHECK dout0_72 Vdout0_72ck202 = 0.9 time = 1015
.meas tran vdout0_72ck202 FIND v(dout0_72) AT=1015.025n

* CHECK dout0_73 Vdout0_73ck202 = 0 time = 1015
.meas tran vdout0_73ck202 FIND v(dout0_73) AT=1015.025n

* CHECK dout0_74 Vdout0_74ck202 = 0 time = 1015
.meas tran vdout0_74ck202 FIND v(dout0_74) AT=1015.025n

* CHECK dout0_75 Vdout0_75ck202 = 0.9 time = 1015
.meas tran vdout0_75ck202 FIND v(dout0_75) AT=1015.025n

* CHECK dout0_76 Vdout0_76ck202 = 0.9 time = 1015
.meas tran vdout0_76ck202 FIND v(dout0_76) AT=1015.025n

* CHECK dout0_77 Vdout0_77ck202 = 0 time = 1015
.meas tran vdout0_77ck202 FIND v(dout0_77) AT=1015.025n

* CHECK dout0_78 Vdout0_78ck202 = 0.9 time = 1015
.meas tran vdout0_78ck202 FIND v(dout0_78) AT=1015.025n

* CHECK dout0_79 Vdout0_79ck202 = 0.9 time = 1015
.meas tran vdout0_79ck202 FIND v(dout0_79) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 1020
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=1020.025n

* CHECK dout0_1 Vdout0_1ck203 = 0.9 time = 1020
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=1020.025n

* CHECK dout0_2 Vdout0_2ck203 = 0 time = 1020
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=1020.025n

* CHECK dout0_3 Vdout0_3ck203 = 0.9 time = 1020
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=1020.025n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 1020
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=1020.025n

* CHECK dout0_5 Vdout0_5ck203 = 0.9 time = 1020
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=1020.025n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 1020
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=1020.025n

* CHECK dout0_7 Vdout0_7ck203 = 0.9 time = 1020
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=1020.025n

* CHECK dout0_8 Vdout0_8ck203 = 0 time = 1020
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=1020.025n

* CHECK dout0_9 Vdout0_9ck203 = 0 time = 1020
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=1020.025n

* CHECK dout0_10 Vdout0_10ck203 = 0 time = 1020
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=1020.025n

* CHECK dout0_11 Vdout0_11ck203 = 0 time = 1020
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=1020.025n

* CHECK dout0_12 Vdout0_12ck203 = 0 time = 1020
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=1020.025n

* CHECK dout0_13 Vdout0_13ck203 = 0 time = 1020
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=1020.025n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 1020
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=1020.025n

* CHECK dout0_15 Vdout0_15ck203 = 0 time = 1020
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=1020.025n

* CHECK dout0_16 Vdout0_16ck203 = 0.9 time = 1020
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=1020.025n

* CHECK dout0_17 Vdout0_17ck203 = 0 time = 1020
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=1020.025n

* CHECK dout0_18 Vdout0_18ck203 = 0 time = 1020
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=1020.025n

* CHECK dout0_19 Vdout0_19ck203 = 0 time = 1020
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=1020.025n

* CHECK dout0_20 Vdout0_20ck203 = 0.9 time = 1020
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=1020.025n

* CHECK dout0_21 Vdout0_21ck203 = 0 time = 1020
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=1020.025n

* CHECK dout0_22 Vdout0_22ck203 = 0.9 time = 1020
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=1020.025n

* CHECK dout0_23 Vdout0_23ck203 = 0.9 time = 1020
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=1020.025n

* CHECK dout0_24 Vdout0_24ck203 = 0.9 time = 1020
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=1020.025n

* CHECK dout0_25 Vdout0_25ck203 = 0.9 time = 1020
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=1020.025n

* CHECK dout0_26 Vdout0_26ck203 = 0.9 time = 1020
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=1020.025n

* CHECK dout0_27 Vdout0_27ck203 = 0 time = 1020
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=1020.025n

* CHECK dout0_28 Vdout0_28ck203 = 0.9 time = 1020
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=1020.025n

* CHECK dout0_29 Vdout0_29ck203 = 0.9 time = 1020
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=1020.025n

* CHECK dout0_30 Vdout0_30ck203 = 0.9 time = 1020
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=1020.025n

* CHECK dout0_31 Vdout0_31ck203 = 0 time = 1020
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=1020.025n

* CHECK dout0_32 Vdout0_32ck203 = 0.9 time = 1020
.meas tran vdout0_32ck203 FIND v(dout0_32) AT=1020.025n

* CHECK dout0_33 Vdout0_33ck203 = 0 time = 1020
.meas tran vdout0_33ck203 FIND v(dout0_33) AT=1020.025n

* CHECK dout0_34 Vdout0_34ck203 = 0.9 time = 1020
.meas tran vdout0_34ck203 FIND v(dout0_34) AT=1020.025n

* CHECK dout0_35 Vdout0_35ck203 = 0.9 time = 1020
.meas tran vdout0_35ck203 FIND v(dout0_35) AT=1020.025n

* CHECK dout0_36 Vdout0_36ck203 = 0 time = 1020
.meas tran vdout0_36ck203 FIND v(dout0_36) AT=1020.025n

* CHECK dout0_37 Vdout0_37ck203 = 0.9 time = 1020
.meas tran vdout0_37ck203 FIND v(dout0_37) AT=1020.025n

* CHECK dout0_38 Vdout0_38ck203 = 0 time = 1020
.meas tran vdout0_38ck203 FIND v(dout0_38) AT=1020.025n

* CHECK dout0_39 Vdout0_39ck203 = 0.9 time = 1020
.meas tran vdout0_39ck203 FIND v(dout0_39) AT=1020.025n

* CHECK dout0_40 Vdout0_40ck203 = 0.9 time = 1020
.meas tran vdout0_40ck203 FIND v(dout0_40) AT=1020.025n

* CHECK dout0_41 Vdout0_41ck203 = 0.9 time = 1020
.meas tran vdout0_41ck203 FIND v(dout0_41) AT=1020.025n

* CHECK dout0_42 Vdout0_42ck203 = 0 time = 1020
.meas tran vdout0_42ck203 FIND v(dout0_42) AT=1020.025n

* CHECK dout0_43 Vdout0_43ck203 = 0.9 time = 1020
.meas tran vdout0_43ck203 FIND v(dout0_43) AT=1020.025n

* CHECK dout0_44 Vdout0_44ck203 = 0 time = 1020
.meas tran vdout0_44ck203 FIND v(dout0_44) AT=1020.025n

* CHECK dout0_45 Vdout0_45ck203 = 0 time = 1020
.meas tran vdout0_45ck203 FIND v(dout0_45) AT=1020.025n

* CHECK dout0_46 Vdout0_46ck203 = 0.9 time = 1020
.meas tran vdout0_46ck203 FIND v(dout0_46) AT=1020.025n

* CHECK dout0_47 Vdout0_47ck203 = 0 time = 1020
.meas tran vdout0_47ck203 FIND v(dout0_47) AT=1020.025n

* CHECK dout0_48 Vdout0_48ck203 = 0.9 time = 1020
.meas tran vdout0_48ck203 FIND v(dout0_48) AT=1020.025n

* CHECK dout0_49 Vdout0_49ck203 = 0 time = 1020
.meas tran vdout0_49ck203 FIND v(dout0_49) AT=1020.025n

* CHECK dout0_50 Vdout0_50ck203 = 0 time = 1020
.meas tran vdout0_50ck203 FIND v(dout0_50) AT=1020.025n

* CHECK dout0_51 Vdout0_51ck203 = 0.9 time = 1020
.meas tran vdout0_51ck203 FIND v(dout0_51) AT=1020.025n

* CHECK dout0_52 Vdout0_52ck203 = 0 time = 1020
.meas tran vdout0_52ck203 FIND v(dout0_52) AT=1020.025n

* CHECK dout0_53 Vdout0_53ck203 = 0 time = 1020
.meas tran vdout0_53ck203 FIND v(dout0_53) AT=1020.025n

* CHECK dout0_54 Vdout0_54ck203 = 0 time = 1020
.meas tran vdout0_54ck203 FIND v(dout0_54) AT=1020.025n

* CHECK dout0_55 Vdout0_55ck203 = 0.9 time = 1020
.meas tran vdout0_55ck203 FIND v(dout0_55) AT=1020.025n

* CHECK dout0_56 Vdout0_56ck203 = 0.9 time = 1020
.meas tran vdout0_56ck203 FIND v(dout0_56) AT=1020.025n

* CHECK dout0_57 Vdout0_57ck203 = 0 time = 1020
.meas tran vdout0_57ck203 FIND v(dout0_57) AT=1020.025n

* CHECK dout0_58 Vdout0_58ck203 = 0.9 time = 1020
.meas tran vdout0_58ck203 FIND v(dout0_58) AT=1020.025n

* CHECK dout0_59 Vdout0_59ck203 = 0 time = 1020
.meas tran vdout0_59ck203 FIND v(dout0_59) AT=1020.025n

* CHECK dout0_60 Vdout0_60ck203 = 0 time = 1020
.meas tran vdout0_60ck203 FIND v(dout0_60) AT=1020.025n

* CHECK dout0_61 Vdout0_61ck203 = 0.9 time = 1020
.meas tran vdout0_61ck203 FIND v(dout0_61) AT=1020.025n

* CHECK dout0_62 Vdout0_62ck203 = 0.9 time = 1020
.meas tran vdout0_62ck203 FIND v(dout0_62) AT=1020.025n

* CHECK dout0_63 Vdout0_63ck203 = 0 time = 1020
.meas tran vdout0_63ck203 FIND v(dout0_63) AT=1020.025n

* CHECK dout0_64 Vdout0_64ck203 = 0.9 time = 1020
.meas tran vdout0_64ck203 FIND v(dout0_64) AT=1020.025n

* CHECK dout0_65 Vdout0_65ck203 = 0 time = 1020
.meas tran vdout0_65ck203 FIND v(dout0_65) AT=1020.025n

* CHECK dout0_66 Vdout0_66ck203 = 0.9 time = 1020
.meas tran vdout0_66ck203 FIND v(dout0_66) AT=1020.025n

* CHECK dout0_67 Vdout0_67ck203 = 0 time = 1020
.meas tran vdout0_67ck203 FIND v(dout0_67) AT=1020.025n

* CHECK dout0_68 Vdout0_68ck203 = 0.9 time = 1020
.meas tran vdout0_68ck203 FIND v(dout0_68) AT=1020.025n

* CHECK dout0_69 Vdout0_69ck203 = 0.9 time = 1020
.meas tran vdout0_69ck203 FIND v(dout0_69) AT=1020.025n

* CHECK dout0_70 Vdout0_70ck203 = 0 time = 1020
.meas tran vdout0_70ck203 FIND v(dout0_70) AT=1020.025n

* CHECK dout0_71 Vdout0_71ck203 = 0 time = 1020
.meas tran vdout0_71ck203 FIND v(dout0_71) AT=1020.025n

* CHECK dout0_72 Vdout0_72ck203 = 0.9 time = 1020
.meas tran vdout0_72ck203 FIND v(dout0_72) AT=1020.025n

* CHECK dout0_73 Vdout0_73ck203 = 0.9 time = 1020
.meas tran vdout0_73ck203 FIND v(dout0_73) AT=1020.025n

* CHECK dout0_74 Vdout0_74ck203 = 0.9 time = 1020
.meas tran vdout0_74ck203 FIND v(dout0_74) AT=1020.025n

* CHECK dout0_75 Vdout0_75ck203 = 0.9 time = 1020
.meas tran vdout0_75ck203 FIND v(dout0_75) AT=1020.025n

* CHECK dout0_76 Vdout0_76ck203 = 0 time = 1020
.meas tran vdout0_76ck203 FIND v(dout0_76) AT=1020.025n

* CHECK dout0_77 Vdout0_77ck203 = 0.9 time = 1020
.meas tran vdout0_77ck203 FIND v(dout0_77) AT=1020.025n

* CHECK dout0_78 Vdout0_78ck203 = 0.9 time = 1020
.meas tran vdout0_78ck203 FIND v(dout0_78) AT=1020.025n

* CHECK dout0_79 Vdout0_79ck203 = 0 time = 1020
.meas tran vdout0_79ck203 FIND v(dout0_79) AT=1020.025n

* CHECK dout0_0 Vdout0_0ck204 = 0 time = 1025
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=1025.025n

* CHECK dout0_1 Vdout0_1ck204 = 0.9 time = 1025
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=1025.025n

* CHECK dout0_2 Vdout0_2ck204 = 0 time = 1025
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=1025.025n

* CHECK dout0_3 Vdout0_3ck204 = 0.9 time = 1025
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=1025.025n

* CHECK dout0_4 Vdout0_4ck204 = 0 time = 1025
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=1025.025n

* CHECK dout0_5 Vdout0_5ck204 = 0.9 time = 1025
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=1025.025n

* CHECK dout0_6 Vdout0_6ck204 = 0 time = 1025
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=1025.025n

* CHECK dout0_7 Vdout0_7ck204 = 0.9 time = 1025
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=1025.025n

* CHECK dout0_8 Vdout0_8ck204 = 0 time = 1025
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=1025.025n

* CHECK dout0_9 Vdout0_9ck204 = 0 time = 1025
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=1025.025n

* CHECK dout0_10 Vdout0_10ck204 = 0 time = 1025
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=1025.025n

* CHECK dout0_11 Vdout0_11ck204 = 0 time = 1025
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=1025.025n

* CHECK dout0_12 Vdout0_12ck204 = 0 time = 1025
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=1025.025n

* CHECK dout0_13 Vdout0_13ck204 = 0 time = 1025
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=1025.025n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 1025
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=1025.025n

* CHECK dout0_15 Vdout0_15ck204 = 0 time = 1025
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=1025.025n

* CHECK dout0_16 Vdout0_16ck204 = 0.9 time = 1025
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=1025.025n

* CHECK dout0_17 Vdout0_17ck204 = 0 time = 1025
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=1025.025n

* CHECK dout0_18 Vdout0_18ck204 = 0 time = 1025
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=1025.025n

* CHECK dout0_19 Vdout0_19ck204 = 0 time = 1025
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=1025.025n

* CHECK dout0_20 Vdout0_20ck204 = 0.9 time = 1025
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=1025.025n

* CHECK dout0_21 Vdout0_21ck204 = 0 time = 1025
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=1025.025n

* CHECK dout0_22 Vdout0_22ck204 = 0.9 time = 1025
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=1025.025n

* CHECK dout0_23 Vdout0_23ck204 = 0.9 time = 1025
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=1025.025n

* CHECK dout0_24 Vdout0_24ck204 = 0.9 time = 1025
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=1025.025n

* CHECK dout0_25 Vdout0_25ck204 = 0.9 time = 1025
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=1025.025n

* CHECK dout0_26 Vdout0_26ck204 = 0.9 time = 1025
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=1025.025n

* CHECK dout0_27 Vdout0_27ck204 = 0 time = 1025
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=1025.025n

* CHECK dout0_28 Vdout0_28ck204 = 0.9 time = 1025
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=1025.025n

* CHECK dout0_29 Vdout0_29ck204 = 0.9 time = 1025
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=1025.025n

* CHECK dout0_30 Vdout0_30ck204 = 0.9 time = 1025
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=1025.025n

* CHECK dout0_31 Vdout0_31ck204 = 0 time = 1025
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=1025.025n

* CHECK dout0_32 Vdout0_32ck204 = 0.9 time = 1025
.meas tran vdout0_32ck204 FIND v(dout0_32) AT=1025.025n

* CHECK dout0_33 Vdout0_33ck204 = 0 time = 1025
.meas tran vdout0_33ck204 FIND v(dout0_33) AT=1025.025n

* CHECK dout0_34 Vdout0_34ck204 = 0.9 time = 1025
.meas tran vdout0_34ck204 FIND v(dout0_34) AT=1025.025n

* CHECK dout0_35 Vdout0_35ck204 = 0.9 time = 1025
.meas tran vdout0_35ck204 FIND v(dout0_35) AT=1025.025n

* CHECK dout0_36 Vdout0_36ck204 = 0 time = 1025
.meas tran vdout0_36ck204 FIND v(dout0_36) AT=1025.025n

* CHECK dout0_37 Vdout0_37ck204 = 0.9 time = 1025
.meas tran vdout0_37ck204 FIND v(dout0_37) AT=1025.025n

* CHECK dout0_38 Vdout0_38ck204 = 0 time = 1025
.meas tran vdout0_38ck204 FIND v(dout0_38) AT=1025.025n

* CHECK dout0_39 Vdout0_39ck204 = 0.9 time = 1025
.meas tran vdout0_39ck204 FIND v(dout0_39) AT=1025.025n

* CHECK dout0_40 Vdout0_40ck204 = 0.9 time = 1025
.meas tran vdout0_40ck204 FIND v(dout0_40) AT=1025.025n

* CHECK dout0_41 Vdout0_41ck204 = 0.9 time = 1025
.meas tran vdout0_41ck204 FIND v(dout0_41) AT=1025.025n

* CHECK dout0_42 Vdout0_42ck204 = 0 time = 1025
.meas tran vdout0_42ck204 FIND v(dout0_42) AT=1025.025n

* CHECK dout0_43 Vdout0_43ck204 = 0.9 time = 1025
.meas tran vdout0_43ck204 FIND v(dout0_43) AT=1025.025n

* CHECK dout0_44 Vdout0_44ck204 = 0 time = 1025
.meas tran vdout0_44ck204 FIND v(dout0_44) AT=1025.025n

* CHECK dout0_45 Vdout0_45ck204 = 0 time = 1025
.meas tran vdout0_45ck204 FIND v(dout0_45) AT=1025.025n

* CHECK dout0_46 Vdout0_46ck204 = 0.9 time = 1025
.meas tran vdout0_46ck204 FIND v(dout0_46) AT=1025.025n

* CHECK dout0_47 Vdout0_47ck204 = 0 time = 1025
.meas tran vdout0_47ck204 FIND v(dout0_47) AT=1025.025n

* CHECK dout0_48 Vdout0_48ck204 = 0.9 time = 1025
.meas tran vdout0_48ck204 FIND v(dout0_48) AT=1025.025n

* CHECK dout0_49 Vdout0_49ck204 = 0 time = 1025
.meas tran vdout0_49ck204 FIND v(dout0_49) AT=1025.025n

* CHECK dout0_50 Vdout0_50ck204 = 0 time = 1025
.meas tran vdout0_50ck204 FIND v(dout0_50) AT=1025.025n

* CHECK dout0_51 Vdout0_51ck204 = 0.9 time = 1025
.meas tran vdout0_51ck204 FIND v(dout0_51) AT=1025.025n

* CHECK dout0_52 Vdout0_52ck204 = 0 time = 1025
.meas tran vdout0_52ck204 FIND v(dout0_52) AT=1025.025n

* CHECK dout0_53 Vdout0_53ck204 = 0 time = 1025
.meas tran vdout0_53ck204 FIND v(dout0_53) AT=1025.025n

* CHECK dout0_54 Vdout0_54ck204 = 0 time = 1025
.meas tran vdout0_54ck204 FIND v(dout0_54) AT=1025.025n

* CHECK dout0_55 Vdout0_55ck204 = 0.9 time = 1025
.meas tran vdout0_55ck204 FIND v(dout0_55) AT=1025.025n

* CHECK dout0_56 Vdout0_56ck204 = 0.9 time = 1025
.meas tran vdout0_56ck204 FIND v(dout0_56) AT=1025.025n

* CHECK dout0_57 Vdout0_57ck204 = 0 time = 1025
.meas tran vdout0_57ck204 FIND v(dout0_57) AT=1025.025n

* CHECK dout0_58 Vdout0_58ck204 = 0.9 time = 1025
.meas tran vdout0_58ck204 FIND v(dout0_58) AT=1025.025n

* CHECK dout0_59 Vdout0_59ck204 = 0 time = 1025
.meas tran vdout0_59ck204 FIND v(dout0_59) AT=1025.025n

* CHECK dout0_60 Vdout0_60ck204 = 0 time = 1025
.meas tran vdout0_60ck204 FIND v(dout0_60) AT=1025.025n

* CHECK dout0_61 Vdout0_61ck204 = 0.9 time = 1025
.meas tran vdout0_61ck204 FIND v(dout0_61) AT=1025.025n

* CHECK dout0_62 Vdout0_62ck204 = 0.9 time = 1025
.meas tran vdout0_62ck204 FIND v(dout0_62) AT=1025.025n

* CHECK dout0_63 Vdout0_63ck204 = 0 time = 1025
.meas tran vdout0_63ck204 FIND v(dout0_63) AT=1025.025n

* CHECK dout0_64 Vdout0_64ck204 = 0.9 time = 1025
.meas tran vdout0_64ck204 FIND v(dout0_64) AT=1025.025n

* CHECK dout0_65 Vdout0_65ck204 = 0 time = 1025
.meas tran vdout0_65ck204 FIND v(dout0_65) AT=1025.025n

* CHECK dout0_66 Vdout0_66ck204 = 0.9 time = 1025
.meas tran vdout0_66ck204 FIND v(dout0_66) AT=1025.025n

* CHECK dout0_67 Vdout0_67ck204 = 0 time = 1025
.meas tran vdout0_67ck204 FIND v(dout0_67) AT=1025.025n

* CHECK dout0_68 Vdout0_68ck204 = 0.9 time = 1025
.meas tran vdout0_68ck204 FIND v(dout0_68) AT=1025.025n

* CHECK dout0_69 Vdout0_69ck204 = 0.9 time = 1025
.meas tran vdout0_69ck204 FIND v(dout0_69) AT=1025.025n

* CHECK dout0_70 Vdout0_70ck204 = 0 time = 1025
.meas tran vdout0_70ck204 FIND v(dout0_70) AT=1025.025n

* CHECK dout0_71 Vdout0_71ck204 = 0 time = 1025
.meas tran vdout0_71ck204 FIND v(dout0_71) AT=1025.025n

* CHECK dout0_72 Vdout0_72ck204 = 0.9 time = 1025
.meas tran vdout0_72ck204 FIND v(dout0_72) AT=1025.025n

* CHECK dout0_73 Vdout0_73ck204 = 0.9 time = 1025
.meas tran vdout0_73ck204 FIND v(dout0_73) AT=1025.025n

* CHECK dout0_74 Vdout0_74ck204 = 0.9 time = 1025
.meas tran vdout0_74ck204 FIND v(dout0_74) AT=1025.025n

* CHECK dout0_75 Vdout0_75ck204 = 0.9 time = 1025
.meas tran vdout0_75ck204 FIND v(dout0_75) AT=1025.025n

* CHECK dout0_76 Vdout0_76ck204 = 0 time = 1025
.meas tran vdout0_76ck204 FIND v(dout0_76) AT=1025.025n

* CHECK dout0_77 Vdout0_77ck204 = 0.9 time = 1025
.meas tran vdout0_77ck204 FIND v(dout0_77) AT=1025.025n

* CHECK dout0_78 Vdout0_78ck204 = 0.9 time = 1025
.meas tran vdout0_78ck204 FIND v(dout0_78) AT=1025.025n

* CHECK dout0_79 Vdout0_79ck204 = 0 time = 1025
.meas tran vdout0_79ck204 FIND v(dout0_79) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
