* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_128x56_14.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_128x56_14 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a1_0 a1_1 a1_2 a1_3 a1_4 a1_5 a1_6 CSB0 CSB1 clk0 clk1 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 vdd gnd freepdk45_sram_1w1r_128x56_14

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_128x56_14.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_128x56_14.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_128x56_14.s_en
* q:	xfreepdk45_sram_1w1r_128x56_14.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_128x56_14.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 00010110100010101101011010010110010101000111100001100100  to  address 1111110 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 00111110011110011010111111001000001111011011110100101110  to  address 1111101 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 00011000001001011010011100001100001111100010011100101001  to  address 1111110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 00111110011110011010111111001000001111011011110100101110 from address 1111101 (from port 1) during cycle 4 (20ns - 25ns)
*	Reading 00011000001001011010011100001100001111100010011100101001 from address 1111110 (from port 1) during cycle 6 (30ns - 35ns)
*	Writing 00111000101100010100101001100111101111100010011100000011  to  address 1111101 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing (partial) 00111110101010000100011001101110111010011110110011010111  to  address 1111110 with mask bit 0100 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing 01111100110000110001000001110110101100111011101000011000  to  address 1111101 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing 01011100100000101100001011110001110011001010110011011000  to  address 1111101 (from port 0) during cycle 11 (55ns - 60ns)
*	Writing (partial) 00010000010000011011010010101001101111110000101010110110  to  address 1111101 with mask bit 1001 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 00011000001001000100011001101100001111100010011100101001 from address 1111110 (from port 1) during cycle 12 (60ns - 65ns)
*	Writing (partial) 10000101011111011101101110100100010010110010011010000010  to  address 1111101 with mask bit 1110 (from port 0) during cycle 13 (65ns - 70ns)
*	Writing 00000010101101001110111010011110110111000100100100111110  to  address 1111110 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 10000101011111011101101110100100010010110000101010110110 from address 1111101 (from port 1) during cycle 16 (80ns - 85ns)
*	Reading 10000101011111011101101110100100010010110000101010110110 from address 1111101 (from port 1) during cycle 17 (85ns - 90ns)
*	Writing (partial) 01010010010111100011011001111111110011110000011100011100  to  address 1111110 with mask bit 0111 (from port 0) during cycle 19 (95ns - 100ns)
*	Writing (partial) 11100110110100111000000010001011001110110001110100001111  to  address 1111101 with mask bit 1001 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 00000010101101100011011001111111110011110000011100011100 from address 1111110 (from port 1) during cycle 21 (105ns - 110ns)
*	Writing 11110110001011111110010011001111010101111110100111000101  to  address 0000001 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 10001110000100010111011010101110100100101100010011100110  to  address 0000000 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 11110110001011111110010011001111010101111110100111000101 from address 0000001 (from port 1) during cycle 23 (115ns - 120ns)
*	Writing (partial) 11111000011011110101111001010001010010000110001001010010  to  address 0000001 with mask bit 0001 (from port 0) during cycle 26 (130ns - 135ns)
*	Reading 10001110000100010111011010101110100100101100010011100110 from address 0000000 (from port 1) during cycle 26 (130ns - 135ns)
*	Reading 11110110001011111110010011001111010101111110001001010010 from address 0000001 (from port 1) during cycle 27 (135ns - 140ns)
*	Writing (partial) 10001010010010001101000110010000100011000111110001111111  to  address 0000001 with mask bit 1010 (from port 0) during cycle 28 (140ns - 145ns)
*	Writing (partial) 00001101110000000111110000000110000000110100110111000100  to  address 1111110 with mask bit 1000 (from port 0) during cycle 29 (145ns - 150ns)
*	Writing (partial) 10111001000101100111100011110111000111000111010111000101  to  address 1111101 with mask bit 0110 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 10001110000100010111011010101110100100101100010011100110 from address 0000000 (from port 1) during cycle 32 (160ns - 165ns)
*	Writing (partial) 00100011101100000111000001001011100011100101000011111101  to  address 1111101 with mask bit 1100 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 10001010010010111110010011000000100011000110001001010010 from address 0000001 (from port 1) during cycle 33 (165ns - 170ns)
*	Writing (partial) 00100011011011110000011000001011010010111001000010111000  to  address 1111101 with mask bit 1010 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 00001101110000100011011001111111110011110000011100011100 from address 1111110 (from port 1) during cycle 34 (170ns - 175ns)
*	Writing (partial) 01110000111110111111100101100001110001111100101110000101  to  address 1111101 with mask bit 0011 (from port 0) during cycle 35 (175ns - 180ns)
*	Reading 10001110000100010111011010101110100100101100010011100110 from address 0000000 (from port 1) during cycle 35 (175ns - 180ns)
*	Writing (partial) 10101101100011110011101001011000100001101011110110101011  to  address 1111101 with mask bit 1011 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 10101101100011000111000001001000100001101011110110101011 from address 1111101 (from port 1) during cycle 37 (185ns - 190ns)
*	Reading 10101101100011000111000001001000100001101011110110101011 from address 1111101 (from port 1) during cycle 38 (190ns - 195ns)
*	Writing 00000110001111100110011100000111000001110100100000000101  to  address 0000000 (from port 0) during cycle 39 (195ns - 200ns)
*	Writing (partial) 01100010000000110111000111010000010011111001111001111011  to  address 0000001 with mask bit 0001 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing (partial) 01010111000111001011110110000111100011000010101100100110  to  address 1111101 with mask bit 1110 (from port 0) during cycle 43 (215ns - 220ns)
*	Writing (partial) 01001111111000000111111111001011101100010010110101111101  to  address 0000000 with mask bit 0111 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing (partial) 00100101111110010000000000000010001010111110110111001100  to  address 1111101 with mask bit 0101 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 10001010010010111110010011000000100011000101111001111011 from address 0000001 (from port 1) during cycle 45 (225ns - 230ns)
*	Writing (partial) 00110110001010100101110010100010101010000001010100001111  to  address 1111101 with mask bit 0110 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 00000110001111000111111111001011101100010010110101111101 from address 0000000 (from port 1) during cycle 46 (230ns - 235ns)
*	Writing (partial) 10010011011110010011011100000010001110110010011110111110  to  address 0000000 with mask bit 0010 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 01010111000111100101110010100010101010000010110111001100 from address 1111101 (from port 1) during cycle 47 (235ns - 240ns)
*	Writing (partial) 10000001100100001111001110111000110100100011010110110110  to  address 1111110 with mask bit 0100 (from port 0) during cycle 48 (240ns - 245ns)
*	Reading 00000110001111000111111111000010001110110010110101111101 from address 0000000 (from port 1) during cycle 48 (240ns - 245ns)
*	Writing 11000001001001001111111111101001001100000011010011110110  to  address 0000001 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 01010111000111100101110010100010101010000010110111001100 from address 1111101 (from port 1) during cycle 50 (250ns - 255ns)
*	Writing 00111001000110111100101000110111110001011110111111010101  to  address 0000000 (from port 0) during cycle 51 (255ns - 260ns)
*	Reading 00001101110000001111001110111111110011110000011100011100 from address 1111110 (from port 1) during cycle 52 (260ns - 265ns)
*	Writing 11100010100001101011010001111001000110001011111101101000  to  address 1111110 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing (partial) 01000111111001100100111110011010101010100011101011111000  to  address 0000001 with mask bit 1010 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 00111001000110111100101000110111110001011110111111010101 from address 0000000 (from port 1) during cycle 54 (270ns - 275ns)
*	Writing (partial) 01101110011110110010001110011110111000010010010101110101  to  address 1111110 with mask bit 1001 (from port 0) during cycle 55 (275ns - 280ns)
*	Reading 00111001000110111100101000110111110001011110111111010101 from address 0000000 (from port 1) during cycle 56 (280ns - 285ns)
*	Writing 00011000100000000011011111011110110011100111100100011111  to  address 0000000 (from port 0) during cycle 58 (290ns - 295ns)
*	Reading 01010111000111100101110010100010101010000010110111001100 from address 1111101 (from port 1) during cycle 58 (290ns - 295ns)
*	Writing 01010010101001010011111010111101010000111011101000101001  to  address 1111101 (from port 0) during cycle 59 (295ns - 300ns)
*	Reading 00011000100000000011011111011110110011100111100100011111 from address 0000000 (from port 1) during cycle 59 (295ns - 300ns)
*	Reading 00011000100000000011011111011110110011100111100100011111 from address 0000000 (from port 1) during cycle 60 (300ns - 305ns)
*	Writing 10001011100100000111001110010110110111010010110001000001  to  address 0000000 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 01000111111001001111111111101010101010100011010011110110 from address 0000001 (from port 1) during cycle 61 (305ns - 310ns)
*	Writing 01100111001101111101011010000111010001001100101111000100  to  address 1111110 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 01010010101001010011111010111101010000111011101000101001 from address 1111101 (from port 1) during cycle 62 (310ns - 315ns)
*	Writing (partial) 11010101001010000010110001111011001110110001011011101011  to  address 0000000 with mask bit 0011 (from port 0) during cycle 63 (315ns - 320ns)
*	Reading 01000111111001001111111111101010101010100011010011110110 from address 0000001 (from port 1) during cycle 63 (315ns - 320ns)
*	Writing (partial) 00011110000101100111110010011010101110101001000111011100  to  address 0000000 with mask bit 1010 (from port 0) during cycle 64 (320ns - 325ns)
*	Reading 01100111001101111101011010000111010001001100101111000100 from address 1111110 (from port 1) during cycle 64 (320ns - 325ns)
*	Reading 01000111111001001111111111101010101010100011010011110110 from address 0000001 (from port 1) during cycle 65 (325ns - 330ns)
*	Writing 11101000110000110100101111000001101001001110011100011110  to  address 0000000 (from port 0) during cycle 66 (330ns - 335ns)
*	Writing 10000000101100100000010000000011011010110001001101001101  to  address 1111101 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 11101111011000110000110111001111011010001010110100100110  to  address 0000000 (from port 0) during cycle 70 (350ns - 355ns)
*	Writing (partial) 01110100100100100100100110001100010110010000101101110110  to  address 1111110 with mask bit 1000 (from port 0) during cycle 71 (355ns - 360ns)
*	Writing (partial) 00111101100101000011101000110011111000010001110110011010  to  address 1111101 with mask bit 1100 (from port 0) during cycle 73 (365ns - 370ns)
*	Reading 11101111011000110000110111001111011010001010110100100110 from address 0000000 (from port 1) during cycle 73 (365ns - 370ns)
*	Writing (partial) 00010100111001110001001111110111110101111001101111101110  to  address 0000000 with mask bit 1000 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing 10000101100001110011101010001100011110000100010000010100  to  address 0000000 (from port 0) during cycle 75 (375ns - 380ns)
*	Writing (partial) 11110101111011001011100110001001011001101000101010101110  to  address 0000001 with mask bit 0100 (from port 0) during cycle 76 (380ns - 385ns)
*	Writing 01111000111110001110111000011100011101100100101011011001  to  address 1111110 (from port 0) during cycle 77 (385ns - 390ns)
*	Writing 10101111101100011110110101000101001110101001001100000001  to  address 1111101 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing 10010111001011100111010101000110010010011110011011110111  to  address 0000001 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 10101111101100011110110101000101001110101001001100000001 from address 1111101 (from port 1) during cycle 79 (395ns - 400ns)
*	Writing 01110011111111011010000011010000010110010000001011101110  to  address 1111110 (from port 0) during cycle 80 (400ns - 405ns)
*	Writing (partial) 10001000011110111001000000000100101000101010010011110100  to  address 0000000 with mask bit 0100 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing (partial) 00101000110010011101110100101110101010101001011000100000  to  address 0000000 with mask bit 0001 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 10101111101100011110110101000101001110101001001100000001 from address 1111101 (from port 1) during cycle 84 (420ns - 425ns)
*	Writing (partial) 10100111100101110111000101111111100111011100101100000110  to  address 0000001 with mask bit 1000 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 01110011111111011010000011010000010110010000001011101110 from address 1111110 (from port 1) during cycle 86 (430ns - 435ns)
*	Writing 01110011110101111111111010001000000110010011001111110011  to  address 0000001 (from port 0) during cycle 87 (435ns - 440ns)
*	Reading 01110011111111011010000011010000010110010000001011101110 from address 1111110 (from port 1) during cycle 87 (435ns - 440ns)
*	Writing (partial) 00001110111001010011111101100100101101101111101011000100  to  address 0000000 with mask bit 0001 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 01110011110101111111111010001000000110010011001111110011 from address 0000001 (from port 1) during cycle 91 (455ns - 460ns)
*	Writing (partial) 11100100001100101011011111010011001111110111100100100101  to  address 1111101 with mask bit 0110 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 01110011111111011010000011010000010110010000001011101110 from address 1111110 (from port 1) during cycle 92 (460ns - 465ns)
*	Writing (partial) 10111101011010001000111000110110010100011000100001101110  to  address 1111110 with mask bit 1101 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing 10010111110000100110010100000110101011110000110100111111  to  address 0000001 (from port 0) during cycle 94 (470ns - 475ns)
*	Writing (partial) 10000001100010010101001100011001010101111000101101101000  to  address 0000001 with mask bit 0110 (from port 0) during cycle 95 (475ns - 480ns)
*	Writing 11010001000101100000001111000100100010011001110011000001  to  address 1111101 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 10010111110000010101001100011001010101111000110100111111 from address 0000001 (from port 1) during cycle 97 (485ns - 490ns)
*	Reading 11010001000101100000001111000100100010011001110011000001 from address 1111101 (from port 1) during cycle 98 (490ns - 495ns)
*	Writing 01000001110111011110110001000001111110011100011111011011  to  address 0000001 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 11010001000101100000001111000100100010011001110011000001 from address 1111101 (from port 1) during cycle 99 (495ns - 500ns)
*	Writing (partial) 11110001110000001011100001010001000110011111011000010101  to  address 0000001 with mask bit 0110 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing 00001110010011000100101111010111111001100001001011010100  to  address 0000001 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 11010001000101100000001111000100100010011001110011000001 from address 1111101 (from port 1) during cycle 102 (510ns - 515ns)
*	Writing 01011010010011010100000100001111000001000110001110111010  to  address 1111101 (from port 0) during cycle 103 (515ns - 520ns)
*	Writing 11101110101001001011101011001111010000101010000000010100  to  address 1111101 (from port 0) during cycle 104 (520ns - 525ns)
*	Writing 01110001011110111001101001111011011001000001010001001001  to  address 0000001 (from port 0) during cycle 105 (525ns - 530ns)
*	Writing 11110000010110100000000001111000110100100010110010000010  to  address 1111101 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 01110001011110111001101001111011011001000001010001001001 from address 0000001 (from port 1) during cycle 106 (530ns - 535ns)
*	Writing (partial) 11100100100100000000001100001111011001111101011001001101  to  address 0000001 with mask bit 1000 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 11110000010110100000000001111000110100100010110010000010 from address 1111101 (from port 1) during cycle 108 (540ns - 545ns)
*	Writing (partial) 01000010000001111110010000001000001001000001010110000000  to  address 0000000 with mask bit 0011 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 10111101011010001000111000110000010110010000100001101110 from address 1111110 (from port 1) during cycle 109 (545ns - 550ns)
*	Writing (partial) 00010100100101101100110101001000110100000100101000010101  to  address 1111101 with mask bit 0011 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 10111101011010001000111000110000010110010000100001101110 from address 1111110 (from port 1) during cycle 110 (550ns - 555ns)
*	Writing 00100000111110001100000001100001001011011000101010001101  to  address 1111101 (from port 0) during cycle 112 (560ns - 565ns)
*	Writing 01001111000100000100100011010001101010100001111001101000  to  address 0000001 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 10000101100001111001000000001000001001000001010110000000 from address 0000000 (from port 1) during cycle 114 (570ns - 575ns)
*	Writing 01111001101010110010010011101000111001011111011001101011  to  address 0000001 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 01011101101111001011010100110000110000001101101111011000  to  address 1111101 (from port 0) during cycle 116 (580ns - 585ns)
*	Reading 01111001101010110010010011101000111001011111011001101011 from address 0000001 (from port 1) during cycle 116 (580ns - 585ns)
*	Writing 11100000100110011111111101101110111010001011011110011000  to  address 0000000 (from port 0) during cycle 118 (590ns - 595ns)
*	Writing (partial) 00010110000010110011001111110110010010011110011110100100  to  address 0000001 with mask bit 1001 (from port 0) during cycle 119 (595ns - 600ns)
*	Writing (partial) 10100001110101111101010011101111101000011001011001000001  to  address 1111101 with mask bit 1110 (from port 0) during cycle 120 (600ns - 605ns)
*	Writing 00110101110111011100010100010011101111011010101100011100  to  address 1111101 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 11100000100110011111111101101110111010001011011110011000 from address 0000000 (from port 1) during cycle 122 (610ns - 615ns)
*	Writing (partial) 01001110110001000001011110110110110100000000011001001010  to  address 0000000 with mask bit 1101 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing (partial) 01100101001111010000111001101000011001011000111010111000  to  address 1111101 with mask bit 1001 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing (partial) 00001001011111001110100000101110010010010011101000110111  to  address 1111101 with mask bit 0001 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing 11101101000101100011100101111011010001000000101100011111  to  address 0000000 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 00010101101001010000010110001101110000111110100011101001  to  address 0000001 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 01100101001111011100010100010011101111011011101000110111 from address 1111101 (from port 1) during cycle 127 (635ns - 640ns)
*	Reading 01100101001111011100010100010011101111011011101000110111 from address 1111101 (from port 1) during cycle 128 (640ns - 645ns)
*	Writing (partial) 11001101010011100110101010100011110110100000001100001011  to  address 0000000 with mask bit 1110 (from port 0) during cycle 129 (645ns - 650ns)
*	Writing 01100110100001010101110000110101011011000110111101011101  to  address 1111101 (from port 0) during cycle 130 (650ns - 655ns)
*	Reading 00010101101001010000010110001101110000111110100011101001 from address 0000001 (from port 1) during cycle 130 (650ns - 655ns)
*	Writing 00010111100001000101111100001100001010010100111001000001  to  address 1111101 (from port 0) during cycle 131 (655ns - 660ns)
*	Writing (partial) 11000111110010101101001111001000000011111111000011000110  to  address 0000000 with mask bit 1101 (from port 0) during cycle 132 (660ns - 665ns)
*	Reading 10111101011010001000111000110000010110010000100001101110 from address 1111110 (from port 1) during cycle 132 (660ns - 665ns)
*	Writing (partial) 01010011000101000001101010001111100010101110000100010111  to  address 1111110 with mask bit 1110 (from port 0) during cycle 133 (665ns - 670ns)
*	Reading 00010101101001010000010110001101110000111110100011101001 from address 0000001 (from port 1) during cycle 134 (670ns - 675ns)
*	Writing (partial) 11000010101001011110001010101111100111011111111100101011  to  address 0000001 with mask bit 0111 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing (partial) 00011000000101101011100100110010110111000000100011000111  to  address 0000001 with mask bit 0100 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 11000111110010101101001111000011110110100011000011000110 from address 0000000 (from port 1) during cycle 137 (685ns - 690ns)
*	Writing 01001100010010000000111110101111101110101001111101011101  to  address 1111110 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 11000111110010101101001111000011110110100011000011000110 from address 0000000 (from port 1) during cycle 139 (695ns - 700ns)
*	Writing 00111000001110011101000010101110100000000010001110011000  to  address 0000001 (from port 0) during cycle 140 (700ns - 705ns)
*	Writing (partial) 01110010101001010010001101101110101010110101011101001101  to  address 1111110 with mask bit 0111 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 11000111110010101101001111000011110110100011000011000110 from address 0000000 (from port 1) during cycle 141 (705ns - 710ns)
*	Writing (partial) 11111001001100011101010101001110110000010011100001011100  to  address 0000000 with mask bit 1101 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 00010111100001000101111100001100001010010100111001000001 from address 1111101 (from port 1) during cycle 142 (710ns - 715ns)
*	Writing 10001000110000000001010100010110100010100010001101010101  to  address 0000001 (from port 0) during cycle 143 (715ns - 720ns)
*	Writing 01100110110001001001111011101110011101001000011000010001  to  address 1111101 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing (partial) 01110011010011000010110111111000010001111011100111101000  to  address 1111110 with mask bit 1100 (from port 0) during cycle 145 (725ns - 730ns)
*	Writing 10110110110001111110010111100101011111011100100100110101  to  address 1111110 (from port 0) during cycle 146 (730ns - 735ns)
*	Reading 10001000110000000001010100010110100010100010001101010101 from address 0000001 (from port 1) during cycle 146 (730ns - 735ns)
*	Writing 00001100000101010110100001111000010010000011011001011100  to  address 1111101 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 10110110110001111110010111100101011111011100100100110101 from address 1111110 (from port 1) during cycle 147 (735ns - 740ns)
*	Reading 10110110110001111110010111100101011111011100100100110101 from address 1111110 (from port 1) during cycle 148 (740ns - 745ns)
*	Writing 10000100111100000001111100000101010010100010111000001101  to  address 1111110 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 10001000110000000001010100010110100010100010001101010101 from address 0000001 (from port 1) during cycle 149 (745ns - 750ns)
*	Writing 11111011111001001000101101101001101000110010101011010000  to  address 0000001 (from port 0) during cycle 150 (750ns - 755ns)
*	Writing 00111101011100010000010111010001000000111110000110011001  to  address 0000001 (from port 0) during cycle 151 (755ns - 760ns)
*	Reading 00001100000101010110100001111000010010000011011001011100 from address 1111101 (from port 1) during cycle 152 (760ns - 765ns)
*	Reading 00001100000101010110100001111000010010000011011001011100 from address 1111101 (from port 1) during cycle 153 (765ns - 770ns)
*	Writing (partial) 01101101001011011001101101110111111010001100110111101000  to  address 0000001 with mask bit 0001 (from port 0) during cycle 154 (770ns - 775ns)
*	Reading 00001100000101010110100001111000010010000011011001011100 from address 1111101 (from port 1) during cycle 154 (770ns - 775ns)
*	Writing (partial) 01011011000111010110101000011100101110000100110001111110  to  address 0000001 with mask bit 0011 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 10000100111100000001111100000101010010100010111000001101 from address 1111110 (from port 1) during cycle 155 (775ns - 780ns)
*	Writing (partial) 00011000001000111010001010001010110101011100010001010100  to  address 0000000 with mask bit 1010 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 10000100111100000001111100000101010010100010111000001101 from address 1111110 (from port 1) during cycle 157 (785ns - 790ns)
*	Writing (partial) 10010000101101000001010000011100111000111101000011101001  to  address 1111110 with mask bit 1100 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing (partial) 01011010010110011001011011100000101110000011011000101001  to  address 1111101 with mask bit 0110 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 00011000001000011101010101001010110101011111100001011100 from address 0000000 (from port 1) during cycle 159 (795ns - 800ns)
*	Reading 00001100000101011001011011100000101110000011011001011100 from address 1111101 (from port 1) during cycle 160 (800ns - 805ns)
*	Writing (partial) 10011111011111011101111101110100110101010111010000000110  to  address 1111110 with mask bit 1011 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 00111101011100010000010111011100101110000100110001111110 from address 0000001 (from port 1) during cycle 161 (805ns - 810ns)
*	Writing (partial) 10000001010001011100000000011000101100110000010011101110  to  address 1111110 with mask bit 0001 (from port 0) during cycle 162 (810ns - 815ns)
*	Writing 01111111100110100100000011011110111111000100010000011101  to  address 0000000 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 00111101011100010000010111011100101110000100110001111110 from address 0000001 (from port 1) during cycle 163 (815ns - 820ns)
*	Reading 00111101011100010000010111011100101110000100110001111110 from address 0000001 (from port 1) during cycle 164 (820ns - 825ns)
*	Writing 00110001010010011011100100000000001010110111001100100011  to  address 0000001 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 01111111100110100100000011011110111111000100010000011101 from address 0000000 (from port 1) during cycle 165 (825ns - 830ns)
*	Writing 11010000101100010000010101100010111001000010011101110001  to  address 0000000 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 00001100000101011001011011100000101110000011011001011100 from address 1111101 (from port 1) during cycle 168 (840ns - 845ns)
*	Writing (partial) 10110101001100011010011000101101100010010011110110111110  to  address 1111110 with mask bit 1010 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 00110001010010011011100100000000001010110111001100100011 from address 0000001 (from port 1) during cycle 169 (845ns - 850ns)
*	Writing 01010110111010101101101111101110001000100010110111101001  to  address 0000001 (from port 0) during cycle 170 (850ns - 855ns)
*	Reading 00001100000101011001011011100000101110000011011001011100 from address 1111101 (from port 1) during cycle 170 (850ns - 855ns)
*	Writing (partial) 01100011110100101110110011001001101100010111000110111001  to  address 1111110 with mask bit 1010 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 11010000101100010000010101100010111001000010011101110001 from address 0000000 (from port 1) during cycle 171 (855ns - 860ns)
*	Writing (partial) 01100101010101111010101100110100101111111100111010010010  to  address 0000000 with mask bit 0011 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing 01110001010001111011111000110010010100010100000011000111  to  address 1111101 (from port 0) during cycle 173 (865ns - 870ns)
*	Writing 00010000111101100111011111010000100100100110100101010100  to  address 0000000 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 174 (870ns - 875ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 175 (875ns - 880ns)
*	Writing (partial) 01111100000011010010001001001010001110011000110001111011  to  address 0000001 with mask bit 0110 (from port 0) during cycle 176 (880ns - 885ns)
*	Reading 01100011110100000001010000011001101100010100010011101110 from address 1111110 (from port 1) during cycle 176 (880ns - 885ns)
*	Writing (partial) 11010010011101000110000000101001111110000100001000100110  to  address 0000001 with mask bit 0001 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 01111001111111001101010111011010011101011101111101001001  to  address 0000000 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing (partial) 11111011100001011101110010110101101001001100011011110011  to  address 0000001 with mask bit 1101 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing (partial) 00010111011010011110110101111111010101010001111100100000  to  address 0000001 with mask bit 0100 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 11111011100001011110110101111010001110011000011011110011 from address 0000001 (from port 1) during cycle 186 (930ns - 935ns)
*	Writing 10110110011111111100100111000001000100000000100001010101  to  address 0000001 (from port 0) during cycle 189 (945ns - 950ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 189 (945ns - 950ns)
*	Writing (partial) 11100001000101100100000101111011000010000100010111001101  to  address 1111110 with mask bit 0001 (from port 0) during cycle 190 (950ns - 955ns)
*	Reading 01100011110100000001010000011001101100010100010111001101 from address 1111110 (from port 1) during cycle 191 (955ns - 960ns)
*	Writing 01101101000111010100011011010011110011100000010111111100  to  address 0000001 (from port 0) during cycle 192 (960ns - 965ns)
*	Writing (partial) 10100100011010001100011000111100000000110011011010010001  to  address 0000000 with mask bit 0100 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 01101101000111010100011011010011110011100000010111111100 from address 0000001 (from port 1) during cycle 193 (965ns - 970ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 195 (975ns - 980ns)
*	Writing (partial) 00001100110110110011111111111111011110011100001000111011  to  address 0000000 with mask bit 0010 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 01101101000111010100011011010011110011100000010111111100 from address 0000001 (from port 1) during cycle 197 (985ns - 990ns)
*	Writing (partial) 10001010011110101110100010110101110000101101011101111010  to  address 1111110 with mask bit 1101 (from port 0) during cycle 198 (990ns - 995ns)
*	Writing 00100100000001110100110111110010111110000001001001010001  to  address 0000000 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 199 (995ns - 1000ns)
*	Writing (partial) 10010101101101110000001101010011010110000011111100111110  to  address 1111110 with mask bit 0001 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 200 (1000ns - 1005ns)
*	Writing (partial) 01000011110000110010100100001101111110110010011010111011  to  address 0000000 with mask bit 1000 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Writing (partial) 10001100001111000000011110010011011010011011111000101011  to  address 0000000 with mask bit 1101 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Writing (partial) 10011101001001100010101000001001111011100001011011101001  to  address 0000001 with mask bit 0101 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Reading 01110001010001111011111000110010010100010100000011000111 from address 1111101 (from port 1) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 1), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 0), (710, 1), (715, 0), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_4  a1_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_5  a1_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_6  a1_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 1), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 0), (950, 1), (955, 0), (960, 1), (965, 0), (970, 1), (975, 0), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0.9 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0.9 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0.9 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0.9 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0.9 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0.9 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0.9 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0.9 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0.9 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0.9 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0.9 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0.9 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0.9 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0.9 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0.9 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0.9 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0.9 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0.9 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0.9 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0.9 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0.9 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0.9 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0.9 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0.9 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0.9 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0.9 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0.9 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0.9 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0.9 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0.9 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0.9 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_0 Vdout1_0ck6 = 0.9 time = 35
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=35.025n

* CHECK dout1_1 Vdout1_1ck6 = 0 time = 35
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=35.025n

* CHECK dout1_2 Vdout1_2ck6 = 0 time = 35
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=35.025n

* CHECK dout1_3 Vdout1_3ck6 = 0.9 time = 35
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=35.025n

* CHECK dout1_4 Vdout1_4ck6 = 0 time = 35
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=35.025n

* CHECK dout1_5 Vdout1_5ck6 = 0.9 time = 35
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=35.025n

* CHECK dout1_6 Vdout1_6ck6 = 0 time = 35
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=35.025n

* CHECK dout1_7 Vdout1_7ck6 = 0 time = 35
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=35.025n

* CHECK dout1_8 Vdout1_8ck6 = 0.9 time = 35
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=35.025n

* CHECK dout1_9 Vdout1_9ck6 = 0.9 time = 35
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=35.025n

* CHECK dout1_10 Vdout1_10ck6 = 0.9 time = 35
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=35.025n

* CHECK dout1_11 Vdout1_11ck6 = 0 time = 35
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=35.025n

* CHECK dout1_12 Vdout1_12ck6 = 0 time = 35
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=35.025n

* CHECK dout1_13 Vdout1_13ck6 = 0.9 time = 35
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=35.025n

* CHECK dout1_14 Vdout1_14ck6 = 0 time = 35
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=35.025n

* CHECK dout1_15 Vdout1_15ck6 = 0 time = 35
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=35.025n

* CHECK dout1_16 Vdout1_16ck6 = 0 time = 35
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=35.025n

* CHECK dout1_17 Vdout1_17ck6 = 0.9 time = 35
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=35.025n

* CHECK dout1_18 Vdout1_18ck6 = 0.9 time = 35
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=35.025n

* CHECK dout1_19 Vdout1_19ck6 = 0.9 time = 35
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=35.025n

* CHECK dout1_20 Vdout1_20ck6 = 0.9 time = 35
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=35.025n

* CHECK dout1_21 Vdout1_21ck6 = 0.9 time = 35
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=35.025n

* CHECK dout1_22 Vdout1_22ck6 = 0 time = 35
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=35.025n

* CHECK dout1_23 Vdout1_23ck6 = 0 time = 35
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=35.025n

* CHECK dout1_24 Vdout1_24ck6 = 0 time = 35
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=35.025n

* CHECK dout1_25 Vdout1_25ck6 = 0 time = 35
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=35.025n

* CHECK dout1_26 Vdout1_26ck6 = 0.9 time = 35
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=35.025n

* CHECK dout1_27 Vdout1_27ck6 = 0.9 time = 35
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=35.025n

* CHECK dout1_28 Vdout1_28ck6 = 0 time = 35
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=35.025n

* CHECK dout1_29 Vdout1_29ck6 = 0 time = 35
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=35.025n

* CHECK dout1_30 Vdout1_30ck6 = 0 time = 35
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=35.025n

* CHECK dout1_31 Vdout1_31ck6 = 0 time = 35
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=35.025n

* CHECK dout1_32 Vdout1_32ck6 = 0.9 time = 35
.meas tran vdout1_32ck6 FIND v(dout1_32) AT=35.025n

* CHECK dout1_33 Vdout1_33ck6 = 0.9 time = 35
.meas tran vdout1_33ck6 FIND v(dout1_33) AT=35.025n

* CHECK dout1_34 Vdout1_34ck6 = 0.9 time = 35
.meas tran vdout1_34ck6 FIND v(dout1_34) AT=35.025n

* CHECK dout1_35 Vdout1_35ck6 = 0 time = 35
.meas tran vdout1_35ck6 FIND v(dout1_35) AT=35.025n

* CHECK dout1_36 Vdout1_36ck6 = 0 time = 35
.meas tran vdout1_36ck6 FIND v(dout1_36) AT=35.025n

* CHECK dout1_37 Vdout1_37ck6 = 0.9 time = 35
.meas tran vdout1_37ck6 FIND v(dout1_37) AT=35.025n

* CHECK dout1_38 Vdout1_38ck6 = 0 time = 35
.meas tran vdout1_38ck6 FIND v(dout1_38) AT=35.025n

* CHECK dout1_39 Vdout1_39ck6 = 0.9 time = 35
.meas tran vdout1_39ck6 FIND v(dout1_39) AT=35.025n

* CHECK dout1_40 Vdout1_40ck6 = 0.9 time = 35
.meas tran vdout1_40ck6 FIND v(dout1_40) AT=35.025n

* CHECK dout1_41 Vdout1_41ck6 = 0 time = 35
.meas tran vdout1_41ck6 FIND v(dout1_41) AT=35.025n

* CHECK dout1_42 Vdout1_42ck6 = 0.9 time = 35
.meas tran vdout1_42ck6 FIND v(dout1_42) AT=35.025n

* CHECK dout1_43 Vdout1_43ck6 = 0 time = 35
.meas tran vdout1_43ck6 FIND v(dout1_43) AT=35.025n

* CHECK dout1_44 Vdout1_44ck6 = 0 time = 35
.meas tran vdout1_44ck6 FIND v(dout1_44) AT=35.025n

* CHECK dout1_45 Vdout1_45ck6 = 0.9 time = 35
.meas tran vdout1_45ck6 FIND v(dout1_45) AT=35.025n

* CHECK dout1_46 Vdout1_46ck6 = 0 time = 35
.meas tran vdout1_46ck6 FIND v(dout1_46) AT=35.025n

* CHECK dout1_47 Vdout1_47ck6 = 0 time = 35
.meas tran vdout1_47ck6 FIND v(dout1_47) AT=35.025n

* CHECK dout1_48 Vdout1_48ck6 = 0 time = 35
.meas tran vdout1_48ck6 FIND v(dout1_48) AT=35.025n

* CHECK dout1_49 Vdout1_49ck6 = 0 time = 35
.meas tran vdout1_49ck6 FIND v(dout1_49) AT=35.025n

* CHECK dout1_50 Vdout1_50ck6 = 0 time = 35
.meas tran vdout1_50ck6 FIND v(dout1_50) AT=35.025n

* CHECK dout1_51 Vdout1_51ck6 = 0.9 time = 35
.meas tran vdout1_51ck6 FIND v(dout1_51) AT=35.025n

* CHECK dout1_52 Vdout1_52ck6 = 0.9 time = 35
.meas tran vdout1_52ck6 FIND v(dout1_52) AT=35.025n

* CHECK dout1_53 Vdout1_53ck6 = 0 time = 35
.meas tran vdout1_53ck6 FIND v(dout1_53) AT=35.025n

* CHECK dout1_54 Vdout1_54ck6 = 0 time = 35
.meas tran vdout1_54ck6 FIND v(dout1_54) AT=35.025n

* CHECK dout1_55 Vdout1_55ck6 = 0 time = 35
.meas tran vdout1_55ck6 FIND v(dout1_55) AT=35.025n

* CHECK dout1_0 Vdout1_0ck12 = 0.9 time = 65
.meas tran vdout1_0ck12 FIND v(dout1_0) AT=65.025n

* CHECK dout1_1 Vdout1_1ck12 = 0 time = 65
.meas tran vdout1_1ck12 FIND v(dout1_1) AT=65.025n

* CHECK dout1_2 Vdout1_2ck12 = 0 time = 65
.meas tran vdout1_2ck12 FIND v(dout1_2) AT=65.025n

* CHECK dout1_3 Vdout1_3ck12 = 0.9 time = 65
.meas tran vdout1_3ck12 FIND v(dout1_3) AT=65.025n

* CHECK dout1_4 Vdout1_4ck12 = 0 time = 65
.meas tran vdout1_4ck12 FIND v(dout1_4) AT=65.025n

* CHECK dout1_5 Vdout1_5ck12 = 0.9 time = 65
.meas tran vdout1_5ck12 FIND v(dout1_5) AT=65.025n

* CHECK dout1_6 Vdout1_6ck12 = 0 time = 65
.meas tran vdout1_6ck12 FIND v(dout1_6) AT=65.025n

* CHECK dout1_7 Vdout1_7ck12 = 0 time = 65
.meas tran vdout1_7ck12 FIND v(dout1_7) AT=65.025n

* CHECK dout1_8 Vdout1_8ck12 = 0.9 time = 65
.meas tran vdout1_8ck12 FIND v(dout1_8) AT=65.025n

* CHECK dout1_9 Vdout1_9ck12 = 0.9 time = 65
.meas tran vdout1_9ck12 FIND v(dout1_9) AT=65.025n

* CHECK dout1_10 Vdout1_10ck12 = 0.9 time = 65
.meas tran vdout1_10ck12 FIND v(dout1_10) AT=65.025n

* CHECK dout1_11 Vdout1_11ck12 = 0 time = 65
.meas tran vdout1_11ck12 FIND v(dout1_11) AT=65.025n

* CHECK dout1_12 Vdout1_12ck12 = 0 time = 65
.meas tran vdout1_12ck12 FIND v(dout1_12) AT=65.025n

* CHECK dout1_13 Vdout1_13ck12 = 0.9 time = 65
.meas tran vdout1_13ck12 FIND v(dout1_13) AT=65.025n

* CHECK dout1_14 Vdout1_14ck12 = 0 time = 65
.meas tran vdout1_14ck12 FIND v(dout1_14) AT=65.025n

* CHECK dout1_15 Vdout1_15ck12 = 0 time = 65
.meas tran vdout1_15ck12 FIND v(dout1_15) AT=65.025n

* CHECK dout1_16 Vdout1_16ck12 = 0 time = 65
.meas tran vdout1_16ck12 FIND v(dout1_16) AT=65.025n

* CHECK dout1_17 Vdout1_17ck12 = 0.9 time = 65
.meas tran vdout1_17ck12 FIND v(dout1_17) AT=65.025n

* CHECK dout1_18 Vdout1_18ck12 = 0.9 time = 65
.meas tran vdout1_18ck12 FIND v(dout1_18) AT=65.025n

* CHECK dout1_19 Vdout1_19ck12 = 0.9 time = 65
.meas tran vdout1_19ck12 FIND v(dout1_19) AT=65.025n

* CHECK dout1_20 Vdout1_20ck12 = 0.9 time = 65
.meas tran vdout1_20ck12 FIND v(dout1_20) AT=65.025n

* CHECK dout1_21 Vdout1_21ck12 = 0.9 time = 65
.meas tran vdout1_21ck12 FIND v(dout1_21) AT=65.025n

* CHECK dout1_22 Vdout1_22ck12 = 0 time = 65
.meas tran vdout1_22ck12 FIND v(dout1_22) AT=65.025n

* CHECK dout1_23 Vdout1_23ck12 = 0 time = 65
.meas tran vdout1_23ck12 FIND v(dout1_23) AT=65.025n

* CHECK dout1_24 Vdout1_24ck12 = 0 time = 65
.meas tran vdout1_24ck12 FIND v(dout1_24) AT=65.025n

* CHECK dout1_25 Vdout1_25ck12 = 0 time = 65
.meas tran vdout1_25ck12 FIND v(dout1_25) AT=65.025n

* CHECK dout1_26 Vdout1_26ck12 = 0.9 time = 65
.meas tran vdout1_26ck12 FIND v(dout1_26) AT=65.025n

* CHECK dout1_27 Vdout1_27ck12 = 0.9 time = 65
.meas tran vdout1_27ck12 FIND v(dout1_27) AT=65.025n

* CHECK dout1_28 Vdout1_28ck12 = 0 time = 65
.meas tran vdout1_28ck12 FIND v(dout1_28) AT=65.025n

* CHECK dout1_29 Vdout1_29ck12 = 0.9 time = 65
.meas tran vdout1_29ck12 FIND v(dout1_29) AT=65.025n

* CHECK dout1_30 Vdout1_30ck12 = 0.9 time = 65
.meas tran vdout1_30ck12 FIND v(dout1_30) AT=65.025n

* CHECK dout1_31 Vdout1_31ck12 = 0 time = 65
.meas tran vdout1_31ck12 FIND v(dout1_31) AT=65.025n

* CHECK dout1_32 Vdout1_32ck12 = 0 time = 65
.meas tran vdout1_32ck12 FIND v(dout1_32) AT=65.025n

* CHECK dout1_33 Vdout1_33ck12 = 0.9 time = 65
.meas tran vdout1_33ck12 FIND v(dout1_33) AT=65.025n

* CHECK dout1_34 Vdout1_34ck12 = 0.9 time = 65
.meas tran vdout1_34ck12 FIND v(dout1_34) AT=65.025n

* CHECK dout1_35 Vdout1_35ck12 = 0 time = 65
.meas tran vdout1_35ck12 FIND v(dout1_35) AT=65.025n

* CHECK dout1_36 Vdout1_36ck12 = 0 time = 65
.meas tran vdout1_36ck12 FIND v(dout1_36) AT=65.025n

* CHECK dout1_37 Vdout1_37ck12 = 0 time = 65
.meas tran vdout1_37ck12 FIND v(dout1_37) AT=65.025n

* CHECK dout1_38 Vdout1_38ck12 = 0.9 time = 65
.meas tran vdout1_38ck12 FIND v(dout1_38) AT=65.025n

* CHECK dout1_39 Vdout1_39ck12 = 0 time = 65
.meas tran vdout1_39ck12 FIND v(dout1_39) AT=65.025n

* CHECK dout1_40 Vdout1_40ck12 = 0 time = 65
.meas tran vdout1_40ck12 FIND v(dout1_40) AT=65.025n

* CHECK dout1_41 Vdout1_41ck12 = 0 time = 65
.meas tran vdout1_41ck12 FIND v(dout1_41) AT=65.025n

* CHECK dout1_42 Vdout1_42ck12 = 0.9 time = 65
.meas tran vdout1_42ck12 FIND v(dout1_42) AT=65.025n

* CHECK dout1_43 Vdout1_43ck12 = 0 time = 65
.meas tran vdout1_43ck12 FIND v(dout1_43) AT=65.025n

* CHECK dout1_44 Vdout1_44ck12 = 0 time = 65
.meas tran vdout1_44ck12 FIND v(dout1_44) AT=65.025n

* CHECK dout1_45 Vdout1_45ck12 = 0.9 time = 65
.meas tran vdout1_45ck12 FIND v(dout1_45) AT=65.025n

* CHECK dout1_46 Vdout1_46ck12 = 0 time = 65
.meas tran vdout1_46ck12 FIND v(dout1_46) AT=65.025n

* CHECK dout1_47 Vdout1_47ck12 = 0 time = 65
.meas tran vdout1_47ck12 FIND v(dout1_47) AT=65.025n

* CHECK dout1_48 Vdout1_48ck12 = 0 time = 65
.meas tran vdout1_48ck12 FIND v(dout1_48) AT=65.025n

* CHECK dout1_49 Vdout1_49ck12 = 0 time = 65
.meas tran vdout1_49ck12 FIND v(dout1_49) AT=65.025n

* CHECK dout1_50 Vdout1_50ck12 = 0 time = 65
.meas tran vdout1_50ck12 FIND v(dout1_50) AT=65.025n

* CHECK dout1_51 Vdout1_51ck12 = 0.9 time = 65
.meas tran vdout1_51ck12 FIND v(dout1_51) AT=65.025n

* CHECK dout1_52 Vdout1_52ck12 = 0.9 time = 65
.meas tran vdout1_52ck12 FIND v(dout1_52) AT=65.025n

* CHECK dout1_53 Vdout1_53ck12 = 0 time = 65
.meas tran vdout1_53ck12 FIND v(dout1_53) AT=65.025n

* CHECK dout1_54 Vdout1_54ck12 = 0 time = 65
.meas tran vdout1_54ck12 FIND v(dout1_54) AT=65.025n

* CHECK dout1_55 Vdout1_55ck12 = 0 time = 65
.meas tran vdout1_55ck12 FIND v(dout1_55) AT=65.025n

* CHECK dout1_0 Vdout1_0ck16 = 0 time = 85
.meas tran vdout1_0ck16 FIND v(dout1_0) AT=85.025n

* CHECK dout1_1 Vdout1_1ck16 = 0.9 time = 85
.meas tran vdout1_1ck16 FIND v(dout1_1) AT=85.025n

* CHECK dout1_2 Vdout1_2ck16 = 0.9 time = 85
.meas tran vdout1_2ck16 FIND v(dout1_2) AT=85.025n

* CHECK dout1_3 Vdout1_3ck16 = 0 time = 85
.meas tran vdout1_3ck16 FIND v(dout1_3) AT=85.025n

* CHECK dout1_4 Vdout1_4ck16 = 0.9 time = 85
.meas tran vdout1_4ck16 FIND v(dout1_4) AT=85.025n

* CHECK dout1_5 Vdout1_5ck16 = 0.9 time = 85
.meas tran vdout1_5ck16 FIND v(dout1_5) AT=85.025n

* CHECK dout1_6 Vdout1_6ck16 = 0 time = 85
.meas tran vdout1_6ck16 FIND v(dout1_6) AT=85.025n

* CHECK dout1_7 Vdout1_7ck16 = 0.9 time = 85
.meas tran vdout1_7ck16 FIND v(dout1_7) AT=85.025n

* CHECK dout1_8 Vdout1_8ck16 = 0 time = 85
.meas tran vdout1_8ck16 FIND v(dout1_8) AT=85.025n

* CHECK dout1_9 Vdout1_9ck16 = 0.9 time = 85
.meas tran vdout1_9ck16 FIND v(dout1_9) AT=85.025n

* CHECK dout1_10 Vdout1_10ck16 = 0 time = 85
.meas tran vdout1_10ck16 FIND v(dout1_10) AT=85.025n

* CHECK dout1_11 Vdout1_11ck16 = 0.9 time = 85
.meas tran vdout1_11ck16 FIND v(dout1_11) AT=85.025n

* CHECK dout1_12 Vdout1_12ck16 = 0 time = 85
.meas tran vdout1_12ck16 FIND v(dout1_12) AT=85.025n

* CHECK dout1_13 Vdout1_13ck16 = 0 time = 85
.meas tran vdout1_13ck16 FIND v(dout1_13) AT=85.025n

* CHECK dout1_14 Vdout1_14ck16 = 0 time = 85
.meas tran vdout1_14ck16 FIND v(dout1_14) AT=85.025n

* CHECK dout1_15 Vdout1_15ck16 = 0 time = 85
.meas tran vdout1_15ck16 FIND v(dout1_15) AT=85.025n

* CHECK dout1_16 Vdout1_16ck16 = 0.9 time = 85
.meas tran vdout1_16ck16 FIND v(dout1_16) AT=85.025n

* CHECK dout1_17 Vdout1_17ck16 = 0.9 time = 85
.meas tran vdout1_17ck16 FIND v(dout1_17) AT=85.025n

* CHECK dout1_18 Vdout1_18ck16 = 0 time = 85
.meas tran vdout1_18ck16 FIND v(dout1_18) AT=85.025n

* CHECK dout1_19 Vdout1_19ck16 = 0.9 time = 85
.meas tran vdout1_19ck16 FIND v(dout1_19) AT=85.025n

* CHECK dout1_20 Vdout1_20ck16 = 0 time = 85
.meas tran vdout1_20ck16 FIND v(dout1_20) AT=85.025n

* CHECK dout1_21 Vdout1_21ck16 = 0 time = 85
.meas tran vdout1_21ck16 FIND v(dout1_21) AT=85.025n

* CHECK dout1_22 Vdout1_22ck16 = 0.9 time = 85
.meas tran vdout1_22ck16 FIND v(dout1_22) AT=85.025n

* CHECK dout1_23 Vdout1_23ck16 = 0 time = 85
.meas tran vdout1_23ck16 FIND v(dout1_23) AT=85.025n

* CHECK dout1_24 Vdout1_24ck16 = 0 time = 85
.meas tran vdout1_24ck16 FIND v(dout1_24) AT=85.025n

* CHECK dout1_25 Vdout1_25ck16 = 0 time = 85
.meas tran vdout1_25ck16 FIND v(dout1_25) AT=85.025n

* CHECK dout1_26 Vdout1_26ck16 = 0.9 time = 85
.meas tran vdout1_26ck16 FIND v(dout1_26) AT=85.025n

* CHECK dout1_27 Vdout1_27ck16 = 0 time = 85
.meas tran vdout1_27ck16 FIND v(dout1_27) AT=85.025n

* CHECK dout1_28 Vdout1_28ck16 = 0 time = 85
.meas tran vdout1_28ck16 FIND v(dout1_28) AT=85.025n

* CHECK dout1_29 Vdout1_29ck16 = 0.9 time = 85
.meas tran vdout1_29ck16 FIND v(dout1_29) AT=85.025n

* CHECK dout1_30 Vdout1_30ck16 = 0 time = 85
.meas tran vdout1_30ck16 FIND v(dout1_30) AT=85.025n

* CHECK dout1_31 Vdout1_31ck16 = 0.9 time = 85
.meas tran vdout1_31ck16 FIND v(dout1_31) AT=85.025n

* CHECK dout1_32 Vdout1_32ck16 = 0.9 time = 85
.meas tran vdout1_32ck16 FIND v(dout1_32) AT=85.025n

* CHECK dout1_33 Vdout1_33ck16 = 0.9 time = 85
.meas tran vdout1_33ck16 FIND v(dout1_33) AT=85.025n

* CHECK dout1_34 Vdout1_34ck16 = 0 time = 85
.meas tran vdout1_34ck16 FIND v(dout1_34) AT=85.025n

* CHECK dout1_35 Vdout1_35ck16 = 0.9 time = 85
.meas tran vdout1_35ck16 FIND v(dout1_35) AT=85.025n

* CHECK dout1_36 Vdout1_36ck16 = 0.9 time = 85
.meas tran vdout1_36ck16 FIND v(dout1_36) AT=85.025n

* CHECK dout1_37 Vdout1_37ck16 = 0 time = 85
.meas tran vdout1_37ck16 FIND v(dout1_37) AT=85.025n

* CHECK dout1_38 Vdout1_38ck16 = 0.9 time = 85
.meas tran vdout1_38ck16 FIND v(dout1_38) AT=85.025n

* CHECK dout1_39 Vdout1_39ck16 = 0.9 time = 85
.meas tran vdout1_39ck16 FIND v(dout1_39) AT=85.025n

* CHECK dout1_40 Vdout1_40ck16 = 0.9 time = 85
.meas tran vdout1_40ck16 FIND v(dout1_40) AT=85.025n

* CHECK dout1_41 Vdout1_41ck16 = 0 time = 85
.meas tran vdout1_41ck16 FIND v(dout1_41) AT=85.025n

* CHECK dout1_42 Vdout1_42ck16 = 0.9 time = 85
.meas tran vdout1_42ck16 FIND v(dout1_42) AT=85.025n

* CHECK dout1_43 Vdout1_43ck16 = 0.9 time = 85
.meas tran vdout1_43ck16 FIND v(dout1_43) AT=85.025n

* CHECK dout1_44 Vdout1_44ck16 = 0.9 time = 85
.meas tran vdout1_44ck16 FIND v(dout1_44) AT=85.025n

* CHECK dout1_45 Vdout1_45ck16 = 0.9 time = 85
.meas tran vdout1_45ck16 FIND v(dout1_45) AT=85.025n

* CHECK dout1_46 Vdout1_46ck16 = 0.9 time = 85
.meas tran vdout1_46ck16 FIND v(dout1_46) AT=85.025n

* CHECK dout1_47 Vdout1_47ck16 = 0 time = 85
.meas tran vdout1_47ck16 FIND v(dout1_47) AT=85.025n

* CHECK dout1_48 Vdout1_48ck16 = 0.9 time = 85
.meas tran vdout1_48ck16 FIND v(dout1_48) AT=85.025n

* CHECK dout1_49 Vdout1_49ck16 = 0 time = 85
.meas tran vdout1_49ck16 FIND v(dout1_49) AT=85.025n

* CHECK dout1_50 Vdout1_50ck16 = 0.9 time = 85
.meas tran vdout1_50ck16 FIND v(dout1_50) AT=85.025n

* CHECK dout1_51 Vdout1_51ck16 = 0 time = 85
.meas tran vdout1_51ck16 FIND v(dout1_51) AT=85.025n

* CHECK dout1_52 Vdout1_52ck16 = 0 time = 85
.meas tran vdout1_52ck16 FIND v(dout1_52) AT=85.025n

* CHECK dout1_53 Vdout1_53ck16 = 0 time = 85
.meas tran vdout1_53ck16 FIND v(dout1_53) AT=85.025n

* CHECK dout1_54 Vdout1_54ck16 = 0 time = 85
.meas tran vdout1_54ck16 FIND v(dout1_54) AT=85.025n

* CHECK dout1_55 Vdout1_55ck16 = 0.9 time = 85
.meas tran vdout1_55ck16 FIND v(dout1_55) AT=85.025n

* CHECK dout1_0 Vdout1_0ck17 = 0 time = 90
.meas tran vdout1_0ck17 FIND v(dout1_0) AT=90.025n

* CHECK dout1_1 Vdout1_1ck17 = 0.9 time = 90
.meas tran vdout1_1ck17 FIND v(dout1_1) AT=90.025n

* CHECK dout1_2 Vdout1_2ck17 = 0.9 time = 90
.meas tran vdout1_2ck17 FIND v(dout1_2) AT=90.025n

* CHECK dout1_3 Vdout1_3ck17 = 0 time = 90
.meas tran vdout1_3ck17 FIND v(dout1_3) AT=90.025n

* CHECK dout1_4 Vdout1_4ck17 = 0.9 time = 90
.meas tran vdout1_4ck17 FIND v(dout1_4) AT=90.025n

* CHECK dout1_5 Vdout1_5ck17 = 0.9 time = 90
.meas tran vdout1_5ck17 FIND v(dout1_5) AT=90.025n

* CHECK dout1_6 Vdout1_6ck17 = 0 time = 90
.meas tran vdout1_6ck17 FIND v(dout1_6) AT=90.025n

* CHECK dout1_7 Vdout1_7ck17 = 0.9 time = 90
.meas tran vdout1_7ck17 FIND v(dout1_7) AT=90.025n

* CHECK dout1_8 Vdout1_8ck17 = 0 time = 90
.meas tran vdout1_8ck17 FIND v(dout1_8) AT=90.025n

* CHECK dout1_9 Vdout1_9ck17 = 0.9 time = 90
.meas tran vdout1_9ck17 FIND v(dout1_9) AT=90.025n

* CHECK dout1_10 Vdout1_10ck17 = 0 time = 90
.meas tran vdout1_10ck17 FIND v(dout1_10) AT=90.025n

* CHECK dout1_11 Vdout1_11ck17 = 0.9 time = 90
.meas tran vdout1_11ck17 FIND v(dout1_11) AT=90.025n

* CHECK dout1_12 Vdout1_12ck17 = 0 time = 90
.meas tran vdout1_12ck17 FIND v(dout1_12) AT=90.025n

* CHECK dout1_13 Vdout1_13ck17 = 0 time = 90
.meas tran vdout1_13ck17 FIND v(dout1_13) AT=90.025n

* CHECK dout1_14 Vdout1_14ck17 = 0 time = 90
.meas tran vdout1_14ck17 FIND v(dout1_14) AT=90.025n

* CHECK dout1_15 Vdout1_15ck17 = 0 time = 90
.meas tran vdout1_15ck17 FIND v(dout1_15) AT=90.025n

* CHECK dout1_16 Vdout1_16ck17 = 0.9 time = 90
.meas tran vdout1_16ck17 FIND v(dout1_16) AT=90.025n

* CHECK dout1_17 Vdout1_17ck17 = 0.9 time = 90
.meas tran vdout1_17ck17 FIND v(dout1_17) AT=90.025n

* CHECK dout1_18 Vdout1_18ck17 = 0 time = 90
.meas tran vdout1_18ck17 FIND v(dout1_18) AT=90.025n

* CHECK dout1_19 Vdout1_19ck17 = 0.9 time = 90
.meas tran vdout1_19ck17 FIND v(dout1_19) AT=90.025n

* CHECK dout1_20 Vdout1_20ck17 = 0 time = 90
.meas tran vdout1_20ck17 FIND v(dout1_20) AT=90.025n

* CHECK dout1_21 Vdout1_21ck17 = 0 time = 90
.meas tran vdout1_21ck17 FIND v(dout1_21) AT=90.025n

* CHECK dout1_22 Vdout1_22ck17 = 0.9 time = 90
.meas tran vdout1_22ck17 FIND v(dout1_22) AT=90.025n

* CHECK dout1_23 Vdout1_23ck17 = 0 time = 90
.meas tran vdout1_23ck17 FIND v(dout1_23) AT=90.025n

* CHECK dout1_24 Vdout1_24ck17 = 0 time = 90
.meas tran vdout1_24ck17 FIND v(dout1_24) AT=90.025n

* CHECK dout1_25 Vdout1_25ck17 = 0 time = 90
.meas tran vdout1_25ck17 FIND v(dout1_25) AT=90.025n

* CHECK dout1_26 Vdout1_26ck17 = 0.9 time = 90
.meas tran vdout1_26ck17 FIND v(dout1_26) AT=90.025n

* CHECK dout1_27 Vdout1_27ck17 = 0 time = 90
.meas tran vdout1_27ck17 FIND v(dout1_27) AT=90.025n

* CHECK dout1_28 Vdout1_28ck17 = 0 time = 90
.meas tran vdout1_28ck17 FIND v(dout1_28) AT=90.025n

* CHECK dout1_29 Vdout1_29ck17 = 0.9 time = 90
.meas tran vdout1_29ck17 FIND v(dout1_29) AT=90.025n

* CHECK dout1_30 Vdout1_30ck17 = 0 time = 90
.meas tran vdout1_30ck17 FIND v(dout1_30) AT=90.025n

* CHECK dout1_31 Vdout1_31ck17 = 0.9 time = 90
.meas tran vdout1_31ck17 FIND v(dout1_31) AT=90.025n

* CHECK dout1_32 Vdout1_32ck17 = 0.9 time = 90
.meas tran vdout1_32ck17 FIND v(dout1_32) AT=90.025n

* CHECK dout1_33 Vdout1_33ck17 = 0.9 time = 90
.meas tran vdout1_33ck17 FIND v(dout1_33) AT=90.025n

* CHECK dout1_34 Vdout1_34ck17 = 0 time = 90
.meas tran vdout1_34ck17 FIND v(dout1_34) AT=90.025n

* CHECK dout1_35 Vdout1_35ck17 = 0.9 time = 90
.meas tran vdout1_35ck17 FIND v(dout1_35) AT=90.025n

* CHECK dout1_36 Vdout1_36ck17 = 0.9 time = 90
.meas tran vdout1_36ck17 FIND v(dout1_36) AT=90.025n

* CHECK dout1_37 Vdout1_37ck17 = 0 time = 90
.meas tran vdout1_37ck17 FIND v(dout1_37) AT=90.025n

* CHECK dout1_38 Vdout1_38ck17 = 0.9 time = 90
.meas tran vdout1_38ck17 FIND v(dout1_38) AT=90.025n

* CHECK dout1_39 Vdout1_39ck17 = 0.9 time = 90
.meas tran vdout1_39ck17 FIND v(dout1_39) AT=90.025n

* CHECK dout1_40 Vdout1_40ck17 = 0.9 time = 90
.meas tran vdout1_40ck17 FIND v(dout1_40) AT=90.025n

* CHECK dout1_41 Vdout1_41ck17 = 0 time = 90
.meas tran vdout1_41ck17 FIND v(dout1_41) AT=90.025n

* CHECK dout1_42 Vdout1_42ck17 = 0.9 time = 90
.meas tran vdout1_42ck17 FIND v(dout1_42) AT=90.025n

* CHECK dout1_43 Vdout1_43ck17 = 0.9 time = 90
.meas tran vdout1_43ck17 FIND v(dout1_43) AT=90.025n

* CHECK dout1_44 Vdout1_44ck17 = 0.9 time = 90
.meas tran vdout1_44ck17 FIND v(dout1_44) AT=90.025n

* CHECK dout1_45 Vdout1_45ck17 = 0.9 time = 90
.meas tran vdout1_45ck17 FIND v(dout1_45) AT=90.025n

* CHECK dout1_46 Vdout1_46ck17 = 0.9 time = 90
.meas tran vdout1_46ck17 FIND v(dout1_46) AT=90.025n

* CHECK dout1_47 Vdout1_47ck17 = 0 time = 90
.meas tran vdout1_47ck17 FIND v(dout1_47) AT=90.025n

* CHECK dout1_48 Vdout1_48ck17 = 0.9 time = 90
.meas tran vdout1_48ck17 FIND v(dout1_48) AT=90.025n

* CHECK dout1_49 Vdout1_49ck17 = 0 time = 90
.meas tran vdout1_49ck17 FIND v(dout1_49) AT=90.025n

* CHECK dout1_50 Vdout1_50ck17 = 0.9 time = 90
.meas tran vdout1_50ck17 FIND v(dout1_50) AT=90.025n

* CHECK dout1_51 Vdout1_51ck17 = 0 time = 90
.meas tran vdout1_51ck17 FIND v(dout1_51) AT=90.025n

* CHECK dout1_52 Vdout1_52ck17 = 0 time = 90
.meas tran vdout1_52ck17 FIND v(dout1_52) AT=90.025n

* CHECK dout1_53 Vdout1_53ck17 = 0 time = 90
.meas tran vdout1_53ck17 FIND v(dout1_53) AT=90.025n

* CHECK dout1_54 Vdout1_54ck17 = 0 time = 90
.meas tran vdout1_54ck17 FIND v(dout1_54) AT=90.025n

* CHECK dout1_55 Vdout1_55ck17 = 0.9 time = 90
.meas tran vdout1_55ck17 FIND v(dout1_55) AT=90.025n

* CHECK dout1_0 Vdout1_0ck21 = 0 time = 110
.meas tran vdout1_0ck21 FIND v(dout1_0) AT=110.025n

* CHECK dout1_1 Vdout1_1ck21 = 0 time = 110
.meas tran vdout1_1ck21 FIND v(dout1_1) AT=110.025n

* CHECK dout1_2 Vdout1_2ck21 = 0.9 time = 110
.meas tran vdout1_2ck21 FIND v(dout1_2) AT=110.025n

* CHECK dout1_3 Vdout1_3ck21 = 0.9 time = 110
.meas tran vdout1_3ck21 FIND v(dout1_3) AT=110.025n

* CHECK dout1_4 Vdout1_4ck21 = 0.9 time = 110
.meas tran vdout1_4ck21 FIND v(dout1_4) AT=110.025n

* CHECK dout1_5 Vdout1_5ck21 = 0 time = 110
.meas tran vdout1_5ck21 FIND v(dout1_5) AT=110.025n

* CHECK dout1_6 Vdout1_6ck21 = 0 time = 110
.meas tran vdout1_6ck21 FIND v(dout1_6) AT=110.025n

* CHECK dout1_7 Vdout1_7ck21 = 0 time = 110
.meas tran vdout1_7ck21 FIND v(dout1_7) AT=110.025n

* CHECK dout1_8 Vdout1_8ck21 = 0.9 time = 110
.meas tran vdout1_8ck21 FIND v(dout1_8) AT=110.025n

* CHECK dout1_9 Vdout1_9ck21 = 0.9 time = 110
.meas tran vdout1_9ck21 FIND v(dout1_9) AT=110.025n

* CHECK dout1_10 Vdout1_10ck21 = 0.9 time = 110
.meas tran vdout1_10ck21 FIND v(dout1_10) AT=110.025n

* CHECK dout1_11 Vdout1_11ck21 = 0 time = 110
.meas tran vdout1_11ck21 FIND v(dout1_11) AT=110.025n

* CHECK dout1_12 Vdout1_12ck21 = 0 time = 110
.meas tran vdout1_12ck21 FIND v(dout1_12) AT=110.025n

* CHECK dout1_13 Vdout1_13ck21 = 0 time = 110
.meas tran vdout1_13ck21 FIND v(dout1_13) AT=110.025n

* CHECK dout1_14 Vdout1_14ck21 = 0 time = 110
.meas tran vdout1_14ck21 FIND v(dout1_14) AT=110.025n

* CHECK dout1_15 Vdout1_15ck21 = 0 time = 110
.meas tran vdout1_15ck21 FIND v(dout1_15) AT=110.025n

* CHECK dout1_16 Vdout1_16ck21 = 0.9 time = 110
.meas tran vdout1_16ck21 FIND v(dout1_16) AT=110.025n

* CHECK dout1_17 Vdout1_17ck21 = 0.9 time = 110
.meas tran vdout1_17ck21 FIND v(dout1_17) AT=110.025n

* CHECK dout1_18 Vdout1_18ck21 = 0.9 time = 110
.meas tran vdout1_18ck21 FIND v(dout1_18) AT=110.025n

* CHECK dout1_19 Vdout1_19ck21 = 0.9 time = 110
.meas tran vdout1_19ck21 FIND v(dout1_19) AT=110.025n

* CHECK dout1_20 Vdout1_20ck21 = 0 time = 110
.meas tran vdout1_20ck21 FIND v(dout1_20) AT=110.025n

* CHECK dout1_21 Vdout1_21ck21 = 0 time = 110
.meas tran vdout1_21ck21 FIND v(dout1_21) AT=110.025n

* CHECK dout1_22 Vdout1_22ck21 = 0.9 time = 110
.meas tran vdout1_22ck21 FIND v(dout1_22) AT=110.025n

* CHECK dout1_23 Vdout1_23ck21 = 0.9 time = 110
.meas tran vdout1_23ck21 FIND v(dout1_23) AT=110.025n

* CHECK dout1_24 Vdout1_24ck21 = 0.9 time = 110
.meas tran vdout1_24ck21 FIND v(dout1_24) AT=110.025n

* CHECK dout1_25 Vdout1_25ck21 = 0.9 time = 110
.meas tran vdout1_25ck21 FIND v(dout1_25) AT=110.025n

* CHECK dout1_26 Vdout1_26ck21 = 0.9 time = 110
.meas tran vdout1_26ck21 FIND v(dout1_26) AT=110.025n

* CHECK dout1_27 Vdout1_27ck21 = 0.9 time = 110
.meas tran vdout1_27ck21 FIND v(dout1_27) AT=110.025n

* CHECK dout1_28 Vdout1_28ck21 = 0.9 time = 110
.meas tran vdout1_28ck21 FIND v(dout1_28) AT=110.025n

* CHECK dout1_29 Vdout1_29ck21 = 0.9 time = 110
.meas tran vdout1_29ck21 FIND v(dout1_29) AT=110.025n

* CHECK dout1_30 Vdout1_30ck21 = 0.9 time = 110
.meas tran vdout1_30ck21 FIND v(dout1_30) AT=110.025n

* CHECK dout1_31 Vdout1_31ck21 = 0 time = 110
.meas tran vdout1_31ck21 FIND v(dout1_31) AT=110.025n

* CHECK dout1_32 Vdout1_32ck21 = 0 time = 110
.meas tran vdout1_32ck21 FIND v(dout1_32) AT=110.025n

* CHECK dout1_33 Vdout1_33ck21 = 0.9 time = 110
.meas tran vdout1_33ck21 FIND v(dout1_33) AT=110.025n

* CHECK dout1_34 Vdout1_34ck21 = 0.9 time = 110
.meas tran vdout1_34ck21 FIND v(dout1_34) AT=110.025n

* CHECK dout1_35 Vdout1_35ck21 = 0 time = 110
.meas tran vdout1_35ck21 FIND v(dout1_35) AT=110.025n

* CHECK dout1_36 Vdout1_36ck21 = 0.9 time = 110
.meas tran vdout1_36ck21 FIND v(dout1_36) AT=110.025n

* CHECK dout1_37 Vdout1_37ck21 = 0.9 time = 110
.meas tran vdout1_37ck21 FIND v(dout1_37) AT=110.025n

* CHECK dout1_38 Vdout1_38ck21 = 0 time = 110
.meas tran vdout1_38ck21 FIND v(dout1_38) AT=110.025n

* CHECK dout1_39 Vdout1_39ck21 = 0 time = 110
.meas tran vdout1_39ck21 FIND v(dout1_39) AT=110.025n

* CHECK dout1_40 Vdout1_40ck21 = 0 time = 110
.meas tran vdout1_40ck21 FIND v(dout1_40) AT=110.025n

* CHECK dout1_41 Vdout1_41ck21 = 0.9 time = 110
.meas tran vdout1_41ck21 FIND v(dout1_41) AT=110.025n

* CHECK dout1_42 Vdout1_42ck21 = 0.9 time = 110
.meas tran vdout1_42ck21 FIND v(dout1_42) AT=110.025n

* CHECK dout1_43 Vdout1_43ck21 = 0 time = 110
.meas tran vdout1_43ck21 FIND v(dout1_43) AT=110.025n

* CHECK dout1_44 Vdout1_44ck21 = 0.9 time = 110
.meas tran vdout1_44ck21 FIND v(dout1_44) AT=110.025n

* CHECK dout1_45 Vdout1_45ck21 = 0.9 time = 110
.meas tran vdout1_45ck21 FIND v(dout1_45) AT=110.025n

* CHECK dout1_46 Vdout1_46ck21 = 0 time = 110
.meas tran vdout1_46ck21 FIND v(dout1_46) AT=110.025n

* CHECK dout1_47 Vdout1_47ck21 = 0.9 time = 110
.meas tran vdout1_47ck21 FIND v(dout1_47) AT=110.025n

* CHECK dout1_48 Vdout1_48ck21 = 0 time = 110
.meas tran vdout1_48ck21 FIND v(dout1_48) AT=110.025n

* CHECK dout1_49 Vdout1_49ck21 = 0.9 time = 110
.meas tran vdout1_49ck21 FIND v(dout1_49) AT=110.025n

* CHECK dout1_50 Vdout1_50ck21 = 0 time = 110
.meas tran vdout1_50ck21 FIND v(dout1_50) AT=110.025n

* CHECK dout1_51 Vdout1_51ck21 = 0 time = 110
.meas tran vdout1_51ck21 FIND v(dout1_51) AT=110.025n

* CHECK dout1_52 Vdout1_52ck21 = 0 time = 110
.meas tran vdout1_52ck21 FIND v(dout1_52) AT=110.025n

* CHECK dout1_53 Vdout1_53ck21 = 0 time = 110
.meas tran vdout1_53ck21 FIND v(dout1_53) AT=110.025n

* CHECK dout1_54 Vdout1_54ck21 = 0 time = 110
.meas tran vdout1_54ck21 FIND v(dout1_54) AT=110.025n

* CHECK dout1_55 Vdout1_55ck21 = 0 time = 110
.meas tran vdout1_55ck21 FIND v(dout1_55) AT=110.025n

* CHECK dout1_0 Vdout1_0ck23 = 0.9 time = 120
.meas tran vdout1_0ck23 FIND v(dout1_0) AT=120.025n

* CHECK dout1_1 Vdout1_1ck23 = 0 time = 120
.meas tran vdout1_1ck23 FIND v(dout1_1) AT=120.025n

* CHECK dout1_2 Vdout1_2ck23 = 0.9 time = 120
.meas tran vdout1_2ck23 FIND v(dout1_2) AT=120.025n

* CHECK dout1_3 Vdout1_3ck23 = 0 time = 120
.meas tran vdout1_3ck23 FIND v(dout1_3) AT=120.025n

* CHECK dout1_4 Vdout1_4ck23 = 0 time = 120
.meas tran vdout1_4ck23 FIND v(dout1_4) AT=120.025n

* CHECK dout1_5 Vdout1_5ck23 = 0 time = 120
.meas tran vdout1_5ck23 FIND v(dout1_5) AT=120.025n

* CHECK dout1_6 Vdout1_6ck23 = 0.9 time = 120
.meas tran vdout1_6ck23 FIND v(dout1_6) AT=120.025n

* CHECK dout1_7 Vdout1_7ck23 = 0.9 time = 120
.meas tran vdout1_7ck23 FIND v(dout1_7) AT=120.025n

* CHECK dout1_8 Vdout1_8ck23 = 0.9 time = 120
.meas tran vdout1_8ck23 FIND v(dout1_8) AT=120.025n

* CHECK dout1_9 Vdout1_9ck23 = 0 time = 120
.meas tran vdout1_9ck23 FIND v(dout1_9) AT=120.025n

* CHECK dout1_10 Vdout1_10ck23 = 0 time = 120
.meas tran vdout1_10ck23 FIND v(dout1_10) AT=120.025n

* CHECK dout1_11 Vdout1_11ck23 = 0.9 time = 120
.meas tran vdout1_11ck23 FIND v(dout1_11) AT=120.025n

* CHECK dout1_12 Vdout1_12ck23 = 0 time = 120
.meas tran vdout1_12ck23 FIND v(dout1_12) AT=120.025n

* CHECK dout1_13 Vdout1_13ck23 = 0.9 time = 120
.meas tran vdout1_13ck23 FIND v(dout1_13) AT=120.025n

* CHECK dout1_14 Vdout1_14ck23 = 0.9 time = 120
.meas tran vdout1_14ck23 FIND v(dout1_14) AT=120.025n

* CHECK dout1_15 Vdout1_15ck23 = 0.9 time = 120
.meas tran vdout1_15ck23 FIND v(dout1_15) AT=120.025n

* CHECK dout1_16 Vdout1_16ck23 = 0.9 time = 120
.meas tran vdout1_16ck23 FIND v(dout1_16) AT=120.025n

* CHECK dout1_17 Vdout1_17ck23 = 0.9 time = 120
.meas tran vdout1_17ck23 FIND v(dout1_17) AT=120.025n

* CHECK dout1_18 Vdout1_18ck23 = 0.9 time = 120
.meas tran vdout1_18ck23 FIND v(dout1_18) AT=120.025n

* CHECK dout1_19 Vdout1_19ck23 = 0 time = 120
.meas tran vdout1_19ck23 FIND v(dout1_19) AT=120.025n

* CHECK dout1_20 Vdout1_20ck23 = 0.9 time = 120
.meas tran vdout1_20ck23 FIND v(dout1_20) AT=120.025n

* CHECK dout1_21 Vdout1_21ck23 = 0 time = 120
.meas tran vdout1_21ck23 FIND v(dout1_21) AT=120.025n

* CHECK dout1_22 Vdout1_22ck23 = 0.9 time = 120
.meas tran vdout1_22ck23 FIND v(dout1_22) AT=120.025n

* CHECK dout1_23 Vdout1_23ck23 = 0 time = 120
.meas tran vdout1_23ck23 FIND v(dout1_23) AT=120.025n

* CHECK dout1_24 Vdout1_24ck23 = 0.9 time = 120
.meas tran vdout1_24ck23 FIND v(dout1_24) AT=120.025n

* CHECK dout1_25 Vdout1_25ck23 = 0.9 time = 120
.meas tran vdout1_25ck23 FIND v(dout1_25) AT=120.025n

* CHECK dout1_26 Vdout1_26ck23 = 0.9 time = 120
.meas tran vdout1_26ck23 FIND v(dout1_26) AT=120.025n

* CHECK dout1_27 Vdout1_27ck23 = 0.9 time = 120
.meas tran vdout1_27ck23 FIND v(dout1_27) AT=120.025n

* CHECK dout1_28 Vdout1_28ck23 = 0 time = 120
.meas tran vdout1_28ck23 FIND v(dout1_28) AT=120.025n

* CHECK dout1_29 Vdout1_29ck23 = 0 time = 120
.meas tran vdout1_29ck23 FIND v(dout1_29) AT=120.025n

* CHECK dout1_30 Vdout1_30ck23 = 0.9 time = 120
.meas tran vdout1_30ck23 FIND v(dout1_30) AT=120.025n

* CHECK dout1_31 Vdout1_31ck23 = 0.9 time = 120
.meas tran vdout1_31ck23 FIND v(dout1_31) AT=120.025n

* CHECK dout1_32 Vdout1_32ck23 = 0 time = 120
.meas tran vdout1_32ck23 FIND v(dout1_32) AT=120.025n

* CHECK dout1_33 Vdout1_33ck23 = 0 time = 120
.meas tran vdout1_33ck23 FIND v(dout1_33) AT=120.025n

* CHECK dout1_34 Vdout1_34ck23 = 0.9 time = 120
.meas tran vdout1_34ck23 FIND v(dout1_34) AT=120.025n

* CHECK dout1_35 Vdout1_35ck23 = 0 time = 120
.meas tran vdout1_35ck23 FIND v(dout1_35) AT=120.025n

* CHECK dout1_36 Vdout1_36ck23 = 0 time = 120
.meas tran vdout1_36ck23 FIND v(dout1_36) AT=120.025n

* CHECK dout1_37 Vdout1_37ck23 = 0.9 time = 120
.meas tran vdout1_37ck23 FIND v(dout1_37) AT=120.025n

* CHECK dout1_38 Vdout1_38ck23 = 0.9 time = 120
.meas tran vdout1_38ck23 FIND v(dout1_38) AT=120.025n

* CHECK dout1_39 Vdout1_39ck23 = 0.9 time = 120
.meas tran vdout1_39ck23 FIND v(dout1_39) AT=120.025n

* CHECK dout1_40 Vdout1_40ck23 = 0.9 time = 120
.meas tran vdout1_40ck23 FIND v(dout1_40) AT=120.025n

* CHECK dout1_41 Vdout1_41ck23 = 0.9 time = 120
.meas tran vdout1_41ck23 FIND v(dout1_41) AT=120.025n

* CHECK dout1_42 Vdout1_42ck23 = 0.9 time = 120
.meas tran vdout1_42ck23 FIND v(dout1_42) AT=120.025n

* CHECK dout1_43 Vdout1_43ck23 = 0.9 time = 120
.meas tran vdout1_43ck23 FIND v(dout1_43) AT=120.025n

* CHECK dout1_44 Vdout1_44ck23 = 0 time = 120
.meas tran vdout1_44ck23 FIND v(dout1_44) AT=120.025n

* CHECK dout1_45 Vdout1_45ck23 = 0.9 time = 120
.meas tran vdout1_45ck23 FIND v(dout1_45) AT=120.025n

* CHECK dout1_46 Vdout1_46ck23 = 0 time = 120
.meas tran vdout1_46ck23 FIND v(dout1_46) AT=120.025n

* CHECK dout1_47 Vdout1_47ck23 = 0 time = 120
.meas tran vdout1_47ck23 FIND v(dout1_47) AT=120.025n

* CHECK dout1_48 Vdout1_48ck23 = 0 time = 120
.meas tran vdout1_48ck23 FIND v(dout1_48) AT=120.025n

* CHECK dout1_49 Vdout1_49ck23 = 0.9 time = 120
.meas tran vdout1_49ck23 FIND v(dout1_49) AT=120.025n

* CHECK dout1_50 Vdout1_50ck23 = 0.9 time = 120
.meas tran vdout1_50ck23 FIND v(dout1_50) AT=120.025n

* CHECK dout1_51 Vdout1_51ck23 = 0 time = 120
.meas tran vdout1_51ck23 FIND v(dout1_51) AT=120.025n

* CHECK dout1_52 Vdout1_52ck23 = 0.9 time = 120
.meas tran vdout1_52ck23 FIND v(dout1_52) AT=120.025n

* CHECK dout1_53 Vdout1_53ck23 = 0.9 time = 120
.meas tran vdout1_53ck23 FIND v(dout1_53) AT=120.025n

* CHECK dout1_54 Vdout1_54ck23 = 0.9 time = 120
.meas tran vdout1_54ck23 FIND v(dout1_54) AT=120.025n

* CHECK dout1_55 Vdout1_55ck23 = 0.9 time = 120
.meas tran vdout1_55ck23 FIND v(dout1_55) AT=120.025n

* CHECK dout1_0 Vdout1_0ck26 = 0 time = 135
.meas tran vdout1_0ck26 FIND v(dout1_0) AT=135.025n

* CHECK dout1_1 Vdout1_1ck26 = 0.9 time = 135
.meas tran vdout1_1ck26 FIND v(dout1_1) AT=135.025n

* CHECK dout1_2 Vdout1_2ck26 = 0.9 time = 135
.meas tran vdout1_2ck26 FIND v(dout1_2) AT=135.025n

* CHECK dout1_3 Vdout1_3ck26 = 0 time = 135
.meas tran vdout1_3ck26 FIND v(dout1_3) AT=135.025n

* CHECK dout1_4 Vdout1_4ck26 = 0 time = 135
.meas tran vdout1_4ck26 FIND v(dout1_4) AT=135.025n

* CHECK dout1_5 Vdout1_5ck26 = 0.9 time = 135
.meas tran vdout1_5ck26 FIND v(dout1_5) AT=135.025n

* CHECK dout1_6 Vdout1_6ck26 = 0.9 time = 135
.meas tran vdout1_6ck26 FIND v(dout1_6) AT=135.025n

* CHECK dout1_7 Vdout1_7ck26 = 0.9 time = 135
.meas tran vdout1_7ck26 FIND v(dout1_7) AT=135.025n

* CHECK dout1_8 Vdout1_8ck26 = 0 time = 135
.meas tran vdout1_8ck26 FIND v(dout1_8) AT=135.025n

* CHECK dout1_9 Vdout1_9ck26 = 0 time = 135
.meas tran vdout1_9ck26 FIND v(dout1_9) AT=135.025n

* CHECK dout1_10 Vdout1_10ck26 = 0.9 time = 135
.meas tran vdout1_10ck26 FIND v(dout1_10) AT=135.025n

* CHECK dout1_11 Vdout1_11ck26 = 0 time = 135
.meas tran vdout1_11ck26 FIND v(dout1_11) AT=135.025n

* CHECK dout1_12 Vdout1_12ck26 = 0 time = 135
.meas tran vdout1_12ck26 FIND v(dout1_12) AT=135.025n

* CHECK dout1_13 Vdout1_13ck26 = 0 time = 135
.meas tran vdout1_13ck26 FIND v(dout1_13) AT=135.025n

* CHECK dout1_14 Vdout1_14ck26 = 0.9 time = 135
.meas tran vdout1_14ck26 FIND v(dout1_14) AT=135.025n

* CHECK dout1_15 Vdout1_15ck26 = 0.9 time = 135
.meas tran vdout1_15ck26 FIND v(dout1_15) AT=135.025n

* CHECK dout1_16 Vdout1_16ck26 = 0 time = 135
.meas tran vdout1_16ck26 FIND v(dout1_16) AT=135.025n

* CHECK dout1_17 Vdout1_17ck26 = 0.9 time = 135
.meas tran vdout1_17ck26 FIND v(dout1_17) AT=135.025n

* CHECK dout1_18 Vdout1_18ck26 = 0 time = 135
.meas tran vdout1_18ck26 FIND v(dout1_18) AT=135.025n

* CHECK dout1_19 Vdout1_19ck26 = 0 time = 135
.meas tran vdout1_19ck26 FIND v(dout1_19) AT=135.025n

* CHECK dout1_20 Vdout1_20ck26 = 0.9 time = 135
.meas tran vdout1_20ck26 FIND v(dout1_20) AT=135.025n

* CHECK dout1_21 Vdout1_21ck26 = 0 time = 135
.meas tran vdout1_21ck26 FIND v(dout1_21) AT=135.025n

* CHECK dout1_22 Vdout1_22ck26 = 0 time = 135
.meas tran vdout1_22ck26 FIND v(dout1_22) AT=135.025n

* CHECK dout1_23 Vdout1_23ck26 = 0.9 time = 135
.meas tran vdout1_23ck26 FIND v(dout1_23) AT=135.025n

* CHECK dout1_24 Vdout1_24ck26 = 0 time = 135
.meas tran vdout1_24ck26 FIND v(dout1_24) AT=135.025n

* CHECK dout1_25 Vdout1_25ck26 = 0.9 time = 135
.meas tran vdout1_25ck26 FIND v(dout1_25) AT=135.025n

* CHECK dout1_26 Vdout1_26ck26 = 0.9 time = 135
.meas tran vdout1_26ck26 FIND v(dout1_26) AT=135.025n

* CHECK dout1_27 Vdout1_27ck26 = 0.9 time = 135
.meas tran vdout1_27ck26 FIND v(dout1_27) AT=135.025n

* CHECK dout1_28 Vdout1_28ck26 = 0 time = 135
.meas tran vdout1_28ck26 FIND v(dout1_28) AT=135.025n

* CHECK dout1_29 Vdout1_29ck26 = 0.9 time = 135
.meas tran vdout1_29ck26 FIND v(dout1_29) AT=135.025n

* CHECK dout1_30 Vdout1_30ck26 = 0 time = 135
.meas tran vdout1_30ck26 FIND v(dout1_30) AT=135.025n

* CHECK dout1_31 Vdout1_31ck26 = 0.9 time = 135
.meas tran vdout1_31ck26 FIND v(dout1_31) AT=135.025n

* CHECK dout1_32 Vdout1_32ck26 = 0 time = 135
.meas tran vdout1_32ck26 FIND v(dout1_32) AT=135.025n

* CHECK dout1_33 Vdout1_33ck26 = 0.9 time = 135
.meas tran vdout1_33ck26 FIND v(dout1_33) AT=135.025n

* CHECK dout1_34 Vdout1_34ck26 = 0.9 time = 135
.meas tran vdout1_34ck26 FIND v(dout1_34) AT=135.025n

* CHECK dout1_35 Vdout1_35ck26 = 0 time = 135
.meas tran vdout1_35ck26 FIND v(dout1_35) AT=135.025n

* CHECK dout1_36 Vdout1_36ck26 = 0.9 time = 135
.meas tran vdout1_36ck26 FIND v(dout1_36) AT=135.025n

* CHECK dout1_37 Vdout1_37ck26 = 0.9 time = 135
.meas tran vdout1_37ck26 FIND v(dout1_37) AT=135.025n

* CHECK dout1_38 Vdout1_38ck26 = 0.9 time = 135
.meas tran vdout1_38ck26 FIND v(dout1_38) AT=135.025n

* CHECK dout1_39 Vdout1_39ck26 = 0 time = 135
.meas tran vdout1_39ck26 FIND v(dout1_39) AT=135.025n

* CHECK dout1_40 Vdout1_40ck26 = 0.9 time = 135
.meas tran vdout1_40ck26 FIND v(dout1_40) AT=135.025n

* CHECK dout1_41 Vdout1_41ck26 = 0 time = 135
.meas tran vdout1_41ck26 FIND v(dout1_41) AT=135.025n

* CHECK dout1_42 Vdout1_42ck26 = 0 time = 135
.meas tran vdout1_42ck26 FIND v(dout1_42) AT=135.025n

* CHECK dout1_43 Vdout1_43ck26 = 0 time = 135
.meas tran vdout1_43ck26 FIND v(dout1_43) AT=135.025n

* CHECK dout1_44 Vdout1_44ck26 = 0.9 time = 135
.meas tran vdout1_44ck26 FIND v(dout1_44) AT=135.025n

* CHECK dout1_45 Vdout1_45ck26 = 0 time = 135
.meas tran vdout1_45ck26 FIND v(dout1_45) AT=135.025n

* CHECK dout1_46 Vdout1_46ck26 = 0 time = 135
.meas tran vdout1_46ck26 FIND v(dout1_46) AT=135.025n

* CHECK dout1_47 Vdout1_47ck26 = 0 time = 135
.meas tran vdout1_47ck26 FIND v(dout1_47) AT=135.025n

* CHECK dout1_48 Vdout1_48ck26 = 0 time = 135
.meas tran vdout1_48ck26 FIND v(dout1_48) AT=135.025n

* CHECK dout1_49 Vdout1_49ck26 = 0.9 time = 135
.meas tran vdout1_49ck26 FIND v(dout1_49) AT=135.025n

* CHECK dout1_50 Vdout1_50ck26 = 0.9 time = 135
.meas tran vdout1_50ck26 FIND v(dout1_50) AT=135.025n

* CHECK dout1_51 Vdout1_51ck26 = 0.9 time = 135
.meas tran vdout1_51ck26 FIND v(dout1_51) AT=135.025n

* CHECK dout1_52 Vdout1_52ck26 = 0 time = 135
.meas tran vdout1_52ck26 FIND v(dout1_52) AT=135.025n

* CHECK dout1_53 Vdout1_53ck26 = 0 time = 135
.meas tran vdout1_53ck26 FIND v(dout1_53) AT=135.025n

* CHECK dout1_54 Vdout1_54ck26 = 0 time = 135
.meas tran vdout1_54ck26 FIND v(dout1_54) AT=135.025n

* CHECK dout1_55 Vdout1_55ck26 = 0.9 time = 135
.meas tran vdout1_55ck26 FIND v(dout1_55) AT=135.025n

* CHECK dout1_0 Vdout1_0ck27 = 0 time = 140
.meas tran vdout1_0ck27 FIND v(dout1_0) AT=140.025n

* CHECK dout1_1 Vdout1_1ck27 = 0.9 time = 140
.meas tran vdout1_1ck27 FIND v(dout1_1) AT=140.025n

* CHECK dout1_2 Vdout1_2ck27 = 0 time = 140
.meas tran vdout1_2ck27 FIND v(dout1_2) AT=140.025n

* CHECK dout1_3 Vdout1_3ck27 = 0 time = 140
.meas tran vdout1_3ck27 FIND v(dout1_3) AT=140.025n

* CHECK dout1_4 Vdout1_4ck27 = 0.9 time = 140
.meas tran vdout1_4ck27 FIND v(dout1_4) AT=140.025n

* CHECK dout1_5 Vdout1_5ck27 = 0 time = 140
.meas tran vdout1_5ck27 FIND v(dout1_5) AT=140.025n

* CHECK dout1_6 Vdout1_6ck27 = 0.9 time = 140
.meas tran vdout1_6ck27 FIND v(dout1_6) AT=140.025n

* CHECK dout1_7 Vdout1_7ck27 = 0 time = 140
.meas tran vdout1_7ck27 FIND v(dout1_7) AT=140.025n

* CHECK dout1_8 Vdout1_8ck27 = 0 time = 140
.meas tran vdout1_8ck27 FIND v(dout1_8) AT=140.025n

* CHECK dout1_9 Vdout1_9ck27 = 0.9 time = 140
.meas tran vdout1_9ck27 FIND v(dout1_9) AT=140.025n

* CHECK dout1_10 Vdout1_10ck27 = 0 time = 140
.meas tran vdout1_10ck27 FIND v(dout1_10) AT=140.025n

* CHECK dout1_11 Vdout1_11ck27 = 0 time = 140
.meas tran vdout1_11ck27 FIND v(dout1_11) AT=140.025n

* CHECK dout1_12 Vdout1_12ck27 = 0 time = 140
.meas tran vdout1_12ck27 FIND v(dout1_12) AT=140.025n

* CHECK dout1_13 Vdout1_13ck27 = 0.9 time = 140
.meas tran vdout1_13ck27 FIND v(dout1_13) AT=140.025n

* CHECK dout1_14 Vdout1_14ck27 = 0.9 time = 140
.meas tran vdout1_14ck27 FIND v(dout1_14) AT=140.025n

* CHECK dout1_15 Vdout1_15ck27 = 0.9 time = 140
.meas tran vdout1_15ck27 FIND v(dout1_15) AT=140.025n

* CHECK dout1_16 Vdout1_16ck27 = 0.9 time = 140
.meas tran vdout1_16ck27 FIND v(dout1_16) AT=140.025n

* CHECK dout1_17 Vdout1_17ck27 = 0.9 time = 140
.meas tran vdout1_17ck27 FIND v(dout1_17) AT=140.025n

* CHECK dout1_18 Vdout1_18ck27 = 0.9 time = 140
.meas tran vdout1_18ck27 FIND v(dout1_18) AT=140.025n

* CHECK dout1_19 Vdout1_19ck27 = 0 time = 140
.meas tran vdout1_19ck27 FIND v(dout1_19) AT=140.025n

* CHECK dout1_20 Vdout1_20ck27 = 0.9 time = 140
.meas tran vdout1_20ck27 FIND v(dout1_20) AT=140.025n

* CHECK dout1_21 Vdout1_21ck27 = 0 time = 140
.meas tran vdout1_21ck27 FIND v(dout1_21) AT=140.025n

* CHECK dout1_22 Vdout1_22ck27 = 0.9 time = 140
.meas tran vdout1_22ck27 FIND v(dout1_22) AT=140.025n

* CHECK dout1_23 Vdout1_23ck27 = 0 time = 140
.meas tran vdout1_23ck27 FIND v(dout1_23) AT=140.025n

* CHECK dout1_24 Vdout1_24ck27 = 0.9 time = 140
.meas tran vdout1_24ck27 FIND v(dout1_24) AT=140.025n

* CHECK dout1_25 Vdout1_25ck27 = 0.9 time = 140
.meas tran vdout1_25ck27 FIND v(dout1_25) AT=140.025n

* CHECK dout1_26 Vdout1_26ck27 = 0.9 time = 140
.meas tran vdout1_26ck27 FIND v(dout1_26) AT=140.025n

* CHECK dout1_27 Vdout1_27ck27 = 0.9 time = 140
.meas tran vdout1_27ck27 FIND v(dout1_27) AT=140.025n

* CHECK dout1_28 Vdout1_28ck27 = 0 time = 140
.meas tran vdout1_28ck27 FIND v(dout1_28) AT=140.025n

* CHECK dout1_29 Vdout1_29ck27 = 0 time = 140
.meas tran vdout1_29ck27 FIND v(dout1_29) AT=140.025n

* CHECK dout1_30 Vdout1_30ck27 = 0.9 time = 140
.meas tran vdout1_30ck27 FIND v(dout1_30) AT=140.025n

* CHECK dout1_31 Vdout1_31ck27 = 0.9 time = 140
.meas tran vdout1_31ck27 FIND v(dout1_31) AT=140.025n

* CHECK dout1_32 Vdout1_32ck27 = 0 time = 140
.meas tran vdout1_32ck27 FIND v(dout1_32) AT=140.025n

* CHECK dout1_33 Vdout1_33ck27 = 0 time = 140
.meas tran vdout1_33ck27 FIND v(dout1_33) AT=140.025n

* CHECK dout1_34 Vdout1_34ck27 = 0.9 time = 140
.meas tran vdout1_34ck27 FIND v(dout1_34) AT=140.025n

* CHECK dout1_35 Vdout1_35ck27 = 0 time = 140
.meas tran vdout1_35ck27 FIND v(dout1_35) AT=140.025n

* CHECK dout1_36 Vdout1_36ck27 = 0 time = 140
.meas tran vdout1_36ck27 FIND v(dout1_36) AT=140.025n

* CHECK dout1_37 Vdout1_37ck27 = 0.9 time = 140
.meas tran vdout1_37ck27 FIND v(dout1_37) AT=140.025n

* CHECK dout1_38 Vdout1_38ck27 = 0.9 time = 140
.meas tran vdout1_38ck27 FIND v(dout1_38) AT=140.025n

* CHECK dout1_39 Vdout1_39ck27 = 0.9 time = 140
.meas tran vdout1_39ck27 FIND v(dout1_39) AT=140.025n

* CHECK dout1_40 Vdout1_40ck27 = 0.9 time = 140
.meas tran vdout1_40ck27 FIND v(dout1_40) AT=140.025n

* CHECK dout1_41 Vdout1_41ck27 = 0.9 time = 140
.meas tran vdout1_41ck27 FIND v(dout1_41) AT=140.025n

* CHECK dout1_42 Vdout1_42ck27 = 0.9 time = 140
.meas tran vdout1_42ck27 FIND v(dout1_42) AT=140.025n

* CHECK dout1_43 Vdout1_43ck27 = 0.9 time = 140
.meas tran vdout1_43ck27 FIND v(dout1_43) AT=140.025n

* CHECK dout1_44 Vdout1_44ck27 = 0 time = 140
.meas tran vdout1_44ck27 FIND v(dout1_44) AT=140.025n

* CHECK dout1_45 Vdout1_45ck27 = 0.9 time = 140
.meas tran vdout1_45ck27 FIND v(dout1_45) AT=140.025n

* CHECK dout1_46 Vdout1_46ck27 = 0 time = 140
.meas tran vdout1_46ck27 FIND v(dout1_46) AT=140.025n

* CHECK dout1_47 Vdout1_47ck27 = 0 time = 140
.meas tran vdout1_47ck27 FIND v(dout1_47) AT=140.025n

* CHECK dout1_48 Vdout1_48ck27 = 0 time = 140
.meas tran vdout1_48ck27 FIND v(dout1_48) AT=140.025n

* CHECK dout1_49 Vdout1_49ck27 = 0.9 time = 140
.meas tran vdout1_49ck27 FIND v(dout1_49) AT=140.025n

* CHECK dout1_50 Vdout1_50ck27 = 0.9 time = 140
.meas tran vdout1_50ck27 FIND v(dout1_50) AT=140.025n

* CHECK dout1_51 Vdout1_51ck27 = 0 time = 140
.meas tran vdout1_51ck27 FIND v(dout1_51) AT=140.025n

* CHECK dout1_52 Vdout1_52ck27 = 0.9 time = 140
.meas tran vdout1_52ck27 FIND v(dout1_52) AT=140.025n

* CHECK dout1_53 Vdout1_53ck27 = 0.9 time = 140
.meas tran vdout1_53ck27 FIND v(dout1_53) AT=140.025n

* CHECK dout1_54 Vdout1_54ck27 = 0.9 time = 140
.meas tran vdout1_54ck27 FIND v(dout1_54) AT=140.025n

* CHECK dout1_55 Vdout1_55ck27 = 0.9 time = 140
.meas tran vdout1_55ck27 FIND v(dout1_55) AT=140.025n

* CHECK dout1_0 Vdout1_0ck32 = 0 time = 165
.meas tran vdout1_0ck32 FIND v(dout1_0) AT=165.025n

* CHECK dout1_1 Vdout1_1ck32 = 0.9 time = 165
.meas tran vdout1_1ck32 FIND v(dout1_1) AT=165.025n

* CHECK dout1_2 Vdout1_2ck32 = 0.9 time = 165
.meas tran vdout1_2ck32 FIND v(dout1_2) AT=165.025n

* CHECK dout1_3 Vdout1_3ck32 = 0 time = 165
.meas tran vdout1_3ck32 FIND v(dout1_3) AT=165.025n

* CHECK dout1_4 Vdout1_4ck32 = 0 time = 165
.meas tran vdout1_4ck32 FIND v(dout1_4) AT=165.025n

* CHECK dout1_5 Vdout1_5ck32 = 0.9 time = 165
.meas tran vdout1_5ck32 FIND v(dout1_5) AT=165.025n

* CHECK dout1_6 Vdout1_6ck32 = 0.9 time = 165
.meas tran vdout1_6ck32 FIND v(dout1_6) AT=165.025n

* CHECK dout1_7 Vdout1_7ck32 = 0.9 time = 165
.meas tran vdout1_7ck32 FIND v(dout1_7) AT=165.025n

* CHECK dout1_8 Vdout1_8ck32 = 0 time = 165
.meas tran vdout1_8ck32 FIND v(dout1_8) AT=165.025n

* CHECK dout1_9 Vdout1_9ck32 = 0 time = 165
.meas tran vdout1_9ck32 FIND v(dout1_9) AT=165.025n

* CHECK dout1_10 Vdout1_10ck32 = 0.9 time = 165
.meas tran vdout1_10ck32 FIND v(dout1_10) AT=165.025n

* CHECK dout1_11 Vdout1_11ck32 = 0 time = 165
.meas tran vdout1_11ck32 FIND v(dout1_11) AT=165.025n

* CHECK dout1_12 Vdout1_12ck32 = 0 time = 165
.meas tran vdout1_12ck32 FIND v(dout1_12) AT=165.025n

* CHECK dout1_13 Vdout1_13ck32 = 0 time = 165
.meas tran vdout1_13ck32 FIND v(dout1_13) AT=165.025n

* CHECK dout1_14 Vdout1_14ck32 = 0.9 time = 165
.meas tran vdout1_14ck32 FIND v(dout1_14) AT=165.025n

* CHECK dout1_15 Vdout1_15ck32 = 0.9 time = 165
.meas tran vdout1_15ck32 FIND v(dout1_15) AT=165.025n

* CHECK dout1_16 Vdout1_16ck32 = 0 time = 165
.meas tran vdout1_16ck32 FIND v(dout1_16) AT=165.025n

* CHECK dout1_17 Vdout1_17ck32 = 0.9 time = 165
.meas tran vdout1_17ck32 FIND v(dout1_17) AT=165.025n

* CHECK dout1_18 Vdout1_18ck32 = 0 time = 165
.meas tran vdout1_18ck32 FIND v(dout1_18) AT=165.025n

* CHECK dout1_19 Vdout1_19ck32 = 0 time = 165
.meas tran vdout1_19ck32 FIND v(dout1_19) AT=165.025n

* CHECK dout1_20 Vdout1_20ck32 = 0.9 time = 165
.meas tran vdout1_20ck32 FIND v(dout1_20) AT=165.025n

* CHECK dout1_21 Vdout1_21ck32 = 0 time = 165
.meas tran vdout1_21ck32 FIND v(dout1_21) AT=165.025n

* CHECK dout1_22 Vdout1_22ck32 = 0 time = 165
.meas tran vdout1_22ck32 FIND v(dout1_22) AT=165.025n

* CHECK dout1_23 Vdout1_23ck32 = 0.9 time = 165
.meas tran vdout1_23ck32 FIND v(dout1_23) AT=165.025n

* CHECK dout1_24 Vdout1_24ck32 = 0 time = 165
.meas tran vdout1_24ck32 FIND v(dout1_24) AT=165.025n

* CHECK dout1_25 Vdout1_25ck32 = 0.9 time = 165
.meas tran vdout1_25ck32 FIND v(dout1_25) AT=165.025n

* CHECK dout1_26 Vdout1_26ck32 = 0.9 time = 165
.meas tran vdout1_26ck32 FIND v(dout1_26) AT=165.025n

* CHECK dout1_27 Vdout1_27ck32 = 0.9 time = 165
.meas tran vdout1_27ck32 FIND v(dout1_27) AT=165.025n

* CHECK dout1_28 Vdout1_28ck32 = 0 time = 165
.meas tran vdout1_28ck32 FIND v(dout1_28) AT=165.025n

* CHECK dout1_29 Vdout1_29ck32 = 0.9 time = 165
.meas tran vdout1_29ck32 FIND v(dout1_29) AT=165.025n

* CHECK dout1_30 Vdout1_30ck32 = 0 time = 165
.meas tran vdout1_30ck32 FIND v(dout1_30) AT=165.025n

* CHECK dout1_31 Vdout1_31ck32 = 0.9 time = 165
.meas tran vdout1_31ck32 FIND v(dout1_31) AT=165.025n

* CHECK dout1_32 Vdout1_32ck32 = 0 time = 165
.meas tran vdout1_32ck32 FIND v(dout1_32) AT=165.025n

* CHECK dout1_33 Vdout1_33ck32 = 0.9 time = 165
.meas tran vdout1_33ck32 FIND v(dout1_33) AT=165.025n

* CHECK dout1_34 Vdout1_34ck32 = 0.9 time = 165
.meas tran vdout1_34ck32 FIND v(dout1_34) AT=165.025n

* CHECK dout1_35 Vdout1_35ck32 = 0 time = 165
.meas tran vdout1_35ck32 FIND v(dout1_35) AT=165.025n

* CHECK dout1_36 Vdout1_36ck32 = 0.9 time = 165
.meas tran vdout1_36ck32 FIND v(dout1_36) AT=165.025n

* CHECK dout1_37 Vdout1_37ck32 = 0.9 time = 165
.meas tran vdout1_37ck32 FIND v(dout1_37) AT=165.025n

* CHECK dout1_38 Vdout1_38ck32 = 0.9 time = 165
.meas tran vdout1_38ck32 FIND v(dout1_38) AT=165.025n

* CHECK dout1_39 Vdout1_39ck32 = 0 time = 165
.meas tran vdout1_39ck32 FIND v(dout1_39) AT=165.025n

* CHECK dout1_40 Vdout1_40ck32 = 0.9 time = 165
.meas tran vdout1_40ck32 FIND v(dout1_40) AT=165.025n

* CHECK dout1_41 Vdout1_41ck32 = 0 time = 165
.meas tran vdout1_41ck32 FIND v(dout1_41) AT=165.025n

* CHECK dout1_42 Vdout1_42ck32 = 0 time = 165
.meas tran vdout1_42ck32 FIND v(dout1_42) AT=165.025n

* CHECK dout1_43 Vdout1_43ck32 = 0 time = 165
.meas tran vdout1_43ck32 FIND v(dout1_43) AT=165.025n

* CHECK dout1_44 Vdout1_44ck32 = 0.9 time = 165
.meas tran vdout1_44ck32 FIND v(dout1_44) AT=165.025n

* CHECK dout1_45 Vdout1_45ck32 = 0 time = 165
.meas tran vdout1_45ck32 FIND v(dout1_45) AT=165.025n

* CHECK dout1_46 Vdout1_46ck32 = 0 time = 165
.meas tran vdout1_46ck32 FIND v(dout1_46) AT=165.025n

* CHECK dout1_47 Vdout1_47ck32 = 0 time = 165
.meas tran vdout1_47ck32 FIND v(dout1_47) AT=165.025n

* CHECK dout1_48 Vdout1_48ck32 = 0 time = 165
.meas tran vdout1_48ck32 FIND v(dout1_48) AT=165.025n

* CHECK dout1_49 Vdout1_49ck32 = 0.9 time = 165
.meas tran vdout1_49ck32 FIND v(dout1_49) AT=165.025n

* CHECK dout1_50 Vdout1_50ck32 = 0.9 time = 165
.meas tran vdout1_50ck32 FIND v(dout1_50) AT=165.025n

* CHECK dout1_51 Vdout1_51ck32 = 0.9 time = 165
.meas tran vdout1_51ck32 FIND v(dout1_51) AT=165.025n

* CHECK dout1_52 Vdout1_52ck32 = 0 time = 165
.meas tran vdout1_52ck32 FIND v(dout1_52) AT=165.025n

* CHECK dout1_53 Vdout1_53ck32 = 0 time = 165
.meas tran vdout1_53ck32 FIND v(dout1_53) AT=165.025n

* CHECK dout1_54 Vdout1_54ck32 = 0 time = 165
.meas tran vdout1_54ck32 FIND v(dout1_54) AT=165.025n

* CHECK dout1_55 Vdout1_55ck32 = 0.9 time = 165
.meas tran vdout1_55ck32 FIND v(dout1_55) AT=165.025n

* CHECK dout1_0 Vdout1_0ck33 = 0 time = 170
.meas tran vdout1_0ck33 FIND v(dout1_0) AT=170.025n

* CHECK dout1_1 Vdout1_1ck33 = 0.9 time = 170
.meas tran vdout1_1ck33 FIND v(dout1_1) AT=170.025n

* CHECK dout1_2 Vdout1_2ck33 = 0 time = 170
.meas tran vdout1_2ck33 FIND v(dout1_2) AT=170.025n

* CHECK dout1_3 Vdout1_3ck33 = 0 time = 170
.meas tran vdout1_3ck33 FIND v(dout1_3) AT=170.025n

* CHECK dout1_4 Vdout1_4ck33 = 0.9 time = 170
.meas tran vdout1_4ck33 FIND v(dout1_4) AT=170.025n

* CHECK dout1_5 Vdout1_5ck33 = 0 time = 170
.meas tran vdout1_5ck33 FIND v(dout1_5) AT=170.025n

* CHECK dout1_6 Vdout1_6ck33 = 0.9 time = 170
.meas tran vdout1_6ck33 FIND v(dout1_6) AT=170.025n

* CHECK dout1_7 Vdout1_7ck33 = 0 time = 170
.meas tran vdout1_7ck33 FIND v(dout1_7) AT=170.025n

* CHECK dout1_8 Vdout1_8ck33 = 0 time = 170
.meas tran vdout1_8ck33 FIND v(dout1_8) AT=170.025n

* CHECK dout1_9 Vdout1_9ck33 = 0.9 time = 170
.meas tran vdout1_9ck33 FIND v(dout1_9) AT=170.025n

* CHECK dout1_10 Vdout1_10ck33 = 0 time = 170
.meas tran vdout1_10ck33 FIND v(dout1_10) AT=170.025n

* CHECK dout1_11 Vdout1_11ck33 = 0 time = 170
.meas tran vdout1_11ck33 FIND v(dout1_11) AT=170.025n

* CHECK dout1_12 Vdout1_12ck33 = 0 time = 170
.meas tran vdout1_12ck33 FIND v(dout1_12) AT=170.025n

* CHECK dout1_13 Vdout1_13ck33 = 0.9 time = 170
.meas tran vdout1_13ck33 FIND v(dout1_13) AT=170.025n

* CHECK dout1_14 Vdout1_14ck33 = 0.9 time = 170
.meas tran vdout1_14ck33 FIND v(dout1_14) AT=170.025n

* CHECK dout1_15 Vdout1_15ck33 = 0 time = 170
.meas tran vdout1_15ck33 FIND v(dout1_15) AT=170.025n

* CHECK dout1_16 Vdout1_16ck33 = 0 time = 170
.meas tran vdout1_16ck33 FIND v(dout1_16) AT=170.025n

* CHECK dout1_17 Vdout1_17ck33 = 0 time = 170
.meas tran vdout1_17ck33 FIND v(dout1_17) AT=170.025n

* CHECK dout1_18 Vdout1_18ck33 = 0.9 time = 170
.meas tran vdout1_18ck33 FIND v(dout1_18) AT=170.025n

* CHECK dout1_19 Vdout1_19ck33 = 0.9 time = 170
.meas tran vdout1_19ck33 FIND v(dout1_19) AT=170.025n

* CHECK dout1_20 Vdout1_20ck33 = 0 time = 170
.meas tran vdout1_20ck33 FIND v(dout1_20) AT=170.025n

* CHECK dout1_21 Vdout1_21ck33 = 0 time = 170
.meas tran vdout1_21ck33 FIND v(dout1_21) AT=170.025n

* CHECK dout1_22 Vdout1_22ck33 = 0 time = 170
.meas tran vdout1_22ck33 FIND v(dout1_22) AT=170.025n

* CHECK dout1_23 Vdout1_23ck33 = 0.9 time = 170
.meas tran vdout1_23ck33 FIND v(dout1_23) AT=170.025n

* CHECK dout1_24 Vdout1_24ck33 = 0 time = 170
.meas tran vdout1_24ck33 FIND v(dout1_24) AT=170.025n

* CHECK dout1_25 Vdout1_25ck33 = 0 time = 170
.meas tran vdout1_25ck33 FIND v(dout1_25) AT=170.025n

* CHECK dout1_26 Vdout1_26ck33 = 0 time = 170
.meas tran vdout1_26ck33 FIND v(dout1_26) AT=170.025n

* CHECK dout1_27 Vdout1_27ck33 = 0 time = 170
.meas tran vdout1_27ck33 FIND v(dout1_27) AT=170.025n

* CHECK dout1_28 Vdout1_28ck33 = 0 time = 170
.meas tran vdout1_28ck33 FIND v(dout1_28) AT=170.025n

* CHECK dout1_29 Vdout1_29ck33 = 0 time = 170
.meas tran vdout1_29ck33 FIND v(dout1_29) AT=170.025n

* CHECK dout1_30 Vdout1_30ck33 = 0.9 time = 170
.meas tran vdout1_30ck33 FIND v(dout1_30) AT=170.025n

* CHECK dout1_31 Vdout1_31ck33 = 0.9 time = 170
.meas tran vdout1_31ck33 FIND v(dout1_31) AT=170.025n

* CHECK dout1_32 Vdout1_32ck33 = 0 time = 170
.meas tran vdout1_32ck33 FIND v(dout1_32) AT=170.025n

* CHECK dout1_33 Vdout1_33ck33 = 0 time = 170
.meas tran vdout1_33ck33 FIND v(dout1_33) AT=170.025n

* CHECK dout1_34 Vdout1_34ck33 = 0.9 time = 170
.meas tran vdout1_34ck33 FIND v(dout1_34) AT=170.025n

* CHECK dout1_35 Vdout1_35ck33 = 0 time = 170
.meas tran vdout1_35ck33 FIND v(dout1_35) AT=170.025n

* CHECK dout1_36 Vdout1_36ck33 = 0 time = 170
.meas tran vdout1_36ck33 FIND v(dout1_36) AT=170.025n

* CHECK dout1_37 Vdout1_37ck33 = 0.9 time = 170
.meas tran vdout1_37ck33 FIND v(dout1_37) AT=170.025n

* CHECK dout1_38 Vdout1_38ck33 = 0.9 time = 170
.meas tran vdout1_38ck33 FIND v(dout1_38) AT=170.025n

* CHECK dout1_39 Vdout1_39ck33 = 0.9 time = 170
.meas tran vdout1_39ck33 FIND v(dout1_39) AT=170.025n

* CHECK dout1_40 Vdout1_40ck33 = 0.9 time = 170
.meas tran vdout1_40ck33 FIND v(dout1_40) AT=170.025n

* CHECK dout1_41 Vdout1_41ck33 = 0.9 time = 170
.meas tran vdout1_41ck33 FIND v(dout1_41) AT=170.025n

* CHECK dout1_42 Vdout1_42ck33 = 0 time = 170
.meas tran vdout1_42ck33 FIND v(dout1_42) AT=170.025n

* CHECK dout1_43 Vdout1_43ck33 = 0.9 time = 170
.meas tran vdout1_43ck33 FIND v(dout1_43) AT=170.025n

* CHECK dout1_44 Vdout1_44ck33 = 0 time = 170
.meas tran vdout1_44ck33 FIND v(dout1_44) AT=170.025n

* CHECK dout1_45 Vdout1_45ck33 = 0 time = 170
.meas tran vdout1_45ck33 FIND v(dout1_45) AT=170.025n

* CHECK dout1_46 Vdout1_46ck33 = 0.9 time = 170
.meas tran vdout1_46ck33 FIND v(dout1_46) AT=170.025n

* CHECK dout1_47 Vdout1_47ck33 = 0 time = 170
.meas tran vdout1_47ck33 FIND v(dout1_47) AT=170.025n

* CHECK dout1_48 Vdout1_48ck33 = 0 time = 170
.meas tran vdout1_48ck33 FIND v(dout1_48) AT=170.025n

* CHECK dout1_49 Vdout1_49ck33 = 0.9 time = 170
.meas tran vdout1_49ck33 FIND v(dout1_49) AT=170.025n

* CHECK dout1_50 Vdout1_50ck33 = 0 time = 170
.meas tran vdout1_50ck33 FIND v(dout1_50) AT=170.025n

* CHECK dout1_51 Vdout1_51ck33 = 0.9 time = 170
.meas tran vdout1_51ck33 FIND v(dout1_51) AT=170.025n

* CHECK dout1_52 Vdout1_52ck33 = 0 time = 170
.meas tran vdout1_52ck33 FIND v(dout1_52) AT=170.025n

* CHECK dout1_53 Vdout1_53ck33 = 0 time = 170
.meas tran vdout1_53ck33 FIND v(dout1_53) AT=170.025n

* CHECK dout1_54 Vdout1_54ck33 = 0 time = 170
.meas tran vdout1_54ck33 FIND v(dout1_54) AT=170.025n

* CHECK dout1_55 Vdout1_55ck33 = 0.9 time = 170
.meas tran vdout1_55ck33 FIND v(dout1_55) AT=170.025n

* CHECK dout1_0 Vdout1_0ck34 = 0 time = 175
.meas tran vdout1_0ck34 FIND v(dout1_0) AT=175.025n

* CHECK dout1_1 Vdout1_1ck34 = 0 time = 175
.meas tran vdout1_1ck34 FIND v(dout1_1) AT=175.025n

* CHECK dout1_2 Vdout1_2ck34 = 0.9 time = 175
.meas tran vdout1_2ck34 FIND v(dout1_2) AT=175.025n

* CHECK dout1_3 Vdout1_3ck34 = 0.9 time = 175
.meas tran vdout1_3ck34 FIND v(dout1_3) AT=175.025n

* CHECK dout1_4 Vdout1_4ck34 = 0.9 time = 175
.meas tran vdout1_4ck34 FIND v(dout1_4) AT=175.025n

* CHECK dout1_5 Vdout1_5ck34 = 0 time = 175
.meas tran vdout1_5ck34 FIND v(dout1_5) AT=175.025n

* CHECK dout1_6 Vdout1_6ck34 = 0 time = 175
.meas tran vdout1_6ck34 FIND v(dout1_6) AT=175.025n

* CHECK dout1_7 Vdout1_7ck34 = 0 time = 175
.meas tran vdout1_7ck34 FIND v(dout1_7) AT=175.025n

* CHECK dout1_8 Vdout1_8ck34 = 0.9 time = 175
.meas tran vdout1_8ck34 FIND v(dout1_8) AT=175.025n

* CHECK dout1_9 Vdout1_9ck34 = 0.9 time = 175
.meas tran vdout1_9ck34 FIND v(dout1_9) AT=175.025n

* CHECK dout1_10 Vdout1_10ck34 = 0.9 time = 175
.meas tran vdout1_10ck34 FIND v(dout1_10) AT=175.025n

* CHECK dout1_11 Vdout1_11ck34 = 0 time = 175
.meas tran vdout1_11ck34 FIND v(dout1_11) AT=175.025n

* CHECK dout1_12 Vdout1_12ck34 = 0 time = 175
.meas tran vdout1_12ck34 FIND v(dout1_12) AT=175.025n

* CHECK dout1_13 Vdout1_13ck34 = 0 time = 175
.meas tran vdout1_13ck34 FIND v(dout1_13) AT=175.025n

* CHECK dout1_14 Vdout1_14ck34 = 0 time = 175
.meas tran vdout1_14ck34 FIND v(dout1_14) AT=175.025n

* CHECK dout1_15 Vdout1_15ck34 = 0 time = 175
.meas tran vdout1_15ck34 FIND v(dout1_15) AT=175.025n

* CHECK dout1_16 Vdout1_16ck34 = 0.9 time = 175
.meas tran vdout1_16ck34 FIND v(dout1_16) AT=175.025n

* CHECK dout1_17 Vdout1_17ck34 = 0.9 time = 175
.meas tran vdout1_17ck34 FIND v(dout1_17) AT=175.025n

* CHECK dout1_18 Vdout1_18ck34 = 0.9 time = 175
.meas tran vdout1_18ck34 FIND v(dout1_18) AT=175.025n

* CHECK dout1_19 Vdout1_19ck34 = 0.9 time = 175
.meas tran vdout1_19ck34 FIND v(dout1_19) AT=175.025n

* CHECK dout1_20 Vdout1_20ck34 = 0 time = 175
.meas tran vdout1_20ck34 FIND v(dout1_20) AT=175.025n

* CHECK dout1_21 Vdout1_21ck34 = 0 time = 175
.meas tran vdout1_21ck34 FIND v(dout1_21) AT=175.025n

* CHECK dout1_22 Vdout1_22ck34 = 0.9 time = 175
.meas tran vdout1_22ck34 FIND v(dout1_22) AT=175.025n

* CHECK dout1_23 Vdout1_23ck34 = 0.9 time = 175
.meas tran vdout1_23ck34 FIND v(dout1_23) AT=175.025n

* CHECK dout1_24 Vdout1_24ck34 = 0.9 time = 175
.meas tran vdout1_24ck34 FIND v(dout1_24) AT=175.025n

* CHECK dout1_25 Vdout1_25ck34 = 0.9 time = 175
.meas tran vdout1_25ck34 FIND v(dout1_25) AT=175.025n

* CHECK dout1_26 Vdout1_26ck34 = 0.9 time = 175
.meas tran vdout1_26ck34 FIND v(dout1_26) AT=175.025n

* CHECK dout1_27 Vdout1_27ck34 = 0.9 time = 175
.meas tran vdout1_27ck34 FIND v(dout1_27) AT=175.025n

* CHECK dout1_28 Vdout1_28ck34 = 0.9 time = 175
.meas tran vdout1_28ck34 FIND v(dout1_28) AT=175.025n

* CHECK dout1_29 Vdout1_29ck34 = 0.9 time = 175
.meas tran vdout1_29ck34 FIND v(dout1_29) AT=175.025n

* CHECK dout1_30 Vdout1_30ck34 = 0.9 time = 175
.meas tran vdout1_30ck34 FIND v(dout1_30) AT=175.025n

* CHECK dout1_31 Vdout1_31ck34 = 0 time = 175
.meas tran vdout1_31ck34 FIND v(dout1_31) AT=175.025n

* CHECK dout1_32 Vdout1_32ck34 = 0 time = 175
.meas tran vdout1_32ck34 FIND v(dout1_32) AT=175.025n

* CHECK dout1_33 Vdout1_33ck34 = 0.9 time = 175
.meas tran vdout1_33ck34 FIND v(dout1_33) AT=175.025n

* CHECK dout1_34 Vdout1_34ck34 = 0.9 time = 175
.meas tran vdout1_34ck34 FIND v(dout1_34) AT=175.025n

* CHECK dout1_35 Vdout1_35ck34 = 0 time = 175
.meas tran vdout1_35ck34 FIND v(dout1_35) AT=175.025n

* CHECK dout1_36 Vdout1_36ck34 = 0.9 time = 175
.meas tran vdout1_36ck34 FIND v(dout1_36) AT=175.025n

* CHECK dout1_37 Vdout1_37ck34 = 0.9 time = 175
.meas tran vdout1_37ck34 FIND v(dout1_37) AT=175.025n

* CHECK dout1_38 Vdout1_38ck34 = 0 time = 175
.meas tran vdout1_38ck34 FIND v(dout1_38) AT=175.025n

* CHECK dout1_39 Vdout1_39ck34 = 0 time = 175
.meas tran vdout1_39ck34 FIND v(dout1_39) AT=175.025n

* CHECK dout1_40 Vdout1_40ck34 = 0 time = 175
.meas tran vdout1_40ck34 FIND v(dout1_40) AT=175.025n

* CHECK dout1_41 Vdout1_41ck34 = 0.9 time = 175
.meas tran vdout1_41ck34 FIND v(dout1_41) AT=175.025n

* CHECK dout1_42 Vdout1_42ck34 = 0 time = 175
.meas tran vdout1_42ck34 FIND v(dout1_42) AT=175.025n

* CHECK dout1_43 Vdout1_43ck34 = 0 time = 175
.meas tran vdout1_43ck34 FIND v(dout1_43) AT=175.025n

* CHECK dout1_44 Vdout1_44ck34 = 0 time = 175
.meas tran vdout1_44ck34 FIND v(dout1_44) AT=175.025n

* CHECK dout1_45 Vdout1_45ck34 = 0 time = 175
.meas tran vdout1_45ck34 FIND v(dout1_45) AT=175.025n

* CHECK dout1_46 Vdout1_46ck34 = 0.9 time = 175
.meas tran vdout1_46ck34 FIND v(dout1_46) AT=175.025n

* CHECK dout1_47 Vdout1_47ck34 = 0.9 time = 175
.meas tran vdout1_47ck34 FIND v(dout1_47) AT=175.025n

* CHECK dout1_48 Vdout1_48ck34 = 0.9 time = 175
.meas tran vdout1_48ck34 FIND v(dout1_48) AT=175.025n

* CHECK dout1_49 Vdout1_49ck34 = 0 time = 175
.meas tran vdout1_49ck34 FIND v(dout1_49) AT=175.025n

* CHECK dout1_50 Vdout1_50ck34 = 0.9 time = 175
.meas tran vdout1_50ck34 FIND v(dout1_50) AT=175.025n

* CHECK dout1_51 Vdout1_51ck34 = 0.9 time = 175
.meas tran vdout1_51ck34 FIND v(dout1_51) AT=175.025n

* CHECK dout1_52 Vdout1_52ck34 = 0 time = 175
.meas tran vdout1_52ck34 FIND v(dout1_52) AT=175.025n

* CHECK dout1_53 Vdout1_53ck34 = 0 time = 175
.meas tran vdout1_53ck34 FIND v(dout1_53) AT=175.025n

* CHECK dout1_54 Vdout1_54ck34 = 0 time = 175
.meas tran vdout1_54ck34 FIND v(dout1_54) AT=175.025n

* CHECK dout1_55 Vdout1_55ck34 = 0 time = 175
.meas tran vdout1_55ck34 FIND v(dout1_55) AT=175.025n

* CHECK dout1_0 Vdout1_0ck35 = 0 time = 180
.meas tran vdout1_0ck35 FIND v(dout1_0) AT=180.025n

* CHECK dout1_1 Vdout1_1ck35 = 0.9 time = 180
.meas tran vdout1_1ck35 FIND v(dout1_1) AT=180.025n

* CHECK dout1_2 Vdout1_2ck35 = 0.9 time = 180
.meas tran vdout1_2ck35 FIND v(dout1_2) AT=180.025n

* CHECK dout1_3 Vdout1_3ck35 = 0 time = 180
.meas tran vdout1_3ck35 FIND v(dout1_3) AT=180.025n

* CHECK dout1_4 Vdout1_4ck35 = 0 time = 180
.meas tran vdout1_4ck35 FIND v(dout1_4) AT=180.025n

* CHECK dout1_5 Vdout1_5ck35 = 0.9 time = 180
.meas tran vdout1_5ck35 FIND v(dout1_5) AT=180.025n

* CHECK dout1_6 Vdout1_6ck35 = 0.9 time = 180
.meas tran vdout1_6ck35 FIND v(dout1_6) AT=180.025n

* CHECK dout1_7 Vdout1_7ck35 = 0.9 time = 180
.meas tran vdout1_7ck35 FIND v(dout1_7) AT=180.025n

* CHECK dout1_8 Vdout1_8ck35 = 0 time = 180
.meas tran vdout1_8ck35 FIND v(dout1_8) AT=180.025n

* CHECK dout1_9 Vdout1_9ck35 = 0 time = 180
.meas tran vdout1_9ck35 FIND v(dout1_9) AT=180.025n

* CHECK dout1_10 Vdout1_10ck35 = 0.9 time = 180
.meas tran vdout1_10ck35 FIND v(dout1_10) AT=180.025n

* CHECK dout1_11 Vdout1_11ck35 = 0 time = 180
.meas tran vdout1_11ck35 FIND v(dout1_11) AT=180.025n

* CHECK dout1_12 Vdout1_12ck35 = 0 time = 180
.meas tran vdout1_12ck35 FIND v(dout1_12) AT=180.025n

* CHECK dout1_13 Vdout1_13ck35 = 0 time = 180
.meas tran vdout1_13ck35 FIND v(dout1_13) AT=180.025n

* CHECK dout1_14 Vdout1_14ck35 = 0.9 time = 180
.meas tran vdout1_14ck35 FIND v(dout1_14) AT=180.025n

* CHECK dout1_15 Vdout1_15ck35 = 0.9 time = 180
.meas tran vdout1_15ck35 FIND v(dout1_15) AT=180.025n

* CHECK dout1_16 Vdout1_16ck35 = 0 time = 180
.meas tran vdout1_16ck35 FIND v(dout1_16) AT=180.025n

* CHECK dout1_17 Vdout1_17ck35 = 0.9 time = 180
.meas tran vdout1_17ck35 FIND v(dout1_17) AT=180.025n

* CHECK dout1_18 Vdout1_18ck35 = 0 time = 180
.meas tran vdout1_18ck35 FIND v(dout1_18) AT=180.025n

* CHECK dout1_19 Vdout1_19ck35 = 0 time = 180
.meas tran vdout1_19ck35 FIND v(dout1_19) AT=180.025n

* CHECK dout1_20 Vdout1_20ck35 = 0.9 time = 180
.meas tran vdout1_20ck35 FIND v(dout1_20) AT=180.025n

* CHECK dout1_21 Vdout1_21ck35 = 0 time = 180
.meas tran vdout1_21ck35 FIND v(dout1_21) AT=180.025n

* CHECK dout1_22 Vdout1_22ck35 = 0 time = 180
.meas tran vdout1_22ck35 FIND v(dout1_22) AT=180.025n

* CHECK dout1_23 Vdout1_23ck35 = 0.9 time = 180
.meas tran vdout1_23ck35 FIND v(dout1_23) AT=180.025n

* CHECK dout1_24 Vdout1_24ck35 = 0 time = 180
.meas tran vdout1_24ck35 FIND v(dout1_24) AT=180.025n

* CHECK dout1_25 Vdout1_25ck35 = 0.9 time = 180
.meas tran vdout1_25ck35 FIND v(dout1_25) AT=180.025n

* CHECK dout1_26 Vdout1_26ck35 = 0.9 time = 180
.meas tran vdout1_26ck35 FIND v(dout1_26) AT=180.025n

* CHECK dout1_27 Vdout1_27ck35 = 0.9 time = 180
.meas tran vdout1_27ck35 FIND v(dout1_27) AT=180.025n

* CHECK dout1_28 Vdout1_28ck35 = 0 time = 180
.meas tran vdout1_28ck35 FIND v(dout1_28) AT=180.025n

* CHECK dout1_29 Vdout1_29ck35 = 0.9 time = 180
.meas tran vdout1_29ck35 FIND v(dout1_29) AT=180.025n

* CHECK dout1_30 Vdout1_30ck35 = 0 time = 180
.meas tran vdout1_30ck35 FIND v(dout1_30) AT=180.025n

* CHECK dout1_31 Vdout1_31ck35 = 0.9 time = 180
.meas tran vdout1_31ck35 FIND v(dout1_31) AT=180.025n

* CHECK dout1_32 Vdout1_32ck35 = 0 time = 180
.meas tran vdout1_32ck35 FIND v(dout1_32) AT=180.025n

* CHECK dout1_33 Vdout1_33ck35 = 0.9 time = 180
.meas tran vdout1_33ck35 FIND v(dout1_33) AT=180.025n

* CHECK dout1_34 Vdout1_34ck35 = 0.9 time = 180
.meas tran vdout1_34ck35 FIND v(dout1_34) AT=180.025n

* CHECK dout1_35 Vdout1_35ck35 = 0 time = 180
.meas tran vdout1_35ck35 FIND v(dout1_35) AT=180.025n

* CHECK dout1_36 Vdout1_36ck35 = 0.9 time = 180
.meas tran vdout1_36ck35 FIND v(dout1_36) AT=180.025n

* CHECK dout1_37 Vdout1_37ck35 = 0.9 time = 180
.meas tran vdout1_37ck35 FIND v(dout1_37) AT=180.025n

* CHECK dout1_38 Vdout1_38ck35 = 0.9 time = 180
.meas tran vdout1_38ck35 FIND v(dout1_38) AT=180.025n

* CHECK dout1_39 Vdout1_39ck35 = 0 time = 180
.meas tran vdout1_39ck35 FIND v(dout1_39) AT=180.025n

* CHECK dout1_40 Vdout1_40ck35 = 0.9 time = 180
.meas tran vdout1_40ck35 FIND v(dout1_40) AT=180.025n

* CHECK dout1_41 Vdout1_41ck35 = 0 time = 180
.meas tran vdout1_41ck35 FIND v(dout1_41) AT=180.025n

* CHECK dout1_42 Vdout1_42ck35 = 0 time = 180
.meas tran vdout1_42ck35 FIND v(dout1_42) AT=180.025n

* CHECK dout1_43 Vdout1_43ck35 = 0 time = 180
.meas tran vdout1_43ck35 FIND v(dout1_43) AT=180.025n

* CHECK dout1_44 Vdout1_44ck35 = 0.9 time = 180
.meas tran vdout1_44ck35 FIND v(dout1_44) AT=180.025n

* CHECK dout1_45 Vdout1_45ck35 = 0 time = 180
.meas tran vdout1_45ck35 FIND v(dout1_45) AT=180.025n

* CHECK dout1_46 Vdout1_46ck35 = 0 time = 180
.meas tran vdout1_46ck35 FIND v(dout1_46) AT=180.025n

* CHECK dout1_47 Vdout1_47ck35 = 0 time = 180
.meas tran vdout1_47ck35 FIND v(dout1_47) AT=180.025n

* CHECK dout1_48 Vdout1_48ck35 = 0 time = 180
.meas tran vdout1_48ck35 FIND v(dout1_48) AT=180.025n

* CHECK dout1_49 Vdout1_49ck35 = 0.9 time = 180
.meas tran vdout1_49ck35 FIND v(dout1_49) AT=180.025n

* CHECK dout1_50 Vdout1_50ck35 = 0.9 time = 180
.meas tran vdout1_50ck35 FIND v(dout1_50) AT=180.025n

* CHECK dout1_51 Vdout1_51ck35 = 0.9 time = 180
.meas tran vdout1_51ck35 FIND v(dout1_51) AT=180.025n

* CHECK dout1_52 Vdout1_52ck35 = 0 time = 180
.meas tran vdout1_52ck35 FIND v(dout1_52) AT=180.025n

* CHECK dout1_53 Vdout1_53ck35 = 0 time = 180
.meas tran vdout1_53ck35 FIND v(dout1_53) AT=180.025n

* CHECK dout1_54 Vdout1_54ck35 = 0 time = 180
.meas tran vdout1_54ck35 FIND v(dout1_54) AT=180.025n

* CHECK dout1_55 Vdout1_55ck35 = 0.9 time = 180
.meas tran vdout1_55ck35 FIND v(dout1_55) AT=180.025n

* CHECK dout1_0 Vdout1_0ck37 = 0.9 time = 190
.meas tran vdout1_0ck37 FIND v(dout1_0) AT=190.025n

* CHECK dout1_1 Vdout1_1ck37 = 0.9 time = 190
.meas tran vdout1_1ck37 FIND v(dout1_1) AT=190.025n

* CHECK dout1_2 Vdout1_2ck37 = 0 time = 190
.meas tran vdout1_2ck37 FIND v(dout1_2) AT=190.025n

* CHECK dout1_3 Vdout1_3ck37 = 0.9 time = 190
.meas tran vdout1_3ck37 FIND v(dout1_3) AT=190.025n

* CHECK dout1_4 Vdout1_4ck37 = 0 time = 190
.meas tran vdout1_4ck37 FIND v(dout1_4) AT=190.025n

* CHECK dout1_5 Vdout1_5ck37 = 0.9 time = 190
.meas tran vdout1_5ck37 FIND v(dout1_5) AT=190.025n

* CHECK dout1_6 Vdout1_6ck37 = 0 time = 190
.meas tran vdout1_6ck37 FIND v(dout1_6) AT=190.025n

* CHECK dout1_7 Vdout1_7ck37 = 0.9 time = 190
.meas tran vdout1_7ck37 FIND v(dout1_7) AT=190.025n

* CHECK dout1_8 Vdout1_8ck37 = 0.9 time = 190
.meas tran vdout1_8ck37 FIND v(dout1_8) AT=190.025n

* CHECK dout1_9 Vdout1_9ck37 = 0 time = 190
.meas tran vdout1_9ck37 FIND v(dout1_9) AT=190.025n

* CHECK dout1_10 Vdout1_10ck37 = 0.9 time = 190
.meas tran vdout1_10ck37 FIND v(dout1_10) AT=190.025n

* CHECK dout1_11 Vdout1_11ck37 = 0.9 time = 190
.meas tran vdout1_11ck37 FIND v(dout1_11) AT=190.025n

* CHECK dout1_12 Vdout1_12ck37 = 0.9 time = 190
.meas tran vdout1_12ck37 FIND v(dout1_12) AT=190.025n

* CHECK dout1_13 Vdout1_13ck37 = 0.9 time = 190
.meas tran vdout1_13ck37 FIND v(dout1_13) AT=190.025n

* CHECK dout1_14 Vdout1_14ck37 = 0 time = 190
.meas tran vdout1_14ck37 FIND v(dout1_14) AT=190.025n

* CHECK dout1_15 Vdout1_15ck37 = 0.9 time = 190
.meas tran vdout1_15ck37 FIND v(dout1_15) AT=190.025n

* CHECK dout1_16 Vdout1_16ck37 = 0 time = 190
.meas tran vdout1_16ck37 FIND v(dout1_16) AT=190.025n

* CHECK dout1_17 Vdout1_17ck37 = 0.9 time = 190
.meas tran vdout1_17ck37 FIND v(dout1_17) AT=190.025n

* CHECK dout1_18 Vdout1_18ck37 = 0.9 time = 190
.meas tran vdout1_18ck37 FIND v(dout1_18) AT=190.025n

* CHECK dout1_19 Vdout1_19ck37 = 0 time = 190
.meas tran vdout1_19ck37 FIND v(dout1_19) AT=190.025n

* CHECK dout1_20 Vdout1_20ck37 = 0 time = 190
.meas tran vdout1_20ck37 FIND v(dout1_20) AT=190.025n

* CHECK dout1_21 Vdout1_21ck37 = 0 time = 190
.meas tran vdout1_21ck37 FIND v(dout1_21) AT=190.025n

* CHECK dout1_22 Vdout1_22ck37 = 0 time = 190
.meas tran vdout1_22ck37 FIND v(dout1_22) AT=190.025n

* CHECK dout1_23 Vdout1_23ck37 = 0.9 time = 190
.meas tran vdout1_23ck37 FIND v(dout1_23) AT=190.025n

* CHECK dout1_24 Vdout1_24ck37 = 0 time = 190
.meas tran vdout1_24ck37 FIND v(dout1_24) AT=190.025n

* CHECK dout1_25 Vdout1_25ck37 = 0 time = 190
.meas tran vdout1_25ck37 FIND v(dout1_25) AT=190.025n

* CHECK dout1_26 Vdout1_26ck37 = 0 time = 190
.meas tran vdout1_26ck37 FIND v(dout1_26) AT=190.025n

* CHECK dout1_27 Vdout1_27ck37 = 0.9 time = 190
.meas tran vdout1_27ck37 FIND v(dout1_27) AT=190.025n

* CHECK dout1_28 Vdout1_28ck37 = 0 time = 190
.meas tran vdout1_28ck37 FIND v(dout1_28) AT=190.025n

* CHECK dout1_29 Vdout1_29ck37 = 0 time = 190
.meas tran vdout1_29ck37 FIND v(dout1_29) AT=190.025n

* CHECK dout1_30 Vdout1_30ck37 = 0.9 time = 190
.meas tran vdout1_30ck37 FIND v(dout1_30) AT=190.025n

* CHECK dout1_31 Vdout1_31ck37 = 0 time = 190
.meas tran vdout1_31ck37 FIND v(dout1_31) AT=190.025n

* CHECK dout1_32 Vdout1_32ck37 = 0 time = 190
.meas tran vdout1_32ck37 FIND v(dout1_32) AT=190.025n

* CHECK dout1_33 Vdout1_33ck37 = 0 time = 190
.meas tran vdout1_33ck37 FIND v(dout1_33) AT=190.025n

* CHECK dout1_34 Vdout1_34ck37 = 0 time = 190
.meas tran vdout1_34ck37 FIND v(dout1_34) AT=190.025n

* CHECK dout1_35 Vdout1_35ck37 = 0 time = 190
.meas tran vdout1_35ck37 FIND v(dout1_35) AT=190.025n

* CHECK dout1_36 Vdout1_36ck37 = 0.9 time = 190
.meas tran vdout1_36ck37 FIND v(dout1_36) AT=190.025n

* CHECK dout1_37 Vdout1_37ck37 = 0.9 time = 190
.meas tran vdout1_37ck37 FIND v(dout1_37) AT=190.025n

* CHECK dout1_38 Vdout1_38ck37 = 0.9 time = 190
.meas tran vdout1_38ck37 FIND v(dout1_38) AT=190.025n

* CHECK dout1_39 Vdout1_39ck37 = 0 time = 190
.meas tran vdout1_39ck37 FIND v(dout1_39) AT=190.025n

* CHECK dout1_40 Vdout1_40ck37 = 0 time = 190
.meas tran vdout1_40ck37 FIND v(dout1_40) AT=190.025n

* CHECK dout1_41 Vdout1_41ck37 = 0 time = 190
.meas tran vdout1_41ck37 FIND v(dout1_41) AT=190.025n

* CHECK dout1_42 Vdout1_42ck37 = 0.9 time = 190
.meas tran vdout1_42ck37 FIND v(dout1_42) AT=190.025n

* CHECK dout1_43 Vdout1_43ck37 = 0.9 time = 190
.meas tran vdout1_43ck37 FIND v(dout1_43) AT=190.025n

* CHECK dout1_44 Vdout1_44ck37 = 0 time = 190
.meas tran vdout1_44ck37 FIND v(dout1_44) AT=190.025n

* CHECK dout1_45 Vdout1_45ck37 = 0 time = 190
.meas tran vdout1_45ck37 FIND v(dout1_45) AT=190.025n

* CHECK dout1_46 Vdout1_46ck37 = 0 time = 190
.meas tran vdout1_46ck37 FIND v(dout1_46) AT=190.025n

* CHECK dout1_47 Vdout1_47ck37 = 0.9 time = 190
.meas tran vdout1_47ck37 FIND v(dout1_47) AT=190.025n

* CHECK dout1_48 Vdout1_48ck37 = 0.9 time = 190
.meas tran vdout1_48ck37 FIND v(dout1_48) AT=190.025n

* CHECK dout1_49 Vdout1_49ck37 = 0 time = 190
.meas tran vdout1_49ck37 FIND v(dout1_49) AT=190.025n

* CHECK dout1_50 Vdout1_50ck37 = 0.9 time = 190
.meas tran vdout1_50ck37 FIND v(dout1_50) AT=190.025n

* CHECK dout1_51 Vdout1_51ck37 = 0.9 time = 190
.meas tran vdout1_51ck37 FIND v(dout1_51) AT=190.025n

* CHECK dout1_52 Vdout1_52ck37 = 0 time = 190
.meas tran vdout1_52ck37 FIND v(dout1_52) AT=190.025n

* CHECK dout1_53 Vdout1_53ck37 = 0.9 time = 190
.meas tran vdout1_53ck37 FIND v(dout1_53) AT=190.025n

* CHECK dout1_54 Vdout1_54ck37 = 0 time = 190
.meas tran vdout1_54ck37 FIND v(dout1_54) AT=190.025n

* CHECK dout1_55 Vdout1_55ck37 = 0.9 time = 190
.meas tran vdout1_55ck37 FIND v(dout1_55) AT=190.025n

* CHECK dout1_0 Vdout1_0ck38 = 0.9 time = 195
.meas tran vdout1_0ck38 FIND v(dout1_0) AT=195.025n

* CHECK dout1_1 Vdout1_1ck38 = 0.9 time = 195
.meas tran vdout1_1ck38 FIND v(dout1_1) AT=195.025n

* CHECK dout1_2 Vdout1_2ck38 = 0 time = 195
.meas tran vdout1_2ck38 FIND v(dout1_2) AT=195.025n

* CHECK dout1_3 Vdout1_3ck38 = 0.9 time = 195
.meas tran vdout1_3ck38 FIND v(dout1_3) AT=195.025n

* CHECK dout1_4 Vdout1_4ck38 = 0 time = 195
.meas tran vdout1_4ck38 FIND v(dout1_4) AT=195.025n

* CHECK dout1_5 Vdout1_5ck38 = 0.9 time = 195
.meas tran vdout1_5ck38 FIND v(dout1_5) AT=195.025n

* CHECK dout1_6 Vdout1_6ck38 = 0 time = 195
.meas tran vdout1_6ck38 FIND v(dout1_6) AT=195.025n

* CHECK dout1_7 Vdout1_7ck38 = 0.9 time = 195
.meas tran vdout1_7ck38 FIND v(dout1_7) AT=195.025n

* CHECK dout1_8 Vdout1_8ck38 = 0.9 time = 195
.meas tran vdout1_8ck38 FIND v(dout1_8) AT=195.025n

* CHECK dout1_9 Vdout1_9ck38 = 0 time = 195
.meas tran vdout1_9ck38 FIND v(dout1_9) AT=195.025n

* CHECK dout1_10 Vdout1_10ck38 = 0.9 time = 195
.meas tran vdout1_10ck38 FIND v(dout1_10) AT=195.025n

* CHECK dout1_11 Vdout1_11ck38 = 0.9 time = 195
.meas tran vdout1_11ck38 FIND v(dout1_11) AT=195.025n

* CHECK dout1_12 Vdout1_12ck38 = 0.9 time = 195
.meas tran vdout1_12ck38 FIND v(dout1_12) AT=195.025n

* CHECK dout1_13 Vdout1_13ck38 = 0.9 time = 195
.meas tran vdout1_13ck38 FIND v(dout1_13) AT=195.025n

* CHECK dout1_14 Vdout1_14ck38 = 0 time = 195
.meas tran vdout1_14ck38 FIND v(dout1_14) AT=195.025n

* CHECK dout1_15 Vdout1_15ck38 = 0.9 time = 195
.meas tran vdout1_15ck38 FIND v(dout1_15) AT=195.025n

* CHECK dout1_16 Vdout1_16ck38 = 0 time = 195
.meas tran vdout1_16ck38 FIND v(dout1_16) AT=195.025n

* CHECK dout1_17 Vdout1_17ck38 = 0.9 time = 195
.meas tran vdout1_17ck38 FIND v(dout1_17) AT=195.025n

* CHECK dout1_18 Vdout1_18ck38 = 0.9 time = 195
.meas tran vdout1_18ck38 FIND v(dout1_18) AT=195.025n

* CHECK dout1_19 Vdout1_19ck38 = 0 time = 195
.meas tran vdout1_19ck38 FIND v(dout1_19) AT=195.025n

* CHECK dout1_20 Vdout1_20ck38 = 0 time = 195
.meas tran vdout1_20ck38 FIND v(dout1_20) AT=195.025n

* CHECK dout1_21 Vdout1_21ck38 = 0 time = 195
.meas tran vdout1_21ck38 FIND v(dout1_21) AT=195.025n

* CHECK dout1_22 Vdout1_22ck38 = 0 time = 195
.meas tran vdout1_22ck38 FIND v(dout1_22) AT=195.025n

* CHECK dout1_23 Vdout1_23ck38 = 0.9 time = 195
.meas tran vdout1_23ck38 FIND v(dout1_23) AT=195.025n

* CHECK dout1_24 Vdout1_24ck38 = 0 time = 195
.meas tran vdout1_24ck38 FIND v(dout1_24) AT=195.025n

* CHECK dout1_25 Vdout1_25ck38 = 0 time = 195
.meas tran vdout1_25ck38 FIND v(dout1_25) AT=195.025n

* CHECK dout1_26 Vdout1_26ck38 = 0 time = 195
.meas tran vdout1_26ck38 FIND v(dout1_26) AT=195.025n

* CHECK dout1_27 Vdout1_27ck38 = 0.9 time = 195
.meas tran vdout1_27ck38 FIND v(dout1_27) AT=195.025n

* CHECK dout1_28 Vdout1_28ck38 = 0 time = 195
.meas tran vdout1_28ck38 FIND v(dout1_28) AT=195.025n

* CHECK dout1_29 Vdout1_29ck38 = 0 time = 195
.meas tran vdout1_29ck38 FIND v(dout1_29) AT=195.025n

* CHECK dout1_30 Vdout1_30ck38 = 0.9 time = 195
.meas tran vdout1_30ck38 FIND v(dout1_30) AT=195.025n

* CHECK dout1_31 Vdout1_31ck38 = 0 time = 195
.meas tran vdout1_31ck38 FIND v(dout1_31) AT=195.025n

* CHECK dout1_32 Vdout1_32ck38 = 0 time = 195
.meas tran vdout1_32ck38 FIND v(dout1_32) AT=195.025n

* CHECK dout1_33 Vdout1_33ck38 = 0 time = 195
.meas tran vdout1_33ck38 FIND v(dout1_33) AT=195.025n

* CHECK dout1_34 Vdout1_34ck38 = 0 time = 195
.meas tran vdout1_34ck38 FIND v(dout1_34) AT=195.025n

* CHECK dout1_35 Vdout1_35ck38 = 0 time = 195
.meas tran vdout1_35ck38 FIND v(dout1_35) AT=195.025n

* CHECK dout1_36 Vdout1_36ck38 = 0.9 time = 195
.meas tran vdout1_36ck38 FIND v(dout1_36) AT=195.025n

* CHECK dout1_37 Vdout1_37ck38 = 0.9 time = 195
.meas tran vdout1_37ck38 FIND v(dout1_37) AT=195.025n

* CHECK dout1_38 Vdout1_38ck38 = 0.9 time = 195
.meas tran vdout1_38ck38 FIND v(dout1_38) AT=195.025n

* CHECK dout1_39 Vdout1_39ck38 = 0 time = 195
.meas tran vdout1_39ck38 FIND v(dout1_39) AT=195.025n

* CHECK dout1_40 Vdout1_40ck38 = 0 time = 195
.meas tran vdout1_40ck38 FIND v(dout1_40) AT=195.025n

* CHECK dout1_41 Vdout1_41ck38 = 0 time = 195
.meas tran vdout1_41ck38 FIND v(dout1_41) AT=195.025n

* CHECK dout1_42 Vdout1_42ck38 = 0.9 time = 195
.meas tran vdout1_42ck38 FIND v(dout1_42) AT=195.025n

* CHECK dout1_43 Vdout1_43ck38 = 0.9 time = 195
.meas tran vdout1_43ck38 FIND v(dout1_43) AT=195.025n

* CHECK dout1_44 Vdout1_44ck38 = 0 time = 195
.meas tran vdout1_44ck38 FIND v(dout1_44) AT=195.025n

* CHECK dout1_45 Vdout1_45ck38 = 0 time = 195
.meas tran vdout1_45ck38 FIND v(dout1_45) AT=195.025n

* CHECK dout1_46 Vdout1_46ck38 = 0 time = 195
.meas tran vdout1_46ck38 FIND v(dout1_46) AT=195.025n

* CHECK dout1_47 Vdout1_47ck38 = 0.9 time = 195
.meas tran vdout1_47ck38 FIND v(dout1_47) AT=195.025n

* CHECK dout1_48 Vdout1_48ck38 = 0.9 time = 195
.meas tran vdout1_48ck38 FIND v(dout1_48) AT=195.025n

* CHECK dout1_49 Vdout1_49ck38 = 0 time = 195
.meas tran vdout1_49ck38 FIND v(dout1_49) AT=195.025n

* CHECK dout1_50 Vdout1_50ck38 = 0.9 time = 195
.meas tran vdout1_50ck38 FIND v(dout1_50) AT=195.025n

* CHECK dout1_51 Vdout1_51ck38 = 0.9 time = 195
.meas tran vdout1_51ck38 FIND v(dout1_51) AT=195.025n

* CHECK dout1_52 Vdout1_52ck38 = 0 time = 195
.meas tran vdout1_52ck38 FIND v(dout1_52) AT=195.025n

* CHECK dout1_53 Vdout1_53ck38 = 0.9 time = 195
.meas tran vdout1_53ck38 FIND v(dout1_53) AT=195.025n

* CHECK dout1_54 Vdout1_54ck38 = 0 time = 195
.meas tran vdout1_54ck38 FIND v(dout1_54) AT=195.025n

* CHECK dout1_55 Vdout1_55ck38 = 0.9 time = 195
.meas tran vdout1_55ck38 FIND v(dout1_55) AT=195.025n

* CHECK dout1_0 Vdout1_0ck45 = 0.9 time = 230
.meas tran vdout1_0ck45 FIND v(dout1_0) AT=230.025n

* CHECK dout1_1 Vdout1_1ck45 = 0.9 time = 230
.meas tran vdout1_1ck45 FIND v(dout1_1) AT=230.025n

* CHECK dout1_2 Vdout1_2ck45 = 0 time = 230
.meas tran vdout1_2ck45 FIND v(dout1_2) AT=230.025n

* CHECK dout1_3 Vdout1_3ck45 = 0.9 time = 230
.meas tran vdout1_3ck45 FIND v(dout1_3) AT=230.025n

* CHECK dout1_4 Vdout1_4ck45 = 0.9 time = 230
.meas tran vdout1_4ck45 FIND v(dout1_4) AT=230.025n

* CHECK dout1_5 Vdout1_5ck45 = 0.9 time = 230
.meas tran vdout1_5ck45 FIND v(dout1_5) AT=230.025n

* CHECK dout1_6 Vdout1_6ck45 = 0.9 time = 230
.meas tran vdout1_6ck45 FIND v(dout1_6) AT=230.025n

* CHECK dout1_7 Vdout1_7ck45 = 0 time = 230
.meas tran vdout1_7ck45 FIND v(dout1_7) AT=230.025n

* CHECK dout1_8 Vdout1_8ck45 = 0 time = 230
.meas tran vdout1_8ck45 FIND v(dout1_8) AT=230.025n

* CHECK dout1_9 Vdout1_9ck45 = 0.9 time = 230
.meas tran vdout1_9ck45 FIND v(dout1_9) AT=230.025n

* CHECK dout1_10 Vdout1_10ck45 = 0.9 time = 230
.meas tran vdout1_10ck45 FIND v(dout1_10) AT=230.025n

* CHECK dout1_11 Vdout1_11ck45 = 0.9 time = 230
.meas tran vdout1_11ck45 FIND v(dout1_11) AT=230.025n

* CHECK dout1_12 Vdout1_12ck45 = 0.9 time = 230
.meas tran vdout1_12ck45 FIND v(dout1_12) AT=230.025n

* CHECK dout1_13 Vdout1_13ck45 = 0 time = 230
.meas tran vdout1_13ck45 FIND v(dout1_13) AT=230.025n

* CHECK dout1_14 Vdout1_14ck45 = 0.9 time = 230
.meas tran vdout1_14ck45 FIND v(dout1_14) AT=230.025n

* CHECK dout1_15 Vdout1_15ck45 = 0 time = 230
.meas tran vdout1_15ck45 FIND v(dout1_15) AT=230.025n

* CHECK dout1_16 Vdout1_16ck45 = 0 time = 230
.meas tran vdout1_16ck45 FIND v(dout1_16) AT=230.025n

* CHECK dout1_17 Vdout1_17ck45 = 0 time = 230
.meas tran vdout1_17ck45 FIND v(dout1_17) AT=230.025n

* CHECK dout1_18 Vdout1_18ck45 = 0.9 time = 230
.meas tran vdout1_18ck45 FIND v(dout1_18) AT=230.025n

* CHECK dout1_19 Vdout1_19ck45 = 0.9 time = 230
.meas tran vdout1_19ck45 FIND v(dout1_19) AT=230.025n

* CHECK dout1_20 Vdout1_20ck45 = 0 time = 230
.meas tran vdout1_20ck45 FIND v(dout1_20) AT=230.025n

* CHECK dout1_21 Vdout1_21ck45 = 0 time = 230
.meas tran vdout1_21ck45 FIND v(dout1_21) AT=230.025n

* CHECK dout1_22 Vdout1_22ck45 = 0 time = 230
.meas tran vdout1_22ck45 FIND v(dout1_22) AT=230.025n

* CHECK dout1_23 Vdout1_23ck45 = 0.9 time = 230
.meas tran vdout1_23ck45 FIND v(dout1_23) AT=230.025n

* CHECK dout1_24 Vdout1_24ck45 = 0 time = 230
.meas tran vdout1_24ck45 FIND v(dout1_24) AT=230.025n

* CHECK dout1_25 Vdout1_25ck45 = 0 time = 230
.meas tran vdout1_25ck45 FIND v(dout1_25) AT=230.025n

* CHECK dout1_26 Vdout1_26ck45 = 0 time = 230
.meas tran vdout1_26ck45 FIND v(dout1_26) AT=230.025n

* CHECK dout1_27 Vdout1_27ck45 = 0 time = 230
.meas tran vdout1_27ck45 FIND v(dout1_27) AT=230.025n

* CHECK dout1_28 Vdout1_28ck45 = 0 time = 230
.meas tran vdout1_28ck45 FIND v(dout1_28) AT=230.025n

* CHECK dout1_29 Vdout1_29ck45 = 0 time = 230
.meas tran vdout1_29ck45 FIND v(dout1_29) AT=230.025n

* CHECK dout1_30 Vdout1_30ck45 = 0.9 time = 230
.meas tran vdout1_30ck45 FIND v(dout1_30) AT=230.025n

* CHECK dout1_31 Vdout1_31ck45 = 0.9 time = 230
.meas tran vdout1_31ck45 FIND v(dout1_31) AT=230.025n

* CHECK dout1_32 Vdout1_32ck45 = 0 time = 230
.meas tran vdout1_32ck45 FIND v(dout1_32) AT=230.025n

* CHECK dout1_33 Vdout1_33ck45 = 0 time = 230
.meas tran vdout1_33ck45 FIND v(dout1_33) AT=230.025n

* CHECK dout1_34 Vdout1_34ck45 = 0.9 time = 230
.meas tran vdout1_34ck45 FIND v(dout1_34) AT=230.025n

* CHECK dout1_35 Vdout1_35ck45 = 0 time = 230
.meas tran vdout1_35ck45 FIND v(dout1_35) AT=230.025n

* CHECK dout1_36 Vdout1_36ck45 = 0 time = 230
.meas tran vdout1_36ck45 FIND v(dout1_36) AT=230.025n

* CHECK dout1_37 Vdout1_37ck45 = 0.9 time = 230
.meas tran vdout1_37ck45 FIND v(dout1_37) AT=230.025n

* CHECK dout1_38 Vdout1_38ck45 = 0.9 time = 230
.meas tran vdout1_38ck45 FIND v(dout1_38) AT=230.025n

* CHECK dout1_39 Vdout1_39ck45 = 0.9 time = 230
.meas tran vdout1_39ck45 FIND v(dout1_39) AT=230.025n

* CHECK dout1_40 Vdout1_40ck45 = 0.9 time = 230
.meas tran vdout1_40ck45 FIND v(dout1_40) AT=230.025n

* CHECK dout1_41 Vdout1_41ck45 = 0.9 time = 230
.meas tran vdout1_41ck45 FIND v(dout1_41) AT=230.025n

* CHECK dout1_42 Vdout1_42ck45 = 0 time = 230
.meas tran vdout1_42ck45 FIND v(dout1_42) AT=230.025n

* CHECK dout1_43 Vdout1_43ck45 = 0.9 time = 230
.meas tran vdout1_43ck45 FIND v(dout1_43) AT=230.025n

* CHECK dout1_44 Vdout1_44ck45 = 0 time = 230
.meas tran vdout1_44ck45 FIND v(dout1_44) AT=230.025n

* CHECK dout1_45 Vdout1_45ck45 = 0 time = 230
.meas tran vdout1_45ck45 FIND v(dout1_45) AT=230.025n

* CHECK dout1_46 Vdout1_46ck45 = 0.9 time = 230
.meas tran vdout1_46ck45 FIND v(dout1_46) AT=230.025n

* CHECK dout1_47 Vdout1_47ck45 = 0 time = 230
.meas tran vdout1_47ck45 FIND v(dout1_47) AT=230.025n

* CHECK dout1_48 Vdout1_48ck45 = 0 time = 230
.meas tran vdout1_48ck45 FIND v(dout1_48) AT=230.025n

* CHECK dout1_49 Vdout1_49ck45 = 0.9 time = 230
.meas tran vdout1_49ck45 FIND v(dout1_49) AT=230.025n

* CHECK dout1_50 Vdout1_50ck45 = 0 time = 230
.meas tran vdout1_50ck45 FIND v(dout1_50) AT=230.025n

* CHECK dout1_51 Vdout1_51ck45 = 0.9 time = 230
.meas tran vdout1_51ck45 FIND v(dout1_51) AT=230.025n

* CHECK dout1_52 Vdout1_52ck45 = 0 time = 230
.meas tran vdout1_52ck45 FIND v(dout1_52) AT=230.025n

* CHECK dout1_53 Vdout1_53ck45 = 0 time = 230
.meas tran vdout1_53ck45 FIND v(dout1_53) AT=230.025n

* CHECK dout1_54 Vdout1_54ck45 = 0 time = 230
.meas tran vdout1_54ck45 FIND v(dout1_54) AT=230.025n

* CHECK dout1_55 Vdout1_55ck45 = 0.9 time = 230
.meas tran vdout1_55ck45 FIND v(dout1_55) AT=230.025n

* CHECK dout1_0 Vdout1_0ck46 = 0.9 time = 235
.meas tran vdout1_0ck46 FIND v(dout1_0) AT=235.025n

* CHECK dout1_1 Vdout1_1ck46 = 0 time = 235
.meas tran vdout1_1ck46 FIND v(dout1_1) AT=235.025n

* CHECK dout1_2 Vdout1_2ck46 = 0.9 time = 235
.meas tran vdout1_2ck46 FIND v(dout1_2) AT=235.025n

* CHECK dout1_3 Vdout1_3ck46 = 0.9 time = 235
.meas tran vdout1_3ck46 FIND v(dout1_3) AT=235.025n

* CHECK dout1_4 Vdout1_4ck46 = 0.9 time = 235
.meas tran vdout1_4ck46 FIND v(dout1_4) AT=235.025n

* CHECK dout1_5 Vdout1_5ck46 = 0.9 time = 235
.meas tran vdout1_5ck46 FIND v(dout1_5) AT=235.025n

* CHECK dout1_6 Vdout1_6ck46 = 0.9 time = 235
.meas tran vdout1_6ck46 FIND v(dout1_6) AT=235.025n

* CHECK dout1_7 Vdout1_7ck46 = 0 time = 235
.meas tran vdout1_7ck46 FIND v(dout1_7) AT=235.025n

* CHECK dout1_8 Vdout1_8ck46 = 0.9 time = 235
.meas tran vdout1_8ck46 FIND v(dout1_8) AT=235.025n

* CHECK dout1_9 Vdout1_9ck46 = 0 time = 235
.meas tran vdout1_9ck46 FIND v(dout1_9) AT=235.025n

* CHECK dout1_10 Vdout1_10ck46 = 0.9 time = 235
.meas tran vdout1_10ck46 FIND v(dout1_10) AT=235.025n

* CHECK dout1_11 Vdout1_11ck46 = 0.9 time = 235
.meas tran vdout1_11ck46 FIND v(dout1_11) AT=235.025n

* CHECK dout1_12 Vdout1_12ck46 = 0 time = 235
.meas tran vdout1_12ck46 FIND v(dout1_12) AT=235.025n

* CHECK dout1_13 Vdout1_13ck46 = 0.9 time = 235
.meas tran vdout1_13ck46 FIND v(dout1_13) AT=235.025n

* CHECK dout1_14 Vdout1_14ck46 = 0 time = 235
.meas tran vdout1_14ck46 FIND v(dout1_14) AT=235.025n

* CHECK dout1_15 Vdout1_15ck46 = 0 time = 235
.meas tran vdout1_15ck46 FIND v(dout1_15) AT=235.025n

* CHECK dout1_16 Vdout1_16ck46 = 0.9 time = 235
.meas tran vdout1_16ck46 FIND v(dout1_16) AT=235.025n

* CHECK dout1_17 Vdout1_17ck46 = 0 time = 235
.meas tran vdout1_17ck46 FIND v(dout1_17) AT=235.025n

* CHECK dout1_18 Vdout1_18ck46 = 0 time = 235
.meas tran vdout1_18ck46 FIND v(dout1_18) AT=235.025n

* CHECK dout1_19 Vdout1_19ck46 = 0 time = 235
.meas tran vdout1_19ck46 FIND v(dout1_19) AT=235.025n

* CHECK dout1_20 Vdout1_20ck46 = 0.9 time = 235
.meas tran vdout1_20ck46 FIND v(dout1_20) AT=235.025n

* CHECK dout1_21 Vdout1_21ck46 = 0.9 time = 235
.meas tran vdout1_21ck46 FIND v(dout1_21) AT=235.025n

* CHECK dout1_22 Vdout1_22ck46 = 0 time = 235
.meas tran vdout1_22ck46 FIND v(dout1_22) AT=235.025n

* CHECK dout1_23 Vdout1_23ck46 = 0.9 time = 235
.meas tran vdout1_23ck46 FIND v(dout1_23) AT=235.025n

* CHECK dout1_24 Vdout1_24ck46 = 0.9 time = 235
.meas tran vdout1_24ck46 FIND v(dout1_24) AT=235.025n

* CHECK dout1_25 Vdout1_25ck46 = 0.9 time = 235
.meas tran vdout1_25ck46 FIND v(dout1_25) AT=235.025n

* CHECK dout1_26 Vdout1_26ck46 = 0 time = 235
.meas tran vdout1_26ck46 FIND v(dout1_26) AT=235.025n

* CHECK dout1_27 Vdout1_27ck46 = 0.9 time = 235
.meas tran vdout1_27ck46 FIND v(dout1_27) AT=235.025n

* CHECK dout1_28 Vdout1_28ck46 = 0 time = 235
.meas tran vdout1_28ck46 FIND v(dout1_28) AT=235.025n

* CHECK dout1_29 Vdout1_29ck46 = 0 time = 235
.meas tran vdout1_29ck46 FIND v(dout1_29) AT=235.025n

* CHECK dout1_30 Vdout1_30ck46 = 0.9 time = 235
.meas tran vdout1_30ck46 FIND v(dout1_30) AT=235.025n

* CHECK dout1_31 Vdout1_31ck46 = 0.9 time = 235
.meas tran vdout1_31ck46 FIND v(dout1_31) AT=235.025n

* CHECK dout1_32 Vdout1_32ck46 = 0.9 time = 235
.meas tran vdout1_32ck46 FIND v(dout1_32) AT=235.025n

* CHECK dout1_33 Vdout1_33ck46 = 0.9 time = 235
.meas tran vdout1_33ck46 FIND v(dout1_33) AT=235.025n

* CHECK dout1_34 Vdout1_34ck46 = 0.9 time = 235
.meas tran vdout1_34ck46 FIND v(dout1_34) AT=235.025n

* CHECK dout1_35 Vdout1_35ck46 = 0.9 time = 235
.meas tran vdout1_35ck46 FIND v(dout1_35) AT=235.025n

* CHECK dout1_36 Vdout1_36ck46 = 0.9 time = 235
.meas tran vdout1_36ck46 FIND v(dout1_36) AT=235.025n

* CHECK dout1_37 Vdout1_37ck46 = 0.9 time = 235
.meas tran vdout1_37ck46 FIND v(dout1_37) AT=235.025n

* CHECK dout1_38 Vdout1_38ck46 = 0.9 time = 235
.meas tran vdout1_38ck46 FIND v(dout1_38) AT=235.025n

* CHECK dout1_39 Vdout1_39ck46 = 0 time = 235
.meas tran vdout1_39ck46 FIND v(dout1_39) AT=235.025n

* CHECK dout1_40 Vdout1_40ck46 = 0 time = 235
.meas tran vdout1_40ck46 FIND v(dout1_40) AT=235.025n

* CHECK dout1_41 Vdout1_41ck46 = 0 time = 235
.meas tran vdout1_41ck46 FIND v(dout1_41) AT=235.025n

* CHECK dout1_42 Vdout1_42ck46 = 0.9 time = 235
.meas tran vdout1_42ck46 FIND v(dout1_42) AT=235.025n

* CHECK dout1_43 Vdout1_43ck46 = 0.9 time = 235
.meas tran vdout1_43ck46 FIND v(dout1_43) AT=235.025n

* CHECK dout1_44 Vdout1_44ck46 = 0.9 time = 235
.meas tran vdout1_44ck46 FIND v(dout1_44) AT=235.025n

* CHECK dout1_45 Vdout1_45ck46 = 0.9 time = 235
.meas tran vdout1_45ck46 FIND v(dout1_45) AT=235.025n

* CHECK dout1_46 Vdout1_46ck46 = 0 time = 235
.meas tran vdout1_46ck46 FIND v(dout1_46) AT=235.025n

* CHECK dout1_47 Vdout1_47ck46 = 0 time = 235
.meas tran vdout1_47ck46 FIND v(dout1_47) AT=235.025n

* CHECK dout1_48 Vdout1_48ck46 = 0 time = 235
.meas tran vdout1_48ck46 FIND v(dout1_48) AT=235.025n

* CHECK dout1_49 Vdout1_49ck46 = 0.9 time = 235
.meas tran vdout1_49ck46 FIND v(dout1_49) AT=235.025n

* CHECK dout1_50 Vdout1_50ck46 = 0.9 time = 235
.meas tran vdout1_50ck46 FIND v(dout1_50) AT=235.025n

* CHECK dout1_51 Vdout1_51ck46 = 0 time = 235
.meas tran vdout1_51ck46 FIND v(dout1_51) AT=235.025n

* CHECK dout1_52 Vdout1_52ck46 = 0 time = 235
.meas tran vdout1_52ck46 FIND v(dout1_52) AT=235.025n

* CHECK dout1_53 Vdout1_53ck46 = 0 time = 235
.meas tran vdout1_53ck46 FIND v(dout1_53) AT=235.025n

* CHECK dout1_54 Vdout1_54ck46 = 0 time = 235
.meas tran vdout1_54ck46 FIND v(dout1_54) AT=235.025n

* CHECK dout1_55 Vdout1_55ck46 = 0 time = 235
.meas tran vdout1_55ck46 FIND v(dout1_55) AT=235.025n

* CHECK dout1_0 Vdout1_0ck47 = 0 time = 240
.meas tran vdout1_0ck47 FIND v(dout1_0) AT=240.025n

* CHECK dout1_1 Vdout1_1ck47 = 0 time = 240
.meas tran vdout1_1ck47 FIND v(dout1_1) AT=240.025n

* CHECK dout1_2 Vdout1_2ck47 = 0.9 time = 240
.meas tran vdout1_2ck47 FIND v(dout1_2) AT=240.025n

* CHECK dout1_3 Vdout1_3ck47 = 0.9 time = 240
.meas tran vdout1_3ck47 FIND v(dout1_3) AT=240.025n

* CHECK dout1_4 Vdout1_4ck47 = 0 time = 240
.meas tran vdout1_4ck47 FIND v(dout1_4) AT=240.025n

* CHECK dout1_5 Vdout1_5ck47 = 0 time = 240
.meas tran vdout1_5ck47 FIND v(dout1_5) AT=240.025n

* CHECK dout1_6 Vdout1_6ck47 = 0.9 time = 240
.meas tran vdout1_6ck47 FIND v(dout1_6) AT=240.025n

* CHECK dout1_7 Vdout1_7ck47 = 0.9 time = 240
.meas tran vdout1_7ck47 FIND v(dout1_7) AT=240.025n

* CHECK dout1_8 Vdout1_8ck47 = 0.9 time = 240
.meas tran vdout1_8ck47 FIND v(dout1_8) AT=240.025n

* CHECK dout1_9 Vdout1_9ck47 = 0 time = 240
.meas tran vdout1_9ck47 FIND v(dout1_9) AT=240.025n

* CHECK dout1_10 Vdout1_10ck47 = 0.9 time = 240
.meas tran vdout1_10ck47 FIND v(dout1_10) AT=240.025n

* CHECK dout1_11 Vdout1_11ck47 = 0.9 time = 240
.meas tran vdout1_11ck47 FIND v(dout1_11) AT=240.025n

* CHECK dout1_12 Vdout1_12ck47 = 0 time = 240
.meas tran vdout1_12ck47 FIND v(dout1_12) AT=240.025n

* CHECK dout1_13 Vdout1_13ck47 = 0.9 time = 240
.meas tran vdout1_13ck47 FIND v(dout1_13) AT=240.025n

* CHECK dout1_14 Vdout1_14ck47 = 0 time = 240
.meas tran vdout1_14ck47 FIND v(dout1_14) AT=240.025n

* CHECK dout1_15 Vdout1_15ck47 = 0 time = 240
.meas tran vdout1_15ck47 FIND v(dout1_15) AT=240.025n

* CHECK dout1_16 Vdout1_16ck47 = 0 time = 240
.meas tran vdout1_16ck47 FIND v(dout1_16) AT=240.025n

* CHECK dout1_17 Vdout1_17ck47 = 0 time = 240
.meas tran vdout1_17ck47 FIND v(dout1_17) AT=240.025n

* CHECK dout1_18 Vdout1_18ck47 = 0 time = 240
.meas tran vdout1_18ck47 FIND v(dout1_18) AT=240.025n

* CHECK dout1_19 Vdout1_19ck47 = 0.9 time = 240
.meas tran vdout1_19ck47 FIND v(dout1_19) AT=240.025n

* CHECK dout1_20 Vdout1_20ck47 = 0 time = 240
.meas tran vdout1_20ck47 FIND v(dout1_20) AT=240.025n

* CHECK dout1_21 Vdout1_21ck47 = 0.9 time = 240
.meas tran vdout1_21ck47 FIND v(dout1_21) AT=240.025n

* CHECK dout1_22 Vdout1_22ck47 = 0 time = 240
.meas tran vdout1_22ck47 FIND v(dout1_22) AT=240.025n

* CHECK dout1_23 Vdout1_23ck47 = 0.9 time = 240
.meas tran vdout1_23ck47 FIND v(dout1_23) AT=240.025n

* CHECK dout1_24 Vdout1_24ck47 = 0 time = 240
.meas tran vdout1_24ck47 FIND v(dout1_24) AT=240.025n

* CHECK dout1_25 Vdout1_25ck47 = 0.9 time = 240
.meas tran vdout1_25ck47 FIND v(dout1_25) AT=240.025n

* CHECK dout1_26 Vdout1_26ck47 = 0 time = 240
.meas tran vdout1_26ck47 FIND v(dout1_26) AT=240.025n

* CHECK dout1_27 Vdout1_27ck47 = 0 time = 240
.meas tran vdout1_27ck47 FIND v(dout1_27) AT=240.025n

* CHECK dout1_28 Vdout1_28ck47 = 0 time = 240
.meas tran vdout1_28ck47 FIND v(dout1_28) AT=240.025n

* CHECK dout1_29 Vdout1_29ck47 = 0.9 time = 240
.meas tran vdout1_29ck47 FIND v(dout1_29) AT=240.025n

* CHECK dout1_30 Vdout1_30ck47 = 0 time = 240
.meas tran vdout1_30ck47 FIND v(dout1_30) AT=240.025n

* CHECK dout1_31 Vdout1_31ck47 = 0.9 time = 240
.meas tran vdout1_31ck47 FIND v(dout1_31) AT=240.025n

* CHECK dout1_32 Vdout1_32ck47 = 0 time = 240
.meas tran vdout1_32ck47 FIND v(dout1_32) AT=240.025n

* CHECK dout1_33 Vdout1_33ck47 = 0 time = 240
.meas tran vdout1_33ck47 FIND v(dout1_33) AT=240.025n

* CHECK dout1_34 Vdout1_34ck47 = 0.9 time = 240
.meas tran vdout1_34ck47 FIND v(dout1_34) AT=240.025n

* CHECK dout1_35 Vdout1_35ck47 = 0.9 time = 240
.meas tran vdout1_35ck47 FIND v(dout1_35) AT=240.025n

* CHECK dout1_36 Vdout1_36ck47 = 0.9 time = 240
.meas tran vdout1_36ck47 FIND v(dout1_36) AT=240.025n

* CHECK dout1_37 Vdout1_37ck47 = 0 time = 240
.meas tran vdout1_37ck47 FIND v(dout1_37) AT=240.025n

* CHECK dout1_38 Vdout1_38ck47 = 0.9 time = 240
.meas tran vdout1_38ck47 FIND v(dout1_38) AT=240.025n

* CHECK dout1_39 Vdout1_39ck47 = 0 time = 240
.meas tran vdout1_39ck47 FIND v(dout1_39) AT=240.025n

* CHECK dout1_40 Vdout1_40ck47 = 0 time = 240
.meas tran vdout1_40ck47 FIND v(dout1_40) AT=240.025n

* CHECK dout1_41 Vdout1_41ck47 = 0.9 time = 240
.meas tran vdout1_41ck47 FIND v(dout1_41) AT=240.025n

* CHECK dout1_42 Vdout1_42ck47 = 0.9 time = 240
.meas tran vdout1_42ck47 FIND v(dout1_42) AT=240.025n

* CHECK dout1_43 Vdout1_43ck47 = 0.9 time = 240
.meas tran vdout1_43ck47 FIND v(dout1_43) AT=240.025n

* CHECK dout1_44 Vdout1_44ck47 = 0.9 time = 240
.meas tran vdout1_44ck47 FIND v(dout1_44) AT=240.025n

* CHECK dout1_45 Vdout1_45ck47 = 0 time = 240
.meas tran vdout1_45ck47 FIND v(dout1_45) AT=240.025n

* CHECK dout1_46 Vdout1_46ck47 = 0 time = 240
.meas tran vdout1_46ck47 FIND v(dout1_46) AT=240.025n

* CHECK dout1_47 Vdout1_47ck47 = 0 time = 240
.meas tran vdout1_47ck47 FIND v(dout1_47) AT=240.025n

* CHECK dout1_48 Vdout1_48ck47 = 0.9 time = 240
.meas tran vdout1_48ck47 FIND v(dout1_48) AT=240.025n

* CHECK dout1_49 Vdout1_49ck47 = 0.9 time = 240
.meas tran vdout1_49ck47 FIND v(dout1_49) AT=240.025n

* CHECK dout1_50 Vdout1_50ck47 = 0.9 time = 240
.meas tran vdout1_50ck47 FIND v(dout1_50) AT=240.025n

* CHECK dout1_51 Vdout1_51ck47 = 0 time = 240
.meas tran vdout1_51ck47 FIND v(dout1_51) AT=240.025n

* CHECK dout1_52 Vdout1_52ck47 = 0.9 time = 240
.meas tran vdout1_52ck47 FIND v(dout1_52) AT=240.025n

* CHECK dout1_53 Vdout1_53ck47 = 0 time = 240
.meas tran vdout1_53ck47 FIND v(dout1_53) AT=240.025n

* CHECK dout1_54 Vdout1_54ck47 = 0.9 time = 240
.meas tran vdout1_54ck47 FIND v(dout1_54) AT=240.025n

* CHECK dout1_55 Vdout1_55ck47 = 0 time = 240
.meas tran vdout1_55ck47 FIND v(dout1_55) AT=240.025n

* CHECK dout1_0 Vdout1_0ck48 = 0.9 time = 245
.meas tran vdout1_0ck48 FIND v(dout1_0) AT=245.025n

* CHECK dout1_1 Vdout1_1ck48 = 0 time = 245
.meas tran vdout1_1ck48 FIND v(dout1_1) AT=245.025n

* CHECK dout1_2 Vdout1_2ck48 = 0.9 time = 245
.meas tran vdout1_2ck48 FIND v(dout1_2) AT=245.025n

* CHECK dout1_3 Vdout1_3ck48 = 0.9 time = 245
.meas tran vdout1_3ck48 FIND v(dout1_3) AT=245.025n

* CHECK dout1_4 Vdout1_4ck48 = 0.9 time = 245
.meas tran vdout1_4ck48 FIND v(dout1_4) AT=245.025n

* CHECK dout1_5 Vdout1_5ck48 = 0.9 time = 245
.meas tran vdout1_5ck48 FIND v(dout1_5) AT=245.025n

* CHECK dout1_6 Vdout1_6ck48 = 0.9 time = 245
.meas tran vdout1_6ck48 FIND v(dout1_6) AT=245.025n

* CHECK dout1_7 Vdout1_7ck48 = 0 time = 245
.meas tran vdout1_7ck48 FIND v(dout1_7) AT=245.025n

* CHECK dout1_8 Vdout1_8ck48 = 0.9 time = 245
.meas tran vdout1_8ck48 FIND v(dout1_8) AT=245.025n

* CHECK dout1_9 Vdout1_9ck48 = 0 time = 245
.meas tran vdout1_9ck48 FIND v(dout1_9) AT=245.025n

* CHECK dout1_10 Vdout1_10ck48 = 0.9 time = 245
.meas tran vdout1_10ck48 FIND v(dout1_10) AT=245.025n

* CHECK dout1_11 Vdout1_11ck48 = 0.9 time = 245
.meas tran vdout1_11ck48 FIND v(dout1_11) AT=245.025n

* CHECK dout1_12 Vdout1_12ck48 = 0 time = 245
.meas tran vdout1_12ck48 FIND v(dout1_12) AT=245.025n

* CHECK dout1_13 Vdout1_13ck48 = 0.9 time = 245
.meas tran vdout1_13ck48 FIND v(dout1_13) AT=245.025n

* CHECK dout1_14 Vdout1_14ck48 = 0 time = 245
.meas tran vdout1_14ck48 FIND v(dout1_14) AT=245.025n

* CHECK dout1_15 Vdout1_15ck48 = 0 time = 245
.meas tran vdout1_15ck48 FIND v(dout1_15) AT=245.025n

* CHECK dout1_16 Vdout1_16ck48 = 0.9 time = 245
.meas tran vdout1_16ck48 FIND v(dout1_16) AT=245.025n

* CHECK dout1_17 Vdout1_17ck48 = 0.9 time = 245
.meas tran vdout1_17ck48 FIND v(dout1_17) AT=245.025n

* CHECK dout1_18 Vdout1_18ck48 = 0 time = 245
.meas tran vdout1_18ck48 FIND v(dout1_18) AT=245.025n

* CHECK dout1_19 Vdout1_19ck48 = 0.9 time = 245
.meas tran vdout1_19ck48 FIND v(dout1_19) AT=245.025n

* CHECK dout1_20 Vdout1_20ck48 = 0.9 time = 245
.meas tran vdout1_20ck48 FIND v(dout1_20) AT=245.025n

* CHECK dout1_21 Vdout1_21ck48 = 0.9 time = 245
.meas tran vdout1_21ck48 FIND v(dout1_21) AT=245.025n

* CHECK dout1_22 Vdout1_22ck48 = 0 time = 245
.meas tran vdout1_22ck48 FIND v(dout1_22) AT=245.025n

* CHECK dout1_23 Vdout1_23ck48 = 0 time = 245
.meas tran vdout1_23ck48 FIND v(dout1_23) AT=245.025n

* CHECK dout1_24 Vdout1_24ck48 = 0 time = 245
.meas tran vdout1_24ck48 FIND v(dout1_24) AT=245.025n

* CHECK dout1_25 Vdout1_25ck48 = 0.9 time = 245
.meas tran vdout1_25ck48 FIND v(dout1_25) AT=245.025n

* CHECK dout1_26 Vdout1_26ck48 = 0 time = 245
.meas tran vdout1_26ck48 FIND v(dout1_26) AT=245.025n

* CHECK dout1_27 Vdout1_27ck48 = 0 time = 245
.meas tran vdout1_27ck48 FIND v(dout1_27) AT=245.025n

* CHECK dout1_28 Vdout1_28ck48 = 0 time = 245
.meas tran vdout1_28ck48 FIND v(dout1_28) AT=245.025n

* CHECK dout1_29 Vdout1_29ck48 = 0 time = 245
.meas tran vdout1_29ck48 FIND v(dout1_29) AT=245.025n

* CHECK dout1_30 Vdout1_30ck48 = 0.9 time = 245
.meas tran vdout1_30ck48 FIND v(dout1_30) AT=245.025n

* CHECK dout1_31 Vdout1_31ck48 = 0.9 time = 245
.meas tran vdout1_31ck48 FIND v(dout1_31) AT=245.025n

* CHECK dout1_32 Vdout1_32ck48 = 0.9 time = 245
.meas tran vdout1_32ck48 FIND v(dout1_32) AT=245.025n

* CHECK dout1_33 Vdout1_33ck48 = 0.9 time = 245
.meas tran vdout1_33ck48 FIND v(dout1_33) AT=245.025n

* CHECK dout1_34 Vdout1_34ck48 = 0.9 time = 245
.meas tran vdout1_34ck48 FIND v(dout1_34) AT=245.025n

* CHECK dout1_35 Vdout1_35ck48 = 0.9 time = 245
.meas tran vdout1_35ck48 FIND v(dout1_35) AT=245.025n

* CHECK dout1_36 Vdout1_36ck48 = 0.9 time = 245
.meas tran vdout1_36ck48 FIND v(dout1_36) AT=245.025n

* CHECK dout1_37 Vdout1_37ck48 = 0.9 time = 245
.meas tran vdout1_37ck48 FIND v(dout1_37) AT=245.025n

* CHECK dout1_38 Vdout1_38ck48 = 0.9 time = 245
.meas tran vdout1_38ck48 FIND v(dout1_38) AT=245.025n

* CHECK dout1_39 Vdout1_39ck48 = 0 time = 245
.meas tran vdout1_39ck48 FIND v(dout1_39) AT=245.025n

* CHECK dout1_40 Vdout1_40ck48 = 0 time = 245
.meas tran vdout1_40ck48 FIND v(dout1_40) AT=245.025n

* CHECK dout1_41 Vdout1_41ck48 = 0 time = 245
.meas tran vdout1_41ck48 FIND v(dout1_41) AT=245.025n

* CHECK dout1_42 Vdout1_42ck48 = 0.9 time = 245
.meas tran vdout1_42ck48 FIND v(dout1_42) AT=245.025n

* CHECK dout1_43 Vdout1_43ck48 = 0.9 time = 245
.meas tran vdout1_43ck48 FIND v(dout1_43) AT=245.025n

* CHECK dout1_44 Vdout1_44ck48 = 0.9 time = 245
.meas tran vdout1_44ck48 FIND v(dout1_44) AT=245.025n

* CHECK dout1_45 Vdout1_45ck48 = 0.9 time = 245
.meas tran vdout1_45ck48 FIND v(dout1_45) AT=245.025n

* CHECK dout1_46 Vdout1_46ck48 = 0 time = 245
.meas tran vdout1_46ck48 FIND v(dout1_46) AT=245.025n

* CHECK dout1_47 Vdout1_47ck48 = 0 time = 245
.meas tran vdout1_47ck48 FIND v(dout1_47) AT=245.025n

* CHECK dout1_48 Vdout1_48ck48 = 0 time = 245
.meas tran vdout1_48ck48 FIND v(dout1_48) AT=245.025n

* CHECK dout1_49 Vdout1_49ck48 = 0.9 time = 245
.meas tran vdout1_49ck48 FIND v(dout1_49) AT=245.025n

* CHECK dout1_50 Vdout1_50ck48 = 0.9 time = 245
.meas tran vdout1_50ck48 FIND v(dout1_50) AT=245.025n

* CHECK dout1_51 Vdout1_51ck48 = 0 time = 245
.meas tran vdout1_51ck48 FIND v(dout1_51) AT=245.025n

* CHECK dout1_52 Vdout1_52ck48 = 0 time = 245
.meas tran vdout1_52ck48 FIND v(dout1_52) AT=245.025n

* CHECK dout1_53 Vdout1_53ck48 = 0 time = 245
.meas tran vdout1_53ck48 FIND v(dout1_53) AT=245.025n

* CHECK dout1_54 Vdout1_54ck48 = 0 time = 245
.meas tran vdout1_54ck48 FIND v(dout1_54) AT=245.025n

* CHECK dout1_55 Vdout1_55ck48 = 0 time = 245
.meas tran vdout1_55ck48 FIND v(dout1_55) AT=245.025n

* CHECK dout1_0 Vdout1_0ck50 = 0 time = 255
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=255.025n

* CHECK dout1_1 Vdout1_1ck50 = 0 time = 255
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=255.025n

* CHECK dout1_2 Vdout1_2ck50 = 0.9 time = 255
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=255.025n

* CHECK dout1_3 Vdout1_3ck50 = 0.9 time = 255
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=255.025n

* CHECK dout1_4 Vdout1_4ck50 = 0 time = 255
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=255.025n

* CHECK dout1_5 Vdout1_5ck50 = 0 time = 255
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=255.025n

* CHECK dout1_6 Vdout1_6ck50 = 0.9 time = 255
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=255.025n

* CHECK dout1_7 Vdout1_7ck50 = 0.9 time = 255
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=255.025n

* CHECK dout1_8 Vdout1_8ck50 = 0.9 time = 255
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=255.025n

* CHECK dout1_9 Vdout1_9ck50 = 0 time = 255
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=255.025n

* CHECK dout1_10 Vdout1_10ck50 = 0.9 time = 255
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=255.025n

* CHECK dout1_11 Vdout1_11ck50 = 0.9 time = 255
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=255.025n

* CHECK dout1_12 Vdout1_12ck50 = 0 time = 255
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=255.025n

* CHECK dout1_13 Vdout1_13ck50 = 0.9 time = 255
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=255.025n

* CHECK dout1_14 Vdout1_14ck50 = 0 time = 255
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=255.025n

* CHECK dout1_15 Vdout1_15ck50 = 0 time = 255
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=255.025n

* CHECK dout1_16 Vdout1_16ck50 = 0 time = 255
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=255.025n

* CHECK dout1_17 Vdout1_17ck50 = 0 time = 255
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=255.025n

* CHECK dout1_18 Vdout1_18ck50 = 0 time = 255
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=255.025n

* CHECK dout1_19 Vdout1_19ck50 = 0.9 time = 255
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=255.025n

* CHECK dout1_20 Vdout1_20ck50 = 0 time = 255
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=255.025n

* CHECK dout1_21 Vdout1_21ck50 = 0.9 time = 255
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=255.025n

* CHECK dout1_22 Vdout1_22ck50 = 0 time = 255
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=255.025n

* CHECK dout1_23 Vdout1_23ck50 = 0.9 time = 255
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=255.025n

* CHECK dout1_24 Vdout1_24ck50 = 0 time = 255
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=255.025n

* CHECK dout1_25 Vdout1_25ck50 = 0.9 time = 255
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=255.025n

* CHECK dout1_26 Vdout1_26ck50 = 0 time = 255
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=255.025n

* CHECK dout1_27 Vdout1_27ck50 = 0 time = 255
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=255.025n

* CHECK dout1_28 Vdout1_28ck50 = 0 time = 255
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=255.025n

* CHECK dout1_29 Vdout1_29ck50 = 0.9 time = 255
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=255.025n

* CHECK dout1_30 Vdout1_30ck50 = 0 time = 255
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=255.025n

* CHECK dout1_31 Vdout1_31ck50 = 0.9 time = 255
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=255.025n

* CHECK dout1_32 Vdout1_32ck50 = 0 time = 255
.meas tran vdout1_32ck50 FIND v(dout1_32) AT=255.025n

* CHECK dout1_33 Vdout1_33ck50 = 0 time = 255
.meas tran vdout1_33ck50 FIND v(dout1_33) AT=255.025n

* CHECK dout1_34 Vdout1_34ck50 = 0.9 time = 255
.meas tran vdout1_34ck50 FIND v(dout1_34) AT=255.025n

* CHECK dout1_35 Vdout1_35ck50 = 0.9 time = 255
.meas tran vdout1_35ck50 FIND v(dout1_35) AT=255.025n

* CHECK dout1_36 Vdout1_36ck50 = 0.9 time = 255
.meas tran vdout1_36ck50 FIND v(dout1_36) AT=255.025n

* CHECK dout1_37 Vdout1_37ck50 = 0 time = 255
.meas tran vdout1_37ck50 FIND v(dout1_37) AT=255.025n

* CHECK dout1_38 Vdout1_38ck50 = 0.9 time = 255
.meas tran vdout1_38ck50 FIND v(dout1_38) AT=255.025n

* CHECK dout1_39 Vdout1_39ck50 = 0 time = 255
.meas tran vdout1_39ck50 FIND v(dout1_39) AT=255.025n

* CHECK dout1_40 Vdout1_40ck50 = 0 time = 255
.meas tran vdout1_40ck50 FIND v(dout1_40) AT=255.025n

* CHECK dout1_41 Vdout1_41ck50 = 0.9 time = 255
.meas tran vdout1_41ck50 FIND v(dout1_41) AT=255.025n

* CHECK dout1_42 Vdout1_42ck50 = 0.9 time = 255
.meas tran vdout1_42ck50 FIND v(dout1_42) AT=255.025n

* CHECK dout1_43 Vdout1_43ck50 = 0.9 time = 255
.meas tran vdout1_43ck50 FIND v(dout1_43) AT=255.025n

* CHECK dout1_44 Vdout1_44ck50 = 0.9 time = 255
.meas tran vdout1_44ck50 FIND v(dout1_44) AT=255.025n

* CHECK dout1_45 Vdout1_45ck50 = 0 time = 255
.meas tran vdout1_45ck50 FIND v(dout1_45) AT=255.025n

* CHECK dout1_46 Vdout1_46ck50 = 0 time = 255
.meas tran vdout1_46ck50 FIND v(dout1_46) AT=255.025n

* CHECK dout1_47 Vdout1_47ck50 = 0 time = 255
.meas tran vdout1_47ck50 FIND v(dout1_47) AT=255.025n

* CHECK dout1_48 Vdout1_48ck50 = 0.9 time = 255
.meas tran vdout1_48ck50 FIND v(dout1_48) AT=255.025n

* CHECK dout1_49 Vdout1_49ck50 = 0.9 time = 255
.meas tran vdout1_49ck50 FIND v(dout1_49) AT=255.025n

* CHECK dout1_50 Vdout1_50ck50 = 0.9 time = 255
.meas tran vdout1_50ck50 FIND v(dout1_50) AT=255.025n

* CHECK dout1_51 Vdout1_51ck50 = 0 time = 255
.meas tran vdout1_51ck50 FIND v(dout1_51) AT=255.025n

* CHECK dout1_52 Vdout1_52ck50 = 0.9 time = 255
.meas tran vdout1_52ck50 FIND v(dout1_52) AT=255.025n

* CHECK dout1_53 Vdout1_53ck50 = 0 time = 255
.meas tran vdout1_53ck50 FIND v(dout1_53) AT=255.025n

* CHECK dout1_54 Vdout1_54ck50 = 0.9 time = 255
.meas tran vdout1_54ck50 FIND v(dout1_54) AT=255.025n

* CHECK dout1_55 Vdout1_55ck50 = 0 time = 255
.meas tran vdout1_55ck50 FIND v(dout1_55) AT=255.025n

* CHECK dout1_0 Vdout1_0ck52 = 0 time = 265
.meas tran vdout1_0ck52 FIND v(dout1_0) AT=265.025n

* CHECK dout1_1 Vdout1_1ck52 = 0 time = 265
.meas tran vdout1_1ck52 FIND v(dout1_1) AT=265.025n

* CHECK dout1_2 Vdout1_2ck52 = 0.9 time = 265
.meas tran vdout1_2ck52 FIND v(dout1_2) AT=265.025n

* CHECK dout1_3 Vdout1_3ck52 = 0.9 time = 265
.meas tran vdout1_3ck52 FIND v(dout1_3) AT=265.025n

* CHECK dout1_4 Vdout1_4ck52 = 0.9 time = 265
.meas tran vdout1_4ck52 FIND v(dout1_4) AT=265.025n

* CHECK dout1_5 Vdout1_5ck52 = 0 time = 265
.meas tran vdout1_5ck52 FIND v(dout1_5) AT=265.025n

* CHECK dout1_6 Vdout1_6ck52 = 0 time = 265
.meas tran vdout1_6ck52 FIND v(dout1_6) AT=265.025n

* CHECK dout1_7 Vdout1_7ck52 = 0 time = 265
.meas tran vdout1_7ck52 FIND v(dout1_7) AT=265.025n

* CHECK dout1_8 Vdout1_8ck52 = 0.9 time = 265
.meas tran vdout1_8ck52 FIND v(dout1_8) AT=265.025n

* CHECK dout1_9 Vdout1_9ck52 = 0.9 time = 265
.meas tran vdout1_9ck52 FIND v(dout1_9) AT=265.025n

* CHECK dout1_10 Vdout1_10ck52 = 0.9 time = 265
.meas tran vdout1_10ck52 FIND v(dout1_10) AT=265.025n

* CHECK dout1_11 Vdout1_11ck52 = 0 time = 265
.meas tran vdout1_11ck52 FIND v(dout1_11) AT=265.025n

* CHECK dout1_12 Vdout1_12ck52 = 0 time = 265
.meas tran vdout1_12ck52 FIND v(dout1_12) AT=265.025n

* CHECK dout1_13 Vdout1_13ck52 = 0 time = 265
.meas tran vdout1_13ck52 FIND v(dout1_13) AT=265.025n

* CHECK dout1_14 Vdout1_14ck52 = 0 time = 265
.meas tran vdout1_14ck52 FIND v(dout1_14) AT=265.025n

* CHECK dout1_15 Vdout1_15ck52 = 0 time = 265
.meas tran vdout1_15ck52 FIND v(dout1_15) AT=265.025n

* CHECK dout1_16 Vdout1_16ck52 = 0.9 time = 265
.meas tran vdout1_16ck52 FIND v(dout1_16) AT=265.025n

* CHECK dout1_17 Vdout1_17ck52 = 0.9 time = 265
.meas tran vdout1_17ck52 FIND v(dout1_17) AT=265.025n

* CHECK dout1_18 Vdout1_18ck52 = 0.9 time = 265
.meas tran vdout1_18ck52 FIND v(dout1_18) AT=265.025n

* CHECK dout1_19 Vdout1_19ck52 = 0.9 time = 265
.meas tran vdout1_19ck52 FIND v(dout1_19) AT=265.025n

* CHECK dout1_20 Vdout1_20ck52 = 0 time = 265
.meas tran vdout1_20ck52 FIND v(dout1_20) AT=265.025n

* CHECK dout1_21 Vdout1_21ck52 = 0 time = 265
.meas tran vdout1_21ck52 FIND v(dout1_21) AT=265.025n

* CHECK dout1_22 Vdout1_22ck52 = 0.9 time = 265
.meas tran vdout1_22ck52 FIND v(dout1_22) AT=265.025n

* CHECK dout1_23 Vdout1_23ck52 = 0.9 time = 265
.meas tran vdout1_23ck52 FIND v(dout1_23) AT=265.025n

* CHECK dout1_24 Vdout1_24ck52 = 0.9 time = 265
.meas tran vdout1_24ck52 FIND v(dout1_24) AT=265.025n

* CHECK dout1_25 Vdout1_25ck52 = 0.9 time = 265
.meas tran vdout1_25ck52 FIND v(dout1_25) AT=265.025n

* CHECK dout1_26 Vdout1_26ck52 = 0.9 time = 265
.meas tran vdout1_26ck52 FIND v(dout1_26) AT=265.025n

* CHECK dout1_27 Vdout1_27ck52 = 0.9 time = 265
.meas tran vdout1_27ck52 FIND v(dout1_27) AT=265.025n

* CHECK dout1_28 Vdout1_28ck52 = 0.9 time = 265
.meas tran vdout1_28ck52 FIND v(dout1_28) AT=265.025n

* CHECK dout1_29 Vdout1_29ck52 = 0.9 time = 265
.meas tran vdout1_29ck52 FIND v(dout1_29) AT=265.025n

* CHECK dout1_30 Vdout1_30ck52 = 0 time = 265
.meas tran vdout1_30ck52 FIND v(dout1_30) AT=265.025n

* CHECK dout1_31 Vdout1_31ck52 = 0.9 time = 265
.meas tran vdout1_31ck52 FIND v(dout1_31) AT=265.025n

* CHECK dout1_32 Vdout1_32ck52 = 0.9 time = 265
.meas tran vdout1_32ck52 FIND v(dout1_32) AT=265.025n

* CHECK dout1_33 Vdout1_33ck52 = 0.9 time = 265
.meas tran vdout1_33ck52 FIND v(dout1_33) AT=265.025n

* CHECK dout1_34 Vdout1_34ck52 = 0 time = 265
.meas tran vdout1_34ck52 FIND v(dout1_34) AT=265.025n

* CHECK dout1_35 Vdout1_35ck52 = 0 time = 265
.meas tran vdout1_35ck52 FIND v(dout1_35) AT=265.025n

* CHECK dout1_36 Vdout1_36ck52 = 0.9 time = 265
.meas tran vdout1_36ck52 FIND v(dout1_36) AT=265.025n

* CHECK dout1_37 Vdout1_37ck52 = 0.9 time = 265
.meas tran vdout1_37ck52 FIND v(dout1_37) AT=265.025n

* CHECK dout1_38 Vdout1_38ck52 = 0.9 time = 265
.meas tran vdout1_38ck52 FIND v(dout1_38) AT=265.025n

* CHECK dout1_39 Vdout1_39ck52 = 0.9 time = 265
.meas tran vdout1_39ck52 FIND v(dout1_39) AT=265.025n

* CHECK dout1_40 Vdout1_40ck52 = 0 time = 265
.meas tran vdout1_40ck52 FIND v(dout1_40) AT=265.025n

* CHECK dout1_41 Vdout1_41ck52 = 0 time = 265
.meas tran vdout1_41ck52 FIND v(dout1_41) AT=265.025n

* CHECK dout1_42 Vdout1_42ck52 = 0 time = 265
.meas tran vdout1_42ck52 FIND v(dout1_42) AT=265.025n

* CHECK dout1_43 Vdout1_43ck52 = 0 time = 265
.meas tran vdout1_43ck52 FIND v(dout1_43) AT=265.025n

* CHECK dout1_44 Vdout1_44ck52 = 0 time = 265
.meas tran vdout1_44ck52 FIND v(dout1_44) AT=265.025n

* CHECK dout1_45 Vdout1_45ck52 = 0 time = 265
.meas tran vdout1_45ck52 FIND v(dout1_45) AT=265.025n

* CHECK dout1_46 Vdout1_46ck52 = 0.9 time = 265
.meas tran vdout1_46ck52 FIND v(dout1_46) AT=265.025n

* CHECK dout1_47 Vdout1_47ck52 = 0.9 time = 265
.meas tran vdout1_47ck52 FIND v(dout1_47) AT=265.025n

* CHECK dout1_48 Vdout1_48ck52 = 0.9 time = 265
.meas tran vdout1_48ck52 FIND v(dout1_48) AT=265.025n

* CHECK dout1_49 Vdout1_49ck52 = 0 time = 265
.meas tran vdout1_49ck52 FIND v(dout1_49) AT=265.025n

* CHECK dout1_50 Vdout1_50ck52 = 0.9 time = 265
.meas tran vdout1_50ck52 FIND v(dout1_50) AT=265.025n

* CHECK dout1_51 Vdout1_51ck52 = 0.9 time = 265
.meas tran vdout1_51ck52 FIND v(dout1_51) AT=265.025n

* CHECK dout1_52 Vdout1_52ck52 = 0 time = 265
.meas tran vdout1_52ck52 FIND v(dout1_52) AT=265.025n

* CHECK dout1_53 Vdout1_53ck52 = 0 time = 265
.meas tran vdout1_53ck52 FIND v(dout1_53) AT=265.025n

* CHECK dout1_54 Vdout1_54ck52 = 0 time = 265
.meas tran vdout1_54ck52 FIND v(dout1_54) AT=265.025n

* CHECK dout1_55 Vdout1_55ck52 = 0 time = 265
.meas tran vdout1_55ck52 FIND v(dout1_55) AT=265.025n

* CHECK dout1_0 Vdout1_0ck54 = 0.9 time = 275
.meas tran vdout1_0ck54 FIND v(dout1_0) AT=275.025n

* CHECK dout1_1 Vdout1_1ck54 = 0 time = 275
.meas tran vdout1_1ck54 FIND v(dout1_1) AT=275.025n

* CHECK dout1_2 Vdout1_2ck54 = 0.9 time = 275
.meas tran vdout1_2ck54 FIND v(dout1_2) AT=275.025n

* CHECK dout1_3 Vdout1_3ck54 = 0 time = 275
.meas tran vdout1_3ck54 FIND v(dout1_3) AT=275.025n

* CHECK dout1_4 Vdout1_4ck54 = 0.9 time = 275
.meas tran vdout1_4ck54 FIND v(dout1_4) AT=275.025n

* CHECK dout1_5 Vdout1_5ck54 = 0 time = 275
.meas tran vdout1_5ck54 FIND v(dout1_5) AT=275.025n

* CHECK dout1_6 Vdout1_6ck54 = 0.9 time = 275
.meas tran vdout1_6ck54 FIND v(dout1_6) AT=275.025n

* CHECK dout1_7 Vdout1_7ck54 = 0.9 time = 275
.meas tran vdout1_7ck54 FIND v(dout1_7) AT=275.025n

* CHECK dout1_8 Vdout1_8ck54 = 0.9 time = 275
.meas tran vdout1_8ck54 FIND v(dout1_8) AT=275.025n

* CHECK dout1_9 Vdout1_9ck54 = 0.9 time = 275
.meas tran vdout1_9ck54 FIND v(dout1_9) AT=275.025n

* CHECK dout1_10 Vdout1_10ck54 = 0.9 time = 275
.meas tran vdout1_10ck54 FIND v(dout1_10) AT=275.025n

* CHECK dout1_11 Vdout1_11ck54 = 0.9 time = 275
.meas tran vdout1_11ck54 FIND v(dout1_11) AT=275.025n

* CHECK dout1_12 Vdout1_12ck54 = 0 time = 275
.meas tran vdout1_12ck54 FIND v(dout1_12) AT=275.025n

* CHECK dout1_13 Vdout1_13ck54 = 0.9 time = 275
.meas tran vdout1_13ck54 FIND v(dout1_13) AT=275.025n

* CHECK dout1_14 Vdout1_14ck54 = 0.9 time = 275
.meas tran vdout1_14ck54 FIND v(dout1_14) AT=275.025n

* CHECK dout1_15 Vdout1_15ck54 = 0.9 time = 275
.meas tran vdout1_15ck54 FIND v(dout1_15) AT=275.025n

* CHECK dout1_16 Vdout1_16ck54 = 0.9 time = 275
.meas tran vdout1_16ck54 FIND v(dout1_16) AT=275.025n

* CHECK dout1_17 Vdout1_17ck54 = 0 time = 275
.meas tran vdout1_17ck54 FIND v(dout1_17) AT=275.025n

* CHECK dout1_18 Vdout1_18ck54 = 0.9 time = 275
.meas tran vdout1_18ck54 FIND v(dout1_18) AT=275.025n

* CHECK dout1_19 Vdout1_19ck54 = 0 time = 275
.meas tran vdout1_19ck54 FIND v(dout1_19) AT=275.025n

* CHECK dout1_20 Vdout1_20ck54 = 0 time = 275
.meas tran vdout1_20ck54 FIND v(dout1_20) AT=275.025n

* CHECK dout1_21 Vdout1_21ck54 = 0 time = 275
.meas tran vdout1_21ck54 FIND v(dout1_21) AT=275.025n

* CHECK dout1_22 Vdout1_22ck54 = 0.9 time = 275
.meas tran vdout1_22ck54 FIND v(dout1_22) AT=275.025n

* CHECK dout1_23 Vdout1_23ck54 = 0.9 time = 275
.meas tran vdout1_23ck54 FIND v(dout1_23) AT=275.025n

* CHECK dout1_24 Vdout1_24ck54 = 0.9 time = 275
.meas tran vdout1_24ck54 FIND v(dout1_24) AT=275.025n

* CHECK dout1_25 Vdout1_25ck54 = 0.9 time = 275
.meas tran vdout1_25ck54 FIND v(dout1_25) AT=275.025n

* CHECK dout1_26 Vdout1_26ck54 = 0.9 time = 275
.meas tran vdout1_26ck54 FIND v(dout1_26) AT=275.025n

* CHECK dout1_27 Vdout1_27ck54 = 0 time = 275
.meas tran vdout1_27ck54 FIND v(dout1_27) AT=275.025n

* CHECK dout1_28 Vdout1_28ck54 = 0.9 time = 275
.meas tran vdout1_28ck54 FIND v(dout1_28) AT=275.025n

* CHECK dout1_29 Vdout1_29ck54 = 0.9 time = 275
.meas tran vdout1_29ck54 FIND v(dout1_29) AT=275.025n

* CHECK dout1_30 Vdout1_30ck54 = 0 time = 275
.meas tran vdout1_30ck54 FIND v(dout1_30) AT=275.025n

* CHECK dout1_31 Vdout1_31ck54 = 0 time = 275
.meas tran vdout1_31ck54 FIND v(dout1_31) AT=275.025n

* CHECK dout1_32 Vdout1_32ck54 = 0 time = 275
.meas tran vdout1_32ck54 FIND v(dout1_32) AT=275.025n

* CHECK dout1_33 Vdout1_33ck54 = 0.9 time = 275
.meas tran vdout1_33ck54 FIND v(dout1_33) AT=275.025n

* CHECK dout1_34 Vdout1_34ck54 = 0 time = 275
.meas tran vdout1_34ck54 FIND v(dout1_34) AT=275.025n

* CHECK dout1_35 Vdout1_35ck54 = 0.9 time = 275
.meas tran vdout1_35ck54 FIND v(dout1_35) AT=275.025n

* CHECK dout1_36 Vdout1_36ck54 = 0 time = 275
.meas tran vdout1_36ck54 FIND v(dout1_36) AT=275.025n

* CHECK dout1_37 Vdout1_37ck54 = 0 time = 275
.meas tran vdout1_37ck54 FIND v(dout1_37) AT=275.025n

* CHECK dout1_38 Vdout1_38ck54 = 0.9 time = 275
.meas tran vdout1_38ck54 FIND v(dout1_38) AT=275.025n

* CHECK dout1_39 Vdout1_39ck54 = 0.9 time = 275
.meas tran vdout1_39ck54 FIND v(dout1_39) AT=275.025n

* CHECK dout1_40 Vdout1_40ck54 = 0.9 time = 275
.meas tran vdout1_40ck54 FIND v(dout1_40) AT=275.025n

* CHECK dout1_41 Vdout1_41ck54 = 0.9 time = 275
.meas tran vdout1_41ck54 FIND v(dout1_41) AT=275.025n

* CHECK dout1_42 Vdout1_42ck54 = 0 time = 275
.meas tran vdout1_42ck54 FIND v(dout1_42) AT=275.025n

* CHECK dout1_43 Vdout1_43ck54 = 0.9 time = 275
.meas tran vdout1_43ck54 FIND v(dout1_43) AT=275.025n

* CHECK dout1_44 Vdout1_44ck54 = 0.9 time = 275
.meas tran vdout1_44ck54 FIND v(dout1_44) AT=275.025n

* CHECK dout1_45 Vdout1_45ck54 = 0 time = 275
.meas tran vdout1_45ck54 FIND v(dout1_45) AT=275.025n

* CHECK dout1_46 Vdout1_46ck54 = 0 time = 275
.meas tran vdout1_46ck54 FIND v(dout1_46) AT=275.025n

* CHECK dout1_47 Vdout1_47ck54 = 0 time = 275
.meas tran vdout1_47ck54 FIND v(dout1_47) AT=275.025n

* CHECK dout1_48 Vdout1_48ck54 = 0.9 time = 275
.meas tran vdout1_48ck54 FIND v(dout1_48) AT=275.025n

* CHECK dout1_49 Vdout1_49ck54 = 0 time = 275
.meas tran vdout1_49ck54 FIND v(dout1_49) AT=275.025n

* CHECK dout1_50 Vdout1_50ck54 = 0 time = 275
.meas tran vdout1_50ck54 FIND v(dout1_50) AT=275.025n

* CHECK dout1_51 Vdout1_51ck54 = 0.9 time = 275
.meas tran vdout1_51ck54 FIND v(dout1_51) AT=275.025n

* CHECK dout1_52 Vdout1_52ck54 = 0.9 time = 275
.meas tran vdout1_52ck54 FIND v(dout1_52) AT=275.025n

* CHECK dout1_53 Vdout1_53ck54 = 0.9 time = 275
.meas tran vdout1_53ck54 FIND v(dout1_53) AT=275.025n

* CHECK dout1_54 Vdout1_54ck54 = 0 time = 275
.meas tran vdout1_54ck54 FIND v(dout1_54) AT=275.025n

* CHECK dout1_55 Vdout1_55ck54 = 0 time = 275
.meas tran vdout1_55ck54 FIND v(dout1_55) AT=275.025n

* CHECK dout1_0 Vdout1_0ck56 = 0.9 time = 285
.meas tran vdout1_0ck56 FIND v(dout1_0) AT=285.025n

* CHECK dout1_1 Vdout1_1ck56 = 0 time = 285
.meas tran vdout1_1ck56 FIND v(dout1_1) AT=285.025n

* CHECK dout1_2 Vdout1_2ck56 = 0.9 time = 285
.meas tran vdout1_2ck56 FIND v(dout1_2) AT=285.025n

* CHECK dout1_3 Vdout1_3ck56 = 0 time = 285
.meas tran vdout1_3ck56 FIND v(dout1_3) AT=285.025n

* CHECK dout1_4 Vdout1_4ck56 = 0.9 time = 285
.meas tran vdout1_4ck56 FIND v(dout1_4) AT=285.025n

* CHECK dout1_5 Vdout1_5ck56 = 0 time = 285
.meas tran vdout1_5ck56 FIND v(dout1_5) AT=285.025n

* CHECK dout1_6 Vdout1_6ck56 = 0.9 time = 285
.meas tran vdout1_6ck56 FIND v(dout1_6) AT=285.025n

* CHECK dout1_7 Vdout1_7ck56 = 0.9 time = 285
.meas tran vdout1_7ck56 FIND v(dout1_7) AT=285.025n

* CHECK dout1_8 Vdout1_8ck56 = 0.9 time = 285
.meas tran vdout1_8ck56 FIND v(dout1_8) AT=285.025n

* CHECK dout1_9 Vdout1_9ck56 = 0.9 time = 285
.meas tran vdout1_9ck56 FIND v(dout1_9) AT=285.025n

* CHECK dout1_10 Vdout1_10ck56 = 0.9 time = 285
.meas tran vdout1_10ck56 FIND v(dout1_10) AT=285.025n

* CHECK dout1_11 Vdout1_11ck56 = 0.9 time = 285
.meas tran vdout1_11ck56 FIND v(dout1_11) AT=285.025n

* CHECK dout1_12 Vdout1_12ck56 = 0 time = 285
.meas tran vdout1_12ck56 FIND v(dout1_12) AT=285.025n

* CHECK dout1_13 Vdout1_13ck56 = 0.9 time = 285
.meas tran vdout1_13ck56 FIND v(dout1_13) AT=285.025n

* CHECK dout1_14 Vdout1_14ck56 = 0.9 time = 285
.meas tran vdout1_14ck56 FIND v(dout1_14) AT=285.025n

* CHECK dout1_15 Vdout1_15ck56 = 0.9 time = 285
.meas tran vdout1_15ck56 FIND v(dout1_15) AT=285.025n

* CHECK dout1_16 Vdout1_16ck56 = 0.9 time = 285
.meas tran vdout1_16ck56 FIND v(dout1_16) AT=285.025n

* CHECK dout1_17 Vdout1_17ck56 = 0 time = 285
.meas tran vdout1_17ck56 FIND v(dout1_17) AT=285.025n

* CHECK dout1_18 Vdout1_18ck56 = 0.9 time = 285
.meas tran vdout1_18ck56 FIND v(dout1_18) AT=285.025n

* CHECK dout1_19 Vdout1_19ck56 = 0 time = 285
.meas tran vdout1_19ck56 FIND v(dout1_19) AT=285.025n

* CHECK dout1_20 Vdout1_20ck56 = 0 time = 285
.meas tran vdout1_20ck56 FIND v(dout1_20) AT=285.025n

* CHECK dout1_21 Vdout1_21ck56 = 0 time = 285
.meas tran vdout1_21ck56 FIND v(dout1_21) AT=285.025n

* CHECK dout1_22 Vdout1_22ck56 = 0.9 time = 285
.meas tran vdout1_22ck56 FIND v(dout1_22) AT=285.025n

* CHECK dout1_23 Vdout1_23ck56 = 0.9 time = 285
.meas tran vdout1_23ck56 FIND v(dout1_23) AT=285.025n

* CHECK dout1_24 Vdout1_24ck56 = 0.9 time = 285
.meas tran vdout1_24ck56 FIND v(dout1_24) AT=285.025n

* CHECK dout1_25 Vdout1_25ck56 = 0.9 time = 285
.meas tran vdout1_25ck56 FIND v(dout1_25) AT=285.025n

* CHECK dout1_26 Vdout1_26ck56 = 0.9 time = 285
.meas tran vdout1_26ck56 FIND v(dout1_26) AT=285.025n

* CHECK dout1_27 Vdout1_27ck56 = 0 time = 285
.meas tran vdout1_27ck56 FIND v(dout1_27) AT=285.025n

* CHECK dout1_28 Vdout1_28ck56 = 0.9 time = 285
.meas tran vdout1_28ck56 FIND v(dout1_28) AT=285.025n

* CHECK dout1_29 Vdout1_29ck56 = 0.9 time = 285
.meas tran vdout1_29ck56 FIND v(dout1_29) AT=285.025n

* CHECK dout1_30 Vdout1_30ck56 = 0 time = 285
.meas tran vdout1_30ck56 FIND v(dout1_30) AT=285.025n

* CHECK dout1_31 Vdout1_31ck56 = 0 time = 285
.meas tran vdout1_31ck56 FIND v(dout1_31) AT=285.025n

* CHECK dout1_32 Vdout1_32ck56 = 0 time = 285
.meas tran vdout1_32ck56 FIND v(dout1_32) AT=285.025n

* CHECK dout1_33 Vdout1_33ck56 = 0.9 time = 285
.meas tran vdout1_33ck56 FIND v(dout1_33) AT=285.025n

* CHECK dout1_34 Vdout1_34ck56 = 0 time = 285
.meas tran vdout1_34ck56 FIND v(dout1_34) AT=285.025n

* CHECK dout1_35 Vdout1_35ck56 = 0.9 time = 285
.meas tran vdout1_35ck56 FIND v(dout1_35) AT=285.025n

* CHECK dout1_36 Vdout1_36ck56 = 0 time = 285
.meas tran vdout1_36ck56 FIND v(dout1_36) AT=285.025n

* CHECK dout1_37 Vdout1_37ck56 = 0 time = 285
.meas tran vdout1_37ck56 FIND v(dout1_37) AT=285.025n

* CHECK dout1_38 Vdout1_38ck56 = 0.9 time = 285
.meas tran vdout1_38ck56 FIND v(dout1_38) AT=285.025n

* CHECK dout1_39 Vdout1_39ck56 = 0.9 time = 285
.meas tran vdout1_39ck56 FIND v(dout1_39) AT=285.025n

* CHECK dout1_40 Vdout1_40ck56 = 0.9 time = 285
.meas tran vdout1_40ck56 FIND v(dout1_40) AT=285.025n

* CHECK dout1_41 Vdout1_41ck56 = 0.9 time = 285
.meas tran vdout1_41ck56 FIND v(dout1_41) AT=285.025n

* CHECK dout1_42 Vdout1_42ck56 = 0 time = 285
.meas tran vdout1_42ck56 FIND v(dout1_42) AT=285.025n

* CHECK dout1_43 Vdout1_43ck56 = 0.9 time = 285
.meas tran vdout1_43ck56 FIND v(dout1_43) AT=285.025n

* CHECK dout1_44 Vdout1_44ck56 = 0.9 time = 285
.meas tran vdout1_44ck56 FIND v(dout1_44) AT=285.025n

* CHECK dout1_45 Vdout1_45ck56 = 0 time = 285
.meas tran vdout1_45ck56 FIND v(dout1_45) AT=285.025n

* CHECK dout1_46 Vdout1_46ck56 = 0 time = 285
.meas tran vdout1_46ck56 FIND v(dout1_46) AT=285.025n

* CHECK dout1_47 Vdout1_47ck56 = 0 time = 285
.meas tran vdout1_47ck56 FIND v(dout1_47) AT=285.025n

* CHECK dout1_48 Vdout1_48ck56 = 0.9 time = 285
.meas tran vdout1_48ck56 FIND v(dout1_48) AT=285.025n

* CHECK dout1_49 Vdout1_49ck56 = 0 time = 285
.meas tran vdout1_49ck56 FIND v(dout1_49) AT=285.025n

* CHECK dout1_50 Vdout1_50ck56 = 0 time = 285
.meas tran vdout1_50ck56 FIND v(dout1_50) AT=285.025n

* CHECK dout1_51 Vdout1_51ck56 = 0.9 time = 285
.meas tran vdout1_51ck56 FIND v(dout1_51) AT=285.025n

* CHECK dout1_52 Vdout1_52ck56 = 0.9 time = 285
.meas tran vdout1_52ck56 FIND v(dout1_52) AT=285.025n

* CHECK dout1_53 Vdout1_53ck56 = 0.9 time = 285
.meas tran vdout1_53ck56 FIND v(dout1_53) AT=285.025n

* CHECK dout1_54 Vdout1_54ck56 = 0 time = 285
.meas tran vdout1_54ck56 FIND v(dout1_54) AT=285.025n

* CHECK dout1_55 Vdout1_55ck56 = 0 time = 285
.meas tran vdout1_55ck56 FIND v(dout1_55) AT=285.025n

* CHECK dout1_0 Vdout1_0ck58 = 0 time = 295
.meas tran vdout1_0ck58 FIND v(dout1_0) AT=295.025n

* CHECK dout1_1 Vdout1_1ck58 = 0 time = 295
.meas tran vdout1_1ck58 FIND v(dout1_1) AT=295.025n

* CHECK dout1_2 Vdout1_2ck58 = 0.9 time = 295
.meas tran vdout1_2ck58 FIND v(dout1_2) AT=295.025n

* CHECK dout1_3 Vdout1_3ck58 = 0.9 time = 295
.meas tran vdout1_3ck58 FIND v(dout1_3) AT=295.025n

* CHECK dout1_4 Vdout1_4ck58 = 0 time = 295
.meas tran vdout1_4ck58 FIND v(dout1_4) AT=295.025n

* CHECK dout1_5 Vdout1_5ck58 = 0 time = 295
.meas tran vdout1_5ck58 FIND v(dout1_5) AT=295.025n

* CHECK dout1_6 Vdout1_6ck58 = 0.9 time = 295
.meas tran vdout1_6ck58 FIND v(dout1_6) AT=295.025n

* CHECK dout1_7 Vdout1_7ck58 = 0.9 time = 295
.meas tran vdout1_7ck58 FIND v(dout1_7) AT=295.025n

* CHECK dout1_8 Vdout1_8ck58 = 0.9 time = 295
.meas tran vdout1_8ck58 FIND v(dout1_8) AT=295.025n

* CHECK dout1_9 Vdout1_9ck58 = 0 time = 295
.meas tran vdout1_9ck58 FIND v(dout1_9) AT=295.025n

* CHECK dout1_10 Vdout1_10ck58 = 0.9 time = 295
.meas tran vdout1_10ck58 FIND v(dout1_10) AT=295.025n

* CHECK dout1_11 Vdout1_11ck58 = 0.9 time = 295
.meas tran vdout1_11ck58 FIND v(dout1_11) AT=295.025n

* CHECK dout1_12 Vdout1_12ck58 = 0 time = 295
.meas tran vdout1_12ck58 FIND v(dout1_12) AT=295.025n

* CHECK dout1_13 Vdout1_13ck58 = 0.9 time = 295
.meas tran vdout1_13ck58 FIND v(dout1_13) AT=295.025n

* CHECK dout1_14 Vdout1_14ck58 = 0 time = 295
.meas tran vdout1_14ck58 FIND v(dout1_14) AT=295.025n

* CHECK dout1_15 Vdout1_15ck58 = 0 time = 295
.meas tran vdout1_15ck58 FIND v(dout1_15) AT=295.025n

* CHECK dout1_16 Vdout1_16ck58 = 0 time = 295
.meas tran vdout1_16ck58 FIND v(dout1_16) AT=295.025n

* CHECK dout1_17 Vdout1_17ck58 = 0 time = 295
.meas tran vdout1_17ck58 FIND v(dout1_17) AT=295.025n

* CHECK dout1_18 Vdout1_18ck58 = 0 time = 295
.meas tran vdout1_18ck58 FIND v(dout1_18) AT=295.025n

* CHECK dout1_19 Vdout1_19ck58 = 0.9 time = 295
.meas tran vdout1_19ck58 FIND v(dout1_19) AT=295.025n

* CHECK dout1_20 Vdout1_20ck58 = 0 time = 295
.meas tran vdout1_20ck58 FIND v(dout1_20) AT=295.025n

* CHECK dout1_21 Vdout1_21ck58 = 0.9 time = 295
.meas tran vdout1_21ck58 FIND v(dout1_21) AT=295.025n

* CHECK dout1_22 Vdout1_22ck58 = 0 time = 295
.meas tran vdout1_22ck58 FIND v(dout1_22) AT=295.025n

* CHECK dout1_23 Vdout1_23ck58 = 0.9 time = 295
.meas tran vdout1_23ck58 FIND v(dout1_23) AT=295.025n

* CHECK dout1_24 Vdout1_24ck58 = 0 time = 295
.meas tran vdout1_24ck58 FIND v(dout1_24) AT=295.025n

* CHECK dout1_25 Vdout1_25ck58 = 0.9 time = 295
.meas tran vdout1_25ck58 FIND v(dout1_25) AT=295.025n

* CHECK dout1_26 Vdout1_26ck58 = 0 time = 295
.meas tran vdout1_26ck58 FIND v(dout1_26) AT=295.025n

* CHECK dout1_27 Vdout1_27ck58 = 0 time = 295
.meas tran vdout1_27ck58 FIND v(dout1_27) AT=295.025n

* CHECK dout1_28 Vdout1_28ck58 = 0 time = 295
.meas tran vdout1_28ck58 FIND v(dout1_28) AT=295.025n

* CHECK dout1_29 Vdout1_29ck58 = 0.9 time = 295
.meas tran vdout1_29ck58 FIND v(dout1_29) AT=295.025n

* CHECK dout1_30 Vdout1_30ck58 = 0 time = 295
.meas tran vdout1_30ck58 FIND v(dout1_30) AT=295.025n

* CHECK dout1_31 Vdout1_31ck58 = 0.9 time = 295
.meas tran vdout1_31ck58 FIND v(dout1_31) AT=295.025n

* CHECK dout1_32 Vdout1_32ck58 = 0 time = 295
.meas tran vdout1_32ck58 FIND v(dout1_32) AT=295.025n

* CHECK dout1_33 Vdout1_33ck58 = 0 time = 295
.meas tran vdout1_33ck58 FIND v(dout1_33) AT=295.025n

* CHECK dout1_34 Vdout1_34ck58 = 0.9 time = 295
.meas tran vdout1_34ck58 FIND v(dout1_34) AT=295.025n

* CHECK dout1_35 Vdout1_35ck58 = 0.9 time = 295
.meas tran vdout1_35ck58 FIND v(dout1_35) AT=295.025n

* CHECK dout1_36 Vdout1_36ck58 = 0.9 time = 295
.meas tran vdout1_36ck58 FIND v(dout1_36) AT=295.025n

* CHECK dout1_37 Vdout1_37ck58 = 0 time = 295
.meas tran vdout1_37ck58 FIND v(dout1_37) AT=295.025n

* CHECK dout1_38 Vdout1_38ck58 = 0.9 time = 295
.meas tran vdout1_38ck58 FIND v(dout1_38) AT=295.025n

* CHECK dout1_39 Vdout1_39ck58 = 0 time = 295
.meas tran vdout1_39ck58 FIND v(dout1_39) AT=295.025n

* CHECK dout1_40 Vdout1_40ck58 = 0 time = 295
.meas tran vdout1_40ck58 FIND v(dout1_40) AT=295.025n

* CHECK dout1_41 Vdout1_41ck58 = 0.9 time = 295
.meas tran vdout1_41ck58 FIND v(dout1_41) AT=295.025n

* CHECK dout1_42 Vdout1_42ck58 = 0.9 time = 295
.meas tran vdout1_42ck58 FIND v(dout1_42) AT=295.025n

* CHECK dout1_43 Vdout1_43ck58 = 0.9 time = 295
.meas tran vdout1_43ck58 FIND v(dout1_43) AT=295.025n

* CHECK dout1_44 Vdout1_44ck58 = 0.9 time = 295
.meas tran vdout1_44ck58 FIND v(dout1_44) AT=295.025n

* CHECK dout1_45 Vdout1_45ck58 = 0 time = 295
.meas tran vdout1_45ck58 FIND v(dout1_45) AT=295.025n

* CHECK dout1_46 Vdout1_46ck58 = 0 time = 295
.meas tran vdout1_46ck58 FIND v(dout1_46) AT=295.025n

* CHECK dout1_47 Vdout1_47ck58 = 0 time = 295
.meas tran vdout1_47ck58 FIND v(dout1_47) AT=295.025n

* CHECK dout1_48 Vdout1_48ck58 = 0.9 time = 295
.meas tran vdout1_48ck58 FIND v(dout1_48) AT=295.025n

* CHECK dout1_49 Vdout1_49ck58 = 0.9 time = 295
.meas tran vdout1_49ck58 FIND v(dout1_49) AT=295.025n

* CHECK dout1_50 Vdout1_50ck58 = 0.9 time = 295
.meas tran vdout1_50ck58 FIND v(dout1_50) AT=295.025n

* CHECK dout1_51 Vdout1_51ck58 = 0 time = 295
.meas tran vdout1_51ck58 FIND v(dout1_51) AT=295.025n

* CHECK dout1_52 Vdout1_52ck58 = 0.9 time = 295
.meas tran vdout1_52ck58 FIND v(dout1_52) AT=295.025n

* CHECK dout1_53 Vdout1_53ck58 = 0 time = 295
.meas tran vdout1_53ck58 FIND v(dout1_53) AT=295.025n

* CHECK dout1_54 Vdout1_54ck58 = 0.9 time = 295
.meas tran vdout1_54ck58 FIND v(dout1_54) AT=295.025n

* CHECK dout1_55 Vdout1_55ck58 = 0 time = 295
.meas tran vdout1_55ck58 FIND v(dout1_55) AT=295.025n

* CHECK dout1_0 Vdout1_0ck59 = 0.9 time = 300
.meas tran vdout1_0ck59 FIND v(dout1_0) AT=300.025n

* CHECK dout1_1 Vdout1_1ck59 = 0.9 time = 300
.meas tran vdout1_1ck59 FIND v(dout1_1) AT=300.025n

* CHECK dout1_2 Vdout1_2ck59 = 0.9 time = 300
.meas tran vdout1_2ck59 FIND v(dout1_2) AT=300.025n

* CHECK dout1_3 Vdout1_3ck59 = 0.9 time = 300
.meas tran vdout1_3ck59 FIND v(dout1_3) AT=300.025n

* CHECK dout1_4 Vdout1_4ck59 = 0.9 time = 300
.meas tran vdout1_4ck59 FIND v(dout1_4) AT=300.025n

* CHECK dout1_5 Vdout1_5ck59 = 0 time = 300
.meas tran vdout1_5ck59 FIND v(dout1_5) AT=300.025n

* CHECK dout1_6 Vdout1_6ck59 = 0 time = 300
.meas tran vdout1_6ck59 FIND v(dout1_6) AT=300.025n

* CHECK dout1_7 Vdout1_7ck59 = 0 time = 300
.meas tran vdout1_7ck59 FIND v(dout1_7) AT=300.025n

* CHECK dout1_8 Vdout1_8ck59 = 0.9 time = 300
.meas tran vdout1_8ck59 FIND v(dout1_8) AT=300.025n

* CHECK dout1_9 Vdout1_9ck59 = 0 time = 300
.meas tran vdout1_9ck59 FIND v(dout1_9) AT=300.025n

* CHECK dout1_10 Vdout1_10ck59 = 0 time = 300
.meas tran vdout1_10ck59 FIND v(dout1_10) AT=300.025n

* CHECK dout1_11 Vdout1_11ck59 = 0.9 time = 300
.meas tran vdout1_11ck59 FIND v(dout1_11) AT=300.025n

* CHECK dout1_12 Vdout1_12ck59 = 0.9 time = 300
.meas tran vdout1_12ck59 FIND v(dout1_12) AT=300.025n

* CHECK dout1_13 Vdout1_13ck59 = 0.9 time = 300
.meas tran vdout1_13ck59 FIND v(dout1_13) AT=300.025n

* CHECK dout1_14 Vdout1_14ck59 = 0.9 time = 300
.meas tran vdout1_14ck59 FIND v(dout1_14) AT=300.025n

* CHECK dout1_15 Vdout1_15ck59 = 0 time = 300
.meas tran vdout1_15ck59 FIND v(dout1_15) AT=300.025n

* CHECK dout1_16 Vdout1_16ck59 = 0 time = 300
.meas tran vdout1_16ck59 FIND v(dout1_16) AT=300.025n

* CHECK dout1_17 Vdout1_17ck59 = 0.9 time = 300
.meas tran vdout1_17ck59 FIND v(dout1_17) AT=300.025n

* CHECK dout1_18 Vdout1_18ck59 = 0.9 time = 300
.meas tran vdout1_18ck59 FIND v(dout1_18) AT=300.025n

* CHECK dout1_19 Vdout1_19ck59 = 0.9 time = 300
.meas tran vdout1_19ck59 FIND v(dout1_19) AT=300.025n

* CHECK dout1_20 Vdout1_20ck59 = 0 time = 300
.meas tran vdout1_20ck59 FIND v(dout1_20) AT=300.025n

* CHECK dout1_21 Vdout1_21ck59 = 0 time = 300
.meas tran vdout1_21ck59 FIND v(dout1_21) AT=300.025n

* CHECK dout1_22 Vdout1_22ck59 = 0.9 time = 300
.meas tran vdout1_22ck59 FIND v(dout1_22) AT=300.025n

* CHECK dout1_23 Vdout1_23ck59 = 0.9 time = 300
.meas tran vdout1_23ck59 FIND v(dout1_23) AT=300.025n

* CHECK dout1_24 Vdout1_24ck59 = 0 time = 300
.meas tran vdout1_24ck59 FIND v(dout1_24) AT=300.025n

* CHECK dout1_25 Vdout1_25ck59 = 0.9 time = 300
.meas tran vdout1_25ck59 FIND v(dout1_25) AT=300.025n

* CHECK dout1_26 Vdout1_26ck59 = 0.9 time = 300
.meas tran vdout1_26ck59 FIND v(dout1_26) AT=300.025n

* CHECK dout1_27 Vdout1_27ck59 = 0.9 time = 300
.meas tran vdout1_27ck59 FIND v(dout1_27) AT=300.025n

* CHECK dout1_28 Vdout1_28ck59 = 0.9 time = 300
.meas tran vdout1_28ck59 FIND v(dout1_28) AT=300.025n

* CHECK dout1_29 Vdout1_29ck59 = 0 time = 300
.meas tran vdout1_29ck59 FIND v(dout1_29) AT=300.025n

* CHECK dout1_30 Vdout1_30ck59 = 0.9 time = 300
.meas tran vdout1_30ck59 FIND v(dout1_30) AT=300.025n

* CHECK dout1_31 Vdout1_31ck59 = 0.9 time = 300
.meas tran vdout1_31ck59 FIND v(dout1_31) AT=300.025n

* CHECK dout1_32 Vdout1_32ck59 = 0.9 time = 300
.meas tran vdout1_32ck59 FIND v(dout1_32) AT=300.025n

* CHECK dout1_33 Vdout1_33ck59 = 0.9 time = 300
.meas tran vdout1_33ck59 FIND v(dout1_33) AT=300.025n

* CHECK dout1_34 Vdout1_34ck59 = 0.9 time = 300
.meas tran vdout1_34ck59 FIND v(dout1_34) AT=300.025n

* CHECK dout1_35 Vdout1_35ck59 = 0 time = 300
.meas tran vdout1_35ck59 FIND v(dout1_35) AT=300.025n

* CHECK dout1_36 Vdout1_36ck59 = 0.9 time = 300
.meas tran vdout1_36ck59 FIND v(dout1_36) AT=300.025n

* CHECK dout1_37 Vdout1_37ck59 = 0.9 time = 300
.meas tran vdout1_37ck59 FIND v(dout1_37) AT=300.025n

* CHECK dout1_38 Vdout1_38ck59 = 0 time = 300
.meas tran vdout1_38ck59 FIND v(dout1_38) AT=300.025n

* CHECK dout1_39 Vdout1_39ck59 = 0 time = 300
.meas tran vdout1_39ck59 FIND v(dout1_39) AT=300.025n

* CHECK dout1_40 Vdout1_40ck59 = 0 time = 300
.meas tran vdout1_40ck59 FIND v(dout1_40) AT=300.025n

* CHECK dout1_41 Vdout1_41ck59 = 0 time = 300
.meas tran vdout1_41ck59 FIND v(dout1_41) AT=300.025n

* CHECK dout1_42 Vdout1_42ck59 = 0 time = 300
.meas tran vdout1_42ck59 FIND v(dout1_42) AT=300.025n

* CHECK dout1_43 Vdout1_43ck59 = 0 time = 300
.meas tran vdout1_43ck59 FIND v(dout1_43) AT=300.025n

* CHECK dout1_44 Vdout1_44ck59 = 0 time = 300
.meas tran vdout1_44ck59 FIND v(dout1_44) AT=300.025n

* CHECK dout1_45 Vdout1_45ck59 = 0 time = 300
.meas tran vdout1_45ck59 FIND v(dout1_45) AT=300.025n

* CHECK dout1_46 Vdout1_46ck59 = 0 time = 300
.meas tran vdout1_46ck59 FIND v(dout1_46) AT=300.025n

* CHECK dout1_47 Vdout1_47ck59 = 0.9 time = 300
.meas tran vdout1_47ck59 FIND v(dout1_47) AT=300.025n

* CHECK dout1_48 Vdout1_48ck59 = 0 time = 300
.meas tran vdout1_48ck59 FIND v(dout1_48) AT=300.025n

* CHECK dout1_49 Vdout1_49ck59 = 0 time = 300
.meas tran vdout1_49ck59 FIND v(dout1_49) AT=300.025n

* CHECK dout1_50 Vdout1_50ck59 = 0 time = 300
.meas tran vdout1_50ck59 FIND v(dout1_50) AT=300.025n

* CHECK dout1_51 Vdout1_51ck59 = 0.9 time = 300
.meas tran vdout1_51ck59 FIND v(dout1_51) AT=300.025n

* CHECK dout1_52 Vdout1_52ck59 = 0.9 time = 300
.meas tran vdout1_52ck59 FIND v(dout1_52) AT=300.025n

* CHECK dout1_53 Vdout1_53ck59 = 0 time = 300
.meas tran vdout1_53ck59 FIND v(dout1_53) AT=300.025n

* CHECK dout1_54 Vdout1_54ck59 = 0 time = 300
.meas tran vdout1_54ck59 FIND v(dout1_54) AT=300.025n

* CHECK dout1_55 Vdout1_55ck59 = 0 time = 300
.meas tran vdout1_55ck59 FIND v(dout1_55) AT=300.025n

* CHECK dout1_0 Vdout1_0ck60 = 0.9 time = 305
.meas tran vdout1_0ck60 FIND v(dout1_0) AT=305.025n

* CHECK dout1_1 Vdout1_1ck60 = 0.9 time = 305
.meas tran vdout1_1ck60 FIND v(dout1_1) AT=305.025n

* CHECK dout1_2 Vdout1_2ck60 = 0.9 time = 305
.meas tran vdout1_2ck60 FIND v(dout1_2) AT=305.025n

* CHECK dout1_3 Vdout1_3ck60 = 0.9 time = 305
.meas tran vdout1_3ck60 FIND v(dout1_3) AT=305.025n

* CHECK dout1_4 Vdout1_4ck60 = 0.9 time = 305
.meas tran vdout1_4ck60 FIND v(dout1_4) AT=305.025n

* CHECK dout1_5 Vdout1_5ck60 = 0 time = 305
.meas tran vdout1_5ck60 FIND v(dout1_5) AT=305.025n

* CHECK dout1_6 Vdout1_6ck60 = 0 time = 305
.meas tran vdout1_6ck60 FIND v(dout1_6) AT=305.025n

* CHECK dout1_7 Vdout1_7ck60 = 0 time = 305
.meas tran vdout1_7ck60 FIND v(dout1_7) AT=305.025n

* CHECK dout1_8 Vdout1_8ck60 = 0.9 time = 305
.meas tran vdout1_8ck60 FIND v(dout1_8) AT=305.025n

* CHECK dout1_9 Vdout1_9ck60 = 0 time = 305
.meas tran vdout1_9ck60 FIND v(dout1_9) AT=305.025n

* CHECK dout1_10 Vdout1_10ck60 = 0 time = 305
.meas tran vdout1_10ck60 FIND v(dout1_10) AT=305.025n

* CHECK dout1_11 Vdout1_11ck60 = 0.9 time = 305
.meas tran vdout1_11ck60 FIND v(dout1_11) AT=305.025n

* CHECK dout1_12 Vdout1_12ck60 = 0.9 time = 305
.meas tran vdout1_12ck60 FIND v(dout1_12) AT=305.025n

* CHECK dout1_13 Vdout1_13ck60 = 0.9 time = 305
.meas tran vdout1_13ck60 FIND v(dout1_13) AT=305.025n

* CHECK dout1_14 Vdout1_14ck60 = 0.9 time = 305
.meas tran vdout1_14ck60 FIND v(dout1_14) AT=305.025n

* CHECK dout1_15 Vdout1_15ck60 = 0 time = 305
.meas tran vdout1_15ck60 FIND v(dout1_15) AT=305.025n

* CHECK dout1_16 Vdout1_16ck60 = 0 time = 305
.meas tran vdout1_16ck60 FIND v(dout1_16) AT=305.025n

* CHECK dout1_17 Vdout1_17ck60 = 0.9 time = 305
.meas tran vdout1_17ck60 FIND v(dout1_17) AT=305.025n

* CHECK dout1_18 Vdout1_18ck60 = 0.9 time = 305
.meas tran vdout1_18ck60 FIND v(dout1_18) AT=305.025n

* CHECK dout1_19 Vdout1_19ck60 = 0.9 time = 305
.meas tran vdout1_19ck60 FIND v(dout1_19) AT=305.025n

* CHECK dout1_20 Vdout1_20ck60 = 0 time = 305
.meas tran vdout1_20ck60 FIND v(dout1_20) AT=305.025n

* CHECK dout1_21 Vdout1_21ck60 = 0 time = 305
.meas tran vdout1_21ck60 FIND v(dout1_21) AT=305.025n

* CHECK dout1_22 Vdout1_22ck60 = 0.9 time = 305
.meas tran vdout1_22ck60 FIND v(dout1_22) AT=305.025n

* CHECK dout1_23 Vdout1_23ck60 = 0.9 time = 305
.meas tran vdout1_23ck60 FIND v(dout1_23) AT=305.025n

* CHECK dout1_24 Vdout1_24ck60 = 0 time = 305
.meas tran vdout1_24ck60 FIND v(dout1_24) AT=305.025n

* CHECK dout1_25 Vdout1_25ck60 = 0.9 time = 305
.meas tran vdout1_25ck60 FIND v(dout1_25) AT=305.025n

* CHECK dout1_26 Vdout1_26ck60 = 0.9 time = 305
.meas tran vdout1_26ck60 FIND v(dout1_26) AT=305.025n

* CHECK dout1_27 Vdout1_27ck60 = 0.9 time = 305
.meas tran vdout1_27ck60 FIND v(dout1_27) AT=305.025n

* CHECK dout1_28 Vdout1_28ck60 = 0.9 time = 305
.meas tran vdout1_28ck60 FIND v(dout1_28) AT=305.025n

* CHECK dout1_29 Vdout1_29ck60 = 0 time = 305
.meas tran vdout1_29ck60 FIND v(dout1_29) AT=305.025n

* CHECK dout1_30 Vdout1_30ck60 = 0.9 time = 305
.meas tran vdout1_30ck60 FIND v(dout1_30) AT=305.025n

* CHECK dout1_31 Vdout1_31ck60 = 0.9 time = 305
.meas tran vdout1_31ck60 FIND v(dout1_31) AT=305.025n

* CHECK dout1_32 Vdout1_32ck60 = 0.9 time = 305
.meas tran vdout1_32ck60 FIND v(dout1_32) AT=305.025n

* CHECK dout1_33 Vdout1_33ck60 = 0.9 time = 305
.meas tran vdout1_33ck60 FIND v(dout1_33) AT=305.025n

* CHECK dout1_34 Vdout1_34ck60 = 0.9 time = 305
.meas tran vdout1_34ck60 FIND v(dout1_34) AT=305.025n

* CHECK dout1_35 Vdout1_35ck60 = 0 time = 305
.meas tran vdout1_35ck60 FIND v(dout1_35) AT=305.025n

* CHECK dout1_36 Vdout1_36ck60 = 0.9 time = 305
.meas tran vdout1_36ck60 FIND v(dout1_36) AT=305.025n

* CHECK dout1_37 Vdout1_37ck60 = 0.9 time = 305
.meas tran vdout1_37ck60 FIND v(dout1_37) AT=305.025n

* CHECK dout1_38 Vdout1_38ck60 = 0 time = 305
.meas tran vdout1_38ck60 FIND v(dout1_38) AT=305.025n

* CHECK dout1_39 Vdout1_39ck60 = 0 time = 305
.meas tran vdout1_39ck60 FIND v(dout1_39) AT=305.025n

* CHECK dout1_40 Vdout1_40ck60 = 0 time = 305
.meas tran vdout1_40ck60 FIND v(dout1_40) AT=305.025n

* CHECK dout1_41 Vdout1_41ck60 = 0 time = 305
.meas tran vdout1_41ck60 FIND v(dout1_41) AT=305.025n

* CHECK dout1_42 Vdout1_42ck60 = 0 time = 305
.meas tran vdout1_42ck60 FIND v(dout1_42) AT=305.025n

* CHECK dout1_43 Vdout1_43ck60 = 0 time = 305
.meas tran vdout1_43ck60 FIND v(dout1_43) AT=305.025n

* CHECK dout1_44 Vdout1_44ck60 = 0 time = 305
.meas tran vdout1_44ck60 FIND v(dout1_44) AT=305.025n

* CHECK dout1_45 Vdout1_45ck60 = 0 time = 305
.meas tran vdout1_45ck60 FIND v(dout1_45) AT=305.025n

* CHECK dout1_46 Vdout1_46ck60 = 0 time = 305
.meas tran vdout1_46ck60 FIND v(dout1_46) AT=305.025n

* CHECK dout1_47 Vdout1_47ck60 = 0.9 time = 305
.meas tran vdout1_47ck60 FIND v(dout1_47) AT=305.025n

* CHECK dout1_48 Vdout1_48ck60 = 0 time = 305
.meas tran vdout1_48ck60 FIND v(dout1_48) AT=305.025n

* CHECK dout1_49 Vdout1_49ck60 = 0 time = 305
.meas tran vdout1_49ck60 FIND v(dout1_49) AT=305.025n

* CHECK dout1_50 Vdout1_50ck60 = 0 time = 305
.meas tran vdout1_50ck60 FIND v(dout1_50) AT=305.025n

* CHECK dout1_51 Vdout1_51ck60 = 0.9 time = 305
.meas tran vdout1_51ck60 FIND v(dout1_51) AT=305.025n

* CHECK dout1_52 Vdout1_52ck60 = 0.9 time = 305
.meas tran vdout1_52ck60 FIND v(dout1_52) AT=305.025n

* CHECK dout1_53 Vdout1_53ck60 = 0 time = 305
.meas tran vdout1_53ck60 FIND v(dout1_53) AT=305.025n

* CHECK dout1_54 Vdout1_54ck60 = 0 time = 305
.meas tran vdout1_54ck60 FIND v(dout1_54) AT=305.025n

* CHECK dout1_55 Vdout1_55ck60 = 0 time = 305
.meas tran vdout1_55ck60 FIND v(dout1_55) AT=305.025n

* CHECK dout1_0 Vdout1_0ck61 = 0 time = 310
.meas tran vdout1_0ck61 FIND v(dout1_0) AT=310.025n

* CHECK dout1_1 Vdout1_1ck61 = 0.9 time = 310
.meas tran vdout1_1ck61 FIND v(dout1_1) AT=310.025n

* CHECK dout1_2 Vdout1_2ck61 = 0.9 time = 310
.meas tran vdout1_2ck61 FIND v(dout1_2) AT=310.025n

* CHECK dout1_3 Vdout1_3ck61 = 0 time = 310
.meas tran vdout1_3ck61 FIND v(dout1_3) AT=310.025n

* CHECK dout1_4 Vdout1_4ck61 = 0.9 time = 310
.meas tran vdout1_4ck61 FIND v(dout1_4) AT=310.025n

* CHECK dout1_5 Vdout1_5ck61 = 0.9 time = 310
.meas tran vdout1_5ck61 FIND v(dout1_5) AT=310.025n

* CHECK dout1_6 Vdout1_6ck61 = 0.9 time = 310
.meas tran vdout1_6ck61 FIND v(dout1_6) AT=310.025n

* CHECK dout1_7 Vdout1_7ck61 = 0.9 time = 310
.meas tran vdout1_7ck61 FIND v(dout1_7) AT=310.025n

* CHECK dout1_8 Vdout1_8ck61 = 0 time = 310
.meas tran vdout1_8ck61 FIND v(dout1_8) AT=310.025n

* CHECK dout1_9 Vdout1_9ck61 = 0 time = 310
.meas tran vdout1_9ck61 FIND v(dout1_9) AT=310.025n

* CHECK dout1_10 Vdout1_10ck61 = 0.9 time = 310
.meas tran vdout1_10ck61 FIND v(dout1_10) AT=310.025n

* CHECK dout1_11 Vdout1_11ck61 = 0 time = 310
.meas tran vdout1_11ck61 FIND v(dout1_11) AT=310.025n

* CHECK dout1_12 Vdout1_12ck61 = 0.9 time = 310
.meas tran vdout1_12ck61 FIND v(dout1_12) AT=310.025n

* CHECK dout1_13 Vdout1_13ck61 = 0.9 time = 310
.meas tran vdout1_13ck61 FIND v(dout1_13) AT=310.025n

* CHECK dout1_14 Vdout1_14ck61 = 0 time = 310
.meas tran vdout1_14ck61 FIND v(dout1_14) AT=310.025n

* CHECK dout1_15 Vdout1_15ck61 = 0 time = 310
.meas tran vdout1_15ck61 FIND v(dout1_15) AT=310.025n

* CHECK dout1_16 Vdout1_16ck61 = 0 time = 310
.meas tran vdout1_16ck61 FIND v(dout1_16) AT=310.025n

* CHECK dout1_17 Vdout1_17ck61 = 0.9 time = 310
.meas tran vdout1_17ck61 FIND v(dout1_17) AT=310.025n

* CHECK dout1_18 Vdout1_18ck61 = 0 time = 310
.meas tran vdout1_18ck61 FIND v(dout1_18) AT=310.025n

* CHECK dout1_19 Vdout1_19ck61 = 0.9 time = 310
.meas tran vdout1_19ck61 FIND v(dout1_19) AT=310.025n

* CHECK dout1_20 Vdout1_20ck61 = 0 time = 310
.meas tran vdout1_20ck61 FIND v(dout1_20) AT=310.025n

* CHECK dout1_21 Vdout1_21ck61 = 0.9 time = 310
.meas tran vdout1_21ck61 FIND v(dout1_21) AT=310.025n

* CHECK dout1_22 Vdout1_22ck61 = 0 time = 310
.meas tran vdout1_22ck61 FIND v(dout1_22) AT=310.025n

* CHECK dout1_23 Vdout1_23ck61 = 0.9 time = 310
.meas tran vdout1_23ck61 FIND v(dout1_23) AT=310.025n

* CHECK dout1_24 Vdout1_24ck61 = 0 time = 310
.meas tran vdout1_24ck61 FIND v(dout1_24) AT=310.025n

* CHECK dout1_25 Vdout1_25ck61 = 0.9 time = 310
.meas tran vdout1_25ck61 FIND v(dout1_25) AT=310.025n

* CHECK dout1_26 Vdout1_26ck61 = 0 time = 310
.meas tran vdout1_26ck61 FIND v(dout1_26) AT=310.025n

* CHECK dout1_27 Vdout1_27ck61 = 0.9 time = 310
.meas tran vdout1_27ck61 FIND v(dout1_27) AT=310.025n

* CHECK dout1_28 Vdout1_28ck61 = 0 time = 310
.meas tran vdout1_28ck61 FIND v(dout1_28) AT=310.025n

* CHECK dout1_29 Vdout1_29ck61 = 0.9 time = 310
.meas tran vdout1_29ck61 FIND v(dout1_29) AT=310.025n

* CHECK dout1_30 Vdout1_30ck61 = 0.9 time = 310
.meas tran vdout1_30ck61 FIND v(dout1_30) AT=310.025n

* CHECK dout1_31 Vdout1_31ck61 = 0.9 time = 310
.meas tran vdout1_31ck61 FIND v(dout1_31) AT=310.025n

* CHECK dout1_32 Vdout1_32ck61 = 0.9 time = 310
.meas tran vdout1_32ck61 FIND v(dout1_32) AT=310.025n

* CHECK dout1_33 Vdout1_33ck61 = 0.9 time = 310
.meas tran vdout1_33ck61 FIND v(dout1_33) AT=310.025n

* CHECK dout1_34 Vdout1_34ck61 = 0.9 time = 310
.meas tran vdout1_34ck61 FIND v(dout1_34) AT=310.025n

* CHECK dout1_35 Vdout1_35ck61 = 0.9 time = 310
.meas tran vdout1_35ck61 FIND v(dout1_35) AT=310.025n

* CHECK dout1_36 Vdout1_36ck61 = 0.9 time = 310
.meas tran vdout1_36ck61 FIND v(dout1_36) AT=310.025n

* CHECK dout1_37 Vdout1_37ck61 = 0.9 time = 310
.meas tran vdout1_37ck61 FIND v(dout1_37) AT=310.025n

* CHECK dout1_38 Vdout1_38ck61 = 0.9 time = 310
.meas tran vdout1_38ck61 FIND v(dout1_38) AT=310.025n

* CHECK dout1_39 Vdout1_39ck61 = 0.9 time = 310
.meas tran vdout1_39ck61 FIND v(dout1_39) AT=310.025n

* CHECK dout1_40 Vdout1_40ck61 = 0 time = 310
.meas tran vdout1_40ck61 FIND v(dout1_40) AT=310.025n

* CHECK dout1_41 Vdout1_41ck61 = 0 time = 310
.meas tran vdout1_41ck61 FIND v(dout1_41) AT=310.025n

* CHECK dout1_42 Vdout1_42ck61 = 0.9 time = 310
.meas tran vdout1_42ck61 FIND v(dout1_42) AT=310.025n

* CHECK dout1_43 Vdout1_43ck61 = 0 time = 310
.meas tran vdout1_43ck61 FIND v(dout1_43) AT=310.025n

* CHECK dout1_44 Vdout1_44ck61 = 0 time = 310
.meas tran vdout1_44ck61 FIND v(dout1_44) AT=310.025n

* CHECK dout1_45 Vdout1_45ck61 = 0.9 time = 310
.meas tran vdout1_45ck61 FIND v(dout1_45) AT=310.025n

* CHECK dout1_46 Vdout1_46ck61 = 0.9 time = 310
.meas tran vdout1_46ck61 FIND v(dout1_46) AT=310.025n

* CHECK dout1_47 Vdout1_47ck61 = 0.9 time = 310
.meas tran vdout1_47ck61 FIND v(dout1_47) AT=310.025n

* CHECK dout1_48 Vdout1_48ck61 = 0.9 time = 310
.meas tran vdout1_48ck61 FIND v(dout1_48) AT=310.025n

* CHECK dout1_49 Vdout1_49ck61 = 0.9 time = 310
.meas tran vdout1_49ck61 FIND v(dout1_49) AT=310.025n

* CHECK dout1_50 Vdout1_50ck61 = 0.9 time = 310
.meas tran vdout1_50ck61 FIND v(dout1_50) AT=310.025n

* CHECK dout1_51 Vdout1_51ck61 = 0 time = 310
.meas tran vdout1_51ck61 FIND v(dout1_51) AT=310.025n

* CHECK dout1_52 Vdout1_52ck61 = 0 time = 310
.meas tran vdout1_52ck61 FIND v(dout1_52) AT=310.025n

* CHECK dout1_53 Vdout1_53ck61 = 0 time = 310
.meas tran vdout1_53ck61 FIND v(dout1_53) AT=310.025n

* CHECK dout1_54 Vdout1_54ck61 = 0.9 time = 310
.meas tran vdout1_54ck61 FIND v(dout1_54) AT=310.025n

* CHECK dout1_55 Vdout1_55ck61 = 0 time = 310
.meas tran vdout1_55ck61 FIND v(dout1_55) AT=310.025n

* CHECK dout1_0 Vdout1_0ck62 = 0.9 time = 315
.meas tran vdout1_0ck62 FIND v(dout1_0) AT=315.025n

* CHECK dout1_1 Vdout1_1ck62 = 0 time = 315
.meas tran vdout1_1ck62 FIND v(dout1_1) AT=315.025n

* CHECK dout1_2 Vdout1_2ck62 = 0 time = 315
.meas tran vdout1_2ck62 FIND v(dout1_2) AT=315.025n

* CHECK dout1_3 Vdout1_3ck62 = 0.9 time = 315
.meas tran vdout1_3ck62 FIND v(dout1_3) AT=315.025n

* CHECK dout1_4 Vdout1_4ck62 = 0 time = 315
.meas tran vdout1_4ck62 FIND v(dout1_4) AT=315.025n

* CHECK dout1_5 Vdout1_5ck62 = 0.9 time = 315
.meas tran vdout1_5ck62 FIND v(dout1_5) AT=315.025n

* CHECK dout1_6 Vdout1_6ck62 = 0 time = 315
.meas tran vdout1_6ck62 FIND v(dout1_6) AT=315.025n

* CHECK dout1_7 Vdout1_7ck62 = 0 time = 315
.meas tran vdout1_7ck62 FIND v(dout1_7) AT=315.025n

* CHECK dout1_8 Vdout1_8ck62 = 0 time = 315
.meas tran vdout1_8ck62 FIND v(dout1_8) AT=315.025n

* CHECK dout1_9 Vdout1_9ck62 = 0.9 time = 315
.meas tran vdout1_9ck62 FIND v(dout1_9) AT=315.025n

* CHECK dout1_10 Vdout1_10ck62 = 0 time = 315
.meas tran vdout1_10ck62 FIND v(dout1_10) AT=315.025n

* CHECK dout1_11 Vdout1_11ck62 = 0.9 time = 315
.meas tran vdout1_11ck62 FIND v(dout1_11) AT=315.025n

* CHECK dout1_12 Vdout1_12ck62 = 0.9 time = 315
.meas tran vdout1_12ck62 FIND v(dout1_12) AT=315.025n

* CHECK dout1_13 Vdout1_13ck62 = 0.9 time = 315
.meas tran vdout1_13ck62 FIND v(dout1_13) AT=315.025n

* CHECK dout1_14 Vdout1_14ck62 = 0 time = 315
.meas tran vdout1_14ck62 FIND v(dout1_14) AT=315.025n

* CHECK dout1_15 Vdout1_15ck62 = 0.9 time = 315
.meas tran vdout1_15ck62 FIND v(dout1_15) AT=315.025n

* CHECK dout1_16 Vdout1_16ck62 = 0.9 time = 315
.meas tran vdout1_16ck62 FIND v(dout1_16) AT=315.025n

* CHECK dout1_17 Vdout1_17ck62 = 0.9 time = 315
.meas tran vdout1_17ck62 FIND v(dout1_17) AT=315.025n

* CHECK dout1_18 Vdout1_18ck62 = 0 time = 315
.meas tran vdout1_18ck62 FIND v(dout1_18) AT=315.025n

* CHECK dout1_19 Vdout1_19ck62 = 0 time = 315
.meas tran vdout1_19ck62 FIND v(dout1_19) AT=315.025n

* CHECK dout1_20 Vdout1_20ck62 = 0 time = 315
.meas tran vdout1_20ck62 FIND v(dout1_20) AT=315.025n

* CHECK dout1_21 Vdout1_21ck62 = 0 time = 315
.meas tran vdout1_21ck62 FIND v(dout1_21) AT=315.025n

* CHECK dout1_22 Vdout1_22ck62 = 0.9 time = 315
.meas tran vdout1_22ck62 FIND v(dout1_22) AT=315.025n

* CHECK dout1_23 Vdout1_23ck62 = 0 time = 315
.meas tran vdout1_23ck62 FIND v(dout1_23) AT=315.025n

* CHECK dout1_24 Vdout1_24ck62 = 0.9 time = 315
.meas tran vdout1_24ck62 FIND v(dout1_24) AT=315.025n

* CHECK dout1_25 Vdout1_25ck62 = 0 time = 315
.meas tran vdout1_25ck62 FIND v(dout1_25) AT=315.025n

* CHECK dout1_26 Vdout1_26ck62 = 0.9 time = 315
.meas tran vdout1_26ck62 FIND v(dout1_26) AT=315.025n

* CHECK dout1_27 Vdout1_27ck62 = 0.9 time = 315
.meas tran vdout1_27ck62 FIND v(dout1_27) AT=315.025n

* CHECK dout1_28 Vdout1_28ck62 = 0.9 time = 315
.meas tran vdout1_28ck62 FIND v(dout1_28) AT=315.025n

* CHECK dout1_29 Vdout1_29ck62 = 0.9 time = 315
.meas tran vdout1_29ck62 FIND v(dout1_29) AT=315.025n

* CHECK dout1_30 Vdout1_30ck62 = 0 time = 315
.meas tran vdout1_30ck62 FIND v(dout1_30) AT=315.025n

* CHECK dout1_31 Vdout1_31ck62 = 0.9 time = 315
.meas tran vdout1_31ck62 FIND v(dout1_31) AT=315.025n

* CHECK dout1_32 Vdout1_32ck62 = 0 time = 315
.meas tran vdout1_32ck62 FIND v(dout1_32) AT=315.025n

* CHECK dout1_33 Vdout1_33ck62 = 0.9 time = 315
.meas tran vdout1_33ck62 FIND v(dout1_33) AT=315.025n

* CHECK dout1_34 Vdout1_34ck62 = 0.9 time = 315
.meas tran vdout1_34ck62 FIND v(dout1_34) AT=315.025n

* CHECK dout1_35 Vdout1_35ck62 = 0.9 time = 315
.meas tran vdout1_35ck62 FIND v(dout1_35) AT=315.025n

* CHECK dout1_36 Vdout1_36ck62 = 0.9 time = 315
.meas tran vdout1_36ck62 FIND v(dout1_36) AT=315.025n

* CHECK dout1_37 Vdout1_37ck62 = 0.9 time = 315
.meas tran vdout1_37ck62 FIND v(dout1_37) AT=315.025n

* CHECK dout1_38 Vdout1_38ck62 = 0 time = 315
.meas tran vdout1_38ck62 FIND v(dout1_38) AT=315.025n

* CHECK dout1_39 Vdout1_39ck62 = 0 time = 315
.meas tran vdout1_39ck62 FIND v(dout1_39) AT=315.025n

* CHECK dout1_40 Vdout1_40ck62 = 0.9 time = 315
.meas tran vdout1_40ck62 FIND v(dout1_40) AT=315.025n

* CHECK dout1_41 Vdout1_41ck62 = 0 time = 315
.meas tran vdout1_41ck62 FIND v(dout1_41) AT=315.025n

* CHECK dout1_42 Vdout1_42ck62 = 0.9 time = 315
.meas tran vdout1_42ck62 FIND v(dout1_42) AT=315.025n

* CHECK dout1_43 Vdout1_43ck62 = 0 time = 315
.meas tran vdout1_43ck62 FIND v(dout1_43) AT=315.025n

* CHECK dout1_44 Vdout1_44ck62 = 0 time = 315
.meas tran vdout1_44ck62 FIND v(dout1_44) AT=315.025n

* CHECK dout1_45 Vdout1_45ck62 = 0.9 time = 315
.meas tran vdout1_45ck62 FIND v(dout1_45) AT=315.025n

* CHECK dout1_46 Vdout1_46ck62 = 0 time = 315
.meas tran vdout1_46ck62 FIND v(dout1_46) AT=315.025n

* CHECK dout1_47 Vdout1_47ck62 = 0.9 time = 315
.meas tran vdout1_47ck62 FIND v(dout1_47) AT=315.025n

* CHECK dout1_48 Vdout1_48ck62 = 0 time = 315
.meas tran vdout1_48ck62 FIND v(dout1_48) AT=315.025n

* CHECK dout1_49 Vdout1_49ck62 = 0.9 time = 315
.meas tran vdout1_49ck62 FIND v(dout1_49) AT=315.025n

* CHECK dout1_50 Vdout1_50ck62 = 0 time = 315
.meas tran vdout1_50ck62 FIND v(dout1_50) AT=315.025n

* CHECK dout1_51 Vdout1_51ck62 = 0 time = 315
.meas tran vdout1_51ck62 FIND v(dout1_51) AT=315.025n

* CHECK dout1_52 Vdout1_52ck62 = 0.9 time = 315
.meas tran vdout1_52ck62 FIND v(dout1_52) AT=315.025n

* CHECK dout1_53 Vdout1_53ck62 = 0 time = 315
.meas tran vdout1_53ck62 FIND v(dout1_53) AT=315.025n

* CHECK dout1_54 Vdout1_54ck62 = 0.9 time = 315
.meas tran vdout1_54ck62 FIND v(dout1_54) AT=315.025n

* CHECK dout1_55 Vdout1_55ck62 = 0 time = 315
.meas tran vdout1_55ck62 FIND v(dout1_55) AT=315.025n

* CHECK dout1_0 Vdout1_0ck63 = 0 time = 320
.meas tran vdout1_0ck63 FIND v(dout1_0) AT=320.025n

* CHECK dout1_1 Vdout1_1ck63 = 0.9 time = 320
.meas tran vdout1_1ck63 FIND v(dout1_1) AT=320.025n

* CHECK dout1_2 Vdout1_2ck63 = 0.9 time = 320
.meas tran vdout1_2ck63 FIND v(dout1_2) AT=320.025n

* CHECK dout1_3 Vdout1_3ck63 = 0 time = 320
.meas tran vdout1_3ck63 FIND v(dout1_3) AT=320.025n

* CHECK dout1_4 Vdout1_4ck63 = 0.9 time = 320
.meas tran vdout1_4ck63 FIND v(dout1_4) AT=320.025n

* CHECK dout1_5 Vdout1_5ck63 = 0.9 time = 320
.meas tran vdout1_5ck63 FIND v(dout1_5) AT=320.025n

* CHECK dout1_6 Vdout1_6ck63 = 0.9 time = 320
.meas tran vdout1_6ck63 FIND v(dout1_6) AT=320.025n

* CHECK dout1_7 Vdout1_7ck63 = 0.9 time = 320
.meas tran vdout1_7ck63 FIND v(dout1_7) AT=320.025n

* CHECK dout1_8 Vdout1_8ck63 = 0 time = 320
.meas tran vdout1_8ck63 FIND v(dout1_8) AT=320.025n

* CHECK dout1_9 Vdout1_9ck63 = 0 time = 320
.meas tran vdout1_9ck63 FIND v(dout1_9) AT=320.025n

* CHECK dout1_10 Vdout1_10ck63 = 0.9 time = 320
.meas tran vdout1_10ck63 FIND v(dout1_10) AT=320.025n

* CHECK dout1_11 Vdout1_11ck63 = 0 time = 320
.meas tran vdout1_11ck63 FIND v(dout1_11) AT=320.025n

* CHECK dout1_12 Vdout1_12ck63 = 0.9 time = 320
.meas tran vdout1_12ck63 FIND v(dout1_12) AT=320.025n

* CHECK dout1_13 Vdout1_13ck63 = 0.9 time = 320
.meas tran vdout1_13ck63 FIND v(dout1_13) AT=320.025n

* CHECK dout1_14 Vdout1_14ck63 = 0 time = 320
.meas tran vdout1_14ck63 FIND v(dout1_14) AT=320.025n

* CHECK dout1_15 Vdout1_15ck63 = 0 time = 320
.meas tran vdout1_15ck63 FIND v(dout1_15) AT=320.025n

* CHECK dout1_16 Vdout1_16ck63 = 0 time = 320
.meas tran vdout1_16ck63 FIND v(dout1_16) AT=320.025n

* CHECK dout1_17 Vdout1_17ck63 = 0.9 time = 320
.meas tran vdout1_17ck63 FIND v(dout1_17) AT=320.025n

* CHECK dout1_18 Vdout1_18ck63 = 0 time = 320
.meas tran vdout1_18ck63 FIND v(dout1_18) AT=320.025n

* CHECK dout1_19 Vdout1_19ck63 = 0.9 time = 320
.meas tran vdout1_19ck63 FIND v(dout1_19) AT=320.025n

* CHECK dout1_20 Vdout1_20ck63 = 0 time = 320
.meas tran vdout1_20ck63 FIND v(dout1_20) AT=320.025n

* CHECK dout1_21 Vdout1_21ck63 = 0.9 time = 320
.meas tran vdout1_21ck63 FIND v(dout1_21) AT=320.025n

* CHECK dout1_22 Vdout1_22ck63 = 0 time = 320
.meas tran vdout1_22ck63 FIND v(dout1_22) AT=320.025n

* CHECK dout1_23 Vdout1_23ck63 = 0.9 time = 320
.meas tran vdout1_23ck63 FIND v(dout1_23) AT=320.025n

* CHECK dout1_24 Vdout1_24ck63 = 0 time = 320
.meas tran vdout1_24ck63 FIND v(dout1_24) AT=320.025n

* CHECK dout1_25 Vdout1_25ck63 = 0.9 time = 320
.meas tran vdout1_25ck63 FIND v(dout1_25) AT=320.025n

* CHECK dout1_26 Vdout1_26ck63 = 0 time = 320
.meas tran vdout1_26ck63 FIND v(dout1_26) AT=320.025n

* CHECK dout1_27 Vdout1_27ck63 = 0.9 time = 320
.meas tran vdout1_27ck63 FIND v(dout1_27) AT=320.025n

* CHECK dout1_28 Vdout1_28ck63 = 0 time = 320
.meas tran vdout1_28ck63 FIND v(dout1_28) AT=320.025n

* CHECK dout1_29 Vdout1_29ck63 = 0.9 time = 320
.meas tran vdout1_29ck63 FIND v(dout1_29) AT=320.025n

* CHECK dout1_30 Vdout1_30ck63 = 0.9 time = 320
.meas tran vdout1_30ck63 FIND v(dout1_30) AT=320.025n

* CHECK dout1_31 Vdout1_31ck63 = 0.9 time = 320
.meas tran vdout1_31ck63 FIND v(dout1_31) AT=320.025n

* CHECK dout1_32 Vdout1_32ck63 = 0.9 time = 320
.meas tran vdout1_32ck63 FIND v(dout1_32) AT=320.025n

* CHECK dout1_33 Vdout1_33ck63 = 0.9 time = 320
.meas tran vdout1_33ck63 FIND v(dout1_33) AT=320.025n

* CHECK dout1_34 Vdout1_34ck63 = 0.9 time = 320
.meas tran vdout1_34ck63 FIND v(dout1_34) AT=320.025n

* CHECK dout1_35 Vdout1_35ck63 = 0.9 time = 320
.meas tran vdout1_35ck63 FIND v(dout1_35) AT=320.025n

* CHECK dout1_36 Vdout1_36ck63 = 0.9 time = 320
.meas tran vdout1_36ck63 FIND v(dout1_36) AT=320.025n

* CHECK dout1_37 Vdout1_37ck63 = 0.9 time = 320
.meas tran vdout1_37ck63 FIND v(dout1_37) AT=320.025n

* CHECK dout1_38 Vdout1_38ck63 = 0.9 time = 320
.meas tran vdout1_38ck63 FIND v(dout1_38) AT=320.025n

* CHECK dout1_39 Vdout1_39ck63 = 0.9 time = 320
.meas tran vdout1_39ck63 FIND v(dout1_39) AT=320.025n

* CHECK dout1_40 Vdout1_40ck63 = 0 time = 320
.meas tran vdout1_40ck63 FIND v(dout1_40) AT=320.025n

* CHECK dout1_41 Vdout1_41ck63 = 0 time = 320
.meas tran vdout1_41ck63 FIND v(dout1_41) AT=320.025n

* CHECK dout1_42 Vdout1_42ck63 = 0.9 time = 320
.meas tran vdout1_42ck63 FIND v(dout1_42) AT=320.025n

* CHECK dout1_43 Vdout1_43ck63 = 0 time = 320
.meas tran vdout1_43ck63 FIND v(dout1_43) AT=320.025n

* CHECK dout1_44 Vdout1_44ck63 = 0 time = 320
.meas tran vdout1_44ck63 FIND v(dout1_44) AT=320.025n

* CHECK dout1_45 Vdout1_45ck63 = 0.9 time = 320
.meas tran vdout1_45ck63 FIND v(dout1_45) AT=320.025n

* CHECK dout1_46 Vdout1_46ck63 = 0.9 time = 320
.meas tran vdout1_46ck63 FIND v(dout1_46) AT=320.025n

* CHECK dout1_47 Vdout1_47ck63 = 0.9 time = 320
.meas tran vdout1_47ck63 FIND v(dout1_47) AT=320.025n

* CHECK dout1_48 Vdout1_48ck63 = 0.9 time = 320
.meas tran vdout1_48ck63 FIND v(dout1_48) AT=320.025n

* CHECK dout1_49 Vdout1_49ck63 = 0.9 time = 320
.meas tran vdout1_49ck63 FIND v(dout1_49) AT=320.025n

* CHECK dout1_50 Vdout1_50ck63 = 0.9 time = 320
.meas tran vdout1_50ck63 FIND v(dout1_50) AT=320.025n

* CHECK dout1_51 Vdout1_51ck63 = 0 time = 320
.meas tran vdout1_51ck63 FIND v(dout1_51) AT=320.025n

* CHECK dout1_52 Vdout1_52ck63 = 0 time = 320
.meas tran vdout1_52ck63 FIND v(dout1_52) AT=320.025n

* CHECK dout1_53 Vdout1_53ck63 = 0 time = 320
.meas tran vdout1_53ck63 FIND v(dout1_53) AT=320.025n

* CHECK dout1_54 Vdout1_54ck63 = 0.9 time = 320
.meas tran vdout1_54ck63 FIND v(dout1_54) AT=320.025n

* CHECK dout1_55 Vdout1_55ck63 = 0 time = 320
.meas tran vdout1_55ck63 FIND v(dout1_55) AT=320.025n

* CHECK dout1_0 Vdout1_0ck64 = 0 time = 325
.meas tran vdout1_0ck64 FIND v(dout1_0) AT=325.025n

* CHECK dout1_1 Vdout1_1ck64 = 0 time = 325
.meas tran vdout1_1ck64 FIND v(dout1_1) AT=325.025n

* CHECK dout1_2 Vdout1_2ck64 = 0.9 time = 325
.meas tran vdout1_2ck64 FIND v(dout1_2) AT=325.025n

* CHECK dout1_3 Vdout1_3ck64 = 0 time = 325
.meas tran vdout1_3ck64 FIND v(dout1_3) AT=325.025n

* CHECK dout1_4 Vdout1_4ck64 = 0 time = 325
.meas tran vdout1_4ck64 FIND v(dout1_4) AT=325.025n

* CHECK dout1_5 Vdout1_5ck64 = 0 time = 325
.meas tran vdout1_5ck64 FIND v(dout1_5) AT=325.025n

* CHECK dout1_6 Vdout1_6ck64 = 0.9 time = 325
.meas tran vdout1_6ck64 FIND v(dout1_6) AT=325.025n

* CHECK dout1_7 Vdout1_7ck64 = 0.9 time = 325
.meas tran vdout1_7ck64 FIND v(dout1_7) AT=325.025n

* CHECK dout1_8 Vdout1_8ck64 = 0.9 time = 325
.meas tran vdout1_8ck64 FIND v(dout1_8) AT=325.025n

* CHECK dout1_9 Vdout1_9ck64 = 0.9 time = 325
.meas tran vdout1_9ck64 FIND v(dout1_9) AT=325.025n

* CHECK dout1_10 Vdout1_10ck64 = 0 time = 325
.meas tran vdout1_10ck64 FIND v(dout1_10) AT=325.025n

* CHECK dout1_11 Vdout1_11ck64 = 0.9 time = 325
.meas tran vdout1_11ck64 FIND v(dout1_11) AT=325.025n

* CHECK dout1_12 Vdout1_12ck64 = 0 time = 325
.meas tran vdout1_12ck64 FIND v(dout1_12) AT=325.025n

* CHECK dout1_13 Vdout1_13ck64 = 0 time = 325
.meas tran vdout1_13ck64 FIND v(dout1_13) AT=325.025n

* CHECK dout1_14 Vdout1_14ck64 = 0.9 time = 325
.meas tran vdout1_14ck64 FIND v(dout1_14) AT=325.025n

* CHECK dout1_15 Vdout1_15ck64 = 0.9 time = 325
.meas tran vdout1_15ck64 FIND v(dout1_15) AT=325.025n

* CHECK dout1_16 Vdout1_16ck64 = 0 time = 325
.meas tran vdout1_16ck64 FIND v(dout1_16) AT=325.025n

* CHECK dout1_17 Vdout1_17ck64 = 0 time = 325
.meas tran vdout1_17ck64 FIND v(dout1_17) AT=325.025n

* CHECK dout1_18 Vdout1_18ck64 = 0.9 time = 325
.meas tran vdout1_18ck64 FIND v(dout1_18) AT=325.025n

* CHECK dout1_19 Vdout1_19ck64 = 0 time = 325
.meas tran vdout1_19ck64 FIND v(dout1_19) AT=325.025n

* CHECK dout1_20 Vdout1_20ck64 = 0 time = 325
.meas tran vdout1_20ck64 FIND v(dout1_20) AT=325.025n

* CHECK dout1_21 Vdout1_21ck64 = 0 time = 325
.meas tran vdout1_21ck64 FIND v(dout1_21) AT=325.025n

* CHECK dout1_22 Vdout1_22ck64 = 0.9 time = 325
.meas tran vdout1_22ck64 FIND v(dout1_22) AT=325.025n

* CHECK dout1_23 Vdout1_23ck64 = 0 time = 325
.meas tran vdout1_23ck64 FIND v(dout1_23) AT=325.025n

* CHECK dout1_24 Vdout1_24ck64 = 0.9 time = 325
.meas tran vdout1_24ck64 FIND v(dout1_24) AT=325.025n

* CHECK dout1_25 Vdout1_25ck64 = 0.9 time = 325
.meas tran vdout1_25ck64 FIND v(dout1_25) AT=325.025n

* CHECK dout1_26 Vdout1_26ck64 = 0.9 time = 325
.meas tran vdout1_26ck64 FIND v(dout1_26) AT=325.025n

* CHECK dout1_27 Vdout1_27ck64 = 0 time = 325
.meas tran vdout1_27ck64 FIND v(dout1_27) AT=325.025n

* CHECK dout1_28 Vdout1_28ck64 = 0 time = 325
.meas tran vdout1_28ck64 FIND v(dout1_28) AT=325.025n

* CHECK dout1_29 Vdout1_29ck64 = 0 time = 325
.meas tran vdout1_29ck64 FIND v(dout1_29) AT=325.025n

* CHECK dout1_30 Vdout1_30ck64 = 0 time = 325
.meas tran vdout1_30ck64 FIND v(dout1_30) AT=325.025n

* CHECK dout1_31 Vdout1_31ck64 = 0.9 time = 325
.meas tran vdout1_31ck64 FIND v(dout1_31) AT=325.025n

* CHECK dout1_32 Vdout1_32ck64 = 0 time = 325
.meas tran vdout1_32ck64 FIND v(dout1_32) AT=325.025n

* CHECK dout1_33 Vdout1_33ck64 = 0.9 time = 325
.meas tran vdout1_33ck64 FIND v(dout1_33) AT=325.025n

* CHECK dout1_34 Vdout1_34ck64 = 0.9 time = 325
.meas tran vdout1_34ck64 FIND v(dout1_34) AT=325.025n

* CHECK dout1_35 Vdout1_35ck64 = 0 time = 325
.meas tran vdout1_35ck64 FIND v(dout1_35) AT=325.025n

* CHECK dout1_36 Vdout1_36ck64 = 0.9 time = 325
.meas tran vdout1_36ck64 FIND v(dout1_36) AT=325.025n

* CHECK dout1_37 Vdout1_37ck64 = 0 time = 325
.meas tran vdout1_37ck64 FIND v(dout1_37) AT=325.025n

* CHECK dout1_38 Vdout1_38ck64 = 0.9 time = 325
.meas tran vdout1_38ck64 FIND v(dout1_38) AT=325.025n

* CHECK dout1_39 Vdout1_39ck64 = 0.9 time = 325
.meas tran vdout1_39ck64 FIND v(dout1_39) AT=325.025n

* CHECK dout1_40 Vdout1_40ck64 = 0.9 time = 325
.meas tran vdout1_40ck64 FIND v(dout1_40) AT=325.025n

* CHECK dout1_41 Vdout1_41ck64 = 0.9 time = 325
.meas tran vdout1_41ck64 FIND v(dout1_41) AT=325.025n

* CHECK dout1_42 Vdout1_42ck64 = 0.9 time = 325
.meas tran vdout1_42ck64 FIND v(dout1_42) AT=325.025n

* CHECK dout1_43 Vdout1_43ck64 = 0 time = 325
.meas tran vdout1_43ck64 FIND v(dout1_43) AT=325.025n

* CHECK dout1_44 Vdout1_44ck64 = 0.9 time = 325
.meas tran vdout1_44ck64 FIND v(dout1_44) AT=325.025n

* CHECK dout1_45 Vdout1_45ck64 = 0.9 time = 325
.meas tran vdout1_45ck64 FIND v(dout1_45) AT=325.025n

* CHECK dout1_46 Vdout1_46ck64 = 0 time = 325
.meas tran vdout1_46ck64 FIND v(dout1_46) AT=325.025n

* CHECK dout1_47 Vdout1_47ck64 = 0 time = 325
.meas tran vdout1_47ck64 FIND v(dout1_47) AT=325.025n

* CHECK dout1_48 Vdout1_48ck64 = 0.9 time = 325
.meas tran vdout1_48ck64 FIND v(dout1_48) AT=325.025n

* CHECK dout1_49 Vdout1_49ck64 = 0.9 time = 325
.meas tran vdout1_49ck64 FIND v(dout1_49) AT=325.025n

* CHECK dout1_50 Vdout1_50ck64 = 0.9 time = 325
.meas tran vdout1_50ck64 FIND v(dout1_50) AT=325.025n

* CHECK dout1_51 Vdout1_51ck64 = 0 time = 325
.meas tran vdout1_51ck64 FIND v(dout1_51) AT=325.025n

* CHECK dout1_52 Vdout1_52ck64 = 0 time = 325
.meas tran vdout1_52ck64 FIND v(dout1_52) AT=325.025n

* CHECK dout1_53 Vdout1_53ck64 = 0.9 time = 325
.meas tran vdout1_53ck64 FIND v(dout1_53) AT=325.025n

* CHECK dout1_54 Vdout1_54ck64 = 0.9 time = 325
.meas tran vdout1_54ck64 FIND v(dout1_54) AT=325.025n

* CHECK dout1_55 Vdout1_55ck64 = 0 time = 325
.meas tran vdout1_55ck64 FIND v(dout1_55) AT=325.025n

* CHECK dout1_0 Vdout1_0ck65 = 0 time = 330
.meas tran vdout1_0ck65 FIND v(dout1_0) AT=330.025n

* CHECK dout1_1 Vdout1_1ck65 = 0.9 time = 330
.meas tran vdout1_1ck65 FIND v(dout1_1) AT=330.025n

* CHECK dout1_2 Vdout1_2ck65 = 0.9 time = 330
.meas tran vdout1_2ck65 FIND v(dout1_2) AT=330.025n

* CHECK dout1_3 Vdout1_3ck65 = 0 time = 330
.meas tran vdout1_3ck65 FIND v(dout1_3) AT=330.025n

* CHECK dout1_4 Vdout1_4ck65 = 0.9 time = 330
.meas tran vdout1_4ck65 FIND v(dout1_4) AT=330.025n

* CHECK dout1_5 Vdout1_5ck65 = 0.9 time = 330
.meas tran vdout1_5ck65 FIND v(dout1_5) AT=330.025n

* CHECK dout1_6 Vdout1_6ck65 = 0.9 time = 330
.meas tran vdout1_6ck65 FIND v(dout1_6) AT=330.025n

* CHECK dout1_7 Vdout1_7ck65 = 0.9 time = 330
.meas tran vdout1_7ck65 FIND v(dout1_7) AT=330.025n

* CHECK dout1_8 Vdout1_8ck65 = 0 time = 330
.meas tran vdout1_8ck65 FIND v(dout1_8) AT=330.025n

* CHECK dout1_9 Vdout1_9ck65 = 0 time = 330
.meas tran vdout1_9ck65 FIND v(dout1_9) AT=330.025n

* CHECK dout1_10 Vdout1_10ck65 = 0.9 time = 330
.meas tran vdout1_10ck65 FIND v(dout1_10) AT=330.025n

* CHECK dout1_11 Vdout1_11ck65 = 0 time = 330
.meas tran vdout1_11ck65 FIND v(dout1_11) AT=330.025n

* CHECK dout1_12 Vdout1_12ck65 = 0.9 time = 330
.meas tran vdout1_12ck65 FIND v(dout1_12) AT=330.025n

* CHECK dout1_13 Vdout1_13ck65 = 0.9 time = 330
.meas tran vdout1_13ck65 FIND v(dout1_13) AT=330.025n

* CHECK dout1_14 Vdout1_14ck65 = 0 time = 330
.meas tran vdout1_14ck65 FIND v(dout1_14) AT=330.025n

* CHECK dout1_15 Vdout1_15ck65 = 0 time = 330
.meas tran vdout1_15ck65 FIND v(dout1_15) AT=330.025n

* CHECK dout1_16 Vdout1_16ck65 = 0 time = 330
.meas tran vdout1_16ck65 FIND v(dout1_16) AT=330.025n

* CHECK dout1_17 Vdout1_17ck65 = 0.9 time = 330
.meas tran vdout1_17ck65 FIND v(dout1_17) AT=330.025n

* CHECK dout1_18 Vdout1_18ck65 = 0 time = 330
.meas tran vdout1_18ck65 FIND v(dout1_18) AT=330.025n

* CHECK dout1_19 Vdout1_19ck65 = 0.9 time = 330
.meas tran vdout1_19ck65 FIND v(dout1_19) AT=330.025n

* CHECK dout1_20 Vdout1_20ck65 = 0 time = 330
.meas tran vdout1_20ck65 FIND v(dout1_20) AT=330.025n

* CHECK dout1_21 Vdout1_21ck65 = 0.9 time = 330
.meas tran vdout1_21ck65 FIND v(dout1_21) AT=330.025n

* CHECK dout1_22 Vdout1_22ck65 = 0 time = 330
.meas tran vdout1_22ck65 FIND v(dout1_22) AT=330.025n

* CHECK dout1_23 Vdout1_23ck65 = 0.9 time = 330
.meas tran vdout1_23ck65 FIND v(dout1_23) AT=330.025n

* CHECK dout1_24 Vdout1_24ck65 = 0 time = 330
.meas tran vdout1_24ck65 FIND v(dout1_24) AT=330.025n

* CHECK dout1_25 Vdout1_25ck65 = 0.9 time = 330
.meas tran vdout1_25ck65 FIND v(dout1_25) AT=330.025n

* CHECK dout1_26 Vdout1_26ck65 = 0 time = 330
.meas tran vdout1_26ck65 FIND v(dout1_26) AT=330.025n

* CHECK dout1_27 Vdout1_27ck65 = 0.9 time = 330
.meas tran vdout1_27ck65 FIND v(dout1_27) AT=330.025n

* CHECK dout1_28 Vdout1_28ck65 = 0 time = 330
.meas tran vdout1_28ck65 FIND v(dout1_28) AT=330.025n

* CHECK dout1_29 Vdout1_29ck65 = 0.9 time = 330
.meas tran vdout1_29ck65 FIND v(dout1_29) AT=330.025n

* CHECK dout1_30 Vdout1_30ck65 = 0.9 time = 330
.meas tran vdout1_30ck65 FIND v(dout1_30) AT=330.025n

* CHECK dout1_31 Vdout1_31ck65 = 0.9 time = 330
.meas tran vdout1_31ck65 FIND v(dout1_31) AT=330.025n

* CHECK dout1_32 Vdout1_32ck65 = 0.9 time = 330
.meas tran vdout1_32ck65 FIND v(dout1_32) AT=330.025n

* CHECK dout1_33 Vdout1_33ck65 = 0.9 time = 330
.meas tran vdout1_33ck65 FIND v(dout1_33) AT=330.025n

* CHECK dout1_34 Vdout1_34ck65 = 0.9 time = 330
.meas tran vdout1_34ck65 FIND v(dout1_34) AT=330.025n

* CHECK dout1_35 Vdout1_35ck65 = 0.9 time = 330
.meas tran vdout1_35ck65 FIND v(dout1_35) AT=330.025n

* CHECK dout1_36 Vdout1_36ck65 = 0.9 time = 330
.meas tran vdout1_36ck65 FIND v(dout1_36) AT=330.025n

* CHECK dout1_37 Vdout1_37ck65 = 0.9 time = 330
.meas tran vdout1_37ck65 FIND v(dout1_37) AT=330.025n

* CHECK dout1_38 Vdout1_38ck65 = 0.9 time = 330
.meas tran vdout1_38ck65 FIND v(dout1_38) AT=330.025n

* CHECK dout1_39 Vdout1_39ck65 = 0.9 time = 330
.meas tran vdout1_39ck65 FIND v(dout1_39) AT=330.025n

* CHECK dout1_40 Vdout1_40ck65 = 0 time = 330
.meas tran vdout1_40ck65 FIND v(dout1_40) AT=330.025n

* CHECK dout1_41 Vdout1_41ck65 = 0 time = 330
.meas tran vdout1_41ck65 FIND v(dout1_41) AT=330.025n

* CHECK dout1_42 Vdout1_42ck65 = 0.9 time = 330
.meas tran vdout1_42ck65 FIND v(dout1_42) AT=330.025n

* CHECK dout1_43 Vdout1_43ck65 = 0 time = 330
.meas tran vdout1_43ck65 FIND v(dout1_43) AT=330.025n

* CHECK dout1_44 Vdout1_44ck65 = 0 time = 330
.meas tran vdout1_44ck65 FIND v(dout1_44) AT=330.025n

* CHECK dout1_45 Vdout1_45ck65 = 0.9 time = 330
.meas tran vdout1_45ck65 FIND v(dout1_45) AT=330.025n

* CHECK dout1_46 Vdout1_46ck65 = 0.9 time = 330
.meas tran vdout1_46ck65 FIND v(dout1_46) AT=330.025n

* CHECK dout1_47 Vdout1_47ck65 = 0.9 time = 330
.meas tran vdout1_47ck65 FIND v(dout1_47) AT=330.025n

* CHECK dout1_48 Vdout1_48ck65 = 0.9 time = 330
.meas tran vdout1_48ck65 FIND v(dout1_48) AT=330.025n

* CHECK dout1_49 Vdout1_49ck65 = 0.9 time = 330
.meas tran vdout1_49ck65 FIND v(dout1_49) AT=330.025n

* CHECK dout1_50 Vdout1_50ck65 = 0.9 time = 330
.meas tran vdout1_50ck65 FIND v(dout1_50) AT=330.025n

* CHECK dout1_51 Vdout1_51ck65 = 0 time = 330
.meas tran vdout1_51ck65 FIND v(dout1_51) AT=330.025n

* CHECK dout1_52 Vdout1_52ck65 = 0 time = 330
.meas tran vdout1_52ck65 FIND v(dout1_52) AT=330.025n

* CHECK dout1_53 Vdout1_53ck65 = 0 time = 330
.meas tran vdout1_53ck65 FIND v(dout1_53) AT=330.025n

* CHECK dout1_54 Vdout1_54ck65 = 0.9 time = 330
.meas tran vdout1_54ck65 FIND v(dout1_54) AT=330.025n

* CHECK dout1_55 Vdout1_55ck65 = 0 time = 330
.meas tran vdout1_55ck65 FIND v(dout1_55) AT=330.025n

* CHECK dout1_0 Vdout1_0ck73 = 0 time = 370
.meas tran vdout1_0ck73 FIND v(dout1_0) AT=370.025n

* CHECK dout1_1 Vdout1_1ck73 = 0.9 time = 370
.meas tran vdout1_1ck73 FIND v(dout1_1) AT=370.025n

* CHECK dout1_2 Vdout1_2ck73 = 0.9 time = 370
.meas tran vdout1_2ck73 FIND v(dout1_2) AT=370.025n

* CHECK dout1_3 Vdout1_3ck73 = 0 time = 370
.meas tran vdout1_3ck73 FIND v(dout1_3) AT=370.025n

* CHECK dout1_4 Vdout1_4ck73 = 0 time = 370
.meas tran vdout1_4ck73 FIND v(dout1_4) AT=370.025n

* CHECK dout1_5 Vdout1_5ck73 = 0.9 time = 370
.meas tran vdout1_5ck73 FIND v(dout1_5) AT=370.025n

* CHECK dout1_6 Vdout1_6ck73 = 0 time = 370
.meas tran vdout1_6ck73 FIND v(dout1_6) AT=370.025n

* CHECK dout1_7 Vdout1_7ck73 = 0 time = 370
.meas tran vdout1_7ck73 FIND v(dout1_7) AT=370.025n

* CHECK dout1_8 Vdout1_8ck73 = 0.9 time = 370
.meas tran vdout1_8ck73 FIND v(dout1_8) AT=370.025n

* CHECK dout1_9 Vdout1_9ck73 = 0 time = 370
.meas tran vdout1_9ck73 FIND v(dout1_9) AT=370.025n

* CHECK dout1_10 Vdout1_10ck73 = 0.9 time = 370
.meas tran vdout1_10ck73 FIND v(dout1_10) AT=370.025n

* CHECK dout1_11 Vdout1_11ck73 = 0.9 time = 370
.meas tran vdout1_11ck73 FIND v(dout1_11) AT=370.025n

* CHECK dout1_12 Vdout1_12ck73 = 0 time = 370
.meas tran vdout1_12ck73 FIND v(dout1_12) AT=370.025n

* CHECK dout1_13 Vdout1_13ck73 = 0.9 time = 370
.meas tran vdout1_13ck73 FIND v(dout1_13) AT=370.025n

* CHECK dout1_14 Vdout1_14ck73 = 0 time = 370
.meas tran vdout1_14ck73 FIND v(dout1_14) AT=370.025n

* CHECK dout1_15 Vdout1_15ck73 = 0.9 time = 370
.meas tran vdout1_15ck73 FIND v(dout1_15) AT=370.025n

* CHECK dout1_16 Vdout1_16ck73 = 0 time = 370
.meas tran vdout1_16ck73 FIND v(dout1_16) AT=370.025n

* CHECK dout1_17 Vdout1_17ck73 = 0 time = 370
.meas tran vdout1_17ck73 FIND v(dout1_17) AT=370.025n

* CHECK dout1_18 Vdout1_18ck73 = 0 time = 370
.meas tran vdout1_18ck73 FIND v(dout1_18) AT=370.025n

* CHECK dout1_19 Vdout1_19ck73 = 0.9 time = 370
.meas tran vdout1_19ck73 FIND v(dout1_19) AT=370.025n

* CHECK dout1_20 Vdout1_20ck73 = 0 time = 370
.meas tran vdout1_20ck73 FIND v(dout1_20) AT=370.025n

* CHECK dout1_21 Vdout1_21ck73 = 0.9 time = 370
.meas tran vdout1_21ck73 FIND v(dout1_21) AT=370.025n

* CHECK dout1_22 Vdout1_22ck73 = 0.9 time = 370
.meas tran vdout1_22ck73 FIND v(dout1_22) AT=370.025n

* CHECK dout1_23 Vdout1_23ck73 = 0 time = 370
.meas tran vdout1_23ck73 FIND v(dout1_23) AT=370.025n

* CHECK dout1_24 Vdout1_24ck73 = 0.9 time = 370
.meas tran vdout1_24ck73 FIND v(dout1_24) AT=370.025n

* CHECK dout1_25 Vdout1_25ck73 = 0.9 time = 370
.meas tran vdout1_25ck73 FIND v(dout1_25) AT=370.025n

* CHECK dout1_26 Vdout1_26ck73 = 0.9 time = 370
.meas tran vdout1_26ck73 FIND v(dout1_26) AT=370.025n

* CHECK dout1_27 Vdout1_27ck73 = 0.9 time = 370
.meas tran vdout1_27ck73 FIND v(dout1_27) AT=370.025n

* CHECK dout1_28 Vdout1_28ck73 = 0 time = 370
.meas tran vdout1_28ck73 FIND v(dout1_28) AT=370.025n

* CHECK dout1_29 Vdout1_29ck73 = 0 time = 370
.meas tran vdout1_29ck73 FIND v(dout1_29) AT=370.025n

* CHECK dout1_30 Vdout1_30ck73 = 0.9 time = 370
.meas tran vdout1_30ck73 FIND v(dout1_30) AT=370.025n

* CHECK dout1_31 Vdout1_31ck73 = 0.9 time = 370
.meas tran vdout1_31ck73 FIND v(dout1_31) AT=370.025n

* CHECK dout1_32 Vdout1_32ck73 = 0.9 time = 370
.meas tran vdout1_32ck73 FIND v(dout1_32) AT=370.025n

* CHECK dout1_33 Vdout1_33ck73 = 0 time = 370
.meas tran vdout1_33ck73 FIND v(dout1_33) AT=370.025n

* CHECK dout1_34 Vdout1_34ck73 = 0.9 time = 370
.meas tran vdout1_34ck73 FIND v(dout1_34) AT=370.025n

* CHECK dout1_35 Vdout1_35ck73 = 0.9 time = 370
.meas tran vdout1_35ck73 FIND v(dout1_35) AT=370.025n

* CHECK dout1_36 Vdout1_36ck73 = 0 time = 370
.meas tran vdout1_36ck73 FIND v(dout1_36) AT=370.025n

* CHECK dout1_37 Vdout1_37ck73 = 0 time = 370
.meas tran vdout1_37ck73 FIND v(dout1_37) AT=370.025n

* CHECK dout1_38 Vdout1_38ck73 = 0 time = 370
.meas tran vdout1_38ck73 FIND v(dout1_38) AT=370.025n

* CHECK dout1_39 Vdout1_39ck73 = 0 time = 370
.meas tran vdout1_39ck73 FIND v(dout1_39) AT=370.025n

* CHECK dout1_40 Vdout1_40ck73 = 0.9 time = 370
.meas tran vdout1_40ck73 FIND v(dout1_40) AT=370.025n

* CHECK dout1_41 Vdout1_41ck73 = 0.9 time = 370
.meas tran vdout1_41ck73 FIND v(dout1_41) AT=370.025n

* CHECK dout1_42 Vdout1_42ck73 = 0 time = 370
.meas tran vdout1_42ck73 FIND v(dout1_42) AT=370.025n

* CHECK dout1_43 Vdout1_43ck73 = 0 time = 370
.meas tran vdout1_43ck73 FIND v(dout1_43) AT=370.025n

* CHECK dout1_44 Vdout1_44ck73 = 0 time = 370
.meas tran vdout1_44ck73 FIND v(dout1_44) AT=370.025n

* CHECK dout1_45 Vdout1_45ck73 = 0.9 time = 370
.meas tran vdout1_45ck73 FIND v(dout1_45) AT=370.025n

* CHECK dout1_46 Vdout1_46ck73 = 0.9 time = 370
.meas tran vdout1_46ck73 FIND v(dout1_46) AT=370.025n

* CHECK dout1_47 Vdout1_47ck73 = 0 time = 370
.meas tran vdout1_47ck73 FIND v(dout1_47) AT=370.025n

* CHECK dout1_48 Vdout1_48ck73 = 0.9 time = 370
.meas tran vdout1_48ck73 FIND v(dout1_48) AT=370.025n

* CHECK dout1_49 Vdout1_49ck73 = 0.9 time = 370
.meas tran vdout1_49ck73 FIND v(dout1_49) AT=370.025n

* CHECK dout1_50 Vdout1_50ck73 = 0.9 time = 370
.meas tran vdout1_50ck73 FIND v(dout1_50) AT=370.025n

* CHECK dout1_51 Vdout1_51ck73 = 0.9 time = 370
.meas tran vdout1_51ck73 FIND v(dout1_51) AT=370.025n

* CHECK dout1_52 Vdout1_52ck73 = 0 time = 370
.meas tran vdout1_52ck73 FIND v(dout1_52) AT=370.025n

* CHECK dout1_53 Vdout1_53ck73 = 0.9 time = 370
.meas tran vdout1_53ck73 FIND v(dout1_53) AT=370.025n

* CHECK dout1_54 Vdout1_54ck73 = 0.9 time = 370
.meas tran vdout1_54ck73 FIND v(dout1_54) AT=370.025n

* CHECK dout1_55 Vdout1_55ck73 = 0.9 time = 370
.meas tran vdout1_55ck73 FIND v(dout1_55) AT=370.025n

* CHECK dout1_0 Vdout1_0ck79 = 0.9 time = 400
.meas tran vdout1_0ck79 FIND v(dout1_0) AT=400.025n

* CHECK dout1_1 Vdout1_1ck79 = 0 time = 400
.meas tran vdout1_1ck79 FIND v(dout1_1) AT=400.025n

* CHECK dout1_2 Vdout1_2ck79 = 0 time = 400
.meas tran vdout1_2ck79 FIND v(dout1_2) AT=400.025n

* CHECK dout1_3 Vdout1_3ck79 = 0 time = 400
.meas tran vdout1_3ck79 FIND v(dout1_3) AT=400.025n

* CHECK dout1_4 Vdout1_4ck79 = 0 time = 400
.meas tran vdout1_4ck79 FIND v(dout1_4) AT=400.025n

* CHECK dout1_5 Vdout1_5ck79 = 0 time = 400
.meas tran vdout1_5ck79 FIND v(dout1_5) AT=400.025n

* CHECK dout1_6 Vdout1_6ck79 = 0 time = 400
.meas tran vdout1_6ck79 FIND v(dout1_6) AT=400.025n

* CHECK dout1_7 Vdout1_7ck79 = 0 time = 400
.meas tran vdout1_7ck79 FIND v(dout1_7) AT=400.025n

* CHECK dout1_8 Vdout1_8ck79 = 0.9 time = 400
.meas tran vdout1_8ck79 FIND v(dout1_8) AT=400.025n

* CHECK dout1_9 Vdout1_9ck79 = 0.9 time = 400
.meas tran vdout1_9ck79 FIND v(dout1_9) AT=400.025n

* CHECK dout1_10 Vdout1_10ck79 = 0 time = 400
.meas tran vdout1_10ck79 FIND v(dout1_10) AT=400.025n

* CHECK dout1_11 Vdout1_11ck79 = 0 time = 400
.meas tran vdout1_11ck79 FIND v(dout1_11) AT=400.025n

* CHECK dout1_12 Vdout1_12ck79 = 0.9 time = 400
.meas tran vdout1_12ck79 FIND v(dout1_12) AT=400.025n

* CHECK dout1_13 Vdout1_13ck79 = 0 time = 400
.meas tran vdout1_13ck79 FIND v(dout1_13) AT=400.025n

* CHECK dout1_14 Vdout1_14ck79 = 0 time = 400
.meas tran vdout1_14ck79 FIND v(dout1_14) AT=400.025n

* CHECK dout1_15 Vdout1_15ck79 = 0.9 time = 400
.meas tran vdout1_15ck79 FIND v(dout1_15) AT=400.025n

* CHECK dout1_16 Vdout1_16ck79 = 0 time = 400
.meas tran vdout1_16ck79 FIND v(dout1_16) AT=400.025n

* CHECK dout1_17 Vdout1_17ck79 = 0.9 time = 400
.meas tran vdout1_17ck79 FIND v(dout1_17) AT=400.025n

* CHECK dout1_18 Vdout1_18ck79 = 0 time = 400
.meas tran vdout1_18ck79 FIND v(dout1_18) AT=400.025n

* CHECK dout1_19 Vdout1_19ck79 = 0.9 time = 400
.meas tran vdout1_19ck79 FIND v(dout1_19) AT=400.025n

* CHECK dout1_20 Vdout1_20ck79 = 0.9 time = 400
.meas tran vdout1_20ck79 FIND v(dout1_20) AT=400.025n

* CHECK dout1_21 Vdout1_21ck79 = 0.9 time = 400
.meas tran vdout1_21ck79 FIND v(dout1_21) AT=400.025n

* CHECK dout1_22 Vdout1_22ck79 = 0 time = 400
.meas tran vdout1_22ck79 FIND v(dout1_22) AT=400.025n

* CHECK dout1_23 Vdout1_23ck79 = 0 time = 400
.meas tran vdout1_23ck79 FIND v(dout1_23) AT=400.025n

* CHECK dout1_24 Vdout1_24ck79 = 0.9 time = 400
.meas tran vdout1_24ck79 FIND v(dout1_24) AT=400.025n

* CHECK dout1_25 Vdout1_25ck79 = 0 time = 400
.meas tran vdout1_25ck79 FIND v(dout1_25) AT=400.025n

* CHECK dout1_26 Vdout1_26ck79 = 0.9 time = 400
.meas tran vdout1_26ck79 FIND v(dout1_26) AT=400.025n

* CHECK dout1_27 Vdout1_27ck79 = 0 time = 400
.meas tran vdout1_27ck79 FIND v(dout1_27) AT=400.025n

* CHECK dout1_28 Vdout1_28ck79 = 0 time = 400
.meas tran vdout1_28ck79 FIND v(dout1_28) AT=400.025n

* CHECK dout1_29 Vdout1_29ck79 = 0 time = 400
.meas tran vdout1_29ck79 FIND v(dout1_29) AT=400.025n

* CHECK dout1_30 Vdout1_30ck79 = 0.9 time = 400
.meas tran vdout1_30ck79 FIND v(dout1_30) AT=400.025n

* CHECK dout1_31 Vdout1_31ck79 = 0 time = 400
.meas tran vdout1_31ck79 FIND v(dout1_31) AT=400.025n

* CHECK dout1_32 Vdout1_32ck79 = 0.9 time = 400
.meas tran vdout1_32ck79 FIND v(dout1_32) AT=400.025n

* CHECK dout1_33 Vdout1_33ck79 = 0 time = 400
.meas tran vdout1_33ck79 FIND v(dout1_33) AT=400.025n

* CHECK dout1_34 Vdout1_34ck79 = 0.9 time = 400
.meas tran vdout1_34ck79 FIND v(dout1_34) AT=400.025n

* CHECK dout1_35 Vdout1_35ck79 = 0.9 time = 400
.meas tran vdout1_35ck79 FIND v(dout1_35) AT=400.025n

* CHECK dout1_36 Vdout1_36ck79 = 0 time = 400
.meas tran vdout1_36ck79 FIND v(dout1_36) AT=400.025n

* CHECK dout1_37 Vdout1_37ck79 = 0.9 time = 400
.meas tran vdout1_37ck79 FIND v(dout1_37) AT=400.025n

* CHECK dout1_38 Vdout1_38ck79 = 0.9 time = 400
.meas tran vdout1_38ck79 FIND v(dout1_38) AT=400.025n

* CHECK dout1_39 Vdout1_39ck79 = 0.9 time = 400
.meas tran vdout1_39ck79 FIND v(dout1_39) AT=400.025n

* CHECK dout1_40 Vdout1_40ck79 = 0.9 time = 400
.meas tran vdout1_40ck79 FIND v(dout1_40) AT=400.025n

* CHECK dout1_41 Vdout1_41ck79 = 0 time = 400
.meas tran vdout1_41ck79 FIND v(dout1_41) AT=400.025n

* CHECK dout1_42 Vdout1_42ck79 = 0 time = 400
.meas tran vdout1_42ck79 FIND v(dout1_42) AT=400.025n

* CHECK dout1_43 Vdout1_43ck79 = 0 time = 400
.meas tran vdout1_43ck79 FIND v(dout1_43) AT=400.025n

* CHECK dout1_44 Vdout1_44ck79 = 0.9 time = 400
.meas tran vdout1_44ck79 FIND v(dout1_44) AT=400.025n

* CHECK dout1_45 Vdout1_45ck79 = 0.9 time = 400
.meas tran vdout1_45ck79 FIND v(dout1_45) AT=400.025n

* CHECK dout1_46 Vdout1_46ck79 = 0 time = 400
.meas tran vdout1_46ck79 FIND v(dout1_46) AT=400.025n

* CHECK dout1_47 Vdout1_47ck79 = 0.9 time = 400
.meas tran vdout1_47ck79 FIND v(dout1_47) AT=400.025n

* CHECK dout1_48 Vdout1_48ck79 = 0.9 time = 400
.meas tran vdout1_48ck79 FIND v(dout1_48) AT=400.025n

* CHECK dout1_49 Vdout1_49ck79 = 0.9 time = 400
.meas tran vdout1_49ck79 FIND v(dout1_49) AT=400.025n

* CHECK dout1_50 Vdout1_50ck79 = 0.9 time = 400
.meas tran vdout1_50ck79 FIND v(dout1_50) AT=400.025n

* CHECK dout1_51 Vdout1_51ck79 = 0.9 time = 400
.meas tran vdout1_51ck79 FIND v(dout1_51) AT=400.025n

* CHECK dout1_52 Vdout1_52ck79 = 0 time = 400
.meas tran vdout1_52ck79 FIND v(dout1_52) AT=400.025n

* CHECK dout1_53 Vdout1_53ck79 = 0.9 time = 400
.meas tran vdout1_53ck79 FIND v(dout1_53) AT=400.025n

* CHECK dout1_54 Vdout1_54ck79 = 0 time = 400
.meas tran vdout1_54ck79 FIND v(dout1_54) AT=400.025n

* CHECK dout1_55 Vdout1_55ck79 = 0.9 time = 400
.meas tran vdout1_55ck79 FIND v(dout1_55) AT=400.025n

* CHECK dout1_0 Vdout1_0ck84 = 0.9 time = 425
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=425.025n

* CHECK dout1_1 Vdout1_1ck84 = 0 time = 425
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=425.025n

* CHECK dout1_2 Vdout1_2ck84 = 0 time = 425
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=425.025n

* CHECK dout1_3 Vdout1_3ck84 = 0 time = 425
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=425.025n

* CHECK dout1_4 Vdout1_4ck84 = 0 time = 425
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=425.025n

* CHECK dout1_5 Vdout1_5ck84 = 0 time = 425
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=425.025n

* CHECK dout1_6 Vdout1_6ck84 = 0 time = 425
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=425.025n

* CHECK dout1_7 Vdout1_7ck84 = 0 time = 425
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=425.025n

* CHECK dout1_8 Vdout1_8ck84 = 0.9 time = 425
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=425.025n

* CHECK dout1_9 Vdout1_9ck84 = 0.9 time = 425
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=425.025n

* CHECK dout1_10 Vdout1_10ck84 = 0 time = 425
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=425.025n

* CHECK dout1_11 Vdout1_11ck84 = 0 time = 425
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=425.025n

* CHECK dout1_12 Vdout1_12ck84 = 0.9 time = 425
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=425.025n

* CHECK dout1_13 Vdout1_13ck84 = 0 time = 425
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=425.025n

* CHECK dout1_14 Vdout1_14ck84 = 0 time = 425
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=425.025n

* CHECK dout1_15 Vdout1_15ck84 = 0.9 time = 425
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=425.025n

* CHECK dout1_16 Vdout1_16ck84 = 0 time = 425
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=425.025n

* CHECK dout1_17 Vdout1_17ck84 = 0.9 time = 425
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=425.025n

* CHECK dout1_18 Vdout1_18ck84 = 0 time = 425
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=425.025n

* CHECK dout1_19 Vdout1_19ck84 = 0.9 time = 425
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=425.025n

* CHECK dout1_20 Vdout1_20ck84 = 0.9 time = 425
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=425.025n

* CHECK dout1_21 Vdout1_21ck84 = 0.9 time = 425
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=425.025n

* CHECK dout1_22 Vdout1_22ck84 = 0 time = 425
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=425.025n

* CHECK dout1_23 Vdout1_23ck84 = 0 time = 425
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=425.025n

* CHECK dout1_24 Vdout1_24ck84 = 0.9 time = 425
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=425.025n

* CHECK dout1_25 Vdout1_25ck84 = 0 time = 425
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=425.025n

* CHECK dout1_26 Vdout1_26ck84 = 0.9 time = 425
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=425.025n

* CHECK dout1_27 Vdout1_27ck84 = 0 time = 425
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=425.025n

* CHECK dout1_28 Vdout1_28ck84 = 0 time = 425
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=425.025n

* CHECK dout1_29 Vdout1_29ck84 = 0 time = 425
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=425.025n

* CHECK dout1_30 Vdout1_30ck84 = 0.9 time = 425
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=425.025n

* CHECK dout1_31 Vdout1_31ck84 = 0 time = 425
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=425.025n

* CHECK dout1_32 Vdout1_32ck84 = 0.9 time = 425
.meas tran vdout1_32ck84 FIND v(dout1_32) AT=425.025n

* CHECK dout1_33 Vdout1_33ck84 = 0 time = 425
.meas tran vdout1_33ck84 FIND v(dout1_33) AT=425.025n

* CHECK dout1_34 Vdout1_34ck84 = 0.9 time = 425
.meas tran vdout1_34ck84 FIND v(dout1_34) AT=425.025n

* CHECK dout1_35 Vdout1_35ck84 = 0.9 time = 425
.meas tran vdout1_35ck84 FIND v(dout1_35) AT=425.025n

* CHECK dout1_36 Vdout1_36ck84 = 0 time = 425
.meas tran vdout1_36ck84 FIND v(dout1_36) AT=425.025n

* CHECK dout1_37 Vdout1_37ck84 = 0.9 time = 425
.meas tran vdout1_37ck84 FIND v(dout1_37) AT=425.025n

* CHECK dout1_38 Vdout1_38ck84 = 0.9 time = 425
.meas tran vdout1_38ck84 FIND v(dout1_38) AT=425.025n

* CHECK dout1_39 Vdout1_39ck84 = 0.9 time = 425
.meas tran vdout1_39ck84 FIND v(dout1_39) AT=425.025n

* CHECK dout1_40 Vdout1_40ck84 = 0.9 time = 425
.meas tran vdout1_40ck84 FIND v(dout1_40) AT=425.025n

* CHECK dout1_41 Vdout1_41ck84 = 0 time = 425
.meas tran vdout1_41ck84 FIND v(dout1_41) AT=425.025n

* CHECK dout1_42 Vdout1_42ck84 = 0 time = 425
.meas tran vdout1_42ck84 FIND v(dout1_42) AT=425.025n

* CHECK dout1_43 Vdout1_43ck84 = 0 time = 425
.meas tran vdout1_43ck84 FIND v(dout1_43) AT=425.025n

* CHECK dout1_44 Vdout1_44ck84 = 0.9 time = 425
.meas tran vdout1_44ck84 FIND v(dout1_44) AT=425.025n

* CHECK dout1_45 Vdout1_45ck84 = 0.9 time = 425
.meas tran vdout1_45ck84 FIND v(dout1_45) AT=425.025n

* CHECK dout1_46 Vdout1_46ck84 = 0 time = 425
.meas tran vdout1_46ck84 FIND v(dout1_46) AT=425.025n

* CHECK dout1_47 Vdout1_47ck84 = 0.9 time = 425
.meas tran vdout1_47ck84 FIND v(dout1_47) AT=425.025n

* CHECK dout1_48 Vdout1_48ck84 = 0.9 time = 425
.meas tran vdout1_48ck84 FIND v(dout1_48) AT=425.025n

* CHECK dout1_49 Vdout1_49ck84 = 0.9 time = 425
.meas tran vdout1_49ck84 FIND v(dout1_49) AT=425.025n

* CHECK dout1_50 Vdout1_50ck84 = 0.9 time = 425
.meas tran vdout1_50ck84 FIND v(dout1_50) AT=425.025n

* CHECK dout1_51 Vdout1_51ck84 = 0.9 time = 425
.meas tran vdout1_51ck84 FIND v(dout1_51) AT=425.025n

* CHECK dout1_52 Vdout1_52ck84 = 0 time = 425
.meas tran vdout1_52ck84 FIND v(dout1_52) AT=425.025n

* CHECK dout1_53 Vdout1_53ck84 = 0.9 time = 425
.meas tran vdout1_53ck84 FIND v(dout1_53) AT=425.025n

* CHECK dout1_54 Vdout1_54ck84 = 0 time = 425
.meas tran vdout1_54ck84 FIND v(dout1_54) AT=425.025n

* CHECK dout1_55 Vdout1_55ck84 = 0.9 time = 425
.meas tran vdout1_55ck84 FIND v(dout1_55) AT=425.025n

* CHECK dout1_0 Vdout1_0ck86 = 0 time = 435
.meas tran vdout1_0ck86 FIND v(dout1_0) AT=435.025n

* CHECK dout1_1 Vdout1_1ck86 = 0.9 time = 435
.meas tran vdout1_1ck86 FIND v(dout1_1) AT=435.025n

* CHECK dout1_2 Vdout1_2ck86 = 0.9 time = 435
.meas tran vdout1_2ck86 FIND v(dout1_2) AT=435.025n

* CHECK dout1_3 Vdout1_3ck86 = 0.9 time = 435
.meas tran vdout1_3ck86 FIND v(dout1_3) AT=435.025n

* CHECK dout1_4 Vdout1_4ck86 = 0 time = 435
.meas tran vdout1_4ck86 FIND v(dout1_4) AT=435.025n

* CHECK dout1_5 Vdout1_5ck86 = 0.9 time = 435
.meas tran vdout1_5ck86 FIND v(dout1_5) AT=435.025n

* CHECK dout1_6 Vdout1_6ck86 = 0.9 time = 435
.meas tran vdout1_6ck86 FIND v(dout1_6) AT=435.025n

* CHECK dout1_7 Vdout1_7ck86 = 0.9 time = 435
.meas tran vdout1_7ck86 FIND v(dout1_7) AT=435.025n

* CHECK dout1_8 Vdout1_8ck86 = 0 time = 435
.meas tran vdout1_8ck86 FIND v(dout1_8) AT=435.025n

* CHECK dout1_9 Vdout1_9ck86 = 0.9 time = 435
.meas tran vdout1_9ck86 FIND v(dout1_9) AT=435.025n

* CHECK dout1_10 Vdout1_10ck86 = 0 time = 435
.meas tran vdout1_10ck86 FIND v(dout1_10) AT=435.025n

* CHECK dout1_11 Vdout1_11ck86 = 0 time = 435
.meas tran vdout1_11ck86 FIND v(dout1_11) AT=435.025n

* CHECK dout1_12 Vdout1_12ck86 = 0 time = 435
.meas tran vdout1_12ck86 FIND v(dout1_12) AT=435.025n

* CHECK dout1_13 Vdout1_13ck86 = 0 time = 435
.meas tran vdout1_13ck86 FIND v(dout1_13) AT=435.025n

* CHECK dout1_14 Vdout1_14ck86 = 0 time = 435
.meas tran vdout1_14ck86 FIND v(dout1_14) AT=435.025n

* CHECK dout1_15 Vdout1_15ck86 = 0 time = 435
.meas tran vdout1_15ck86 FIND v(dout1_15) AT=435.025n

* CHECK dout1_16 Vdout1_16ck86 = 0.9 time = 435
.meas tran vdout1_16ck86 FIND v(dout1_16) AT=435.025n

* CHECK dout1_17 Vdout1_17ck86 = 0 time = 435
.meas tran vdout1_17ck86 FIND v(dout1_17) AT=435.025n

* CHECK dout1_18 Vdout1_18ck86 = 0 time = 435
.meas tran vdout1_18ck86 FIND v(dout1_18) AT=435.025n

* CHECK dout1_19 Vdout1_19ck86 = 0.9 time = 435
.meas tran vdout1_19ck86 FIND v(dout1_19) AT=435.025n

* CHECK dout1_20 Vdout1_20ck86 = 0.9 time = 435
.meas tran vdout1_20ck86 FIND v(dout1_20) AT=435.025n

* CHECK dout1_21 Vdout1_21ck86 = 0 time = 435
.meas tran vdout1_21ck86 FIND v(dout1_21) AT=435.025n

* CHECK dout1_22 Vdout1_22ck86 = 0.9 time = 435
.meas tran vdout1_22ck86 FIND v(dout1_22) AT=435.025n

* CHECK dout1_23 Vdout1_23ck86 = 0 time = 435
.meas tran vdout1_23ck86 FIND v(dout1_23) AT=435.025n

* CHECK dout1_24 Vdout1_24ck86 = 0 time = 435
.meas tran vdout1_24ck86 FIND v(dout1_24) AT=435.025n

* CHECK dout1_25 Vdout1_25ck86 = 0 time = 435
.meas tran vdout1_25ck86 FIND v(dout1_25) AT=435.025n

* CHECK dout1_26 Vdout1_26ck86 = 0 time = 435
.meas tran vdout1_26ck86 FIND v(dout1_26) AT=435.025n

* CHECK dout1_27 Vdout1_27ck86 = 0 time = 435
.meas tran vdout1_27ck86 FIND v(dout1_27) AT=435.025n

* CHECK dout1_28 Vdout1_28ck86 = 0.9 time = 435
.meas tran vdout1_28ck86 FIND v(dout1_28) AT=435.025n

* CHECK dout1_29 Vdout1_29ck86 = 0 time = 435
.meas tran vdout1_29ck86 FIND v(dout1_29) AT=435.025n

* CHECK dout1_30 Vdout1_30ck86 = 0.9 time = 435
.meas tran vdout1_30ck86 FIND v(dout1_30) AT=435.025n

* CHECK dout1_31 Vdout1_31ck86 = 0.9 time = 435
.meas tran vdout1_31ck86 FIND v(dout1_31) AT=435.025n

* CHECK dout1_32 Vdout1_32ck86 = 0 time = 435
.meas tran vdout1_32ck86 FIND v(dout1_32) AT=435.025n

* CHECK dout1_33 Vdout1_33ck86 = 0 time = 435
.meas tran vdout1_33ck86 FIND v(dout1_33) AT=435.025n

* CHECK dout1_34 Vdout1_34ck86 = 0 time = 435
.meas tran vdout1_34ck86 FIND v(dout1_34) AT=435.025n

* CHECK dout1_35 Vdout1_35ck86 = 0 time = 435
.meas tran vdout1_35ck86 FIND v(dout1_35) AT=435.025n

* CHECK dout1_36 Vdout1_36ck86 = 0 time = 435
.meas tran vdout1_36ck86 FIND v(dout1_36) AT=435.025n

* CHECK dout1_37 Vdout1_37ck86 = 0.9 time = 435
.meas tran vdout1_37ck86 FIND v(dout1_37) AT=435.025n

* CHECK dout1_38 Vdout1_38ck86 = 0 time = 435
.meas tran vdout1_38ck86 FIND v(dout1_38) AT=435.025n

* CHECK dout1_39 Vdout1_39ck86 = 0.9 time = 435
.meas tran vdout1_39ck86 FIND v(dout1_39) AT=435.025n

* CHECK dout1_40 Vdout1_40ck86 = 0.9 time = 435
.meas tran vdout1_40ck86 FIND v(dout1_40) AT=435.025n

* CHECK dout1_41 Vdout1_41ck86 = 0 time = 435
.meas tran vdout1_41ck86 FIND v(dout1_41) AT=435.025n

* CHECK dout1_42 Vdout1_42ck86 = 0.9 time = 435
.meas tran vdout1_42ck86 FIND v(dout1_42) AT=435.025n

* CHECK dout1_43 Vdout1_43ck86 = 0.9 time = 435
.meas tran vdout1_43ck86 FIND v(dout1_43) AT=435.025n

* CHECK dout1_44 Vdout1_44ck86 = 0.9 time = 435
.meas tran vdout1_44ck86 FIND v(dout1_44) AT=435.025n

* CHECK dout1_45 Vdout1_45ck86 = 0.9 time = 435
.meas tran vdout1_45ck86 FIND v(dout1_45) AT=435.025n

* CHECK dout1_46 Vdout1_46ck86 = 0.9 time = 435
.meas tran vdout1_46ck86 FIND v(dout1_46) AT=435.025n

* CHECK dout1_47 Vdout1_47ck86 = 0.9 time = 435
.meas tran vdout1_47ck86 FIND v(dout1_47) AT=435.025n

* CHECK dout1_48 Vdout1_48ck86 = 0.9 time = 435
.meas tran vdout1_48ck86 FIND v(dout1_48) AT=435.025n

* CHECK dout1_49 Vdout1_49ck86 = 0.9 time = 435
.meas tran vdout1_49ck86 FIND v(dout1_49) AT=435.025n

* CHECK dout1_50 Vdout1_50ck86 = 0 time = 435
.meas tran vdout1_50ck86 FIND v(dout1_50) AT=435.025n

* CHECK dout1_51 Vdout1_51ck86 = 0 time = 435
.meas tran vdout1_51ck86 FIND v(dout1_51) AT=435.025n

* CHECK dout1_52 Vdout1_52ck86 = 0.9 time = 435
.meas tran vdout1_52ck86 FIND v(dout1_52) AT=435.025n

* CHECK dout1_53 Vdout1_53ck86 = 0.9 time = 435
.meas tran vdout1_53ck86 FIND v(dout1_53) AT=435.025n

* CHECK dout1_54 Vdout1_54ck86 = 0.9 time = 435
.meas tran vdout1_54ck86 FIND v(dout1_54) AT=435.025n

* CHECK dout1_55 Vdout1_55ck86 = 0 time = 435
.meas tran vdout1_55ck86 FIND v(dout1_55) AT=435.025n

* CHECK dout1_0 Vdout1_0ck87 = 0 time = 440
.meas tran vdout1_0ck87 FIND v(dout1_0) AT=440.025n

* CHECK dout1_1 Vdout1_1ck87 = 0.9 time = 440
.meas tran vdout1_1ck87 FIND v(dout1_1) AT=440.025n

* CHECK dout1_2 Vdout1_2ck87 = 0.9 time = 440
.meas tran vdout1_2ck87 FIND v(dout1_2) AT=440.025n

* CHECK dout1_3 Vdout1_3ck87 = 0.9 time = 440
.meas tran vdout1_3ck87 FIND v(dout1_3) AT=440.025n

* CHECK dout1_4 Vdout1_4ck87 = 0 time = 440
.meas tran vdout1_4ck87 FIND v(dout1_4) AT=440.025n

* CHECK dout1_5 Vdout1_5ck87 = 0.9 time = 440
.meas tran vdout1_5ck87 FIND v(dout1_5) AT=440.025n

* CHECK dout1_6 Vdout1_6ck87 = 0.9 time = 440
.meas tran vdout1_6ck87 FIND v(dout1_6) AT=440.025n

* CHECK dout1_7 Vdout1_7ck87 = 0.9 time = 440
.meas tran vdout1_7ck87 FIND v(dout1_7) AT=440.025n

* CHECK dout1_8 Vdout1_8ck87 = 0 time = 440
.meas tran vdout1_8ck87 FIND v(dout1_8) AT=440.025n

* CHECK dout1_9 Vdout1_9ck87 = 0.9 time = 440
.meas tran vdout1_9ck87 FIND v(dout1_9) AT=440.025n

* CHECK dout1_10 Vdout1_10ck87 = 0 time = 440
.meas tran vdout1_10ck87 FIND v(dout1_10) AT=440.025n

* CHECK dout1_11 Vdout1_11ck87 = 0 time = 440
.meas tran vdout1_11ck87 FIND v(dout1_11) AT=440.025n

* CHECK dout1_12 Vdout1_12ck87 = 0 time = 440
.meas tran vdout1_12ck87 FIND v(dout1_12) AT=440.025n

* CHECK dout1_13 Vdout1_13ck87 = 0 time = 440
.meas tran vdout1_13ck87 FIND v(dout1_13) AT=440.025n

* CHECK dout1_14 Vdout1_14ck87 = 0 time = 440
.meas tran vdout1_14ck87 FIND v(dout1_14) AT=440.025n

* CHECK dout1_15 Vdout1_15ck87 = 0 time = 440
.meas tran vdout1_15ck87 FIND v(dout1_15) AT=440.025n

* CHECK dout1_16 Vdout1_16ck87 = 0.9 time = 440
.meas tran vdout1_16ck87 FIND v(dout1_16) AT=440.025n

* CHECK dout1_17 Vdout1_17ck87 = 0 time = 440
.meas tran vdout1_17ck87 FIND v(dout1_17) AT=440.025n

* CHECK dout1_18 Vdout1_18ck87 = 0 time = 440
.meas tran vdout1_18ck87 FIND v(dout1_18) AT=440.025n

* CHECK dout1_19 Vdout1_19ck87 = 0.9 time = 440
.meas tran vdout1_19ck87 FIND v(dout1_19) AT=440.025n

* CHECK dout1_20 Vdout1_20ck87 = 0.9 time = 440
.meas tran vdout1_20ck87 FIND v(dout1_20) AT=440.025n

* CHECK dout1_21 Vdout1_21ck87 = 0 time = 440
.meas tran vdout1_21ck87 FIND v(dout1_21) AT=440.025n

* CHECK dout1_22 Vdout1_22ck87 = 0.9 time = 440
.meas tran vdout1_22ck87 FIND v(dout1_22) AT=440.025n

* CHECK dout1_23 Vdout1_23ck87 = 0 time = 440
.meas tran vdout1_23ck87 FIND v(dout1_23) AT=440.025n

* CHECK dout1_24 Vdout1_24ck87 = 0 time = 440
.meas tran vdout1_24ck87 FIND v(dout1_24) AT=440.025n

* CHECK dout1_25 Vdout1_25ck87 = 0 time = 440
.meas tran vdout1_25ck87 FIND v(dout1_25) AT=440.025n

* CHECK dout1_26 Vdout1_26ck87 = 0 time = 440
.meas tran vdout1_26ck87 FIND v(dout1_26) AT=440.025n

* CHECK dout1_27 Vdout1_27ck87 = 0 time = 440
.meas tran vdout1_27ck87 FIND v(dout1_27) AT=440.025n

* CHECK dout1_28 Vdout1_28ck87 = 0.9 time = 440
.meas tran vdout1_28ck87 FIND v(dout1_28) AT=440.025n

* CHECK dout1_29 Vdout1_29ck87 = 0 time = 440
.meas tran vdout1_29ck87 FIND v(dout1_29) AT=440.025n

* CHECK dout1_30 Vdout1_30ck87 = 0.9 time = 440
.meas tran vdout1_30ck87 FIND v(dout1_30) AT=440.025n

* CHECK dout1_31 Vdout1_31ck87 = 0.9 time = 440
.meas tran vdout1_31ck87 FIND v(dout1_31) AT=440.025n

* CHECK dout1_32 Vdout1_32ck87 = 0 time = 440
.meas tran vdout1_32ck87 FIND v(dout1_32) AT=440.025n

* CHECK dout1_33 Vdout1_33ck87 = 0 time = 440
.meas tran vdout1_33ck87 FIND v(dout1_33) AT=440.025n

* CHECK dout1_34 Vdout1_34ck87 = 0 time = 440
.meas tran vdout1_34ck87 FIND v(dout1_34) AT=440.025n

* CHECK dout1_35 Vdout1_35ck87 = 0 time = 440
.meas tran vdout1_35ck87 FIND v(dout1_35) AT=440.025n

* CHECK dout1_36 Vdout1_36ck87 = 0 time = 440
.meas tran vdout1_36ck87 FIND v(dout1_36) AT=440.025n

* CHECK dout1_37 Vdout1_37ck87 = 0.9 time = 440
.meas tran vdout1_37ck87 FIND v(dout1_37) AT=440.025n

* CHECK dout1_38 Vdout1_38ck87 = 0 time = 440
.meas tran vdout1_38ck87 FIND v(dout1_38) AT=440.025n

* CHECK dout1_39 Vdout1_39ck87 = 0.9 time = 440
.meas tran vdout1_39ck87 FIND v(dout1_39) AT=440.025n

* CHECK dout1_40 Vdout1_40ck87 = 0.9 time = 440
.meas tran vdout1_40ck87 FIND v(dout1_40) AT=440.025n

* CHECK dout1_41 Vdout1_41ck87 = 0 time = 440
.meas tran vdout1_41ck87 FIND v(dout1_41) AT=440.025n

* CHECK dout1_42 Vdout1_42ck87 = 0.9 time = 440
.meas tran vdout1_42ck87 FIND v(dout1_42) AT=440.025n

* CHECK dout1_43 Vdout1_43ck87 = 0.9 time = 440
.meas tran vdout1_43ck87 FIND v(dout1_43) AT=440.025n

* CHECK dout1_44 Vdout1_44ck87 = 0.9 time = 440
.meas tran vdout1_44ck87 FIND v(dout1_44) AT=440.025n

* CHECK dout1_45 Vdout1_45ck87 = 0.9 time = 440
.meas tran vdout1_45ck87 FIND v(dout1_45) AT=440.025n

* CHECK dout1_46 Vdout1_46ck87 = 0.9 time = 440
.meas tran vdout1_46ck87 FIND v(dout1_46) AT=440.025n

* CHECK dout1_47 Vdout1_47ck87 = 0.9 time = 440
.meas tran vdout1_47ck87 FIND v(dout1_47) AT=440.025n

* CHECK dout1_48 Vdout1_48ck87 = 0.9 time = 440
.meas tran vdout1_48ck87 FIND v(dout1_48) AT=440.025n

* CHECK dout1_49 Vdout1_49ck87 = 0.9 time = 440
.meas tran vdout1_49ck87 FIND v(dout1_49) AT=440.025n

* CHECK dout1_50 Vdout1_50ck87 = 0 time = 440
.meas tran vdout1_50ck87 FIND v(dout1_50) AT=440.025n

* CHECK dout1_51 Vdout1_51ck87 = 0 time = 440
.meas tran vdout1_51ck87 FIND v(dout1_51) AT=440.025n

* CHECK dout1_52 Vdout1_52ck87 = 0.9 time = 440
.meas tran vdout1_52ck87 FIND v(dout1_52) AT=440.025n

* CHECK dout1_53 Vdout1_53ck87 = 0.9 time = 440
.meas tran vdout1_53ck87 FIND v(dout1_53) AT=440.025n

* CHECK dout1_54 Vdout1_54ck87 = 0.9 time = 440
.meas tran vdout1_54ck87 FIND v(dout1_54) AT=440.025n

* CHECK dout1_55 Vdout1_55ck87 = 0 time = 440
.meas tran vdout1_55ck87 FIND v(dout1_55) AT=440.025n

* CHECK dout1_0 Vdout1_0ck91 = 0.9 time = 460
.meas tran vdout1_0ck91 FIND v(dout1_0) AT=460.025n

* CHECK dout1_1 Vdout1_1ck91 = 0.9 time = 460
.meas tran vdout1_1ck91 FIND v(dout1_1) AT=460.025n

* CHECK dout1_2 Vdout1_2ck91 = 0 time = 460
.meas tran vdout1_2ck91 FIND v(dout1_2) AT=460.025n

* CHECK dout1_3 Vdout1_3ck91 = 0 time = 460
.meas tran vdout1_3ck91 FIND v(dout1_3) AT=460.025n

* CHECK dout1_4 Vdout1_4ck91 = 0.9 time = 460
.meas tran vdout1_4ck91 FIND v(dout1_4) AT=460.025n

* CHECK dout1_5 Vdout1_5ck91 = 0.9 time = 460
.meas tran vdout1_5ck91 FIND v(dout1_5) AT=460.025n

* CHECK dout1_6 Vdout1_6ck91 = 0.9 time = 460
.meas tran vdout1_6ck91 FIND v(dout1_6) AT=460.025n

* CHECK dout1_7 Vdout1_7ck91 = 0.9 time = 460
.meas tran vdout1_7ck91 FIND v(dout1_7) AT=460.025n

* CHECK dout1_8 Vdout1_8ck91 = 0.9 time = 460
.meas tran vdout1_8ck91 FIND v(dout1_8) AT=460.025n

* CHECK dout1_9 Vdout1_9ck91 = 0.9 time = 460
.meas tran vdout1_9ck91 FIND v(dout1_9) AT=460.025n

* CHECK dout1_10 Vdout1_10ck91 = 0 time = 460
.meas tran vdout1_10ck91 FIND v(dout1_10) AT=460.025n

* CHECK dout1_11 Vdout1_11ck91 = 0 time = 460
.meas tran vdout1_11ck91 FIND v(dout1_11) AT=460.025n

* CHECK dout1_12 Vdout1_12ck91 = 0.9 time = 460
.meas tran vdout1_12ck91 FIND v(dout1_12) AT=460.025n

* CHECK dout1_13 Vdout1_13ck91 = 0.9 time = 460
.meas tran vdout1_13ck91 FIND v(dout1_13) AT=460.025n

* CHECK dout1_14 Vdout1_14ck91 = 0 time = 460
.meas tran vdout1_14ck91 FIND v(dout1_14) AT=460.025n

* CHECK dout1_15 Vdout1_15ck91 = 0 time = 460
.meas tran vdout1_15ck91 FIND v(dout1_15) AT=460.025n

* CHECK dout1_16 Vdout1_16ck91 = 0.9 time = 460
.meas tran vdout1_16ck91 FIND v(dout1_16) AT=460.025n

* CHECK dout1_17 Vdout1_17ck91 = 0 time = 460
.meas tran vdout1_17ck91 FIND v(dout1_17) AT=460.025n

* CHECK dout1_18 Vdout1_18ck91 = 0 time = 460
.meas tran vdout1_18ck91 FIND v(dout1_18) AT=460.025n

* CHECK dout1_19 Vdout1_19ck91 = 0.9 time = 460
.meas tran vdout1_19ck91 FIND v(dout1_19) AT=460.025n

* CHECK dout1_20 Vdout1_20ck91 = 0.9 time = 460
.meas tran vdout1_20ck91 FIND v(dout1_20) AT=460.025n

* CHECK dout1_21 Vdout1_21ck91 = 0 time = 460
.meas tran vdout1_21ck91 FIND v(dout1_21) AT=460.025n

* CHECK dout1_22 Vdout1_22ck91 = 0 time = 460
.meas tran vdout1_22ck91 FIND v(dout1_22) AT=460.025n

* CHECK dout1_23 Vdout1_23ck91 = 0 time = 460
.meas tran vdout1_23ck91 FIND v(dout1_23) AT=460.025n

* CHECK dout1_24 Vdout1_24ck91 = 0 time = 460
.meas tran vdout1_24ck91 FIND v(dout1_24) AT=460.025n

* CHECK dout1_25 Vdout1_25ck91 = 0 time = 460
.meas tran vdout1_25ck91 FIND v(dout1_25) AT=460.025n

* CHECK dout1_26 Vdout1_26ck91 = 0 time = 460
.meas tran vdout1_26ck91 FIND v(dout1_26) AT=460.025n

* CHECK dout1_27 Vdout1_27ck91 = 0.9 time = 460
.meas tran vdout1_27ck91 FIND v(dout1_27) AT=460.025n

* CHECK dout1_28 Vdout1_28ck91 = 0 time = 460
.meas tran vdout1_28ck91 FIND v(dout1_28) AT=460.025n

* CHECK dout1_29 Vdout1_29ck91 = 0 time = 460
.meas tran vdout1_29ck91 FIND v(dout1_29) AT=460.025n

* CHECK dout1_30 Vdout1_30ck91 = 0 time = 460
.meas tran vdout1_30ck91 FIND v(dout1_30) AT=460.025n

* CHECK dout1_31 Vdout1_31ck91 = 0.9 time = 460
.meas tran vdout1_31ck91 FIND v(dout1_31) AT=460.025n

* CHECK dout1_32 Vdout1_32ck91 = 0 time = 460
.meas tran vdout1_32ck91 FIND v(dout1_32) AT=460.025n

* CHECK dout1_33 Vdout1_33ck91 = 0.9 time = 460
.meas tran vdout1_33ck91 FIND v(dout1_33) AT=460.025n

* CHECK dout1_34 Vdout1_34ck91 = 0.9 time = 460
.meas tran vdout1_34ck91 FIND v(dout1_34) AT=460.025n

* CHECK dout1_35 Vdout1_35ck91 = 0.9 time = 460
.meas tran vdout1_35ck91 FIND v(dout1_35) AT=460.025n

* CHECK dout1_36 Vdout1_36ck91 = 0.9 time = 460
.meas tran vdout1_36ck91 FIND v(dout1_36) AT=460.025n

* CHECK dout1_37 Vdout1_37ck91 = 0.9 time = 460
.meas tran vdout1_37ck91 FIND v(dout1_37) AT=460.025n

* CHECK dout1_38 Vdout1_38ck91 = 0.9 time = 460
.meas tran vdout1_38ck91 FIND v(dout1_38) AT=460.025n

* CHECK dout1_39 Vdout1_39ck91 = 0.9 time = 460
.meas tran vdout1_39ck91 FIND v(dout1_39) AT=460.025n

* CHECK dout1_40 Vdout1_40ck91 = 0.9 time = 460
.meas tran vdout1_40ck91 FIND v(dout1_40) AT=460.025n

* CHECK dout1_41 Vdout1_41ck91 = 0.9 time = 460
.meas tran vdout1_41ck91 FIND v(dout1_41) AT=460.025n

* CHECK dout1_42 Vdout1_42ck91 = 0.9 time = 460
.meas tran vdout1_42ck91 FIND v(dout1_42) AT=460.025n

* CHECK dout1_43 Vdout1_43ck91 = 0 time = 460
.meas tran vdout1_43ck91 FIND v(dout1_43) AT=460.025n

* CHECK dout1_44 Vdout1_44ck91 = 0.9 time = 460
.meas tran vdout1_44ck91 FIND v(dout1_44) AT=460.025n

* CHECK dout1_45 Vdout1_45ck91 = 0 time = 460
.meas tran vdout1_45ck91 FIND v(dout1_45) AT=460.025n

* CHECK dout1_46 Vdout1_46ck91 = 0.9 time = 460
.meas tran vdout1_46ck91 FIND v(dout1_46) AT=460.025n

* CHECK dout1_47 Vdout1_47ck91 = 0.9 time = 460
.meas tran vdout1_47ck91 FIND v(dout1_47) AT=460.025n

* CHECK dout1_48 Vdout1_48ck91 = 0.9 time = 460
.meas tran vdout1_48ck91 FIND v(dout1_48) AT=460.025n

* CHECK dout1_49 Vdout1_49ck91 = 0.9 time = 460
.meas tran vdout1_49ck91 FIND v(dout1_49) AT=460.025n

* CHECK dout1_50 Vdout1_50ck91 = 0 time = 460
.meas tran vdout1_50ck91 FIND v(dout1_50) AT=460.025n

* CHECK dout1_51 Vdout1_51ck91 = 0 time = 460
.meas tran vdout1_51ck91 FIND v(dout1_51) AT=460.025n

* CHECK dout1_52 Vdout1_52ck91 = 0.9 time = 460
.meas tran vdout1_52ck91 FIND v(dout1_52) AT=460.025n

* CHECK dout1_53 Vdout1_53ck91 = 0.9 time = 460
.meas tran vdout1_53ck91 FIND v(dout1_53) AT=460.025n

* CHECK dout1_54 Vdout1_54ck91 = 0.9 time = 460
.meas tran vdout1_54ck91 FIND v(dout1_54) AT=460.025n

* CHECK dout1_55 Vdout1_55ck91 = 0 time = 460
.meas tran vdout1_55ck91 FIND v(dout1_55) AT=460.025n

* CHECK dout1_0 Vdout1_0ck92 = 0 time = 465
.meas tran vdout1_0ck92 FIND v(dout1_0) AT=465.025n

* CHECK dout1_1 Vdout1_1ck92 = 0.9 time = 465
.meas tran vdout1_1ck92 FIND v(dout1_1) AT=465.025n

* CHECK dout1_2 Vdout1_2ck92 = 0.9 time = 465
.meas tran vdout1_2ck92 FIND v(dout1_2) AT=465.025n

* CHECK dout1_3 Vdout1_3ck92 = 0.9 time = 465
.meas tran vdout1_3ck92 FIND v(dout1_3) AT=465.025n

* CHECK dout1_4 Vdout1_4ck92 = 0 time = 465
.meas tran vdout1_4ck92 FIND v(dout1_4) AT=465.025n

* CHECK dout1_5 Vdout1_5ck92 = 0.9 time = 465
.meas tran vdout1_5ck92 FIND v(dout1_5) AT=465.025n

* CHECK dout1_6 Vdout1_6ck92 = 0.9 time = 465
.meas tran vdout1_6ck92 FIND v(dout1_6) AT=465.025n

* CHECK dout1_7 Vdout1_7ck92 = 0.9 time = 465
.meas tran vdout1_7ck92 FIND v(dout1_7) AT=465.025n

* CHECK dout1_8 Vdout1_8ck92 = 0 time = 465
.meas tran vdout1_8ck92 FIND v(dout1_8) AT=465.025n

* CHECK dout1_9 Vdout1_9ck92 = 0.9 time = 465
.meas tran vdout1_9ck92 FIND v(dout1_9) AT=465.025n

* CHECK dout1_10 Vdout1_10ck92 = 0 time = 465
.meas tran vdout1_10ck92 FIND v(dout1_10) AT=465.025n

* CHECK dout1_11 Vdout1_11ck92 = 0 time = 465
.meas tran vdout1_11ck92 FIND v(dout1_11) AT=465.025n

* CHECK dout1_12 Vdout1_12ck92 = 0 time = 465
.meas tran vdout1_12ck92 FIND v(dout1_12) AT=465.025n

* CHECK dout1_13 Vdout1_13ck92 = 0 time = 465
.meas tran vdout1_13ck92 FIND v(dout1_13) AT=465.025n

* CHECK dout1_14 Vdout1_14ck92 = 0 time = 465
.meas tran vdout1_14ck92 FIND v(dout1_14) AT=465.025n

* CHECK dout1_15 Vdout1_15ck92 = 0 time = 465
.meas tran vdout1_15ck92 FIND v(dout1_15) AT=465.025n

* CHECK dout1_16 Vdout1_16ck92 = 0.9 time = 465
.meas tran vdout1_16ck92 FIND v(dout1_16) AT=465.025n

* CHECK dout1_17 Vdout1_17ck92 = 0 time = 465
.meas tran vdout1_17ck92 FIND v(dout1_17) AT=465.025n

* CHECK dout1_18 Vdout1_18ck92 = 0 time = 465
.meas tran vdout1_18ck92 FIND v(dout1_18) AT=465.025n

* CHECK dout1_19 Vdout1_19ck92 = 0.9 time = 465
.meas tran vdout1_19ck92 FIND v(dout1_19) AT=465.025n

* CHECK dout1_20 Vdout1_20ck92 = 0.9 time = 465
.meas tran vdout1_20ck92 FIND v(dout1_20) AT=465.025n

* CHECK dout1_21 Vdout1_21ck92 = 0 time = 465
.meas tran vdout1_21ck92 FIND v(dout1_21) AT=465.025n

* CHECK dout1_22 Vdout1_22ck92 = 0.9 time = 465
.meas tran vdout1_22ck92 FIND v(dout1_22) AT=465.025n

* CHECK dout1_23 Vdout1_23ck92 = 0 time = 465
.meas tran vdout1_23ck92 FIND v(dout1_23) AT=465.025n

* CHECK dout1_24 Vdout1_24ck92 = 0 time = 465
.meas tran vdout1_24ck92 FIND v(dout1_24) AT=465.025n

* CHECK dout1_25 Vdout1_25ck92 = 0 time = 465
.meas tran vdout1_25ck92 FIND v(dout1_25) AT=465.025n

* CHECK dout1_26 Vdout1_26ck92 = 0 time = 465
.meas tran vdout1_26ck92 FIND v(dout1_26) AT=465.025n

* CHECK dout1_27 Vdout1_27ck92 = 0 time = 465
.meas tran vdout1_27ck92 FIND v(dout1_27) AT=465.025n

* CHECK dout1_28 Vdout1_28ck92 = 0.9 time = 465
.meas tran vdout1_28ck92 FIND v(dout1_28) AT=465.025n

* CHECK dout1_29 Vdout1_29ck92 = 0 time = 465
.meas tran vdout1_29ck92 FIND v(dout1_29) AT=465.025n

* CHECK dout1_30 Vdout1_30ck92 = 0.9 time = 465
.meas tran vdout1_30ck92 FIND v(dout1_30) AT=465.025n

* CHECK dout1_31 Vdout1_31ck92 = 0.9 time = 465
.meas tran vdout1_31ck92 FIND v(dout1_31) AT=465.025n

* CHECK dout1_32 Vdout1_32ck92 = 0 time = 465
.meas tran vdout1_32ck92 FIND v(dout1_32) AT=465.025n

* CHECK dout1_33 Vdout1_33ck92 = 0 time = 465
.meas tran vdout1_33ck92 FIND v(dout1_33) AT=465.025n

* CHECK dout1_34 Vdout1_34ck92 = 0 time = 465
.meas tran vdout1_34ck92 FIND v(dout1_34) AT=465.025n

* CHECK dout1_35 Vdout1_35ck92 = 0 time = 465
.meas tran vdout1_35ck92 FIND v(dout1_35) AT=465.025n

* CHECK dout1_36 Vdout1_36ck92 = 0 time = 465
.meas tran vdout1_36ck92 FIND v(dout1_36) AT=465.025n

* CHECK dout1_37 Vdout1_37ck92 = 0.9 time = 465
.meas tran vdout1_37ck92 FIND v(dout1_37) AT=465.025n

* CHECK dout1_38 Vdout1_38ck92 = 0 time = 465
.meas tran vdout1_38ck92 FIND v(dout1_38) AT=465.025n

* CHECK dout1_39 Vdout1_39ck92 = 0.9 time = 465
.meas tran vdout1_39ck92 FIND v(dout1_39) AT=465.025n

* CHECK dout1_40 Vdout1_40ck92 = 0.9 time = 465
.meas tran vdout1_40ck92 FIND v(dout1_40) AT=465.025n

* CHECK dout1_41 Vdout1_41ck92 = 0 time = 465
.meas tran vdout1_41ck92 FIND v(dout1_41) AT=465.025n

* CHECK dout1_42 Vdout1_42ck92 = 0.9 time = 465
.meas tran vdout1_42ck92 FIND v(dout1_42) AT=465.025n

* CHECK dout1_43 Vdout1_43ck92 = 0.9 time = 465
.meas tran vdout1_43ck92 FIND v(dout1_43) AT=465.025n

* CHECK dout1_44 Vdout1_44ck92 = 0.9 time = 465
.meas tran vdout1_44ck92 FIND v(dout1_44) AT=465.025n

* CHECK dout1_45 Vdout1_45ck92 = 0.9 time = 465
.meas tran vdout1_45ck92 FIND v(dout1_45) AT=465.025n

* CHECK dout1_46 Vdout1_46ck92 = 0.9 time = 465
.meas tran vdout1_46ck92 FIND v(dout1_46) AT=465.025n

* CHECK dout1_47 Vdout1_47ck92 = 0.9 time = 465
.meas tran vdout1_47ck92 FIND v(dout1_47) AT=465.025n

* CHECK dout1_48 Vdout1_48ck92 = 0.9 time = 465
.meas tran vdout1_48ck92 FIND v(dout1_48) AT=465.025n

* CHECK dout1_49 Vdout1_49ck92 = 0.9 time = 465
.meas tran vdout1_49ck92 FIND v(dout1_49) AT=465.025n

* CHECK dout1_50 Vdout1_50ck92 = 0 time = 465
.meas tran vdout1_50ck92 FIND v(dout1_50) AT=465.025n

* CHECK dout1_51 Vdout1_51ck92 = 0 time = 465
.meas tran vdout1_51ck92 FIND v(dout1_51) AT=465.025n

* CHECK dout1_52 Vdout1_52ck92 = 0.9 time = 465
.meas tran vdout1_52ck92 FIND v(dout1_52) AT=465.025n

* CHECK dout1_53 Vdout1_53ck92 = 0.9 time = 465
.meas tran vdout1_53ck92 FIND v(dout1_53) AT=465.025n

* CHECK dout1_54 Vdout1_54ck92 = 0.9 time = 465
.meas tran vdout1_54ck92 FIND v(dout1_54) AT=465.025n

* CHECK dout1_55 Vdout1_55ck92 = 0 time = 465
.meas tran vdout1_55ck92 FIND v(dout1_55) AT=465.025n

* CHECK dout1_0 Vdout1_0ck97 = 0.9 time = 490
.meas tran vdout1_0ck97 FIND v(dout1_0) AT=490.025n

* CHECK dout1_1 Vdout1_1ck97 = 0.9 time = 490
.meas tran vdout1_1ck97 FIND v(dout1_1) AT=490.025n

* CHECK dout1_2 Vdout1_2ck97 = 0.9 time = 490
.meas tran vdout1_2ck97 FIND v(dout1_2) AT=490.025n

* CHECK dout1_3 Vdout1_3ck97 = 0.9 time = 490
.meas tran vdout1_3ck97 FIND v(dout1_3) AT=490.025n

* CHECK dout1_4 Vdout1_4ck97 = 0.9 time = 490
.meas tran vdout1_4ck97 FIND v(dout1_4) AT=490.025n

* CHECK dout1_5 Vdout1_5ck97 = 0.9 time = 490
.meas tran vdout1_5ck97 FIND v(dout1_5) AT=490.025n

* CHECK dout1_6 Vdout1_6ck97 = 0 time = 490
.meas tran vdout1_6ck97 FIND v(dout1_6) AT=490.025n

* CHECK dout1_7 Vdout1_7ck97 = 0 time = 490
.meas tran vdout1_7ck97 FIND v(dout1_7) AT=490.025n

* CHECK dout1_8 Vdout1_8ck97 = 0.9 time = 490
.meas tran vdout1_8ck97 FIND v(dout1_8) AT=490.025n

* CHECK dout1_9 Vdout1_9ck97 = 0 time = 490
.meas tran vdout1_9ck97 FIND v(dout1_9) AT=490.025n

* CHECK dout1_10 Vdout1_10ck97 = 0.9 time = 490
.meas tran vdout1_10ck97 FIND v(dout1_10) AT=490.025n

* CHECK dout1_11 Vdout1_11ck97 = 0.9 time = 490
.meas tran vdout1_11ck97 FIND v(dout1_11) AT=490.025n

* CHECK dout1_12 Vdout1_12ck97 = 0 time = 490
.meas tran vdout1_12ck97 FIND v(dout1_12) AT=490.025n

* CHECK dout1_13 Vdout1_13ck97 = 0 time = 490
.meas tran vdout1_13ck97 FIND v(dout1_13) AT=490.025n

* CHECK dout1_14 Vdout1_14ck97 = 0 time = 490
.meas tran vdout1_14ck97 FIND v(dout1_14) AT=490.025n

* CHECK dout1_15 Vdout1_15ck97 = 0.9 time = 490
.meas tran vdout1_15ck97 FIND v(dout1_15) AT=490.025n

* CHECK dout1_16 Vdout1_16ck97 = 0.9 time = 490
.meas tran vdout1_16ck97 FIND v(dout1_16) AT=490.025n

* CHECK dout1_17 Vdout1_17ck97 = 0.9 time = 490
.meas tran vdout1_17ck97 FIND v(dout1_17) AT=490.025n

* CHECK dout1_18 Vdout1_18ck97 = 0.9 time = 490
.meas tran vdout1_18ck97 FIND v(dout1_18) AT=490.025n

* CHECK dout1_19 Vdout1_19ck97 = 0 time = 490
.meas tran vdout1_19ck97 FIND v(dout1_19) AT=490.025n

* CHECK dout1_20 Vdout1_20ck97 = 0.9 time = 490
.meas tran vdout1_20ck97 FIND v(dout1_20) AT=490.025n

* CHECK dout1_21 Vdout1_21ck97 = 0 time = 490
.meas tran vdout1_21ck97 FIND v(dout1_21) AT=490.025n

* CHECK dout1_22 Vdout1_22ck97 = 0.9 time = 490
.meas tran vdout1_22ck97 FIND v(dout1_22) AT=490.025n

* CHECK dout1_23 Vdout1_23ck97 = 0 time = 490
.meas tran vdout1_23ck97 FIND v(dout1_23) AT=490.025n

* CHECK dout1_24 Vdout1_24ck97 = 0.9 time = 490
.meas tran vdout1_24ck97 FIND v(dout1_24) AT=490.025n

* CHECK dout1_25 Vdout1_25ck97 = 0 time = 490
.meas tran vdout1_25ck97 FIND v(dout1_25) AT=490.025n

* CHECK dout1_26 Vdout1_26ck97 = 0 time = 490
.meas tran vdout1_26ck97 FIND v(dout1_26) AT=490.025n

* CHECK dout1_27 Vdout1_27ck97 = 0.9 time = 490
.meas tran vdout1_27ck97 FIND v(dout1_27) AT=490.025n

* CHECK dout1_28 Vdout1_28ck97 = 0.9 time = 490
.meas tran vdout1_28ck97 FIND v(dout1_28) AT=490.025n

* CHECK dout1_29 Vdout1_29ck97 = 0 time = 490
.meas tran vdout1_29ck97 FIND v(dout1_29) AT=490.025n

* CHECK dout1_30 Vdout1_30ck97 = 0 time = 490
.meas tran vdout1_30ck97 FIND v(dout1_30) AT=490.025n

* CHECK dout1_31 Vdout1_31ck97 = 0 time = 490
.meas tran vdout1_31ck97 FIND v(dout1_31) AT=490.025n

* CHECK dout1_32 Vdout1_32ck97 = 0.9 time = 490
.meas tran vdout1_32ck97 FIND v(dout1_32) AT=490.025n

* CHECK dout1_33 Vdout1_33ck97 = 0.9 time = 490
.meas tran vdout1_33ck97 FIND v(dout1_33) AT=490.025n

* CHECK dout1_34 Vdout1_34ck97 = 0 time = 490
.meas tran vdout1_34ck97 FIND v(dout1_34) AT=490.025n

* CHECK dout1_35 Vdout1_35ck97 = 0 time = 490
.meas tran vdout1_35ck97 FIND v(dout1_35) AT=490.025n

* CHECK dout1_36 Vdout1_36ck97 = 0.9 time = 490
.meas tran vdout1_36ck97 FIND v(dout1_36) AT=490.025n

* CHECK dout1_37 Vdout1_37ck97 = 0 time = 490
.meas tran vdout1_37ck97 FIND v(dout1_37) AT=490.025n

* CHECK dout1_38 Vdout1_38ck97 = 0.9 time = 490
.meas tran vdout1_38ck97 FIND v(dout1_38) AT=490.025n

* CHECK dout1_39 Vdout1_39ck97 = 0 time = 490
.meas tran vdout1_39ck97 FIND v(dout1_39) AT=490.025n

* CHECK dout1_40 Vdout1_40ck97 = 0.9 time = 490
.meas tran vdout1_40ck97 FIND v(dout1_40) AT=490.025n

* CHECK dout1_41 Vdout1_41ck97 = 0 time = 490
.meas tran vdout1_41ck97 FIND v(dout1_41) AT=490.025n

* CHECK dout1_42 Vdout1_42ck97 = 0 time = 490
.meas tran vdout1_42ck97 FIND v(dout1_42) AT=490.025n

* CHECK dout1_43 Vdout1_43ck97 = 0 time = 490
.meas tran vdout1_43ck97 FIND v(dout1_43) AT=490.025n

* CHECK dout1_44 Vdout1_44ck97 = 0 time = 490
.meas tran vdout1_44ck97 FIND v(dout1_44) AT=490.025n

* CHECK dout1_45 Vdout1_45ck97 = 0 time = 490
.meas tran vdout1_45ck97 FIND v(dout1_45) AT=490.025n

* CHECK dout1_46 Vdout1_46ck97 = 0.9 time = 490
.meas tran vdout1_46ck97 FIND v(dout1_46) AT=490.025n

* CHECK dout1_47 Vdout1_47ck97 = 0.9 time = 490
.meas tran vdout1_47ck97 FIND v(dout1_47) AT=490.025n

* CHECK dout1_48 Vdout1_48ck97 = 0.9 time = 490
.meas tran vdout1_48ck97 FIND v(dout1_48) AT=490.025n

* CHECK dout1_49 Vdout1_49ck97 = 0.9 time = 490
.meas tran vdout1_49ck97 FIND v(dout1_49) AT=490.025n

* CHECK dout1_50 Vdout1_50ck97 = 0.9 time = 490
.meas tran vdout1_50ck97 FIND v(dout1_50) AT=490.025n

* CHECK dout1_51 Vdout1_51ck97 = 0 time = 490
.meas tran vdout1_51ck97 FIND v(dout1_51) AT=490.025n

* CHECK dout1_52 Vdout1_52ck97 = 0.9 time = 490
.meas tran vdout1_52ck97 FIND v(dout1_52) AT=490.025n

* CHECK dout1_53 Vdout1_53ck97 = 0 time = 490
.meas tran vdout1_53ck97 FIND v(dout1_53) AT=490.025n

* CHECK dout1_54 Vdout1_54ck97 = 0 time = 490
.meas tran vdout1_54ck97 FIND v(dout1_54) AT=490.025n

* CHECK dout1_55 Vdout1_55ck97 = 0.9 time = 490
.meas tran vdout1_55ck97 FIND v(dout1_55) AT=490.025n

* CHECK dout1_0 Vdout1_0ck98 = 0.9 time = 495
.meas tran vdout1_0ck98 FIND v(dout1_0) AT=495.025n

* CHECK dout1_1 Vdout1_1ck98 = 0 time = 495
.meas tran vdout1_1ck98 FIND v(dout1_1) AT=495.025n

* CHECK dout1_2 Vdout1_2ck98 = 0 time = 495
.meas tran vdout1_2ck98 FIND v(dout1_2) AT=495.025n

* CHECK dout1_3 Vdout1_3ck98 = 0 time = 495
.meas tran vdout1_3ck98 FIND v(dout1_3) AT=495.025n

* CHECK dout1_4 Vdout1_4ck98 = 0 time = 495
.meas tran vdout1_4ck98 FIND v(dout1_4) AT=495.025n

* CHECK dout1_5 Vdout1_5ck98 = 0 time = 495
.meas tran vdout1_5ck98 FIND v(dout1_5) AT=495.025n

* CHECK dout1_6 Vdout1_6ck98 = 0.9 time = 495
.meas tran vdout1_6ck98 FIND v(dout1_6) AT=495.025n

* CHECK dout1_7 Vdout1_7ck98 = 0.9 time = 495
.meas tran vdout1_7ck98 FIND v(dout1_7) AT=495.025n

* CHECK dout1_8 Vdout1_8ck98 = 0 time = 495
.meas tran vdout1_8ck98 FIND v(dout1_8) AT=495.025n

* CHECK dout1_9 Vdout1_9ck98 = 0 time = 495
.meas tran vdout1_9ck98 FIND v(dout1_9) AT=495.025n

* CHECK dout1_10 Vdout1_10ck98 = 0.9 time = 495
.meas tran vdout1_10ck98 FIND v(dout1_10) AT=495.025n

* CHECK dout1_11 Vdout1_11ck98 = 0.9 time = 495
.meas tran vdout1_11ck98 FIND v(dout1_11) AT=495.025n

* CHECK dout1_12 Vdout1_12ck98 = 0.9 time = 495
.meas tran vdout1_12ck98 FIND v(dout1_12) AT=495.025n

* CHECK dout1_13 Vdout1_13ck98 = 0 time = 495
.meas tran vdout1_13ck98 FIND v(dout1_13) AT=495.025n

* CHECK dout1_14 Vdout1_14ck98 = 0 time = 495
.meas tran vdout1_14ck98 FIND v(dout1_14) AT=495.025n

* CHECK dout1_15 Vdout1_15ck98 = 0.9 time = 495
.meas tran vdout1_15ck98 FIND v(dout1_15) AT=495.025n

* CHECK dout1_16 Vdout1_16ck98 = 0.9 time = 495
.meas tran vdout1_16ck98 FIND v(dout1_16) AT=495.025n

* CHECK dout1_17 Vdout1_17ck98 = 0 time = 495
.meas tran vdout1_17ck98 FIND v(dout1_17) AT=495.025n

* CHECK dout1_18 Vdout1_18ck98 = 0 time = 495
.meas tran vdout1_18ck98 FIND v(dout1_18) AT=495.025n

* CHECK dout1_19 Vdout1_19ck98 = 0.9 time = 495
.meas tran vdout1_19ck98 FIND v(dout1_19) AT=495.025n

* CHECK dout1_20 Vdout1_20ck98 = 0 time = 495
.meas tran vdout1_20ck98 FIND v(dout1_20) AT=495.025n

* CHECK dout1_21 Vdout1_21ck98 = 0 time = 495
.meas tran vdout1_21ck98 FIND v(dout1_21) AT=495.025n

* CHECK dout1_22 Vdout1_22ck98 = 0 time = 495
.meas tran vdout1_22ck98 FIND v(dout1_22) AT=495.025n

* CHECK dout1_23 Vdout1_23ck98 = 0.9 time = 495
.meas tran vdout1_23ck98 FIND v(dout1_23) AT=495.025n

* CHECK dout1_24 Vdout1_24ck98 = 0 time = 495
.meas tran vdout1_24ck98 FIND v(dout1_24) AT=495.025n

* CHECK dout1_25 Vdout1_25ck98 = 0 time = 495
.meas tran vdout1_25ck98 FIND v(dout1_25) AT=495.025n

* CHECK dout1_26 Vdout1_26ck98 = 0.9 time = 495
.meas tran vdout1_26ck98 FIND v(dout1_26) AT=495.025n

* CHECK dout1_27 Vdout1_27ck98 = 0 time = 495
.meas tran vdout1_27ck98 FIND v(dout1_27) AT=495.025n

* CHECK dout1_28 Vdout1_28ck98 = 0 time = 495
.meas tran vdout1_28ck98 FIND v(dout1_28) AT=495.025n

* CHECK dout1_29 Vdout1_29ck98 = 0 time = 495
.meas tran vdout1_29ck98 FIND v(dout1_29) AT=495.025n

* CHECK dout1_30 Vdout1_30ck98 = 0.9 time = 495
.meas tran vdout1_30ck98 FIND v(dout1_30) AT=495.025n

* CHECK dout1_31 Vdout1_31ck98 = 0.9 time = 495
.meas tran vdout1_31ck98 FIND v(dout1_31) AT=495.025n

* CHECK dout1_32 Vdout1_32ck98 = 0.9 time = 495
.meas tran vdout1_32ck98 FIND v(dout1_32) AT=495.025n

* CHECK dout1_33 Vdout1_33ck98 = 0.9 time = 495
.meas tran vdout1_33ck98 FIND v(dout1_33) AT=495.025n

* CHECK dout1_34 Vdout1_34ck98 = 0 time = 495
.meas tran vdout1_34ck98 FIND v(dout1_34) AT=495.025n

* CHECK dout1_35 Vdout1_35ck98 = 0 time = 495
.meas tran vdout1_35ck98 FIND v(dout1_35) AT=495.025n

* CHECK dout1_36 Vdout1_36ck98 = 0 time = 495
.meas tran vdout1_36ck98 FIND v(dout1_36) AT=495.025n

* CHECK dout1_37 Vdout1_37ck98 = 0 time = 495
.meas tran vdout1_37ck98 FIND v(dout1_37) AT=495.025n

* CHECK dout1_38 Vdout1_38ck98 = 0 time = 495
.meas tran vdout1_38ck98 FIND v(dout1_38) AT=495.025n

* CHECK dout1_39 Vdout1_39ck98 = 0 time = 495
.meas tran vdout1_39ck98 FIND v(dout1_39) AT=495.025n

* CHECK dout1_40 Vdout1_40ck98 = 0 time = 495
.meas tran vdout1_40ck98 FIND v(dout1_40) AT=495.025n

* CHECK dout1_41 Vdout1_41ck98 = 0.9 time = 495
.meas tran vdout1_41ck98 FIND v(dout1_41) AT=495.025n

* CHECK dout1_42 Vdout1_42ck98 = 0.9 time = 495
.meas tran vdout1_42ck98 FIND v(dout1_42) AT=495.025n

* CHECK dout1_43 Vdout1_43ck98 = 0 time = 495
.meas tran vdout1_43ck98 FIND v(dout1_43) AT=495.025n

* CHECK dout1_44 Vdout1_44ck98 = 0.9 time = 495
.meas tran vdout1_44ck98 FIND v(dout1_44) AT=495.025n

* CHECK dout1_45 Vdout1_45ck98 = 0 time = 495
.meas tran vdout1_45ck98 FIND v(dout1_45) AT=495.025n

* CHECK dout1_46 Vdout1_46ck98 = 0 time = 495
.meas tran vdout1_46ck98 FIND v(dout1_46) AT=495.025n

* CHECK dout1_47 Vdout1_47ck98 = 0 time = 495
.meas tran vdout1_47ck98 FIND v(dout1_47) AT=495.025n

* CHECK dout1_48 Vdout1_48ck98 = 0.9 time = 495
.meas tran vdout1_48ck98 FIND v(dout1_48) AT=495.025n

* CHECK dout1_49 Vdout1_49ck98 = 0 time = 495
.meas tran vdout1_49ck98 FIND v(dout1_49) AT=495.025n

* CHECK dout1_50 Vdout1_50ck98 = 0 time = 495
.meas tran vdout1_50ck98 FIND v(dout1_50) AT=495.025n

* CHECK dout1_51 Vdout1_51ck98 = 0 time = 495
.meas tran vdout1_51ck98 FIND v(dout1_51) AT=495.025n

* CHECK dout1_52 Vdout1_52ck98 = 0.9 time = 495
.meas tran vdout1_52ck98 FIND v(dout1_52) AT=495.025n

* CHECK dout1_53 Vdout1_53ck98 = 0 time = 495
.meas tran vdout1_53ck98 FIND v(dout1_53) AT=495.025n

* CHECK dout1_54 Vdout1_54ck98 = 0.9 time = 495
.meas tran vdout1_54ck98 FIND v(dout1_54) AT=495.025n

* CHECK dout1_55 Vdout1_55ck98 = 0.9 time = 495
.meas tran vdout1_55ck98 FIND v(dout1_55) AT=495.025n

* CHECK dout1_0 Vdout1_0ck99 = 0.9 time = 500
.meas tran vdout1_0ck99 FIND v(dout1_0) AT=500.025n

* CHECK dout1_1 Vdout1_1ck99 = 0 time = 500
.meas tran vdout1_1ck99 FIND v(dout1_1) AT=500.025n

* CHECK dout1_2 Vdout1_2ck99 = 0 time = 500
.meas tran vdout1_2ck99 FIND v(dout1_2) AT=500.025n

* CHECK dout1_3 Vdout1_3ck99 = 0 time = 500
.meas tran vdout1_3ck99 FIND v(dout1_3) AT=500.025n

* CHECK dout1_4 Vdout1_4ck99 = 0 time = 500
.meas tran vdout1_4ck99 FIND v(dout1_4) AT=500.025n

* CHECK dout1_5 Vdout1_5ck99 = 0 time = 500
.meas tran vdout1_5ck99 FIND v(dout1_5) AT=500.025n

* CHECK dout1_6 Vdout1_6ck99 = 0.9 time = 500
.meas tran vdout1_6ck99 FIND v(dout1_6) AT=500.025n

* CHECK dout1_7 Vdout1_7ck99 = 0.9 time = 500
.meas tran vdout1_7ck99 FIND v(dout1_7) AT=500.025n

* CHECK dout1_8 Vdout1_8ck99 = 0 time = 500
.meas tran vdout1_8ck99 FIND v(dout1_8) AT=500.025n

* CHECK dout1_9 Vdout1_9ck99 = 0 time = 500
.meas tran vdout1_9ck99 FIND v(dout1_9) AT=500.025n

* CHECK dout1_10 Vdout1_10ck99 = 0.9 time = 500
.meas tran vdout1_10ck99 FIND v(dout1_10) AT=500.025n

* CHECK dout1_11 Vdout1_11ck99 = 0.9 time = 500
.meas tran vdout1_11ck99 FIND v(dout1_11) AT=500.025n

* CHECK dout1_12 Vdout1_12ck99 = 0.9 time = 500
.meas tran vdout1_12ck99 FIND v(dout1_12) AT=500.025n

* CHECK dout1_13 Vdout1_13ck99 = 0 time = 500
.meas tran vdout1_13ck99 FIND v(dout1_13) AT=500.025n

* CHECK dout1_14 Vdout1_14ck99 = 0 time = 500
.meas tran vdout1_14ck99 FIND v(dout1_14) AT=500.025n

* CHECK dout1_15 Vdout1_15ck99 = 0.9 time = 500
.meas tran vdout1_15ck99 FIND v(dout1_15) AT=500.025n

* CHECK dout1_16 Vdout1_16ck99 = 0.9 time = 500
.meas tran vdout1_16ck99 FIND v(dout1_16) AT=500.025n

* CHECK dout1_17 Vdout1_17ck99 = 0 time = 500
.meas tran vdout1_17ck99 FIND v(dout1_17) AT=500.025n

* CHECK dout1_18 Vdout1_18ck99 = 0 time = 500
.meas tran vdout1_18ck99 FIND v(dout1_18) AT=500.025n

* CHECK dout1_19 Vdout1_19ck99 = 0.9 time = 500
.meas tran vdout1_19ck99 FIND v(dout1_19) AT=500.025n

* CHECK dout1_20 Vdout1_20ck99 = 0 time = 500
.meas tran vdout1_20ck99 FIND v(dout1_20) AT=500.025n

* CHECK dout1_21 Vdout1_21ck99 = 0 time = 500
.meas tran vdout1_21ck99 FIND v(dout1_21) AT=500.025n

* CHECK dout1_22 Vdout1_22ck99 = 0 time = 500
.meas tran vdout1_22ck99 FIND v(dout1_22) AT=500.025n

* CHECK dout1_23 Vdout1_23ck99 = 0.9 time = 500
.meas tran vdout1_23ck99 FIND v(dout1_23) AT=500.025n

* CHECK dout1_24 Vdout1_24ck99 = 0 time = 500
.meas tran vdout1_24ck99 FIND v(dout1_24) AT=500.025n

* CHECK dout1_25 Vdout1_25ck99 = 0 time = 500
.meas tran vdout1_25ck99 FIND v(dout1_25) AT=500.025n

* CHECK dout1_26 Vdout1_26ck99 = 0.9 time = 500
.meas tran vdout1_26ck99 FIND v(dout1_26) AT=500.025n

* CHECK dout1_27 Vdout1_27ck99 = 0 time = 500
.meas tran vdout1_27ck99 FIND v(dout1_27) AT=500.025n

* CHECK dout1_28 Vdout1_28ck99 = 0 time = 500
.meas tran vdout1_28ck99 FIND v(dout1_28) AT=500.025n

* CHECK dout1_29 Vdout1_29ck99 = 0 time = 500
.meas tran vdout1_29ck99 FIND v(dout1_29) AT=500.025n

* CHECK dout1_30 Vdout1_30ck99 = 0.9 time = 500
.meas tran vdout1_30ck99 FIND v(dout1_30) AT=500.025n

* CHECK dout1_31 Vdout1_31ck99 = 0.9 time = 500
.meas tran vdout1_31ck99 FIND v(dout1_31) AT=500.025n

* CHECK dout1_32 Vdout1_32ck99 = 0.9 time = 500
.meas tran vdout1_32ck99 FIND v(dout1_32) AT=500.025n

* CHECK dout1_33 Vdout1_33ck99 = 0.9 time = 500
.meas tran vdout1_33ck99 FIND v(dout1_33) AT=500.025n

* CHECK dout1_34 Vdout1_34ck99 = 0 time = 500
.meas tran vdout1_34ck99 FIND v(dout1_34) AT=500.025n

* CHECK dout1_35 Vdout1_35ck99 = 0 time = 500
.meas tran vdout1_35ck99 FIND v(dout1_35) AT=500.025n

* CHECK dout1_36 Vdout1_36ck99 = 0 time = 500
.meas tran vdout1_36ck99 FIND v(dout1_36) AT=500.025n

* CHECK dout1_37 Vdout1_37ck99 = 0 time = 500
.meas tran vdout1_37ck99 FIND v(dout1_37) AT=500.025n

* CHECK dout1_38 Vdout1_38ck99 = 0 time = 500
.meas tran vdout1_38ck99 FIND v(dout1_38) AT=500.025n

* CHECK dout1_39 Vdout1_39ck99 = 0 time = 500
.meas tran vdout1_39ck99 FIND v(dout1_39) AT=500.025n

* CHECK dout1_40 Vdout1_40ck99 = 0 time = 500
.meas tran vdout1_40ck99 FIND v(dout1_40) AT=500.025n

* CHECK dout1_41 Vdout1_41ck99 = 0.9 time = 500
.meas tran vdout1_41ck99 FIND v(dout1_41) AT=500.025n

* CHECK dout1_42 Vdout1_42ck99 = 0.9 time = 500
.meas tran vdout1_42ck99 FIND v(dout1_42) AT=500.025n

* CHECK dout1_43 Vdout1_43ck99 = 0 time = 500
.meas tran vdout1_43ck99 FIND v(dout1_43) AT=500.025n

* CHECK dout1_44 Vdout1_44ck99 = 0.9 time = 500
.meas tran vdout1_44ck99 FIND v(dout1_44) AT=500.025n

* CHECK dout1_45 Vdout1_45ck99 = 0 time = 500
.meas tran vdout1_45ck99 FIND v(dout1_45) AT=500.025n

* CHECK dout1_46 Vdout1_46ck99 = 0 time = 500
.meas tran vdout1_46ck99 FIND v(dout1_46) AT=500.025n

* CHECK dout1_47 Vdout1_47ck99 = 0 time = 500
.meas tran vdout1_47ck99 FIND v(dout1_47) AT=500.025n

* CHECK dout1_48 Vdout1_48ck99 = 0.9 time = 500
.meas tran vdout1_48ck99 FIND v(dout1_48) AT=500.025n

* CHECK dout1_49 Vdout1_49ck99 = 0 time = 500
.meas tran vdout1_49ck99 FIND v(dout1_49) AT=500.025n

* CHECK dout1_50 Vdout1_50ck99 = 0 time = 500
.meas tran vdout1_50ck99 FIND v(dout1_50) AT=500.025n

* CHECK dout1_51 Vdout1_51ck99 = 0 time = 500
.meas tran vdout1_51ck99 FIND v(dout1_51) AT=500.025n

* CHECK dout1_52 Vdout1_52ck99 = 0.9 time = 500
.meas tran vdout1_52ck99 FIND v(dout1_52) AT=500.025n

* CHECK dout1_53 Vdout1_53ck99 = 0 time = 500
.meas tran vdout1_53ck99 FIND v(dout1_53) AT=500.025n

* CHECK dout1_54 Vdout1_54ck99 = 0.9 time = 500
.meas tran vdout1_54ck99 FIND v(dout1_54) AT=500.025n

* CHECK dout1_55 Vdout1_55ck99 = 0.9 time = 500
.meas tran vdout1_55ck99 FIND v(dout1_55) AT=500.025n

* CHECK dout1_0 Vdout1_0ck102 = 0.9 time = 515
.meas tran vdout1_0ck102 FIND v(dout1_0) AT=515.025n

* CHECK dout1_1 Vdout1_1ck102 = 0 time = 515
.meas tran vdout1_1ck102 FIND v(dout1_1) AT=515.025n

* CHECK dout1_2 Vdout1_2ck102 = 0 time = 515
.meas tran vdout1_2ck102 FIND v(dout1_2) AT=515.025n

* CHECK dout1_3 Vdout1_3ck102 = 0 time = 515
.meas tran vdout1_3ck102 FIND v(dout1_3) AT=515.025n

* CHECK dout1_4 Vdout1_4ck102 = 0 time = 515
.meas tran vdout1_4ck102 FIND v(dout1_4) AT=515.025n

* CHECK dout1_5 Vdout1_5ck102 = 0 time = 515
.meas tran vdout1_5ck102 FIND v(dout1_5) AT=515.025n

* CHECK dout1_6 Vdout1_6ck102 = 0.9 time = 515
.meas tran vdout1_6ck102 FIND v(dout1_6) AT=515.025n

* CHECK dout1_7 Vdout1_7ck102 = 0.9 time = 515
.meas tran vdout1_7ck102 FIND v(dout1_7) AT=515.025n

* CHECK dout1_8 Vdout1_8ck102 = 0 time = 515
.meas tran vdout1_8ck102 FIND v(dout1_8) AT=515.025n

* CHECK dout1_9 Vdout1_9ck102 = 0 time = 515
.meas tran vdout1_9ck102 FIND v(dout1_9) AT=515.025n

* CHECK dout1_10 Vdout1_10ck102 = 0.9 time = 515
.meas tran vdout1_10ck102 FIND v(dout1_10) AT=515.025n

* CHECK dout1_11 Vdout1_11ck102 = 0.9 time = 515
.meas tran vdout1_11ck102 FIND v(dout1_11) AT=515.025n

* CHECK dout1_12 Vdout1_12ck102 = 0.9 time = 515
.meas tran vdout1_12ck102 FIND v(dout1_12) AT=515.025n

* CHECK dout1_13 Vdout1_13ck102 = 0 time = 515
.meas tran vdout1_13ck102 FIND v(dout1_13) AT=515.025n

* CHECK dout1_14 Vdout1_14ck102 = 0 time = 515
.meas tran vdout1_14ck102 FIND v(dout1_14) AT=515.025n

* CHECK dout1_15 Vdout1_15ck102 = 0.9 time = 515
.meas tran vdout1_15ck102 FIND v(dout1_15) AT=515.025n

* CHECK dout1_16 Vdout1_16ck102 = 0.9 time = 515
.meas tran vdout1_16ck102 FIND v(dout1_16) AT=515.025n

* CHECK dout1_17 Vdout1_17ck102 = 0 time = 515
.meas tran vdout1_17ck102 FIND v(dout1_17) AT=515.025n

* CHECK dout1_18 Vdout1_18ck102 = 0 time = 515
.meas tran vdout1_18ck102 FIND v(dout1_18) AT=515.025n

* CHECK dout1_19 Vdout1_19ck102 = 0.9 time = 515
.meas tran vdout1_19ck102 FIND v(dout1_19) AT=515.025n

* CHECK dout1_20 Vdout1_20ck102 = 0 time = 515
.meas tran vdout1_20ck102 FIND v(dout1_20) AT=515.025n

* CHECK dout1_21 Vdout1_21ck102 = 0 time = 515
.meas tran vdout1_21ck102 FIND v(dout1_21) AT=515.025n

* CHECK dout1_22 Vdout1_22ck102 = 0 time = 515
.meas tran vdout1_22ck102 FIND v(dout1_22) AT=515.025n

* CHECK dout1_23 Vdout1_23ck102 = 0.9 time = 515
.meas tran vdout1_23ck102 FIND v(dout1_23) AT=515.025n

* CHECK dout1_24 Vdout1_24ck102 = 0 time = 515
.meas tran vdout1_24ck102 FIND v(dout1_24) AT=515.025n

* CHECK dout1_25 Vdout1_25ck102 = 0 time = 515
.meas tran vdout1_25ck102 FIND v(dout1_25) AT=515.025n

* CHECK dout1_26 Vdout1_26ck102 = 0.9 time = 515
.meas tran vdout1_26ck102 FIND v(dout1_26) AT=515.025n

* CHECK dout1_27 Vdout1_27ck102 = 0 time = 515
.meas tran vdout1_27ck102 FIND v(dout1_27) AT=515.025n

* CHECK dout1_28 Vdout1_28ck102 = 0 time = 515
.meas tran vdout1_28ck102 FIND v(dout1_28) AT=515.025n

* CHECK dout1_29 Vdout1_29ck102 = 0 time = 515
.meas tran vdout1_29ck102 FIND v(dout1_29) AT=515.025n

* CHECK dout1_30 Vdout1_30ck102 = 0.9 time = 515
.meas tran vdout1_30ck102 FIND v(dout1_30) AT=515.025n

* CHECK dout1_31 Vdout1_31ck102 = 0.9 time = 515
.meas tran vdout1_31ck102 FIND v(dout1_31) AT=515.025n

* CHECK dout1_32 Vdout1_32ck102 = 0.9 time = 515
.meas tran vdout1_32ck102 FIND v(dout1_32) AT=515.025n

* CHECK dout1_33 Vdout1_33ck102 = 0.9 time = 515
.meas tran vdout1_33ck102 FIND v(dout1_33) AT=515.025n

* CHECK dout1_34 Vdout1_34ck102 = 0 time = 515
.meas tran vdout1_34ck102 FIND v(dout1_34) AT=515.025n

* CHECK dout1_35 Vdout1_35ck102 = 0 time = 515
.meas tran vdout1_35ck102 FIND v(dout1_35) AT=515.025n

* CHECK dout1_36 Vdout1_36ck102 = 0 time = 515
.meas tran vdout1_36ck102 FIND v(dout1_36) AT=515.025n

* CHECK dout1_37 Vdout1_37ck102 = 0 time = 515
.meas tran vdout1_37ck102 FIND v(dout1_37) AT=515.025n

* CHECK dout1_38 Vdout1_38ck102 = 0 time = 515
.meas tran vdout1_38ck102 FIND v(dout1_38) AT=515.025n

* CHECK dout1_39 Vdout1_39ck102 = 0 time = 515
.meas tran vdout1_39ck102 FIND v(dout1_39) AT=515.025n

* CHECK dout1_40 Vdout1_40ck102 = 0 time = 515
.meas tran vdout1_40ck102 FIND v(dout1_40) AT=515.025n

* CHECK dout1_41 Vdout1_41ck102 = 0.9 time = 515
.meas tran vdout1_41ck102 FIND v(dout1_41) AT=515.025n

* CHECK dout1_42 Vdout1_42ck102 = 0.9 time = 515
.meas tran vdout1_42ck102 FIND v(dout1_42) AT=515.025n

* CHECK dout1_43 Vdout1_43ck102 = 0 time = 515
.meas tran vdout1_43ck102 FIND v(dout1_43) AT=515.025n

* CHECK dout1_44 Vdout1_44ck102 = 0.9 time = 515
.meas tran vdout1_44ck102 FIND v(dout1_44) AT=515.025n

* CHECK dout1_45 Vdout1_45ck102 = 0 time = 515
.meas tran vdout1_45ck102 FIND v(dout1_45) AT=515.025n

* CHECK dout1_46 Vdout1_46ck102 = 0 time = 515
.meas tran vdout1_46ck102 FIND v(dout1_46) AT=515.025n

* CHECK dout1_47 Vdout1_47ck102 = 0 time = 515
.meas tran vdout1_47ck102 FIND v(dout1_47) AT=515.025n

* CHECK dout1_48 Vdout1_48ck102 = 0.9 time = 515
.meas tran vdout1_48ck102 FIND v(dout1_48) AT=515.025n

* CHECK dout1_49 Vdout1_49ck102 = 0 time = 515
.meas tran vdout1_49ck102 FIND v(dout1_49) AT=515.025n

* CHECK dout1_50 Vdout1_50ck102 = 0 time = 515
.meas tran vdout1_50ck102 FIND v(dout1_50) AT=515.025n

* CHECK dout1_51 Vdout1_51ck102 = 0 time = 515
.meas tran vdout1_51ck102 FIND v(dout1_51) AT=515.025n

* CHECK dout1_52 Vdout1_52ck102 = 0.9 time = 515
.meas tran vdout1_52ck102 FIND v(dout1_52) AT=515.025n

* CHECK dout1_53 Vdout1_53ck102 = 0 time = 515
.meas tran vdout1_53ck102 FIND v(dout1_53) AT=515.025n

* CHECK dout1_54 Vdout1_54ck102 = 0.9 time = 515
.meas tran vdout1_54ck102 FIND v(dout1_54) AT=515.025n

* CHECK dout1_55 Vdout1_55ck102 = 0.9 time = 515
.meas tran vdout1_55ck102 FIND v(dout1_55) AT=515.025n

* CHECK dout1_0 Vdout1_0ck106 = 0.9 time = 535
.meas tran vdout1_0ck106 FIND v(dout1_0) AT=535.025n

* CHECK dout1_1 Vdout1_1ck106 = 0 time = 535
.meas tran vdout1_1ck106 FIND v(dout1_1) AT=535.025n

* CHECK dout1_2 Vdout1_2ck106 = 0 time = 535
.meas tran vdout1_2ck106 FIND v(dout1_2) AT=535.025n

* CHECK dout1_3 Vdout1_3ck106 = 0.9 time = 535
.meas tran vdout1_3ck106 FIND v(dout1_3) AT=535.025n

* CHECK dout1_4 Vdout1_4ck106 = 0 time = 535
.meas tran vdout1_4ck106 FIND v(dout1_4) AT=535.025n

* CHECK dout1_5 Vdout1_5ck106 = 0 time = 535
.meas tran vdout1_5ck106 FIND v(dout1_5) AT=535.025n

* CHECK dout1_6 Vdout1_6ck106 = 0.9 time = 535
.meas tran vdout1_6ck106 FIND v(dout1_6) AT=535.025n

* CHECK dout1_7 Vdout1_7ck106 = 0 time = 535
.meas tran vdout1_7ck106 FIND v(dout1_7) AT=535.025n

* CHECK dout1_8 Vdout1_8ck106 = 0 time = 535
.meas tran vdout1_8ck106 FIND v(dout1_8) AT=535.025n

* CHECK dout1_9 Vdout1_9ck106 = 0 time = 535
.meas tran vdout1_9ck106 FIND v(dout1_9) AT=535.025n

* CHECK dout1_10 Vdout1_10ck106 = 0.9 time = 535
.meas tran vdout1_10ck106 FIND v(dout1_10) AT=535.025n

* CHECK dout1_11 Vdout1_11ck106 = 0 time = 535
.meas tran vdout1_11ck106 FIND v(dout1_11) AT=535.025n

* CHECK dout1_12 Vdout1_12ck106 = 0.9 time = 535
.meas tran vdout1_12ck106 FIND v(dout1_12) AT=535.025n

* CHECK dout1_13 Vdout1_13ck106 = 0 time = 535
.meas tran vdout1_13ck106 FIND v(dout1_13) AT=535.025n

* CHECK dout1_14 Vdout1_14ck106 = 0 time = 535
.meas tran vdout1_14ck106 FIND v(dout1_14) AT=535.025n

* CHECK dout1_15 Vdout1_15ck106 = 0 time = 535
.meas tran vdout1_15ck106 FIND v(dout1_15) AT=535.025n

* CHECK dout1_16 Vdout1_16ck106 = 0 time = 535
.meas tran vdout1_16ck106 FIND v(dout1_16) AT=535.025n

* CHECK dout1_17 Vdout1_17ck106 = 0 time = 535
.meas tran vdout1_17ck106 FIND v(dout1_17) AT=535.025n

* CHECK dout1_18 Vdout1_18ck106 = 0.9 time = 535
.meas tran vdout1_18ck106 FIND v(dout1_18) AT=535.025n

* CHECK dout1_19 Vdout1_19ck106 = 0 time = 535
.meas tran vdout1_19ck106 FIND v(dout1_19) AT=535.025n

* CHECK dout1_20 Vdout1_20ck106 = 0 time = 535
.meas tran vdout1_20ck106 FIND v(dout1_20) AT=535.025n

* CHECK dout1_21 Vdout1_21ck106 = 0.9 time = 535
.meas tran vdout1_21ck106 FIND v(dout1_21) AT=535.025n

* CHECK dout1_22 Vdout1_22ck106 = 0.9 time = 535
.meas tran vdout1_22ck106 FIND v(dout1_22) AT=535.025n

* CHECK dout1_23 Vdout1_23ck106 = 0 time = 535
.meas tran vdout1_23ck106 FIND v(dout1_23) AT=535.025n

* CHECK dout1_24 Vdout1_24ck106 = 0.9 time = 535
.meas tran vdout1_24ck106 FIND v(dout1_24) AT=535.025n

* CHECK dout1_25 Vdout1_25ck106 = 0.9 time = 535
.meas tran vdout1_25ck106 FIND v(dout1_25) AT=535.025n

* CHECK dout1_26 Vdout1_26ck106 = 0 time = 535
.meas tran vdout1_26ck106 FIND v(dout1_26) AT=535.025n

* CHECK dout1_27 Vdout1_27ck106 = 0.9 time = 535
.meas tran vdout1_27ck106 FIND v(dout1_27) AT=535.025n

* CHECK dout1_28 Vdout1_28ck106 = 0.9 time = 535
.meas tran vdout1_28ck106 FIND v(dout1_28) AT=535.025n

* CHECK dout1_29 Vdout1_29ck106 = 0.9 time = 535
.meas tran vdout1_29ck106 FIND v(dout1_29) AT=535.025n

* CHECK dout1_30 Vdout1_30ck106 = 0.9 time = 535
.meas tran vdout1_30ck106 FIND v(dout1_30) AT=535.025n

* CHECK dout1_31 Vdout1_31ck106 = 0 time = 535
.meas tran vdout1_31ck106 FIND v(dout1_31) AT=535.025n

* CHECK dout1_32 Vdout1_32ck106 = 0 time = 535
.meas tran vdout1_32ck106 FIND v(dout1_32) AT=535.025n

* CHECK dout1_33 Vdout1_33ck106 = 0.9 time = 535
.meas tran vdout1_33ck106 FIND v(dout1_33) AT=535.025n

* CHECK dout1_34 Vdout1_34ck106 = 0 time = 535
.meas tran vdout1_34ck106 FIND v(dout1_34) AT=535.025n

* CHECK dout1_35 Vdout1_35ck106 = 0.9 time = 535
.meas tran vdout1_35ck106 FIND v(dout1_35) AT=535.025n

* CHECK dout1_36 Vdout1_36ck106 = 0.9 time = 535
.meas tran vdout1_36ck106 FIND v(dout1_36) AT=535.025n

* CHECK dout1_37 Vdout1_37ck106 = 0 time = 535
.meas tran vdout1_37ck106 FIND v(dout1_37) AT=535.025n

* CHECK dout1_38 Vdout1_38ck106 = 0 time = 535
.meas tran vdout1_38ck106 FIND v(dout1_38) AT=535.025n

* CHECK dout1_39 Vdout1_39ck106 = 0.9 time = 535
.meas tran vdout1_39ck106 FIND v(dout1_39) AT=535.025n

* CHECK dout1_40 Vdout1_40ck106 = 0.9 time = 535
.meas tran vdout1_40ck106 FIND v(dout1_40) AT=535.025n

* CHECK dout1_41 Vdout1_41ck106 = 0.9 time = 535
.meas tran vdout1_41ck106 FIND v(dout1_41) AT=535.025n

* CHECK dout1_42 Vdout1_42ck106 = 0 time = 535
.meas tran vdout1_42ck106 FIND v(dout1_42) AT=535.025n

* CHECK dout1_43 Vdout1_43ck106 = 0.9 time = 535
.meas tran vdout1_43ck106 FIND v(dout1_43) AT=535.025n

* CHECK dout1_44 Vdout1_44ck106 = 0.9 time = 535
.meas tran vdout1_44ck106 FIND v(dout1_44) AT=535.025n

* CHECK dout1_45 Vdout1_45ck106 = 0.9 time = 535
.meas tran vdout1_45ck106 FIND v(dout1_45) AT=535.025n

* CHECK dout1_46 Vdout1_46ck106 = 0.9 time = 535
.meas tran vdout1_46ck106 FIND v(dout1_46) AT=535.025n

* CHECK dout1_47 Vdout1_47ck106 = 0 time = 535
.meas tran vdout1_47ck106 FIND v(dout1_47) AT=535.025n

* CHECK dout1_48 Vdout1_48ck106 = 0.9 time = 535
.meas tran vdout1_48ck106 FIND v(dout1_48) AT=535.025n

* CHECK dout1_49 Vdout1_49ck106 = 0 time = 535
.meas tran vdout1_49ck106 FIND v(dout1_49) AT=535.025n

* CHECK dout1_50 Vdout1_50ck106 = 0 time = 535
.meas tran vdout1_50ck106 FIND v(dout1_50) AT=535.025n

* CHECK dout1_51 Vdout1_51ck106 = 0 time = 535
.meas tran vdout1_51ck106 FIND v(dout1_51) AT=535.025n

* CHECK dout1_52 Vdout1_52ck106 = 0.9 time = 535
.meas tran vdout1_52ck106 FIND v(dout1_52) AT=535.025n

* CHECK dout1_53 Vdout1_53ck106 = 0.9 time = 535
.meas tran vdout1_53ck106 FIND v(dout1_53) AT=535.025n

* CHECK dout1_54 Vdout1_54ck106 = 0.9 time = 535
.meas tran vdout1_54ck106 FIND v(dout1_54) AT=535.025n

* CHECK dout1_55 Vdout1_55ck106 = 0 time = 535
.meas tran vdout1_55ck106 FIND v(dout1_55) AT=535.025n

* CHECK dout1_0 Vdout1_0ck108 = 0 time = 545
.meas tran vdout1_0ck108 FIND v(dout1_0) AT=545.025n

* CHECK dout1_1 Vdout1_1ck108 = 0.9 time = 545
.meas tran vdout1_1ck108 FIND v(dout1_1) AT=545.025n

* CHECK dout1_2 Vdout1_2ck108 = 0 time = 545
.meas tran vdout1_2ck108 FIND v(dout1_2) AT=545.025n

* CHECK dout1_3 Vdout1_3ck108 = 0 time = 545
.meas tran vdout1_3ck108 FIND v(dout1_3) AT=545.025n

* CHECK dout1_4 Vdout1_4ck108 = 0 time = 545
.meas tran vdout1_4ck108 FIND v(dout1_4) AT=545.025n

* CHECK dout1_5 Vdout1_5ck108 = 0 time = 545
.meas tran vdout1_5ck108 FIND v(dout1_5) AT=545.025n

* CHECK dout1_6 Vdout1_6ck108 = 0 time = 545
.meas tran vdout1_6ck108 FIND v(dout1_6) AT=545.025n

* CHECK dout1_7 Vdout1_7ck108 = 0.9 time = 545
.meas tran vdout1_7ck108 FIND v(dout1_7) AT=545.025n

* CHECK dout1_8 Vdout1_8ck108 = 0 time = 545
.meas tran vdout1_8ck108 FIND v(dout1_8) AT=545.025n

* CHECK dout1_9 Vdout1_9ck108 = 0 time = 545
.meas tran vdout1_9ck108 FIND v(dout1_9) AT=545.025n

* CHECK dout1_10 Vdout1_10ck108 = 0.9 time = 545
.meas tran vdout1_10ck108 FIND v(dout1_10) AT=545.025n

* CHECK dout1_11 Vdout1_11ck108 = 0.9 time = 545
.meas tran vdout1_11ck108 FIND v(dout1_11) AT=545.025n

* CHECK dout1_12 Vdout1_12ck108 = 0 time = 545
.meas tran vdout1_12ck108 FIND v(dout1_12) AT=545.025n

* CHECK dout1_13 Vdout1_13ck108 = 0.9 time = 545
.meas tran vdout1_13ck108 FIND v(dout1_13) AT=545.025n

* CHECK dout1_14 Vdout1_14ck108 = 0 time = 545
.meas tran vdout1_14ck108 FIND v(dout1_14) AT=545.025n

* CHECK dout1_15 Vdout1_15ck108 = 0 time = 545
.meas tran vdout1_15ck108 FIND v(dout1_15) AT=545.025n

* CHECK dout1_16 Vdout1_16ck108 = 0 time = 545
.meas tran vdout1_16ck108 FIND v(dout1_16) AT=545.025n

* CHECK dout1_17 Vdout1_17ck108 = 0.9 time = 545
.meas tran vdout1_17ck108 FIND v(dout1_17) AT=545.025n

* CHECK dout1_18 Vdout1_18ck108 = 0 time = 545
.meas tran vdout1_18ck108 FIND v(dout1_18) AT=545.025n

* CHECK dout1_19 Vdout1_19ck108 = 0 time = 545
.meas tran vdout1_19ck108 FIND v(dout1_19) AT=545.025n

* CHECK dout1_20 Vdout1_20ck108 = 0.9 time = 545
.meas tran vdout1_20ck108 FIND v(dout1_20) AT=545.025n

* CHECK dout1_21 Vdout1_21ck108 = 0 time = 545
.meas tran vdout1_21ck108 FIND v(dout1_21) AT=545.025n

* CHECK dout1_22 Vdout1_22ck108 = 0.9 time = 545
.meas tran vdout1_22ck108 FIND v(dout1_22) AT=545.025n

* CHECK dout1_23 Vdout1_23ck108 = 0.9 time = 545
.meas tran vdout1_23ck108 FIND v(dout1_23) AT=545.025n

* CHECK dout1_24 Vdout1_24ck108 = 0 time = 545
.meas tran vdout1_24ck108 FIND v(dout1_24) AT=545.025n

* CHECK dout1_25 Vdout1_25ck108 = 0 time = 545
.meas tran vdout1_25ck108 FIND v(dout1_25) AT=545.025n

* CHECK dout1_26 Vdout1_26ck108 = 0 time = 545
.meas tran vdout1_26ck108 FIND v(dout1_26) AT=545.025n

* CHECK dout1_27 Vdout1_27ck108 = 0.9 time = 545
.meas tran vdout1_27ck108 FIND v(dout1_27) AT=545.025n

* CHECK dout1_28 Vdout1_28ck108 = 0.9 time = 545
.meas tran vdout1_28ck108 FIND v(dout1_28) AT=545.025n

* CHECK dout1_29 Vdout1_29ck108 = 0.9 time = 545
.meas tran vdout1_29ck108 FIND v(dout1_29) AT=545.025n

* CHECK dout1_30 Vdout1_30ck108 = 0.9 time = 545
.meas tran vdout1_30ck108 FIND v(dout1_30) AT=545.025n

* CHECK dout1_31 Vdout1_31ck108 = 0 time = 545
.meas tran vdout1_31ck108 FIND v(dout1_31) AT=545.025n

* CHECK dout1_32 Vdout1_32ck108 = 0 time = 545
.meas tran vdout1_32ck108 FIND v(dout1_32) AT=545.025n

* CHECK dout1_33 Vdout1_33ck108 = 0 time = 545
.meas tran vdout1_33ck108 FIND v(dout1_33) AT=545.025n

* CHECK dout1_34 Vdout1_34ck108 = 0 time = 545
.meas tran vdout1_34ck108 FIND v(dout1_34) AT=545.025n

* CHECK dout1_35 Vdout1_35ck108 = 0 time = 545
.meas tran vdout1_35ck108 FIND v(dout1_35) AT=545.025n

* CHECK dout1_36 Vdout1_36ck108 = 0 time = 545
.meas tran vdout1_36ck108 FIND v(dout1_36) AT=545.025n

* CHECK dout1_37 Vdout1_37ck108 = 0 time = 545
.meas tran vdout1_37ck108 FIND v(dout1_37) AT=545.025n

* CHECK dout1_38 Vdout1_38ck108 = 0 time = 545
.meas tran vdout1_38ck108 FIND v(dout1_38) AT=545.025n

* CHECK dout1_39 Vdout1_39ck108 = 0 time = 545
.meas tran vdout1_39ck108 FIND v(dout1_39) AT=545.025n

* CHECK dout1_40 Vdout1_40ck108 = 0 time = 545
.meas tran vdout1_40ck108 FIND v(dout1_40) AT=545.025n

* CHECK dout1_41 Vdout1_41ck108 = 0.9 time = 545
.meas tran vdout1_41ck108 FIND v(dout1_41) AT=545.025n

* CHECK dout1_42 Vdout1_42ck108 = 0 time = 545
.meas tran vdout1_42ck108 FIND v(dout1_42) AT=545.025n

* CHECK dout1_43 Vdout1_43ck108 = 0.9 time = 545
.meas tran vdout1_43ck108 FIND v(dout1_43) AT=545.025n

* CHECK dout1_44 Vdout1_44ck108 = 0.9 time = 545
.meas tran vdout1_44ck108 FIND v(dout1_44) AT=545.025n

* CHECK dout1_45 Vdout1_45ck108 = 0 time = 545
.meas tran vdout1_45ck108 FIND v(dout1_45) AT=545.025n

* CHECK dout1_46 Vdout1_46ck108 = 0.9 time = 545
.meas tran vdout1_46ck108 FIND v(dout1_46) AT=545.025n

* CHECK dout1_47 Vdout1_47ck108 = 0 time = 545
.meas tran vdout1_47ck108 FIND v(dout1_47) AT=545.025n

* CHECK dout1_48 Vdout1_48ck108 = 0 time = 545
.meas tran vdout1_48ck108 FIND v(dout1_48) AT=545.025n

* CHECK dout1_49 Vdout1_49ck108 = 0 time = 545
.meas tran vdout1_49ck108 FIND v(dout1_49) AT=545.025n

* CHECK dout1_50 Vdout1_50ck108 = 0 time = 545
.meas tran vdout1_50ck108 FIND v(dout1_50) AT=545.025n

* CHECK dout1_51 Vdout1_51ck108 = 0 time = 545
.meas tran vdout1_51ck108 FIND v(dout1_51) AT=545.025n

* CHECK dout1_52 Vdout1_52ck108 = 0.9 time = 545
.meas tran vdout1_52ck108 FIND v(dout1_52) AT=545.025n

* CHECK dout1_53 Vdout1_53ck108 = 0.9 time = 545
.meas tran vdout1_53ck108 FIND v(dout1_53) AT=545.025n

* CHECK dout1_54 Vdout1_54ck108 = 0.9 time = 545
.meas tran vdout1_54ck108 FIND v(dout1_54) AT=545.025n

* CHECK dout1_55 Vdout1_55ck108 = 0.9 time = 545
.meas tran vdout1_55ck108 FIND v(dout1_55) AT=545.025n

* CHECK dout1_0 Vdout1_0ck109 = 0 time = 550
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=550.025n

* CHECK dout1_1 Vdout1_1ck109 = 0.9 time = 550
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=550.025n

* CHECK dout1_2 Vdout1_2ck109 = 0.9 time = 550
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=550.025n

* CHECK dout1_3 Vdout1_3ck109 = 0.9 time = 550
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=550.025n

* CHECK dout1_4 Vdout1_4ck109 = 0 time = 550
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=550.025n

* CHECK dout1_5 Vdout1_5ck109 = 0.9 time = 550
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=550.025n

* CHECK dout1_6 Vdout1_6ck109 = 0.9 time = 550
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=550.025n

* CHECK dout1_7 Vdout1_7ck109 = 0 time = 550
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=550.025n

* CHECK dout1_8 Vdout1_8ck109 = 0 time = 550
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=550.025n

* CHECK dout1_9 Vdout1_9ck109 = 0 time = 550
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=550.025n

* CHECK dout1_10 Vdout1_10ck109 = 0 time = 550
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=550.025n

* CHECK dout1_11 Vdout1_11ck109 = 0.9 time = 550
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=550.025n

* CHECK dout1_12 Vdout1_12ck109 = 0 time = 550
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=550.025n

* CHECK dout1_13 Vdout1_13ck109 = 0 time = 550
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=550.025n

* CHECK dout1_14 Vdout1_14ck109 = 0 time = 550
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=550.025n

* CHECK dout1_15 Vdout1_15ck109 = 0 time = 550
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=550.025n

* CHECK dout1_16 Vdout1_16ck109 = 0.9 time = 550
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=550.025n

* CHECK dout1_17 Vdout1_17ck109 = 0 time = 550
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=550.025n

* CHECK dout1_18 Vdout1_18ck109 = 0 time = 550
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=550.025n

* CHECK dout1_19 Vdout1_19ck109 = 0.9 time = 550
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=550.025n

* CHECK dout1_20 Vdout1_20ck109 = 0.9 time = 550
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=550.025n

* CHECK dout1_21 Vdout1_21ck109 = 0 time = 550
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=550.025n

* CHECK dout1_22 Vdout1_22ck109 = 0.9 time = 550
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=550.025n

* CHECK dout1_23 Vdout1_23ck109 = 0 time = 550
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=550.025n

* CHECK dout1_24 Vdout1_24ck109 = 0 time = 550
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=550.025n

* CHECK dout1_25 Vdout1_25ck109 = 0 time = 550
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=550.025n

* CHECK dout1_26 Vdout1_26ck109 = 0 time = 550
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=550.025n

* CHECK dout1_27 Vdout1_27ck109 = 0 time = 550
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=550.025n

* CHECK dout1_28 Vdout1_28ck109 = 0.9 time = 550
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=550.025n

* CHECK dout1_29 Vdout1_29ck109 = 0.9 time = 550
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=550.025n

* CHECK dout1_30 Vdout1_30ck109 = 0 time = 550
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=550.025n

* CHECK dout1_31 Vdout1_31ck109 = 0 time = 550
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=550.025n

* CHECK dout1_32 Vdout1_32ck109 = 0 time = 550
.meas tran vdout1_32ck109 FIND v(dout1_32) AT=550.025n

* CHECK dout1_33 Vdout1_33ck109 = 0.9 time = 550
.meas tran vdout1_33ck109 FIND v(dout1_33) AT=550.025n

* CHECK dout1_34 Vdout1_34ck109 = 0.9 time = 550
.meas tran vdout1_34ck109 FIND v(dout1_34) AT=550.025n

* CHECK dout1_35 Vdout1_35ck109 = 0.9 time = 550
.meas tran vdout1_35ck109 FIND v(dout1_35) AT=550.025n

* CHECK dout1_36 Vdout1_36ck109 = 0 time = 550
.meas tran vdout1_36ck109 FIND v(dout1_36) AT=550.025n

* CHECK dout1_37 Vdout1_37ck109 = 0 time = 550
.meas tran vdout1_37ck109 FIND v(dout1_37) AT=550.025n

* CHECK dout1_38 Vdout1_38ck109 = 0 time = 550
.meas tran vdout1_38ck109 FIND v(dout1_38) AT=550.025n

* CHECK dout1_39 Vdout1_39ck109 = 0.9 time = 550
.meas tran vdout1_39ck109 FIND v(dout1_39) AT=550.025n

* CHECK dout1_40 Vdout1_40ck109 = 0 time = 550
.meas tran vdout1_40ck109 FIND v(dout1_40) AT=550.025n

* CHECK dout1_41 Vdout1_41ck109 = 0 time = 550
.meas tran vdout1_41ck109 FIND v(dout1_41) AT=550.025n

* CHECK dout1_42 Vdout1_42ck109 = 0 time = 550
.meas tran vdout1_42ck109 FIND v(dout1_42) AT=550.025n

* CHECK dout1_43 Vdout1_43ck109 = 0.9 time = 550
.meas tran vdout1_43ck109 FIND v(dout1_43) AT=550.025n

* CHECK dout1_44 Vdout1_44ck109 = 0 time = 550
.meas tran vdout1_44ck109 FIND v(dout1_44) AT=550.025n

* CHECK dout1_45 Vdout1_45ck109 = 0.9 time = 550
.meas tran vdout1_45ck109 FIND v(dout1_45) AT=550.025n

* CHECK dout1_46 Vdout1_46ck109 = 0.9 time = 550
.meas tran vdout1_46ck109 FIND v(dout1_46) AT=550.025n

* CHECK dout1_47 Vdout1_47ck109 = 0 time = 550
.meas tran vdout1_47ck109 FIND v(dout1_47) AT=550.025n

* CHECK dout1_48 Vdout1_48ck109 = 0.9 time = 550
.meas tran vdout1_48ck109 FIND v(dout1_48) AT=550.025n

* CHECK dout1_49 Vdout1_49ck109 = 0 time = 550
.meas tran vdout1_49ck109 FIND v(dout1_49) AT=550.025n

* CHECK dout1_50 Vdout1_50ck109 = 0.9 time = 550
.meas tran vdout1_50ck109 FIND v(dout1_50) AT=550.025n

* CHECK dout1_51 Vdout1_51ck109 = 0.9 time = 550
.meas tran vdout1_51ck109 FIND v(dout1_51) AT=550.025n

* CHECK dout1_52 Vdout1_52ck109 = 0.9 time = 550
.meas tran vdout1_52ck109 FIND v(dout1_52) AT=550.025n

* CHECK dout1_53 Vdout1_53ck109 = 0.9 time = 550
.meas tran vdout1_53ck109 FIND v(dout1_53) AT=550.025n

* CHECK dout1_54 Vdout1_54ck109 = 0 time = 550
.meas tran vdout1_54ck109 FIND v(dout1_54) AT=550.025n

* CHECK dout1_55 Vdout1_55ck109 = 0.9 time = 550
.meas tran vdout1_55ck109 FIND v(dout1_55) AT=550.025n

* CHECK dout1_0 Vdout1_0ck110 = 0 time = 555
.meas tran vdout1_0ck110 FIND v(dout1_0) AT=555.025n

* CHECK dout1_1 Vdout1_1ck110 = 0.9 time = 555
.meas tran vdout1_1ck110 FIND v(dout1_1) AT=555.025n

* CHECK dout1_2 Vdout1_2ck110 = 0.9 time = 555
.meas tran vdout1_2ck110 FIND v(dout1_2) AT=555.025n

* CHECK dout1_3 Vdout1_3ck110 = 0.9 time = 555
.meas tran vdout1_3ck110 FIND v(dout1_3) AT=555.025n

* CHECK dout1_4 Vdout1_4ck110 = 0 time = 555
.meas tran vdout1_4ck110 FIND v(dout1_4) AT=555.025n

* CHECK dout1_5 Vdout1_5ck110 = 0.9 time = 555
.meas tran vdout1_5ck110 FIND v(dout1_5) AT=555.025n

* CHECK dout1_6 Vdout1_6ck110 = 0.9 time = 555
.meas tran vdout1_6ck110 FIND v(dout1_6) AT=555.025n

* CHECK dout1_7 Vdout1_7ck110 = 0 time = 555
.meas tran vdout1_7ck110 FIND v(dout1_7) AT=555.025n

* CHECK dout1_8 Vdout1_8ck110 = 0 time = 555
.meas tran vdout1_8ck110 FIND v(dout1_8) AT=555.025n

* CHECK dout1_9 Vdout1_9ck110 = 0 time = 555
.meas tran vdout1_9ck110 FIND v(dout1_9) AT=555.025n

* CHECK dout1_10 Vdout1_10ck110 = 0 time = 555
.meas tran vdout1_10ck110 FIND v(dout1_10) AT=555.025n

* CHECK dout1_11 Vdout1_11ck110 = 0.9 time = 555
.meas tran vdout1_11ck110 FIND v(dout1_11) AT=555.025n

* CHECK dout1_12 Vdout1_12ck110 = 0 time = 555
.meas tran vdout1_12ck110 FIND v(dout1_12) AT=555.025n

* CHECK dout1_13 Vdout1_13ck110 = 0 time = 555
.meas tran vdout1_13ck110 FIND v(dout1_13) AT=555.025n

* CHECK dout1_14 Vdout1_14ck110 = 0 time = 555
.meas tran vdout1_14ck110 FIND v(dout1_14) AT=555.025n

* CHECK dout1_15 Vdout1_15ck110 = 0 time = 555
.meas tran vdout1_15ck110 FIND v(dout1_15) AT=555.025n

* CHECK dout1_16 Vdout1_16ck110 = 0.9 time = 555
.meas tran vdout1_16ck110 FIND v(dout1_16) AT=555.025n

* CHECK dout1_17 Vdout1_17ck110 = 0 time = 555
.meas tran vdout1_17ck110 FIND v(dout1_17) AT=555.025n

* CHECK dout1_18 Vdout1_18ck110 = 0 time = 555
.meas tran vdout1_18ck110 FIND v(dout1_18) AT=555.025n

* CHECK dout1_19 Vdout1_19ck110 = 0.9 time = 555
.meas tran vdout1_19ck110 FIND v(dout1_19) AT=555.025n

* CHECK dout1_20 Vdout1_20ck110 = 0.9 time = 555
.meas tran vdout1_20ck110 FIND v(dout1_20) AT=555.025n

* CHECK dout1_21 Vdout1_21ck110 = 0 time = 555
.meas tran vdout1_21ck110 FIND v(dout1_21) AT=555.025n

* CHECK dout1_22 Vdout1_22ck110 = 0.9 time = 555
.meas tran vdout1_22ck110 FIND v(dout1_22) AT=555.025n

* CHECK dout1_23 Vdout1_23ck110 = 0 time = 555
.meas tran vdout1_23ck110 FIND v(dout1_23) AT=555.025n

* CHECK dout1_24 Vdout1_24ck110 = 0 time = 555
.meas tran vdout1_24ck110 FIND v(dout1_24) AT=555.025n

* CHECK dout1_25 Vdout1_25ck110 = 0 time = 555
.meas tran vdout1_25ck110 FIND v(dout1_25) AT=555.025n

* CHECK dout1_26 Vdout1_26ck110 = 0 time = 555
.meas tran vdout1_26ck110 FIND v(dout1_26) AT=555.025n

* CHECK dout1_27 Vdout1_27ck110 = 0 time = 555
.meas tran vdout1_27ck110 FIND v(dout1_27) AT=555.025n

* CHECK dout1_28 Vdout1_28ck110 = 0.9 time = 555
.meas tran vdout1_28ck110 FIND v(dout1_28) AT=555.025n

* CHECK dout1_29 Vdout1_29ck110 = 0.9 time = 555
.meas tran vdout1_29ck110 FIND v(dout1_29) AT=555.025n

* CHECK dout1_30 Vdout1_30ck110 = 0 time = 555
.meas tran vdout1_30ck110 FIND v(dout1_30) AT=555.025n

* CHECK dout1_31 Vdout1_31ck110 = 0 time = 555
.meas tran vdout1_31ck110 FIND v(dout1_31) AT=555.025n

* CHECK dout1_32 Vdout1_32ck110 = 0 time = 555
.meas tran vdout1_32ck110 FIND v(dout1_32) AT=555.025n

* CHECK dout1_33 Vdout1_33ck110 = 0.9 time = 555
.meas tran vdout1_33ck110 FIND v(dout1_33) AT=555.025n

* CHECK dout1_34 Vdout1_34ck110 = 0.9 time = 555
.meas tran vdout1_34ck110 FIND v(dout1_34) AT=555.025n

* CHECK dout1_35 Vdout1_35ck110 = 0.9 time = 555
.meas tran vdout1_35ck110 FIND v(dout1_35) AT=555.025n

* CHECK dout1_36 Vdout1_36ck110 = 0 time = 555
.meas tran vdout1_36ck110 FIND v(dout1_36) AT=555.025n

* CHECK dout1_37 Vdout1_37ck110 = 0 time = 555
.meas tran vdout1_37ck110 FIND v(dout1_37) AT=555.025n

* CHECK dout1_38 Vdout1_38ck110 = 0 time = 555
.meas tran vdout1_38ck110 FIND v(dout1_38) AT=555.025n

* CHECK dout1_39 Vdout1_39ck110 = 0.9 time = 555
.meas tran vdout1_39ck110 FIND v(dout1_39) AT=555.025n

* CHECK dout1_40 Vdout1_40ck110 = 0 time = 555
.meas tran vdout1_40ck110 FIND v(dout1_40) AT=555.025n

* CHECK dout1_41 Vdout1_41ck110 = 0 time = 555
.meas tran vdout1_41ck110 FIND v(dout1_41) AT=555.025n

* CHECK dout1_42 Vdout1_42ck110 = 0 time = 555
.meas tran vdout1_42ck110 FIND v(dout1_42) AT=555.025n

* CHECK dout1_43 Vdout1_43ck110 = 0.9 time = 555
.meas tran vdout1_43ck110 FIND v(dout1_43) AT=555.025n

* CHECK dout1_44 Vdout1_44ck110 = 0 time = 555
.meas tran vdout1_44ck110 FIND v(dout1_44) AT=555.025n

* CHECK dout1_45 Vdout1_45ck110 = 0.9 time = 555
.meas tran vdout1_45ck110 FIND v(dout1_45) AT=555.025n

* CHECK dout1_46 Vdout1_46ck110 = 0.9 time = 555
.meas tran vdout1_46ck110 FIND v(dout1_46) AT=555.025n

* CHECK dout1_47 Vdout1_47ck110 = 0 time = 555
.meas tran vdout1_47ck110 FIND v(dout1_47) AT=555.025n

* CHECK dout1_48 Vdout1_48ck110 = 0.9 time = 555
.meas tran vdout1_48ck110 FIND v(dout1_48) AT=555.025n

* CHECK dout1_49 Vdout1_49ck110 = 0 time = 555
.meas tran vdout1_49ck110 FIND v(dout1_49) AT=555.025n

* CHECK dout1_50 Vdout1_50ck110 = 0.9 time = 555
.meas tran vdout1_50ck110 FIND v(dout1_50) AT=555.025n

* CHECK dout1_51 Vdout1_51ck110 = 0.9 time = 555
.meas tran vdout1_51ck110 FIND v(dout1_51) AT=555.025n

* CHECK dout1_52 Vdout1_52ck110 = 0.9 time = 555
.meas tran vdout1_52ck110 FIND v(dout1_52) AT=555.025n

* CHECK dout1_53 Vdout1_53ck110 = 0.9 time = 555
.meas tran vdout1_53ck110 FIND v(dout1_53) AT=555.025n

* CHECK dout1_54 Vdout1_54ck110 = 0 time = 555
.meas tran vdout1_54ck110 FIND v(dout1_54) AT=555.025n

* CHECK dout1_55 Vdout1_55ck110 = 0.9 time = 555
.meas tran vdout1_55ck110 FIND v(dout1_55) AT=555.025n

* CHECK dout1_0 Vdout1_0ck114 = 0 time = 575
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=575.025n

* CHECK dout1_1 Vdout1_1ck114 = 0 time = 575
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=575.025n

* CHECK dout1_2 Vdout1_2ck114 = 0 time = 575
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=575.025n

* CHECK dout1_3 Vdout1_3ck114 = 0 time = 575
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=575.025n

* CHECK dout1_4 Vdout1_4ck114 = 0 time = 575
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=575.025n

* CHECK dout1_5 Vdout1_5ck114 = 0 time = 575
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=575.025n

* CHECK dout1_6 Vdout1_6ck114 = 0 time = 575
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=575.025n

* CHECK dout1_7 Vdout1_7ck114 = 0.9 time = 575
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=575.025n

* CHECK dout1_8 Vdout1_8ck114 = 0.9 time = 575
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=575.025n

* CHECK dout1_9 Vdout1_9ck114 = 0 time = 575
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=575.025n

* CHECK dout1_10 Vdout1_10ck114 = 0.9 time = 575
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=575.025n

* CHECK dout1_11 Vdout1_11ck114 = 0 time = 575
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=575.025n

* CHECK dout1_12 Vdout1_12ck114 = 0.9 time = 575
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=575.025n

* CHECK dout1_13 Vdout1_13ck114 = 0 time = 575
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=575.025n

* CHECK dout1_14 Vdout1_14ck114 = 0 time = 575
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=575.025n

* CHECK dout1_15 Vdout1_15ck114 = 0 time = 575
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=575.025n

* CHECK dout1_16 Vdout1_16ck114 = 0 time = 575
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=575.025n

* CHECK dout1_17 Vdout1_17ck114 = 0 time = 575
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=575.025n

* CHECK dout1_18 Vdout1_18ck114 = 0.9 time = 575
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=575.025n

* CHECK dout1_19 Vdout1_19ck114 = 0 time = 575
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=575.025n

* CHECK dout1_20 Vdout1_20ck114 = 0 time = 575
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=575.025n

* CHECK dout1_21 Vdout1_21ck114 = 0.9 time = 575
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=575.025n

* CHECK dout1_22 Vdout1_22ck114 = 0 time = 575
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=575.025n

* CHECK dout1_23 Vdout1_23ck114 = 0 time = 575
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=575.025n

* CHECK dout1_24 Vdout1_24ck114 = 0 time = 575
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=575.025n

* CHECK dout1_25 Vdout1_25ck114 = 0 time = 575
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=575.025n

* CHECK dout1_26 Vdout1_26ck114 = 0 time = 575
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=575.025n

* CHECK dout1_27 Vdout1_27ck114 = 0.9 time = 575
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=575.025n

* CHECK dout1_28 Vdout1_28ck114 = 0 time = 575
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=575.025n

* CHECK dout1_29 Vdout1_29ck114 = 0 time = 575
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=575.025n

* CHECK dout1_30 Vdout1_30ck114 = 0 time = 575
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=575.025n

* CHECK dout1_31 Vdout1_31ck114 = 0 time = 575
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=575.025n

* CHECK dout1_32 Vdout1_32ck114 = 0 time = 575
.meas tran vdout1_32ck114 FIND v(dout1_32) AT=575.025n

* CHECK dout1_33 Vdout1_33ck114 = 0 time = 575
.meas tran vdout1_33ck114 FIND v(dout1_33) AT=575.025n

* CHECK dout1_34 Vdout1_34ck114 = 0 time = 575
.meas tran vdout1_34ck114 FIND v(dout1_34) AT=575.025n

* CHECK dout1_35 Vdout1_35ck114 = 0 time = 575
.meas tran vdout1_35ck114 FIND v(dout1_35) AT=575.025n

* CHECK dout1_36 Vdout1_36ck114 = 0.9 time = 575
.meas tran vdout1_36ck114 FIND v(dout1_36) AT=575.025n

* CHECK dout1_37 Vdout1_37ck114 = 0 time = 575
.meas tran vdout1_37ck114 FIND v(dout1_37) AT=575.025n

* CHECK dout1_38 Vdout1_38ck114 = 0 time = 575
.meas tran vdout1_38ck114 FIND v(dout1_38) AT=575.025n

* CHECK dout1_39 Vdout1_39ck114 = 0.9 time = 575
.meas tran vdout1_39ck114 FIND v(dout1_39) AT=575.025n

* CHECK dout1_40 Vdout1_40ck114 = 0.9 time = 575
.meas tran vdout1_40ck114 FIND v(dout1_40) AT=575.025n

* CHECK dout1_41 Vdout1_41ck114 = 0.9 time = 575
.meas tran vdout1_41ck114 FIND v(dout1_41) AT=575.025n

* CHECK dout1_42 Vdout1_42ck114 = 0.9 time = 575
.meas tran vdout1_42ck114 FIND v(dout1_42) AT=575.025n

* CHECK dout1_43 Vdout1_43ck114 = 0 time = 575
.meas tran vdout1_43ck114 FIND v(dout1_43) AT=575.025n

* CHECK dout1_44 Vdout1_44ck114 = 0 time = 575
.meas tran vdout1_44ck114 FIND v(dout1_44) AT=575.025n

* CHECK dout1_45 Vdout1_45ck114 = 0 time = 575
.meas tran vdout1_45ck114 FIND v(dout1_45) AT=575.025n

* CHECK dout1_46 Vdout1_46ck114 = 0 time = 575
.meas tran vdout1_46ck114 FIND v(dout1_46) AT=575.025n

* CHECK dout1_47 Vdout1_47ck114 = 0.9 time = 575
.meas tran vdout1_47ck114 FIND v(dout1_47) AT=575.025n

* CHECK dout1_48 Vdout1_48ck114 = 0.9 time = 575
.meas tran vdout1_48ck114 FIND v(dout1_48) AT=575.025n

* CHECK dout1_49 Vdout1_49ck114 = 0 time = 575
.meas tran vdout1_49ck114 FIND v(dout1_49) AT=575.025n

* CHECK dout1_50 Vdout1_50ck114 = 0.9 time = 575
.meas tran vdout1_50ck114 FIND v(dout1_50) AT=575.025n

* CHECK dout1_51 Vdout1_51ck114 = 0 time = 575
.meas tran vdout1_51ck114 FIND v(dout1_51) AT=575.025n

* CHECK dout1_52 Vdout1_52ck114 = 0 time = 575
.meas tran vdout1_52ck114 FIND v(dout1_52) AT=575.025n

* CHECK dout1_53 Vdout1_53ck114 = 0 time = 575
.meas tran vdout1_53ck114 FIND v(dout1_53) AT=575.025n

* CHECK dout1_54 Vdout1_54ck114 = 0 time = 575
.meas tran vdout1_54ck114 FIND v(dout1_54) AT=575.025n

* CHECK dout1_55 Vdout1_55ck114 = 0.9 time = 575
.meas tran vdout1_55ck114 FIND v(dout1_55) AT=575.025n

* CHECK dout1_0 Vdout1_0ck116 = 0.9 time = 585
.meas tran vdout1_0ck116 FIND v(dout1_0) AT=585.025n

* CHECK dout1_1 Vdout1_1ck116 = 0.9 time = 585
.meas tran vdout1_1ck116 FIND v(dout1_1) AT=585.025n

* CHECK dout1_2 Vdout1_2ck116 = 0 time = 585
.meas tran vdout1_2ck116 FIND v(dout1_2) AT=585.025n

* CHECK dout1_3 Vdout1_3ck116 = 0.9 time = 585
.meas tran vdout1_3ck116 FIND v(dout1_3) AT=585.025n

* CHECK dout1_4 Vdout1_4ck116 = 0 time = 585
.meas tran vdout1_4ck116 FIND v(dout1_4) AT=585.025n

* CHECK dout1_5 Vdout1_5ck116 = 0.9 time = 585
.meas tran vdout1_5ck116 FIND v(dout1_5) AT=585.025n

* CHECK dout1_6 Vdout1_6ck116 = 0.9 time = 585
.meas tran vdout1_6ck116 FIND v(dout1_6) AT=585.025n

* CHECK dout1_7 Vdout1_7ck116 = 0 time = 585
.meas tran vdout1_7ck116 FIND v(dout1_7) AT=585.025n

* CHECK dout1_8 Vdout1_8ck116 = 0 time = 585
.meas tran vdout1_8ck116 FIND v(dout1_8) AT=585.025n

* CHECK dout1_9 Vdout1_9ck116 = 0.9 time = 585
.meas tran vdout1_9ck116 FIND v(dout1_9) AT=585.025n

* CHECK dout1_10 Vdout1_10ck116 = 0.9 time = 585
.meas tran vdout1_10ck116 FIND v(dout1_10) AT=585.025n

* CHECK dout1_11 Vdout1_11ck116 = 0 time = 585
.meas tran vdout1_11ck116 FIND v(dout1_11) AT=585.025n

* CHECK dout1_12 Vdout1_12ck116 = 0.9 time = 585
.meas tran vdout1_12ck116 FIND v(dout1_12) AT=585.025n

* CHECK dout1_13 Vdout1_13ck116 = 0.9 time = 585
.meas tran vdout1_13ck116 FIND v(dout1_13) AT=585.025n

* CHECK dout1_14 Vdout1_14ck116 = 0.9 time = 585
.meas tran vdout1_14ck116 FIND v(dout1_14) AT=585.025n

* CHECK dout1_15 Vdout1_15ck116 = 0.9 time = 585
.meas tran vdout1_15ck116 FIND v(dout1_15) AT=585.025n

* CHECK dout1_16 Vdout1_16ck116 = 0.9 time = 585
.meas tran vdout1_16ck116 FIND v(dout1_16) AT=585.025n

* CHECK dout1_17 Vdout1_17ck116 = 0 time = 585
.meas tran vdout1_17ck116 FIND v(dout1_17) AT=585.025n

* CHECK dout1_18 Vdout1_18ck116 = 0.9 time = 585
.meas tran vdout1_18ck116 FIND v(dout1_18) AT=585.025n

* CHECK dout1_19 Vdout1_19ck116 = 0 time = 585
.meas tran vdout1_19ck116 FIND v(dout1_19) AT=585.025n

* CHECK dout1_20 Vdout1_20ck116 = 0 time = 585
.meas tran vdout1_20ck116 FIND v(dout1_20) AT=585.025n

* CHECK dout1_21 Vdout1_21ck116 = 0.9 time = 585
.meas tran vdout1_21ck116 FIND v(dout1_21) AT=585.025n

* CHECK dout1_22 Vdout1_22ck116 = 0.9 time = 585
.meas tran vdout1_22ck116 FIND v(dout1_22) AT=585.025n

* CHECK dout1_23 Vdout1_23ck116 = 0.9 time = 585
.meas tran vdout1_23ck116 FIND v(dout1_23) AT=585.025n

* CHECK dout1_24 Vdout1_24ck116 = 0 time = 585
.meas tran vdout1_24ck116 FIND v(dout1_24) AT=585.025n

* CHECK dout1_25 Vdout1_25ck116 = 0 time = 585
.meas tran vdout1_25ck116 FIND v(dout1_25) AT=585.025n

* CHECK dout1_26 Vdout1_26ck116 = 0 time = 585
.meas tran vdout1_26ck116 FIND v(dout1_26) AT=585.025n

* CHECK dout1_27 Vdout1_27ck116 = 0.9 time = 585
.meas tran vdout1_27ck116 FIND v(dout1_27) AT=585.025n

* CHECK dout1_28 Vdout1_28ck116 = 0 time = 585
.meas tran vdout1_28ck116 FIND v(dout1_28) AT=585.025n

* CHECK dout1_29 Vdout1_29ck116 = 0.9 time = 585
.meas tran vdout1_29ck116 FIND v(dout1_29) AT=585.025n

* CHECK dout1_30 Vdout1_30ck116 = 0.9 time = 585
.meas tran vdout1_30ck116 FIND v(dout1_30) AT=585.025n

* CHECK dout1_31 Vdout1_31ck116 = 0.9 time = 585
.meas tran vdout1_31ck116 FIND v(dout1_31) AT=585.025n

* CHECK dout1_32 Vdout1_32ck116 = 0 time = 585
.meas tran vdout1_32ck116 FIND v(dout1_32) AT=585.025n

* CHECK dout1_33 Vdout1_33ck116 = 0 time = 585
.meas tran vdout1_33ck116 FIND v(dout1_33) AT=585.025n

* CHECK dout1_34 Vdout1_34ck116 = 0.9 time = 585
.meas tran vdout1_34ck116 FIND v(dout1_34) AT=585.025n

* CHECK dout1_35 Vdout1_35ck116 = 0 time = 585
.meas tran vdout1_35ck116 FIND v(dout1_35) AT=585.025n

* CHECK dout1_36 Vdout1_36ck116 = 0 time = 585
.meas tran vdout1_36ck116 FIND v(dout1_36) AT=585.025n

* CHECK dout1_37 Vdout1_37ck116 = 0.9 time = 585
.meas tran vdout1_37ck116 FIND v(dout1_37) AT=585.025n

* CHECK dout1_38 Vdout1_38ck116 = 0 time = 585
.meas tran vdout1_38ck116 FIND v(dout1_38) AT=585.025n

* CHECK dout1_39 Vdout1_39ck116 = 0 time = 585
.meas tran vdout1_39ck116 FIND v(dout1_39) AT=585.025n

* CHECK dout1_40 Vdout1_40ck116 = 0.9 time = 585
.meas tran vdout1_40ck116 FIND v(dout1_40) AT=585.025n

* CHECK dout1_41 Vdout1_41ck116 = 0.9 time = 585
.meas tran vdout1_41ck116 FIND v(dout1_41) AT=585.025n

* CHECK dout1_42 Vdout1_42ck116 = 0 time = 585
.meas tran vdout1_42ck116 FIND v(dout1_42) AT=585.025n

* CHECK dout1_43 Vdout1_43ck116 = 0.9 time = 585
.meas tran vdout1_43ck116 FIND v(dout1_43) AT=585.025n

* CHECK dout1_44 Vdout1_44ck116 = 0 time = 585
.meas tran vdout1_44ck116 FIND v(dout1_44) AT=585.025n

* CHECK dout1_45 Vdout1_45ck116 = 0.9 time = 585
.meas tran vdout1_45ck116 FIND v(dout1_45) AT=585.025n

* CHECK dout1_46 Vdout1_46ck116 = 0 time = 585
.meas tran vdout1_46ck116 FIND v(dout1_46) AT=585.025n

* CHECK dout1_47 Vdout1_47ck116 = 0.9 time = 585
.meas tran vdout1_47ck116 FIND v(dout1_47) AT=585.025n

* CHECK dout1_48 Vdout1_48ck116 = 0.9 time = 585
.meas tran vdout1_48ck116 FIND v(dout1_48) AT=585.025n

* CHECK dout1_49 Vdout1_49ck116 = 0 time = 585
.meas tran vdout1_49ck116 FIND v(dout1_49) AT=585.025n

* CHECK dout1_50 Vdout1_50ck116 = 0 time = 585
.meas tran vdout1_50ck116 FIND v(dout1_50) AT=585.025n

* CHECK dout1_51 Vdout1_51ck116 = 0.9 time = 585
.meas tran vdout1_51ck116 FIND v(dout1_51) AT=585.025n

* CHECK dout1_52 Vdout1_52ck116 = 0.9 time = 585
.meas tran vdout1_52ck116 FIND v(dout1_52) AT=585.025n

* CHECK dout1_53 Vdout1_53ck116 = 0.9 time = 585
.meas tran vdout1_53ck116 FIND v(dout1_53) AT=585.025n

* CHECK dout1_54 Vdout1_54ck116 = 0.9 time = 585
.meas tran vdout1_54ck116 FIND v(dout1_54) AT=585.025n

* CHECK dout1_55 Vdout1_55ck116 = 0 time = 585
.meas tran vdout1_55ck116 FIND v(dout1_55) AT=585.025n

* CHECK dout1_0 Vdout1_0ck122 = 0 time = 615
.meas tran vdout1_0ck122 FIND v(dout1_0) AT=615.025n

* CHECK dout1_1 Vdout1_1ck122 = 0 time = 615
.meas tran vdout1_1ck122 FIND v(dout1_1) AT=615.025n

* CHECK dout1_2 Vdout1_2ck122 = 0 time = 615
.meas tran vdout1_2ck122 FIND v(dout1_2) AT=615.025n

* CHECK dout1_3 Vdout1_3ck122 = 0.9 time = 615
.meas tran vdout1_3ck122 FIND v(dout1_3) AT=615.025n

* CHECK dout1_4 Vdout1_4ck122 = 0.9 time = 615
.meas tran vdout1_4ck122 FIND v(dout1_4) AT=615.025n

* CHECK dout1_5 Vdout1_5ck122 = 0 time = 615
.meas tran vdout1_5ck122 FIND v(dout1_5) AT=615.025n

* CHECK dout1_6 Vdout1_6ck122 = 0 time = 615
.meas tran vdout1_6ck122 FIND v(dout1_6) AT=615.025n

* CHECK dout1_7 Vdout1_7ck122 = 0.9 time = 615
.meas tran vdout1_7ck122 FIND v(dout1_7) AT=615.025n

* CHECK dout1_8 Vdout1_8ck122 = 0.9 time = 615
.meas tran vdout1_8ck122 FIND v(dout1_8) AT=615.025n

* CHECK dout1_9 Vdout1_9ck122 = 0.9 time = 615
.meas tran vdout1_9ck122 FIND v(dout1_9) AT=615.025n

* CHECK dout1_10 Vdout1_10ck122 = 0.9 time = 615
.meas tran vdout1_10ck122 FIND v(dout1_10) AT=615.025n

* CHECK dout1_11 Vdout1_11ck122 = 0 time = 615
.meas tran vdout1_11ck122 FIND v(dout1_11) AT=615.025n

* CHECK dout1_12 Vdout1_12ck122 = 0.9 time = 615
.meas tran vdout1_12ck122 FIND v(dout1_12) AT=615.025n

* CHECK dout1_13 Vdout1_13ck122 = 0.9 time = 615
.meas tran vdout1_13ck122 FIND v(dout1_13) AT=615.025n

* CHECK dout1_14 Vdout1_14ck122 = 0 time = 615
.meas tran vdout1_14ck122 FIND v(dout1_14) AT=615.025n

* CHECK dout1_15 Vdout1_15ck122 = 0.9 time = 615
.meas tran vdout1_15ck122 FIND v(dout1_15) AT=615.025n

* CHECK dout1_16 Vdout1_16ck122 = 0 time = 615
.meas tran vdout1_16ck122 FIND v(dout1_16) AT=615.025n

* CHECK dout1_17 Vdout1_17ck122 = 0 time = 615
.meas tran vdout1_17ck122 FIND v(dout1_17) AT=615.025n

* CHECK dout1_18 Vdout1_18ck122 = 0 time = 615
.meas tran vdout1_18ck122 FIND v(dout1_18) AT=615.025n

* CHECK dout1_19 Vdout1_19ck122 = 0.9 time = 615
.meas tran vdout1_19ck122 FIND v(dout1_19) AT=615.025n

* CHECK dout1_20 Vdout1_20ck122 = 0 time = 615
.meas tran vdout1_20ck122 FIND v(dout1_20) AT=615.025n

* CHECK dout1_21 Vdout1_21ck122 = 0.9 time = 615
.meas tran vdout1_21ck122 FIND v(dout1_21) AT=615.025n

* CHECK dout1_22 Vdout1_22ck122 = 0.9 time = 615
.meas tran vdout1_22ck122 FIND v(dout1_22) AT=615.025n

* CHECK dout1_23 Vdout1_23ck122 = 0.9 time = 615
.meas tran vdout1_23ck122 FIND v(dout1_23) AT=615.025n

* CHECK dout1_24 Vdout1_24ck122 = 0 time = 615
.meas tran vdout1_24ck122 FIND v(dout1_24) AT=615.025n

* CHECK dout1_25 Vdout1_25ck122 = 0.9 time = 615
.meas tran vdout1_25ck122 FIND v(dout1_25) AT=615.025n

* CHECK dout1_26 Vdout1_26ck122 = 0.9 time = 615
.meas tran vdout1_26ck122 FIND v(dout1_26) AT=615.025n

* CHECK dout1_27 Vdout1_27ck122 = 0.9 time = 615
.meas tran vdout1_27ck122 FIND v(dout1_27) AT=615.025n

* CHECK dout1_28 Vdout1_28ck122 = 0 time = 615
.meas tran vdout1_28ck122 FIND v(dout1_28) AT=615.025n

* CHECK dout1_29 Vdout1_29ck122 = 0.9 time = 615
.meas tran vdout1_29ck122 FIND v(dout1_29) AT=615.025n

* CHECK dout1_30 Vdout1_30ck122 = 0.9 time = 615
.meas tran vdout1_30ck122 FIND v(dout1_30) AT=615.025n

* CHECK dout1_31 Vdout1_31ck122 = 0 time = 615
.meas tran vdout1_31ck122 FIND v(dout1_31) AT=615.025n

* CHECK dout1_32 Vdout1_32ck122 = 0.9 time = 615
.meas tran vdout1_32ck122 FIND v(dout1_32) AT=615.025n

* CHECK dout1_33 Vdout1_33ck122 = 0.9 time = 615
.meas tran vdout1_33ck122 FIND v(dout1_33) AT=615.025n

* CHECK dout1_34 Vdout1_34ck122 = 0.9 time = 615
.meas tran vdout1_34ck122 FIND v(dout1_34) AT=615.025n

* CHECK dout1_35 Vdout1_35ck122 = 0.9 time = 615
.meas tran vdout1_35ck122 FIND v(dout1_35) AT=615.025n

* CHECK dout1_36 Vdout1_36ck122 = 0.9 time = 615
.meas tran vdout1_36ck122 FIND v(dout1_36) AT=615.025n

* CHECK dout1_37 Vdout1_37ck122 = 0.9 time = 615
.meas tran vdout1_37ck122 FIND v(dout1_37) AT=615.025n

* CHECK dout1_38 Vdout1_38ck122 = 0.9 time = 615
.meas tran vdout1_38ck122 FIND v(dout1_38) AT=615.025n

* CHECK dout1_39 Vdout1_39ck122 = 0.9 time = 615
.meas tran vdout1_39ck122 FIND v(dout1_39) AT=615.025n

* CHECK dout1_40 Vdout1_40ck122 = 0.9 time = 615
.meas tran vdout1_40ck122 FIND v(dout1_40) AT=615.025n

* CHECK dout1_41 Vdout1_41ck122 = 0 time = 615
.meas tran vdout1_41ck122 FIND v(dout1_41) AT=615.025n

* CHECK dout1_42 Vdout1_42ck122 = 0 time = 615
.meas tran vdout1_42ck122 FIND v(dout1_42) AT=615.025n

* CHECK dout1_43 Vdout1_43ck122 = 0.9 time = 615
.meas tran vdout1_43ck122 FIND v(dout1_43) AT=615.025n

* CHECK dout1_44 Vdout1_44ck122 = 0.9 time = 615
.meas tran vdout1_44ck122 FIND v(dout1_44) AT=615.025n

* CHECK dout1_45 Vdout1_45ck122 = 0 time = 615
.meas tran vdout1_45ck122 FIND v(dout1_45) AT=615.025n

* CHECK dout1_46 Vdout1_46ck122 = 0 time = 615
.meas tran vdout1_46ck122 FIND v(dout1_46) AT=615.025n

* CHECK dout1_47 Vdout1_47ck122 = 0.9 time = 615
.meas tran vdout1_47ck122 FIND v(dout1_47) AT=615.025n

* CHECK dout1_48 Vdout1_48ck122 = 0 time = 615
.meas tran vdout1_48ck122 FIND v(dout1_48) AT=615.025n

* CHECK dout1_49 Vdout1_49ck122 = 0 time = 615
.meas tran vdout1_49ck122 FIND v(dout1_49) AT=615.025n

* CHECK dout1_50 Vdout1_50ck122 = 0 time = 615
.meas tran vdout1_50ck122 FIND v(dout1_50) AT=615.025n

* CHECK dout1_51 Vdout1_51ck122 = 0 time = 615
.meas tran vdout1_51ck122 FIND v(dout1_51) AT=615.025n

* CHECK dout1_52 Vdout1_52ck122 = 0 time = 615
.meas tran vdout1_52ck122 FIND v(dout1_52) AT=615.025n

* CHECK dout1_53 Vdout1_53ck122 = 0.9 time = 615
.meas tran vdout1_53ck122 FIND v(dout1_53) AT=615.025n

* CHECK dout1_54 Vdout1_54ck122 = 0.9 time = 615
.meas tran vdout1_54ck122 FIND v(dout1_54) AT=615.025n

* CHECK dout1_55 Vdout1_55ck122 = 0.9 time = 615
.meas tran vdout1_55ck122 FIND v(dout1_55) AT=615.025n

* CHECK dout1_0 Vdout1_0ck127 = 0.9 time = 640
.meas tran vdout1_0ck127 FIND v(dout1_0) AT=640.025n

* CHECK dout1_1 Vdout1_1ck127 = 0.9 time = 640
.meas tran vdout1_1ck127 FIND v(dout1_1) AT=640.025n

* CHECK dout1_2 Vdout1_2ck127 = 0.9 time = 640
.meas tran vdout1_2ck127 FIND v(dout1_2) AT=640.025n

* CHECK dout1_3 Vdout1_3ck127 = 0 time = 640
.meas tran vdout1_3ck127 FIND v(dout1_3) AT=640.025n

* CHECK dout1_4 Vdout1_4ck127 = 0.9 time = 640
.meas tran vdout1_4ck127 FIND v(dout1_4) AT=640.025n

* CHECK dout1_5 Vdout1_5ck127 = 0.9 time = 640
.meas tran vdout1_5ck127 FIND v(dout1_5) AT=640.025n

* CHECK dout1_6 Vdout1_6ck127 = 0 time = 640
.meas tran vdout1_6ck127 FIND v(dout1_6) AT=640.025n

* CHECK dout1_7 Vdout1_7ck127 = 0 time = 640
.meas tran vdout1_7ck127 FIND v(dout1_7) AT=640.025n

* CHECK dout1_8 Vdout1_8ck127 = 0 time = 640
.meas tran vdout1_8ck127 FIND v(dout1_8) AT=640.025n

* CHECK dout1_9 Vdout1_9ck127 = 0.9 time = 640
.meas tran vdout1_9ck127 FIND v(dout1_9) AT=640.025n

* CHECK dout1_10 Vdout1_10ck127 = 0 time = 640
.meas tran vdout1_10ck127 FIND v(dout1_10) AT=640.025n

* CHECK dout1_11 Vdout1_11ck127 = 0.9 time = 640
.meas tran vdout1_11ck127 FIND v(dout1_11) AT=640.025n

* CHECK dout1_12 Vdout1_12ck127 = 0.9 time = 640
.meas tran vdout1_12ck127 FIND v(dout1_12) AT=640.025n

* CHECK dout1_13 Vdout1_13ck127 = 0.9 time = 640
.meas tran vdout1_13ck127 FIND v(dout1_13) AT=640.025n

* CHECK dout1_14 Vdout1_14ck127 = 0 time = 640
.meas tran vdout1_14ck127 FIND v(dout1_14) AT=640.025n

* CHECK dout1_15 Vdout1_15ck127 = 0.9 time = 640
.meas tran vdout1_15ck127 FIND v(dout1_15) AT=640.025n

* CHECK dout1_16 Vdout1_16ck127 = 0.9 time = 640
.meas tran vdout1_16ck127 FIND v(dout1_16) AT=640.025n

* CHECK dout1_17 Vdout1_17ck127 = 0 time = 640
.meas tran vdout1_17ck127 FIND v(dout1_17) AT=640.025n

* CHECK dout1_18 Vdout1_18ck127 = 0.9 time = 640
.meas tran vdout1_18ck127 FIND v(dout1_18) AT=640.025n

* CHECK dout1_19 Vdout1_19ck127 = 0.9 time = 640
.meas tran vdout1_19ck127 FIND v(dout1_19) AT=640.025n

* CHECK dout1_20 Vdout1_20ck127 = 0.9 time = 640
.meas tran vdout1_20ck127 FIND v(dout1_20) AT=640.025n

* CHECK dout1_21 Vdout1_21ck127 = 0.9 time = 640
.meas tran vdout1_21ck127 FIND v(dout1_21) AT=640.025n

* CHECK dout1_22 Vdout1_22ck127 = 0 time = 640
.meas tran vdout1_22ck127 FIND v(dout1_22) AT=640.025n

* CHECK dout1_23 Vdout1_23ck127 = 0.9 time = 640
.meas tran vdout1_23ck127 FIND v(dout1_23) AT=640.025n

* CHECK dout1_24 Vdout1_24ck127 = 0.9 time = 640
.meas tran vdout1_24ck127 FIND v(dout1_24) AT=640.025n

* CHECK dout1_25 Vdout1_25ck127 = 0.9 time = 640
.meas tran vdout1_25ck127 FIND v(dout1_25) AT=640.025n

* CHECK dout1_26 Vdout1_26ck127 = 0 time = 640
.meas tran vdout1_26ck127 FIND v(dout1_26) AT=640.025n

* CHECK dout1_27 Vdout1_27ck127 = 0 time = 640
.meas tran vdout1_27ck127 FIND v(dout1_27) AT=640.025n

* CHECK dout1_28 Vdout1_28ck127 = 0.9 time = 640
.meas tran vdout1_28ck127 FIND v(dout1_28) AT=640.025n

* CHECK dout1_29 Vdout1_29ck127 = 0 time = 640
.meas tran vdout1_29ck127 FIND v(dout1_29) AT=640.025n

* CHECK dout1_30 Vdout1_30ck127 = 0 time = 640
.meas tran vdout1_30ck127 FIND v(dout1_30) AT=640.025n

* CHECK dout1_31 Vdout1_31ck127 = 0 time = 640
.meas tran vdout1_31ck127 FIND v(dout1_31) AT=640.025n

* CHECK dout1_32 Vdout1_32ck127 = 0.9 time = 640
.meas tran vdout1_32ck127 FIND v(dout1_32) AT=640.025n

* CHECK dout1_33 Vdout1_33ck127 = 0 time = 640
.meas tran vdout1_33ck127 FIND v(dout1_33) AT=640.025n

* CHECK dout1_34 Vdout1_34ck127 = 0.9 time = 640
.meas tran vdout1_34ck127 FIND v(dout1_34) AT=640.025n

* CHECK dout1_35 Vdout1_35ck127 = 0 time = 640
.meas tran vdout1_35ck127 FIND v(dout1_35) AT=640.025n

* CHECK dout1_36 Vdout1_36ck127 = 0 time = 640
.meas tran vdout1_36ck127 FIND v(dout1_36) AT=640.025n

* CHECK dout1_37 Vdout1_37ck127 = 0 time = 640
.meas tran vdout1_37ck127 FIND v(dout1_37) AT=640.025n

* CHECK dout1_38 Vdout1_38ck127 = 0.9 time = 640
.meas tran vdout1_38ck127 FIND v(dout1_38) AT=640.025n

* CHECK dout1_39 Vdout1_39ck127 = 0.9 time = 640
.meas tran vdout1_39ck127 FIND v(dout1_39) AT=640.025n

* CHECK dout1_40 Vdout1_40ck127 = 0.9 time = 640
.meas tran vdout1_40ck127 FIND v(dout1_40) AT=640.025n

* CHECK dout1_41 Vdout1_41ck127 = 0 time = 640
.meas tran vdout1_41ck127 FIND v(dout1_41) AT=640.025n

* CHECK dout1_42 Vdout1_42ck127 = 0.9 time = 640
.meas tran vdout1_42ck127 FIND v(dout1_42) AT=640.025n

* CHECK dout1_43 Vdout1_43ck127 = 0.9 time = 640
.meas tran vdout1_43ck127 FIND v(dout1_43) AT=640.025n

* CHECK dout1_44 Vdout1_44ck127 = 0.9 time = 640
.meas tran vdout1_44ck127 FIND v(dout1_44) AT=640.025n

* CHECK dout1_45 Vdout1_45ck127 = 0.9 time = 640
.meas tran vdout1_45ck127 FIND v(dout1_45) AT=640.025n

* CHECK dout1_46 Vdout1_46ck127 = 0 time = 640
.meas tran vdout1_46ck127 FIND v(dout1_46) AT=640.025n

* CHECK dout1_47 Vdout1_47ck127 = 0 time = 640
.meas tran vdout1_47ck127 FIND v(dout1_47) AT=640.025n

* CHECK dout1_48 Vdout1_48ck127 = 0.9 time = 640
.meas tran vdout1_48ck127 FIND v(dout1_48) AT=640.025n

* CHECK dout1_49 Vdout1_49ck127 = 0 time = 640
.meas tran vdout1_49ck127 FIND v(dout1_49) AT=640.025n

* CHECK dout1_50 Vdout1_50ck127 = 0.9 time = 640
.meas tran vdout1_50ck127 FIND v(dout1_50) AT=640.025n

* CHECK dout1_51 Vdout1_51ck127 = 0 time = 640
.meas tran vdout1_51ck127 FIND v(dout1_51) AT=640.025n

* CHECK dout1_52 Vdout1_52ck127 = 0 time = 640
.meas tran vdout1_52ck127 FIND v(dout1_52) AT=640.025n

* CHECK dout1_53 Vdout1_53ck127 = 0.9 time = 640
.meas tran vdout1_53ck127 FIND v(dout1_53) AT=640.025n

* CHECK dout1_54 Vdout1_54ck127 = 0.9 time = 640
.meas tran vdout1_54ck127 FIND v(dout1_54) AT=640.025n

* CHECK dout1_55 Vdout1_55ck127 = 0 time = 640
.meas tran vdout1_55ck127 FIND v(dout1_55) AT=640.025n

* CHECK dout1_0 Vdout1_0ck128 = 0.9 time = 645
.meas tran vdout1_0ck128 FIND v(dout1_0) AT=645.025n

* CHECK dout1_1 Vdout1_1ck128 = 0.9 time = 645
.meas tran vdout1_1ck128 FIND v(dout1_1) AT=645.025n

* CHECK dout1_2 Vdout1_2ck128 = 0.9 time = 645
.meas tran vdout1_2ck128 FIND v(dout1_2) AT=645.025n

* CHECK dout1_3 Vdout1_3ck128 = 0 time = 645
.meas tran vdout1_3ck128 FIND v(dout1_3) AT=645.025n

* CHECK dout1_4 Vdout1_4ck128 = 0.9 time = 645
.meas tran vdout1_4ck128 FIND v(dout1_4) AT=645.025n

* CHECK dout1_5 Vdout1_5ck128 = 0.9 time = 645
.meas tran vdout1_5ck128 FIND v(dout1_5) AT=645.025n

* CHECK dout1_6 Vdout1_6ck128 = 0 time = 645
.meas tran vdout1_6ck128 FIND v(dout1_6) AT=645.025n

* CHECK dout1_7 Vdout1_7ck128 = 0 time = 645
.meas tran vdout1_7ck128 FIND v(dout1_7) AT=645.025n

* CHECK dout1_8 Vdout1_8ck128 = 0 time = 645
.meas tran vdout1_8ck128 FIND v(dout1_8) AT=645.025n

* CHECK dout1_9 Vdout1_9ck128 = 0.9 time = 645
.meas tran vdout1_9ck128 FIND v(dout1_9) AT=645.025n

* CHECK dout1_10 Vdout1_10ck128 = 0 time = 645
.meas tran vdout1_10ck128 FIND v(dout1_10) AT=645.025n

* CHECK dout1_11 Vdout1_11ck128 = 0.9 time = 645
.meas tran vdout1_11ck128 FIND v(dout1_11) AT=645.025n

* CHECK dout1_12 Vdout1_12ck128 = 0.9 time = 645
.meas tran vdout1_12ck128 FIND v(dout1_12) AT=645.025n

* CHECK dout1_13 Vdout1_13ck128 = 0.9 time = 645
.meas tran vdout1_13ck128 FIND v(dout1_13) AT=645.025n

* CHECK dout1_14 Vdout1_14ck128 = 0 time = 645
.meas tran vdout1_14ck128 FIND v(dout1_14) AT=645.025n

* CHECK dout1_15 Vdout1_15ck128 = 0.9 time = 645
.meas tran vdout1_15ck128 FIND v(dout1_15) AT=645.025n

* CHECK dout1_16 Vdout1_16ck128 = 0.9 time = 645
.meas tran vdout1_16ck128 FIND v(dout1_16) AT=645.025n

* CHECK dout1_17 Vdout1_17ck128 = 0 time = 645
.meas tran vdout1_17ck128 FIND v(dout1_17) AT=645.025n

* CHECK dout1_18 Vdout1_18ck128 = 0.9 time = 645
.meas tran vdout1_18ck128 FIND v(dout1_18) AT=645.025n

* CHECK dout1_19 Vdout1_19ck128 = 0.9 time = 645
.meas tran vdout1_19ck128 FIND v(dout1_19) AT=645.025n

* CHECK dout1_20 Vdout1_20ck128 = 0.9 time = 645
.meas tran vdout1_20ck128 FIND v(dout1_20) AT=645.025n

* CHECK dout1_21 Vdout1_21ck128 = 0.9 time = 645
.meas tran vdout1_21ck128 FIND v(dout1_21) AT=645.025n

* CHECK dout1_22 Vdout1_22ck128 = 0 time = 645
.meas tran vdout1_22ck128 FIND v(dout1_22) AT=645.025n

* CHECK dout1_23 Vdout1_23ck128 = 0.9 time = 645
.meas tran vdout1_23ck128 FIND v(dout1_23) AT=645.025n

* CHECK dout1_24 Vdout1_24ck128 = 0.9 time = 645
.meas tran vdout1_24ck128 FIND v(dout1_24) AT=645.025n

* CHECK dout1_25 Vdout1_25ck128 = 0.9 time = 645
.meas tran vdout1_25ck128 FIND v(dout1_25) AT=645.025n

* CHECK dout1_26 Vdout1_26ck128 = 0 time = 645
.meas tran vdout1_26ck128 FIND v(dout1_26) AT=645.025n

* CHECK dout1_27 Vdout1_27ck128 = 0 time = 645
.meas tran vdout1_27ck128 FIND v(dout1_27) AT=645.025n

* CHECK dout1_28 Vdout1_28ck128 = 0.9 time = 645
.meas tran vdout1_28ck128 FIND v(dout1_28) AT=645.025n

* CHECK dout1_29 Vdout1_29ck128 = 0 time = 645
.meas tran vdout1_29ck128 FIND v(dout1_29) AT=645.025n

* CHECK dout1_30 Vdout1_30ck128 = 0 time = 645
.meas tran vdout1_30ck128 FIND v(dout1_30) AT=645.025n

* CHECK dout1_31 Vdout1_31ck128 = 0 time = 645
.meas tran vdout1_31ck128 FIND v(dout1_31) AT=645.025n

* CHECK dout1_32 Vdout1_32ck128 = 0.9 time = 645
.meas tran vdout1_32ck128 FIND v(dout1_32) AT=645.025n

* CHECK dout1_33 Vdout1_33ck128 = 0 time = 645
.meas tran vdout1_33ck128 FIND v(dout1_33) AT=645.025n

* CHECK dout1_34 Vdout1_34ck128 = 0.9 time = 645
.meas tran vdout1_34ck128 FIND v(dout1_34) AT=645.025n

* CHECK dout1_35 Vdout1_35ck128 = 0 time = 645
.meas tran vdout1_35ck128 FIND v(dout1_35) AT=645.025n

* CHECK dout1_36 Vdout1_36ck128 = 0 time = 645
.meas tran vdout1_36ck128 FIND v(dout1_36) AT=645.025n

* CHECK dout1_37 Vdout1_37ck128 = 0 time = 645
.meas tran vdout1_37ck128 FIND v(dout1_37) AT=645.025n

* CHECK dout1_38 Vdout1_38ck128 = 0.9 time = 645
.meas tran vdout1_38ck128 FIND v(dout1_38) AT=645.025n

* CHECK dout1_39 Vdout1_39ck128 = 0.9 time = 645
.meas tran vdout1_39ck128 FIND v(dout1_39) AT=645.025n

* CHECK dout1_40 Vdout1_40ck128 = 0.9 time = 645
.meas tran vdout1_40ck128 FIND v(dout1_40) AT=645.025n

* CHECK dout1_41 Vdout1_41ck128 = 0 time = 645
.meas tran vdout1_41ck128 FIND v(dout1_41) AT=645.025n

* CHECK dout1_42 Vdout1_42ck128 = 0.9 time = 645
.meas tran vdout1_42ck128 FIND v(dout1_42) AT=645.025n

* CHECK dout1_43 Vdout1_43ck128 = 0.9 time = 645
.meas tran vdout1_43ck128 FIND v(dout1_43) AT=645.025n

* CHECK dout1_44 Vdout1_44ck128 = 0.9 time = 645
.meas tran vdout1_44ck128 FIND v(dout1_44) AT=645.025n

* CHECK dout1_45 Vdout1_45ck128 = 0.9 time = 645
.meas tran vdout1_45ck128 FIND v(dout1_45) AT=645.025n

* CHECK dout1_46 Vdout1_46ck128 = 0 time = 645
.meas tran vdout1_46ck128 FIND v(dout1_46) AT=645.025n

* CHECK dout1_47 Vdout1_47ck128 = 0 time = 645
.meas tran vdout1_47ck128 FIND v(dout1_47) AT=645.025n

* CHECK dout1_48 Vdout1_48ck128 = 0.9 time = 645
.meas tran vdout1_48ck128 FIND v(dout1_48) AT=645.025n

* CHECK dout1_49 Vdout1_49ck128 = 0 time = 645
.meas tran vdout1_49ck128 FIND v(dout1_49) AT=645.025n

* CHECK dout1_50 Vdout1_50ck128 = 0.9 time = 645
.meas tran vdout1_50ck128 FIND v(dout1_50) AT=645.025n

* CHECK dout1_51 Vdout1_51ck128 = 0 time = 645
.meas tran vdout1_51ck128 FIND v(dout1_51) AT=645.025n

* CHECK dout1_52 Vdout1_52ck128 = 0 time = 645
.meas tran vdout1_52ck128 FIND v(dout1_52) AT=645.025n

* CHECK dout1_53 Vdout1_53ck128 = 0.9 time = 645
.meas tran vdout1_53ck128 FIND v(dout1_53) AT=645.025n

* CHECK dout1_54 Vdout1_54ck128 = 0.9 time = 645
.meas tran vdout1_54ck128 FIND v(dout1_54) AT=645.025n

* CHECK dout1_55 Vdout1_55ck128 = 0 time = 645
.meas tran vdout1_55ck128 FIND v(dout1_55) AT=645.025n

* CHECK dout1_0 Vdout1_0ck130 = 0.9 time = 655
.meas tran vdout1_0ck130 FIND v(dout1_0) AT=655.025n

* CHECK dout1_1 Vdout1_1ck130 = 0 time = 655
.meas tran vdout1_1ck130 FIND v(dout1_1) AT=655.025n

* CHECK dout1_2 Vdout1_2ck130 = 0 time = 655
.meas tran vdout1_2ck130 FIND v(dout1_2) AT=655.025n

* CHECK dout1_3 Vdout1_3ck130 = 0.9 time = 655
.meas tran vdout1_3ck130 FIND v(dout1_3) AT=655.025n

* CHECK dout1_4 Vdout1_4ck130 = 0 time = 655
.meas tran vdout1_4ck130 FIND v(dout1_4) AT=655.025n

* CHECK dout1_5 Vdout1_5ck130 = 0.9 time = 655
.meas tran vdout1_5ck130 FIND v(dout1_5) AT=655.025n

* CHECK dout1_6 Vdout1_6ck130 = 0.9 time = 655
.meas tran vdout1_6ck130 FIND v(dout1_6) AT=655.025n

* CHECK dout1_7 Vdout1_7ck130 = 0.9 time = 655
.meas tran vdout1_7ck130 FIND v(dout1_7) AT=655.025n

* CHECK dout1_8 Vdout1_8ck130 = 0 time = 655
.meas tran vdout1_8ck130 FIND v(dout1_8) AT=655.025n

* CHECK dout1_9 Vdout1_9ck130 = 0 time = 655
.meas tran vdout1_9ck130 FIND v(dout1_9) AT=655.025n

* CHECK dout1_10 Vdout1_10ck130 = 0 time = 655
.meas tran vdout1_10ck130 FIND v(dout1_10) AT=655.025n

* CHECK dout1_11 Vdout1_11ck130 = 0.9 time = 655
.meas tran vdout1_11ck130 FIND v(dout1_11) AT=655.025n

* CHECK dout1_12 Vdout1_12ck130 = 0 time = 655
.meas tran vdout1_12ck130 FIND v(dout1_12) AT=655.025n

* CHECK dout1_13 Vdout1_13ck130 = 0.9 time = 655
.meas tran vdout1_13ck130 FIND v(dout1_13) AT=655.025n

* CHECK dout1_14 Vdout1_14ck130 = 0.9 time = 655
.meas tran vdout1_14ck130 FIND v(dout1_14) AT=655.025n

* CHECK dout1_15 Vdout1_15ck130 = 0.9 time = 655
.meas tran vdout1_15ck130 FIND v(dout1_15) AT=655.025n

* CHECK dout1_16 Vdout1_16ck130 = 0.9 time = 655
.meas tran vdout1_16ck130 FIND v(dout1_16) AT=655.025n

* CHECK dout1_17 Vdout1_17ck130 = 0.9 time = 655
.meas tran vdout1_17ck130 FIND v(dout1_17) AT=655.025n

* CHECK dout1_18 Vdout1_18ck130 = 0 time = 655
.meas tran vdout1_18ck130 FIND v(dout1_18) AT=655.025n

* CHECK dout1_19 Vdout1_19ck130 = 0 time = 655
.meas tran vdout1_19ck130 FIND v(dout1_19) AT=655.025n

* CHECK dout1_20 Vdout1_20ck130 = 0 time = 655
.meas tran vdout1_20ck130 FIND v(dout1_20) AT=655.025n

* CHECK dout1_21 Vdout1_21ck130 = 0 time = 655
.meas tran vdout1_21ck130 FIND v(dout1_21) AT=655.025n

* CHECK dout1_22 Vdout1_22ck130 = 0.9 time = 655
.meas tran vdout1_22ck130 FIND v(dout1_22) AT=655.025n

* CHECK dout1_23 Vdout1_23ck130 = 0.9 time = 655
.meas tran vdout1_23ck130 FIND v(dout1_23) AT=655.025n

* CHECK dout1_24 Vdout1_24ck130 = 0.9 time = 655
.meas tran vdout1_24ck130 FIND v(dout1_24) AT=655.025n

* CHECK dout1_25 Vdout1_25ck130 = 0 time = 655
.meas tran vdout1_25ck130 FIND v(dout1_25) AT=655.025n

* CHECK dout1_26 Vdout1_26ck130 = 0.9 time = 655
.meas tran vdout1_26ck130 FIND v(dout1_26) AT=655.025n

* CHECK dout1_27 Vdout1_27ck130 = 0.9 time = 655
.meas tran vdout1_27ck130 FIND v(dout1_27) AT=655.025n

* CHECK dout1_28 Vdout1_28ck130 = 0 time = 655
.meas tran vdout1_28ck130 FIND v(dout1_28) AT=655.025n

* CHECK dout1_29 Vdout1_29ck130 = 0 time = 655
.meas tran vdout1_29ck130 FIND v(dout1_29) AT=655.025n

* CHECK dout1_30 Vdout1_30ck130 = 0 time = 655
.meas tran vdout1_30ck130 FIND v(dout1_30) AT=655.025n

* CHECK dout1_31 Vdout1_31ck130 = 0.9 time = 655
.meas tran vdout1_31ck130 FIND v(dout1_31) AT=655.025n

* CHECK dout1_32 Vdout1_32ck130 = 0.9 time = 655
.meas tran vdout1_32ck130 FIND v(dout1_32) AT=655.025n

* CHECK dout1_33 Vdout1_33ck130 = 0 time = 655
.meas tran vdout1_33ck130 FIND v(dout1_33) AT=655.025n

* CHECK dout1_34 Vdout1_34ck130 = 0.9 time = 655
.meas tran vdout1_34ck130 FIND v(dout1_34) AT=655.025n

* CHECK dout1_35 Vdout1_35ck130 = 0 time = 655
.meas tran vdout1_35ck130 FIND v(dout1_35) AT=655.025n

* CHECK dout1_36 Vdout1_36ck130 = 0 time = 655
.meas tran vdout1_36ck130 FIND v(dout1_36) AT=655.025n

* CHECK dout1_37 Vdout1_37ck130 = 0 time = 655
.meas tran vdout1_37ck130 FIND v(dout1_37) AT=655.025n

* CHECK dout1_38 Vdout1_38ck130 = 0 time = 655
.meas tran vdout1_38ck130 FIND v(dout1_38) AT=655.025n

* CHECK dout1_39 Vdout1_39ck130 = 0 time = 655
.meas tran vdout1_39ck130 FIND v(dout1_39) AT=655.025n

* CHECK dout1_40 Vdout1_40ck130 = 0.9 time = 655
.meas tran vdout1_40ck130 FIND v(dout1_40) AT=655.025n

* CHECK dout1_41 Vdout1_41ck130 = 0 time = 655
.meas tran vdout1_41ck130 FIND v(dout1_41) AT=655.025n

* CHECK dout1_42 Vdout1_42ck130 = 0.9 time = 655
.meas tran vdout1_42ck130 FIND v(dout1_42) AT=655.025n

* CHECK dout1_43 Vdout1_43ck130 = 0 time = 655
.meas tran vdout1_43ck130 FIND v(dout1_43) AT=655.025n

* CHECK dout1_44 Vdout1_44ck130 = 0 time = 655
.meas tran vdout1_44ck130 FIND v(dout1_44) AT=655.025n

* CHECK dout1_45 Vdout1_45ck130 = 0.9 time = 655
.meas tran vdout1_45ck130 FIND v(dout1_45) AT=655.025n

* CHECK dout1_46 Vdout1_46ck130 = 0 time = 655
.meas tran vdout1_46ck130 FIND v(dout1_46) AT=655.025n

* CHECK dout1_47 Vdout1_47ck130 = 0.9 time = 655
.meas tran vdout1_47ck130 FIND v(dout1_47) AT=655.025n

* CHECK dout1_48 Vdout1_48ck130 = 0.9 time = 655
.meas tran vdout1_48ck130 FIND v(dout1_48) AT=655.025n

* CHECK dout1_49 Vdout1_49ck130 = 0 time = 655
.meas tran vdout1_49ck130 FIND v(dout1_49) AT=655.025n

* CHECK dout1_50 Vdout1_50ck130 = 0.9 time = 655
.meas tran vdout1_50ck130 FIND v(dout1_50) AT=655.025n

* CHECK dout1_51 Vdout1_51ck130 = 0 time = 655
.meas tran vdout1_51ck130 FIND v(dout1_51) AT=655.025n

* CHECK dout1_52 Vdout1_52ck130 = 0.9 time = 655
.meas tran vdout1_52ck130 FIND v(dout1_52) AT=655.025n

* CHECK dout1_53 Vdout1_53ck130 = 0 time = 655
.meas tran vdout1_53ck130 FIND v(dout1_53) AT=655.025n

* CHECK dout1_54 Vdout1_54ck130 = 0 time = 655
.meas tran vdout1_54ck130 FIND v(dout1_54) AT=655.025n

* CHECK dout1_55 Vdout1_55ck130 = 0 time = 655
.meas tran vdout1_55ck130 FIND v(dout1_55) AT=655.025n

* CHECK dout1_0 Vdout1_0ck132 = 0 time = 665
.meas tran vdout1_0ck132 FIND v(dout1_0) AT=665.025n

* CHECK dout1_1 Vdout1_1ck132 = 0.9 time = 665
.meas tran vdout1_1ck132 FIND v(dout1_1) AT=665.025n

* CHECK dout1_2 Vdout1_2ck132 = 0.9 time = 665
.meas tran vdout1_2ck132 FIND v(dout1_2) AT=665.025n

* CHECK dout1_3 Vdout1_3ck132 = 0.9 time = 665
.meas tran vdout1_3ck132 FIND v(dout1_3) AT=665.025n

* CHECK dout1_4 Vdout1_4ck132 = 0 time = 665
.meas tran vdout1_4ck132 FIND v(dout1_4) AT=665.025n

* CHECK dout1_5 Vdout1_5ck132 = 0.9 time = 665
.meas tran vdout1_5ck132 FIND v(dout1_5) AT=665.025n

* CHECK dout1_6 Vdout1_6ck132 = 0.9 time = 665
.meas tran vdout1_6ck132 FIND v(dout1_6) AT=665.025n

* CHECK dout1_7 Vdout1_7ck132 = 0 time = 665
.meas tran vdout1_7ck132 FIND v(dout1_7) AT=665.025n

* CHECK dout1_8 Vdout1_8ck132 = 0 time = 665
.meas tran vdout1_8ck132 FIND v(dout1_8) AT=665.025n

* CHECK dout1_9 Vdout1_9ck132 = 0 time = 665
.meas tran vdout1_9ck132 FIND v(dout1_9) AT=665.025n

* CHECK dout1_10 Vdout1_10ck132 = 0 time = 665
.meas tran vdout1_10ck132 FIND v(dout1_10) AT=665.025n

* CHECK dout1_11 Vdout1_11ck132 = 0.9 time = 665
.meas tran vdout1_11ck132 FIND v(dout1_11) AT=665.025n

* CHECK dout1_12 Vdout1_12ck132 = 0 time = 665
.meas tran vdout1_12ck132 FIND v(dout1_12) AT=665.025n

* CHECK dout1_13 Vdout1_13ck132 = 0 time = 665
.meas tran vdout1_13ck132 FIND v(dout1_13) AT=665.025n

* CHECK dout1_14 Vdout1_14ck132 = 0 time = 665
.meas tran vdout1_14ck132 FIND v(dout1_14) AT=665.025n

* CHECK dout1_15 Vdout1_15ck132 = 0 time = 665
.meas tran vdout1_15ck132 FIND v(dout1_15) AT=665.025n

* CHECK dout1_16 Vdout1_16ck132 = 0.9 time = 665
.meas tran vdout1_16ck132 FIND v(dout1_16) AT=665.025n

* CHECK dout1_17 Vdout1_17ck132 = 0 time = 665
.meas tran vdout1_17ck132 FIND v(dout1_17) AT=665.025n

* CHECK dout1_18 Vdout1_18ck132 = 0 time = 665
.meas tran vdout1_18ck132 FIND v(dout1_18) AT=665.025n

* CHECK dout1_19 Vdout1_19ck132 = 0.9 time = 665
.meas tran vdout1_19ck132 FIND v(dout1_19) AT=665.025n

* CHECK dout1_20 Vdout1_20ck132 = 0.9 time = 665
.meas tran vdout1_20ck132 FIND v(dout1_20) AT=665.025n

* CHECK dout1_21 Vdout1_21ck132 = 0 time = 665
.meas tran vdout1_21ck132 FIND v(dout1_21) AT=665.025n

* CHECK dout1_22 Vdout1_22ck132 = 0.9 time = 665
.meas tran vdout1_22ck132 FIND v(dout1_22) AT=665.025n

* CHECK dout1_23 Vdout1_23ck132 = 0 time = 665
.meas tran vdout1_23ck132 FIND v(dout1_23) AT=665.025n

* CHECK dout1_24 Vdout1_24ck132 = 0 time = 665
.meas tran vdout1_24ck132 FIND v(dout1_24) AT=665.025n

* CHECK dout1_25 Vdout1_25ck132 = 0 time = 665
.meas tran vdout1_25ck132 FIND v(dout1_25) AT=665.025n

* CHECK dout1_26 Vdout1_26ck132 = 0 time = 665
.meas tran vdout1_26ck132 FIND v(dout1_26) AT=665.025n

* CHECK dout1_27 Vdout1_27ck132 = 0 time = 665
.meas tran vdout1_27ck132 FIND v(dout1_27) AT=665.025n

* CHECK dout1_28 Vdout1_28ck132 = 0.9 time = 665
.meas tran vdout1_28ck132 FIND v(dout1_28) AT=665.025n

* CHECK dout1_29 Vdout1_29ck132 = 0.9 time = 665
.meas tran vdout1_29ck132 FIND v(dout1_29) AT=665.025n

* CHECK dout1_30 Vdout1_30ck132 = 0 time = 665
.meas tran vdout1_30ck132 FIND v(dout1_30) AT=665.025n

* CHECK dout1_31 Vdout1_31ck132 = 0 time = 665
.meas tran vdout1_31ck132 FIND v(dout1_31) AT=665.025n

* CHECK dout1_32 Vdout1_32ck132 = 0 time = 665
.meas tran vdout1_32ck132 FIND v(dout1_32) AT=665.025n

* CHECK dout1_33 Vdout1_33ck132 = 0.9 time = 665
.meas tran vdout1_33ck132 FIND v(dout1_33) AT=665.025n

* CHECK dout1_34 Vdout1_34ck132 = 0.9 time = 665
.meas tran vdout1_34ck132 FIND v(dout1_34) AT=665.025n

* CHECK dout1_35 Vdout1_35ck132 = 0.9 time = 665
.meas tran vdout1_35ck132 FIND v(dout1_35) AT=665.025n

* CHECK dout1_36 Vdout1_36ck132 = 0 time = 665
.meas tran vdout1_36ck132 FIND v(dout1_36) AT=665.025n

* CHECK dout1_37 Vdout1_37ck132 = 0 time = 665
.meas tran vdout1_37ck132 FIND v(dout1_37) AT=665.025n

* CHECK dout1_38 Vdout1_38ck132 = 0 time = 665
.meas tran vdout1_38ck132 FIND v(dout1_38) AT=665.025n

* CHECK dout1_39 Vdout1_39ck132 = 0.9 time = 665
.meas tran vdout1_39ck132 FIND v(dout1_39) AT=665.025n

* CHECK dout1_40 Vdout1_40ck132 = 0 time = 665
.meas tran vdout1_40ck132 FIND v(dout1_40) AT=665.025n

* CHECK dout1_41 Vdout1_41ck132 = 0 time = 665
.meas tran vdout1_41ck132 FIND v(dout1_41) AT=665.025n

* CHECK dout1_42 Vdout1_42ck132 = 0 time = 665
.meas tran vdout1_42ck132 FIND v(dout1_42) AT=665.025n

* CHECK dout1_43 Vdout1_43ck132 = 0.9 time = 665
.meas tran vdout1_43ck132 FIND v(dout1_43) AT=665.025n

* CHECK dout1_44 Vdout1_44ck132 = 0 time = 665
.meas tran vdout1_44ck132 FIND v(dout1_44) AT=665.025n

* CHECK dout1_45 Vdout1_45ck132 = 0.9 time = 665
.meas tran vdout1_45ck132 FIND v(dout1_45) AT=665.025n

* CHECK dout1_46 Vdout1_46ck132 = 0.9 time = 665
.meas tran vdout1_46ck132 FIND v(dout1_46) AT=665.025n

* CHECK dout1_47 Vdout1_47ck132 = 0 time = 665
.meas tran vdout1_47ck132 FIND v(dout1_47) AT=665.025n

* CHECK dout1_48 Vdout1_48ck132 = 0.9 time = 665
.meas tran vdout1_48ck132 FIND v(dout1_48) AT=665.025n

* CHECK dout1_49 Vdout1_49ck132 = 0 time = 665
.meas tran vdout1_49ck132 FIND v(dout1_49) AT=665.025n

* CHECK dout1_50 Vdout1_50ck132 = 0.9 time = 665
.meas tran vdout1_50ck132 FIND v(dout1_50) AT=665.025n

* CHECK dout1_51 Vdout1_51ck132 = 0.9 time = 665
.meas tran vdout1_51ck132 FIND v(dout1_51) AT=665.025n

* CHECK dout1_52 Vdout1_52ck132 = 0.9 time = 665
.meas tran vdout1_52ck132 FIND v(dout1_52) AT=665.025n

* CHECK dout1_53 Vdout1_53ck132 = 0.9 time = 665
.meas tran vdout1_53ck132 FIND v(dout1_53) AT=665.025n

* CHECK dout1_54 Vdout1_54ck132 = 0 time = 665
.meas tran vdout1_54ck132 FIND v(dout1_54) AT=665.025n

* CHECK dout1_55 Vdout1_55ck132 = 0.9 time = 665
.meas tran vdout1_55ck132 FIND v(dout1_55) AT=665.025n

* CHECK dout1_0 Vdout1_0ck134 = 0.9 time = 675
.meas tran vdout1_0ck134 FIND v(dout1_0) AT=675.025n

* CHECK dout1_1 Vdout1_1ck134 = 0 time = 675
.meas tran vdout1_1ck134 FIND v(dout1_1) AT=675.025n

* CHECK dout1_2 Vdout1_2ck134 = 0 time = 675
.meas tran vdout1_2ck134 FIND v(dout1_2) AT=675.025n

* CHECK dout1_3 Vdout1_3ck134 = 0.9 time = 675
.meas tran vdout1_3ck134 FIND v(dout1_3) AT=675.025n

* CHECK dout1_4 Vdout1_4ck134 = 0 time = 675
.meas tran vdout1_4ck134 FIND v(dout1_4) AT=675.025n

* CHECK dout1_5 Vdout1_5ck134 = 0.9 time = 675
.meas tran vdout1_5ck134 FIND v(dout1_5) AT=675.025n

* CHECK dout1_6 Vdout1_6ck134 = 0.9 time = 675
.meas tran vdout1_6ck134 FIND v(dout1_6) AT=675.025n

* CHECK dout1_7 Vdout1_7ck134 = 0.9 time = 675
.meas tran vdout1_7ck134 FIND v(dout1_7) AT=675.025n

* CHECK dout1_8 Vdout1_8ck134 = 0 time = 675
.meas tran vdout1_8ck134 FIND v(dout1_8) AT=675.025n

* CHECK dout1_9 Vdout1_9ck134 = 0 time = 675
.meas tran vdout1_9ck134 FIND v(dout1_9) AT=675.025n

* CHECK dout1_10 Vdout1_10ck134 = 0 time = 675
.meas tran vdout1_10ck134 FIND v(dout1_10) AT=675.025n

* CHECK dout1_11 Vdout1_11ck134 = 0.9 time = 675
.meas tran vdout1_11ck134 FIND v(dout1_11) AT=675.025n

* CHECK dout1_12 Vdout1_12ck134 = 0 time = 675
.meas tran vdout1_12ck134 FIND v(dout1_12) AT=675.025n

* CHECK dout1_13 Vdout1_13ck134 = 0.9 time = 675
.meas tran vdout1_13ck134 FIND v(dout1_13) AT=675.025n

* CHECK dout1_14 Vdout1_14ck134 = 0.9 time = 675
.meas tran vdout1_14ck134 FIND v(dout1_14) AT=675.025n

* CHECK dout1_15 Vdout1_15ck134 = 0.9 time = 675
.meas tran vdout1_15ck134 FIND v(dout1_15) AT=675.025n

* CHECK dout1_16 Vdout1_16ck134 = 0.9 time = 675
.meas tran vdout1_16ck134 FIND v(dout1_16) AT=675.025n

* CHECK dout1_17 Vdout1_17ck134 = 0.9 time = 675
.meas tran vdout1_17ck134 FIND v(dout1_17) AT=675.025n

* CHECK dout1_18 Vdout1_18ck134 = 0 time = 675
.meas tran vdout1_18ck134 FIND v(dout1_18) AT=675.025n

* CHECK dout1_19 Vdout1_19ck134 = 0 time = 675
.meas tran vdout1_19ck134 FIND v(dout1_19) AT=675.025n

* CHECK dout1_20 Vdout1_20ck134 = 0 time = 675
.meas tran vdout1_20ck134 FIND v(dout1_20) AT=675.025n

* CHECK dout1_21 Vdout1_21ck134 = 0 time = 675
.meas tran vdout1_21ck134 FIND v(dout1_21) AT=675.025n

* CHECK dout1_22 Vdout1_22ck134 = 0.9 time = 675
.meas tran vdout1_22ck134 FIND v(dout1_22) AT=675.025n

* CHECK dout1_23 Vdout1_23ck134 = 0.9 time = 675
.meas tran vdout1_23ck134 FIND v(dout1_23) AT=675.025n

* CHECK dout1_24 Vdout1_24ck134 = 0.9 time = 675
.meas tran vdout1_24ck134 FIND v(dout1_24) AT=675.025n

* CHECK dout1_25 Vdout1_25ck134 = 0 time = 675
.meas tran vdout1_25ck134 FIND v(dout1_25) AT=675.025n

* CHECK dout1_26 Vdout1_26ck134 = 0.9 time = 675
.meas tran vdout1_26ck134 FIND v(dout1_26) AT=675.025n

* CHECK dout1_27 Vdout1_27ck134 = 0.9 time = 675
.meas tran vdout1_27ck134 FIND v(dout1_27) AT=675.025n

* CHECK dout1_28 Vdout1_28ck134 = 0 time = 675
.meas tran vdout1_28ck134 FIND v(dout1_28) AT=675.025n

* CHECK dout1_29 Vdout1_29ck134 = 0 time = 675
.meas tran vdout1_29ck134 FIND v(dout1_29) AT=675.025n

* CHECK dout1_30 Vdout1_30ck134 = 0 time = 675
.meas tran vdout1_30ck134 FIND v(dout1_30) AT=675.025n

* CHECK dout1_31 Vdout1_31ck134 = 0.9 time = 675
.meas tran vdout1_31ck134 FIND v(dout1_31) AT=675.025n

* CHECK dout1_32 Vdout1_32ck134 = 0.9 time = 675
.meas tran vdout1_32ck134 FIND v(dout1_32) AT=675.025n

* CHECK dout1_33 Vdout1_33ck134 = 0 time = 675
.meas tran vdout1_33ck134 FIND v(dout1_33) AT=675.025n

* CHECK dout1_34 Vdout1_34ck134 = 0.9 time = 675
.meas tran vdout1_34ck134 FIND v(dout1_34) AT=675.025n

* CHECK dout1_35 Vdout1_35ck134 = 0 time = 675
.meas tran vdout1_35ck134 FIND v(dout1_35) AT=675.025n

* CHECK dout1_36 Vdout1_36ck134 = 0 time = 675
.meas tran vdout1_36ck134 FIND v(dout1_36) AT=675.025n

* CHECK dout1_37 Vdout1_37ck134 = 0 time = 675
.meas tran vdout1_37ck134 FIND v(dout1_37) AT=675.025n

* CHECK dout1_38 Vdout1_38ck134 = 0 time = 675
.meas tran vdout1_38ck134 FIND v(dout1_38) AT=675.025n

* CHECK dout1_39 Vdout1_39ck134 = 0 time = 675
.meas tran vdout1_39ck134 FIND v(dout1_39) AT=675.025n

* CHECK dout1_40 Vdout1_40ck134 = 0.9 time = 675
.meas tran vdout1_40ck134 FIND v(dout1_40) AT=675.025n

* CHECK dout1_41 Vdout1_41ck134 = 0 time = 675
.meas tran vdout1_41ck134 FIND v(dout1_41) AT=675.025n

* CHECK dout1_42 Vdout1_42ck134 = 0.9 time = 675
.meas tran vdout1_42ck134 FIND v(dout1_42) AT=675.025n

* CHECK dout1_43 Vdout1_43ck134 = 0 time = 675
.meas tran vdout1_43ck134 FIND v(dout1_43) AT=675.025n

* CHECK dout1_44 Vdout1_44ck134 = 0 time = 675
.meas tran vdout1_44ck134 FIND v(dout1_44) AT=675.025n

* CHECK dout1_45 Vdout1_45ck134 = 0.9 time = 675
.meas tran vdout1_45ck134 FIND v(dout1_45) AT=675.025n

* CHECK dout1_46 Vdout1_46ck134 = 0 time = 675
.meas tran vdout1_46ck134 FIND v(dout1_46) AT=675.025n

* CHECK dout1_47 Vdout1_47ck134 = 0.9 time = 675
.meas tran vdout1_47ck134 FIND v(dout1_47) AT=675.025n

* CHECK dout1_48 Vdout1_48ck134 = 0.9 time = 675
.meas tran vdout1_48ck134 FIND v(dout1_48) AT=675.025n

* CHECK dout1_49 Vdout1_49ck134 = 0 time = 675
.meas tran vdout1_49ck134 FIND v(dout1_49) AT=675.025n

* CHECK dout1_50 Vdout1_50ck134 = 0.9 time = 675
.meas tran vdout1_50ck134 FIND v(dout1_50) AT=675.025n

* CHECK dout1_51 Vdout1_51ck134 = 0 time = 675
.meas tran vdout1_51ck134 FIND v(dout1_51) AT=675.025n

* CHECK dout1_52 Vdout1_52ck134 = 0.9 time = 675
.meas tran vdout1_52ck134 FIND v(dout1_52) AT=675.025n

* CHECK dout1_53 Vdout1_53ck134 = 0 time = 675
.meas tran vdout1_53ck134 FIND v(dout1_53) AT=675.025n

* CHECK dout1_54 Vdout1_54ck134 = 0 time = 675
.meas tran vdout1_54ck134 FIND v(dout1_54) AT=675.025n

* CHECK dout1_55 Vdout1_55ck134 = 0 time = 675
.meas tran vdout1_55ck134 FIND v(dout1_55) AT=675.025n

* CHECK dout1_0 Vdout1_0ck137 = 0 time = 690
.meas tran vdout1_0ck137 FIND v(dout1_0) AT=690.025n

* CHECK dout1_1 Vdout1_1ck137 = 0.9 time = 690
.meas tran vdout1_1ck137 FIND v(dout1_1) AT=690.025n

* CHECK dout1_2 Vdout1_2ck137 = 0.9 time = 690
.meas tran vdout1_2ck137 FIND v(dout1_2) AT=690.025n

* CHECK dout1_3 Vdout1_3ck137 = 0 time = 690
.meas tran vdout1_3ck137 FIND v(dout1_3) AT=690.025n

* CHECK dout1_4 Vdout1_4ck137 = 0 time = 690
.meas tran vdout1_4ck137 FIND v(dout1_4) AT=690.025n

* CHECK dout1_5 Vdout1_5ck137 = 0 time = 690
.meas tran vdout1_5ck137 FIND v(dout1_5) AT=690.025n

* CHECK dout1_6 Vdout1_6ck137 = 0.9 time = 690
.meas tran vdout1_6ck137 FIND v(dout1_6) AT=690.025n

* CHECK dout1_7 Vdout1_7ck137 = 0.9 time = 690
.meas tran vdout1_7ck137 FIND v(dout1_7) AT=690.025n

* CHECK dout1_8 Vdout1_8ck137 = 0 time = 690
.meas tran vdout1_8ck137 FIND v(dout1_8) AT=690.025n

* CHECK dout1_9 Vdout1_9ck137 = 0 time = 690
.meas tran vdout1_9ck137 FIND v(dout1_9) AT=690.025n

* CHECK dout1_10 Vdout1_10ck137 = 0 time = 690
.meas tran vdout1_10ck137 FIND v(dout1_10) AT=690.025n

* CHECK dout1_11 Vdout1_11ck137 = 0 time = 690
.meas tran vdout1_11ck137 FIND v(dout1_11) AT=690.025n

* CHECK dout1_12 Vdout1_12ck137 = 0.9 time = 690
.meas tran vdout1_12ck137 FIND v(dout1_12) AT=690.025n

* CHECK dout1_13 Vdout1_13ck137 = 0.9 time = 690
.meas tran vdout1_13ck137 FIND v(dout1_13) AT=690.025n

* CHECK dout1_14 Vdout1_14ck137 = 0 time = 690
.meas tran vdout1_14ck137 FIND v(dout1_14) AT=690.025n

* CHECK dout1_15 Vdout1_15ck137 = 0 time = 690
.meas tran vdout1_15ck137 FIND v(dout1_15) AT=690.025n

* CHECK dout1_16 Vdout1_16ck137 = 0 time = 690
.meas tran vdout1_16ck137 FIND v(dout1_16) AT=690.025n

* CHECK dout1_17 Vdout1_17ck137 = 0.9 time = 690
.meas tran vdout1_17ck137 FIND v(dout1_17) AT=690.025n

* CHECK dout1_18 Vdout1_18ck137 = 0 time = 690
.meas tran vdout1_18ck137 FIND v(dout1_18) AT=690.025n

* CHECK dout1_19 Vdout1_19ck137 = 0.9 time = 690
.meas tran vdout1_19ck137 FIND v(dout1_19) AT=690.025n

* CHECK dout1_20 Vdout1_20ck137 = 0.9 time = 690
.meas tran vdout1_20ck137 FIND v(dout1_20) AT=690.025n

* CHECK dout1_21 Vdout1_21ck137 = 0 time = 690
.meas tran vdout1_21ck137 FIND v(dout1_21) AT=690.025n

* CHECK dout1_22 Vdout1_22ck137 = 0.9 time = 690
.meas tran vdout1_22ck137 FIND v(dout1_22) AT=690.025n

* CHECK dout1_23 Vdout1_23ck137 = 0.9 time = 690
.meas tran vdout1_23ck137 FIND v(dout1_23) AT=690.025n

* CHECK dout1_24 Vdout1_24ck137 = 0.9 time = 690
.meas tran vdout1_24ck137 FIND v(dout1_24) AT=690.025n

* CHECK dout1_25 Vdout1_25ck137 = 0.9 time = 690
.meas tran vdout1_25ck137 FIND v(dout1_25) AT=690.025n

* CHECK dout1_26 Vdout1_26ck137 = 0 time = 690
.meas tran vdout1_26ck137 FIND v(dout1_26) AT=690.025n

* CHECK dout1_27 Vdout1_27ck137 = 0 time = 690
.meas tran vdout1_27ck137 FIND v(dout1_27) AT=690.025n

* CHECK dout1_28 Vdout1_28ck137 = 0 time = 690
.meas tran vdout1_28ck137 FIND v(dout1_28) AT=690.025n

* CHECK dout1_29 Vdout1_29ck137 = 0 time = 690
.meas tran vdout1_29ck137 FIND v(dout1_29) AT=690.025n

* CHECK dout1_30 Vdout1_30ck137 = 0.9 time = 690
.meas tran vdout1_30ck137 FIND v(dout1_30) AT=690.025n

* CHECK dout1_31 Vdout1_31ck137 = 0.9 time = 690
.meas tran vdout1_31ck137 FIND v(dout1_31) AT=690.025n

* CHECK dout1_32 Vdout1_32ck137 = 0.9 time = 690
.meas tran vdout1_32ck137 FIND v(dout1_32) AT=690.025n

* CHECK dout1_33 Vdout1_33ck137 = 0.9 time = 690
.meas tran vdout1_33ck137 FIND v(dout1_33) AT=690.025n

* CHECK dout1_34 Vdout1_34ck137 = 0 time = 690
.meas tran vdout1_34ck137 FIND v(dout1_34) AT=690.025n

* CHECK dout1_35 Vdout1_35ck137 = 0 time = 690
.meas tran vdout1_35ck137 FIND v(dout1_35) AT=690.025n

* CHECK dout1_36 Vdout1_36ck137 = 0.9 time = 690
.meas tran vdout1_36ck137 FIND v(dout1_36) AT=690.025n

* CHECK dout1_37 Vdout1_37ck137 = 0 time = 690
.meas tran vdout1_37ck137 FIND v(dout1_37) AT=690.025n

* CHECK dout1_38 Vdout1_38ck137 = 0.9 time = 690
.meas tran vdout1_38ck137 FIND v(dout1_38) AT=690.025n

* CHECK dout1_39 Vdout1_39ck137 = 0.9 time = 690
.meas tran vdout1_39ck137 FIND v(dout1_39) AT=690.025n

* CHECK dout1_40 Vdout1_40ck137 = 0 time = 690
.meas tran vdout1_40ck137 FIND v(dout1_40) AT=690.025n

* CHECK dout1_41 Vdout1_41ck137 = 0.9 time = 690
.meas tran vdout1_41ck137 FIND v(dout1_41) AT=690.025n

* CHECK dout1_42 Vdout1_42ck137 = 0 time = 690
.meas tran vdout1_42ck137 FIND v(dout1_42) AT=690.025n

* CHECK dout1_43 Vdout1_43ck137 = 0.9 time = 690
.meas tran vdout1_43ck137 FIND v(dout1_43) AT=690.025n

* CHECK dout1_44 Vdout1_44ck137 = 0 time = 690
.meas tran vdout1_44ck137 FIND v(dout1_44) AT=690.025n

* CHECK dout1_45 Vdout1_45ck137 = 0 time = 690
.meas tran vdout1_45ck137 FIND v(dout1_45) AT=690.025n

* CHECK dout1_46 Vdout1_46ck137 = 0.9 time = 690
.meas tran vdout1_46ck137 FIND v(dout1_46) AT=690.025n

* CHECK dout1_47 Vdout1_47ck137 = 0.9 time = 690
.meas tran vdout1_47ck137 FIND v(dout1_47) AT=690.025n

* CHECK dout1_48 Vdout1_48ck137 = 0.9 time = 690
.meas tran vdout1_48ck137 FIND v(dout1_48) AT=690.025n

* CHECK dout1_49 Vdout1_49ck137 = 0.9 time = 690
.meas tran vdout1_49ck137 FIND v(dout1_49) AT=690.025n

* CHECK dout1_50 Vdout1_50ck137 = 0.9 time = 690
.meas tran vdout1_50ck137 FIND v(dout1_50) AT=690.025n

* CHECK dout1_51 Vdout1_51ck137 = 0 time = 690
.meas tran vdout1_51ck137 FIND v(dout1_51) AT=690.025n

* CHECK dout1_52 Vdout1_52ck137 = 0 time = 690
.meas tran vdout1_52ck137 FIND v(dout1_52) AT=690.025n

* CHECK dout1_53 Vdout1_53ck137 = 0 time = 690
.meas tran vdout1_53ck137 FIND v(dout1_53) AT=690.025n

* CHECK dout1_54 Vdout1_54ck137 = 0.9 time = 690
.meas tran vdout1_54ck137 FIND v(dout1_54) AT=690.025n

* CHECK dout1_55 Vdout1_55ck137 = 0.9 time = 690
.meas tran vdout1_55ck137 FIND v(dout1_55) AT=690.025n

* CHECK dout1_0 Vdout1_0ck139 = 0 time = 700
.meas tran vdout1_0ck139 FIND v(dout1_0) AT=700.025n

* CHECK dout1_1 Vdout1_1ck139 = 0.9 time = 700
.meas tran vdout1_1ck139 FIND v(dout1_1) AT=700.025n

* CHECK dout1_2 Vdout1_2ck139 = 0.9 time = 700
.meas tran vdout1_2ck139 FIND v(dout1_2) AT=700.025n

* CHECK dout1_3 Vdout1_3ck139 = 0 time = 700
.meas tran vdout1_3ck139 FIND v(dout1_3) AT=700.025n

* CHECK dout1_4 Vdout1_4ck139 = 0 time = 700
.meas tran vdout1_4ck139 FIND v(dout1_4) AT=700.025n

* CHECK dout1_5 Vdout1_5ck139 = 0 time = 700
.meas tran vdout1_5ck139 FIND v(dout1_5) AT=700.025n

* CHECK dout1_6 Vdout1_6ck139 = 0.9 time = 700
.meas tran vdout1_6ck139 FIND v(dout1_6) AT=700.025n

* CHECK dout1_7 Vdout1_7ck139 = 0.9 time = 700
.meas tran vdout1_7ck139 FIND v(dout1_7) AT=700.025n

* CHECK dout1_8 Vdout1_8ck139 = 0 time = 700
.meas tran vdout1_8ck139 FIND v(dout1_8) AT=700.025n

* CHECK dout1_9 Vdout1_9ck139 = 0 time = 700
.meas tran vdout1_9ck139 FIND v(dout1_9) AT=700.025n

* CHECK dout1_10 Vdout1_10ck139 = 0 time = 700
.meas tran vdout1_10ck139 FIND v(dout1_10) AT=700.025n

* CHECK dout1_11 Vdout1_11ck139 = 0 time = 700
.meas tran vdout1_11ck139 FIND v(dout1_11) AT=700.025n

* CHECK dout1_12 Vdout1_12ck139 = 0.9 time = 700
.meas tran vdout1_12ck139 FIND v(dout1_12) AT=700.025n

* CHECK dout1_13 Vdout1_13ck139 = 0.9 time = 700
.meas tran vdout1_13ck139 FIND v(dout1_13) AT=700.025n

* CHECK dout1_14 Vdout1_14ck139 = 0 time = 700
.meas tran vdout1_14ck139 FIND v(dout1_14) AT=700.025n

* CHECK dout1_15 Vdout1_15ck139 = 0 time = 700
.meas tran vdout1_15ck139 FIND v(dout1_15) AT=700.025n

* CHECK dout1_16 Vdout1_16ck139 = 0 time = 700
.meas tran vdout1_16ck139 FIND v(dout1_16) AT=700.025n

* CHECK dout1_17 Vdout1_17ck139 = 0.9 time = 700
.meas tran vdout1_17ck139 FIND v(dout1_17) AT=700.025n

* CHECK dout1_18 Vdout1_18ck139 = 0 time = 700
.meas tran vdout1_18ck139 FIND v(dout1_18) AT=700.025n

* CHECK dout1_19 Vdout1_19ck139 = 0.9 time = 700
.meas tran vdout1_19ck139 FIND v(dout1_19) AT=700.025n

* CHECK dout1_20 Vdout1_20ck139 = 0.9 time = 700
.meas tran vdout1_20ck139 FIND v(dout1_20) AT=700.025n

* CHECK dout1_21 Vdout1_21ck139 = 0 time = 700
.meas tran vdout1_21ck139 FIND v(dout1_21) AT=700.025n

* CHECK dout1_22 Vdout1_22ck139 = 0.9 time = 700
.meas tran vdout1_22ck139 FIND v(dout1_22) AT=700.025n

* CHECK dout1_23 Vdout1_23ck139 = 0.9 time = 700
.meas tran vdout1_23ck139 FIND v(dout1_23) AT=700.025n

* CHECK dout1_24 Vdout1_24ck139 = 0.9 time = 700
.meas tran vdout1_24ck139 FIND v(dout1_24) AT=700.025n

* CHECK dout1_25 Vdout1_25ck139 = 0.9 time = 700
.meas tran vdout1_25ck139 FIND v(dout1_25) AT=700.025n

* CHECK dout1_26 Vdout1_26ck139 = 0 time = 700
.meas tran vdout1_26ck139 FIND v(dout1_26) AT=700.025n

* CHECK dout1_27 Vdout1_27ck139 = 0 time = 700
.meas tran vdout1_27ck139 FIND v(dout1_27) AT=700.025n

* CHECK dout1_28 Vdout1_28ck139 = 0 time = 700
.meas tran vdout1_28ck139 FIND v(dout1_28) AT=700.025n

* CHECK dout1_29 Vdout1_29ck139 = 0 time = 700
.meas tran vdout1_29ck139 FIND v(dout1_29) AT=700.025n

* CHECK dout1_30 Vdout1_30ck139 = 0.9 time = 700
.meas tran vdout1_30ck139 FIND v(dout1_30) AT=700.025n

* CHECK dout1_31 Vdout1_31ck139 = 0.9 time = 700
.meas tran vdout1_31ck139 FIND v(dout1_31) AT=700.025n

* CHECK dout1_32 Vdout1_32ck139 = 0.9 time = 700
.meas tran vdout1_32ck139 FIND v(dout1_32) AT=700.025n

* CHECK dout1_33 Vdout1_33ck139 = 0.9 time = 700
.meas tran vdout1_33ck139 FIND v(dout1_33) AT=700.025n

* CHECK dout1_34 Vdout1_34ck139 = 0 time = 700
.meas tran vdout1_34ck139 FIND v(dout1_34) AT=700.025n

* CHECK dout1_35 Vdout1_35ck139 = 0 time = 700
.meas tran vdout1_35ck139 FIND v(dout1_35) AT=700.025n

* CHECK dout1_36 Vdout1_36ck139 = 0.9 time = 700
.meas tran vdout1_36ck139 FIND v(dout1_36) AT=700.025n

* CHECK dout1_37 Vdout1_37ck139 = 0 time = 700
.meas tran vdout1_37ck139 FIND v(dout1_37) AT=700.025n

* CHECK dout1_38 Vdout1_38ck139 = 0.9 time = 700
.meas tran vdout1_38ck139 FIND v(dout1_38) AT=700.025n

* CHECK dout1_39 Vdout1_39ck139 = 0.9 time = 700
.meas tran vdout1_39ck139 FIND v(dout1_39) AT=700.025n

* CHECK dout1_40 Vdout1_40ck139 = 0 time = 700
.meas tran vdout1_40ck139 FIND v(dout1_40) AT=700.025n

* CHECK dout1_41 Vdout1_41ck139 = 0.9 time = 700
.meas tran vdout1_41ck139 FIND v(dout1_41) AT=700.025n

* CHECK dout1_42 Vdout1_42ck139 = 0 time = 700
.meas tran vdout1_42ck139 FIND v(dout1_42) AT=700.025n

* CHECK dout1_43 Vdout1_43ck139 = 0.9 time = 700
.meas tran vdout1_43ck139 FIND v(dout1_43) AT=700.025n

* CHECK dout1_44 Vdout1_44ck139 = 0 time = 700
.meas tran vdout1_44ck139 FIND v(dout1_44) AT=700.025n

* CHECK dout1_45 Vdout1_45ck139 = 0 time = 700
.meas tran vdout1_45ck139 FIND v(dout1_45) AT=700.025n

* CHECK dout1_46 Vdout1_46ck139 = 0.9 time = 700
.meas tran vdout1_46ck139 FIND v(dout1_46) AT=700.025n

* CHECK dout1_47 Vdout1_47ck139 = 0.9 time = 700
.meas tran vdout1_47ck139 FIND v(dout1_47) AT=700.025n

* CHECK dout1_48 Vdout1_48ck139 = 0.9 time = 700
.meas tran vdout1_48ck139 FIND v(dout1_48) AT=700.025n

* CHECK dout1_49 Vdout1_49ck139 = 0.9 time = 700
.meas tran vdout1_49ck139 FIND v(dout1_49) AT=700.025n

* CHECK dout1_50 Vdout1_50ck139 = 0.9 time = 700
.meas tran vdout1_50ck139 FIND v(dout1_50) AT=700.025n

* CHECK dout1_51 Vdout1_51ck139 = 0 time = 700
.meas tran vdout1_51ck139 FIND v(dout1_51) AT=700.025n

* CHECK dout1_52 Vdout1_52ck139 = 0 time = 700
.meas tran vdout1_52ck139 FIND v(dout1_52) AT=700.025n

* CHECK dout1_53 Vdout1_53ck139 = 0 time = 700
.meas tran vdout1_53ck139 FIND v(dout1_53) AT=700.025n

* CHECK dout1_54 Vdout1_54ck139 = 0.9 time = 700
.meas tran vdout1_54ck139 FIND v(dout1_54) AT=700.025n

* CHECK dout1_55 Vdout1_55ck139 = 0.9 time = 700
.meas tran vdout1_55ck139 FIND v(dout1_55) AT=700.025n

* CHECK dout1_0 Vdout1_0ck141 = 0 time = 710
.meas tran vdout1_0ck141 FIND v(dout1_0) AT=710.025n

* CHECK dout1_1 Vdout1_1ck141 = 0.9 time = 710
.meas tran vdout1_1ck141 FIND v(dout1_1) AT=710.025n

* CHECK dout1_2 Vdout1_2ck141 = 0.9 time = 710
.meas tran vdout1_2ck141 FIND v(dout1_2) AT=710.025n

* CHECK dout1_3 Vdout1_3ck141 = 0 time = 710
.meas tran vdout1_3ck141 FIND v(dout1_3) AT=710.025n

* CHECK dout1_4 Vdout1_4ck141 = 0 time = 710
.meas tran vdout1_4ck141 FIND v(dout1_4) AT=710.025n

* CHECK dout1_5 Vdout1_5ck141 = 0 time = 710
.meas tran vdout1_5ck141 FIND v(dout1_5) AT=710.025n

* CHECK dout1_6 Vdout1_6ck141 = 0.9 time = 710
.meas tran vdout1_6ck141 FIND v(dout1_6) AT=710.025n

* CHECK dout1_7 Vdout1_7ck141 = 0.9 time = 710
.meas tran vdout1_7ck141 FIND v(dout1_7) AT=710.025n

* CHECK dout1_8 Vdout1_8ck141 = 0 time = 710
.meas tran vdout1_8ck141 FIND v(dout1_8) AT=710.025n

* CHECK dout1_9 Vdout1_9ck141 = 0 time = 710
.meas tran vdout1_9ck141 FIND v(dout1_9) AT=710.025n

* CHECK dout1_10 Vdout1_10ck141 = 0 time = 710
.meas tran vdout1_10ck141 FIND v(dout1_10) AT=710.025n

* CHECK dout1_11 Vdout1_11ck141 = 0 time = 710
.meas tran vdout1_11ck141 FIND v(dout1_11) AT=710.025n

* CHECK dout1_12 Vdout1_12ck141 = 0.9 time = 710
.meas tran vdout1_12ck141 FIND v(dout1_12) AT=710.025n

* CHECK dout1_13 Vdout1_13ck141 = 0.9 time = 710
.meas tran vdout1_13ck141 FIND v(dout1_13) AT=710.025n

* CHECK dout1_14 Vdout1_14ck141 = 0 time = 710
.meas tran vdout1_14ck141 FIND v(dout1_14) AT=710.025n

* CHECK dout1_15 Vdout1_15ck141 = 0 time = 710
.meas tran vdout1_15ck141 FIND v(dout1_15) AT=710.025n

* CHECK dout1_16 Vdout1_16ck141 = 0 time = 710
.meas tran vdout1_16ck141 FIND v(dout1_16) AT=710.025n

* CHECK dout1_17 Vdout1_17ck141 = 0.9 time = 710
.meas tran vdout1_17ck141 FIND v(dout1_17) AT=710.025n

* CHECK dout1_18 Vdout1_18ck141 = 0 time = 710
.meas tran vdout1_18ck141 FIND v(dout1_18) AT=710.025n

* CHECK dout1_19 Vdout1_19ck141 = 0.9 time = 710
.meas tran vdout1_19ck141 FIND v(dout1_19) AT=710.025n

* CHECK dout1_20 Vdout1_20ck141 = 0.9 time = 710
.meas tran vdout1_20ck141 FIND v(dout1_20) AT=710.025n

* CHECK dout1_21 Vdout1_21ck141 = 0 time = 710
.meas tran vdout1_21ck141 FIND v(dout1_21) AT=710.025n

* CHECK dout1_22 Vdout1_22ck141 = 0.9 time = 710
.meas tran vdout1_22ck141 FIND v(dout1_22) AT=710.025n

* CHECK dout1_23 Vdout1_23ck141 = 0.9 time = 710
.meas tran vdout1_23ck141 FIND v(dout1_23) AT=710.025n

* CHECK dout1_24 Vdout1_24ck141 = 0.9 time = 710
.meas tran vdout1_24ck141 FIND v(dout1_24) AT=710.025n

* CHECK dout1_25 Vdout1_25ck141 = 0.9 time = 710
.meas tran vdout1_25ck141 FIND v(dout1_25) AT=710.025n

* CHECK dout1_26 Vdout1_26ck141 = 0 time = 710
.meas tran vdout1_26ck141 FIND v(dout1_26) AT=710.025n

* CHECK dout1_27 Vdout1_27ck141 = 0 time = 710
.meas tran vdout1_27ck141 FIND v(dout1_27) AT=710.025n

* CHECK dout1_28 Vdout1_28ck141 = 0 time = 710
.meas tran vdout1_28ck141 FIND v(dout1_28) AT=710.025n

* CHECK dout1_29 Vdout1_29ck141 = 0 time = 710
.meas tran vdout1_29ck141 FIND v(dout1_29) AT=710.025n

* CHECK dout1_30 Vdout1_30ck141 = 0.9 time = 710
.meas tran vdout1_30ck141 FIND v(dout1_30) AT=710.025n

* CHECK dout1_31 Vdout1_31ck141 = 0.9 time = 710
.meas tran vdout1_31ck141 FIND v(dout1_31) AT=710.025n

* CHECK dout1_32 Vdout1_32ck141 = 0.9 time = 710
.meas tran vdout1_32ck141 FIND v(dout1_32) AT=710.025n

* CHECK dout1_33 Vdout1_33ck141 = 0.9 time = 710
.meas tran vdout1_33ck141 FIND v(dout1_33) AT=710.025n

* CHECK dout1_34 Vdout1_34ck141 = 0 time = 710
.meas tran vdout1_34ck141 FIND v(dout1_34) AT=710.025n

* CHECK dout1_35 Vdout1_35ck141 = 0 time = 710
.meas tran vdout1_35ck141 FIND v(dout1_35) AT=710.025n

* CHECK dout1_36 Vdout1_36ck141 = 0.9 time = 710
.meas tran vdout1_36ck141 FIND v(dout1_36) AT=710.025n

* CHECK dout1_37 Vdout1_37ck141 = 0 time = 710
.meas tran vdout1_37ck141 FIND v(dout1_37) AT=710.025n

* CHECK dout1_38 Vdout1_38ck141 = 0.9 time = 710
.meas tran vdout1_38ck141 FIND v(dout1_38) AT=710.025n

* CHECK dout1_39 Vdout1_39ck141 = 0.9 time = 710
.meas tran vdout1_39ck141 FIND v(dout1_39) AT=710.025n

* CHECK dout1_40 Vdout1_40ck141 = 0 time = 710
.meas tran vdout1_40ck141 FIND v(dout1_40) AT=710.025n

* CHECK dout1_41 Vdout1_41ck141 = 0.9 time = 710
.meas tran vdout1_41ck141 FIND v(dout1_41) AT=710.025n

* CHECK dout1_42 Vdout1_42ck141 = 0 time = 710
.meas tran vdout1_42ck141 FIND v(dout1_42) AT=710.025n

* CHECK dout1_43 Vdout1_43ck141 = 0.9 time = 710
.meas tran vdout1_43ck141 FIND v(dout1_43) AT=710.025n

* CHECK dout1_44 Vdout1_44ck141 = 0 time = 710
.meas tran vdout1_44ck141 FIND v(dout1_44) AT=710.025n

* CHECK dout1_45 Vdout1_45ck141 = 0 time = 710
.meas tran vdout1_45ck141 FIND v(dout1_45) AT=710.025n

* CHECK dout1_46 Vdout1_46ck141 = 0.9 time = 710
.meas tran vdout1_46ck141 FIND v(dout1_46) AT=710.025n

* CHECK dout1_47 Vdout1_47ck141 = 0.9 time = 710
.meas tran vdout1_47ck141 FIND v(dout1_47) AT=710.025n

* CHECK dout1_48 Vdout1_48ck141 = 0.9 time = 710
.meas tran vdout1_48ck141 FIND v(dout1_48) AT=710.025n

* CHECK dout1_49 Vdout1_49ck141 = 0.9 time = 710
.meas tran vdout1_49ck141 FIND v(dout1_49) AT=710.025n

* CHECK dout1_50 Vdout1_50ck141 = 0.9 time = 710
.meas tran vdout1_50ck141 FIND v(dout1_50) AT=710.025n

* CHECK dout1_51 Vdout1_51ck141 = 0 time = 710
.meas tran vdout1_51ck141 FIND v(dout1_51) AT=710.025n

* CHECK dout1_52 Vdout1_52ck141 = 0 time = 710
.meas tran vdout1_52ck141 FIND v(dout1_52) AT=710.025n

* CHECK dout1_53 Vdout1_53ck141 = 0 time = 710
.meas tran vdout1_53ck141 FIND v(dout1_53) AT=710.025n

* CHECK dout1_54 Vdout1_54ck141 = 0.9 time = 710
.meas tran vdout1_54ck141 FIND v(dout1_54) AT=710.025n

* CHECK dout1_55 Vdout1_55ck141 = 0.9 time = 710
.meas tran vdout1_55ck141 FIND v(dout1_55) AT=710.025n

* CHECK dout1_0 Vdout1_0ck142 = 0.9 time = 715
.meas tran vdout1_0ck142 FIND v(dout1_0) AT=715.025n

* CHECK dout1_1 Vdout1_1ck142 = 0 time = 715
.meas tran vdout1_1ck142 FIND v(dout1_1) AT=715.025n

* CHECK dout1_2 Vdout1_2ck142 = 0 time = 715
.meas tran vdout1_2ck142 FIND v(dout1_2) AT=715.025n

* CHECK dout1_3 Vdout1_3ck142 = 0 time = 715
.meas tran vdout1_3ck142 FIND v(dout1_3) AT=715.025n

* CHECK dout1_4 Vdout1_4ck142 = 0 time = 715
.meas tran vdout1_4ck142 FIND v(dout1_4) AT=715.025n

* CHECK dout1_5 Vdout1_5ck142 = 0 time = 715
.meas tran vdout1_5ck142 FIND v(dout1_5) AT=715.025n

* CHECK dout1_6 Vdout1_6ck142 = 0.9 time = 715
.meas tran vdout1_6ck142 FIND v(dout1_6) AT=715.025n

* CHECK dout1_7 Vdout1_7ck142 = 0 time = 715
.meas tran vdout1_7ck142 FIND v(dout1_7) AT=715.025n

* CHECK dout1_8 Vdout1_8ck142 = 0 time = 715
.meas tran vdout1_8ck142 FIND v(dout1_8) AT=715.025n

* CHECK dout1_9 Vdout1_9ck142 = 0.9 time = 715
.meas tran vdout1_9ck142 FIND v(dout1_9) AT=715.025n

* CHECK dout1_10 Vdout1_10ck142 = 0.9 time = 715
.meas tran vdout1_10ck142 FIND v(dout1_10) AT=715.025n

* CHECK dout1_11 Vdout1_11ck142 = 0.9 time = 715
.meas tran vdout1_11ck142 FIND v(dout1_11) AT=715.025n

* CHECK dout1_12 Vdout1_12ck142 = 0 time = 715
.meas tran vdout1_12ck142 FIND v(dout1_12) AT=715.025n

* CHECK dout1_13 Vdout1_13ck142 = 0 time = 715
.meas tran vdout1_13ck142 FIND v(dout1_13) AT=715.025n

* CHECK dout1_14 Vdout1_14ck142 = 0.9 time = 715
.meas tran vdout1_14ck142 FIND v(dout1_14) AT=715.025n

* CHECK dout1_15 Vdout1_15ck142 = 0 time = 715
.meas tran vdout1_15ck142 FIND v(dout1_15) AT=715.025n

* CHECK dout1_16 Vdout1_16ck142 = 0.9 time = 715
.meas tran vdout1_16ck142 FIND v(dout1_16) AT=715.025n

* CHECK dout1_17 Vdout1_17ck142 = 0 time = 715
.meas tran vdout1_17ck142 FIND v(dout1_17) AT=715.025n

* CHECK dout1_18 Vdout1_18ck142 = 0 time = 715
.meas tran vdout1_18ck142 FIND v(dout1_18) AT=715.025n

* CHECK dout1_19 Vdout1_19ck142 = 0.9 time = 715
.meas tran vdout1_19ck142 FIND v(dout1_19) AT=715.025n

* CHECK dout1_20 Vdout1_20ck142 = 0 time = 715
.meas tran vdout1_20ck142 FIND v(dout1_20) AT=715.025n

* CHECK dout1_21 Vdout1_21ck142 = 0.9 time = 715
.meas tran vdout1_21ck142 FIND v(dout1_21) AT=715.025n

* CHECK dout1_22 Vdout1_22ck142 = 0 time = 715
.meas tran vdout1_22ck142 FIND v(dout1_22) AT=715.025n

* CHECK dout1_23 Vdout1_23ck142 = 0 time = 715
.meas tran vdout1_23ck142 FIND v(dout1_23) AT=715.025n

* CHECK dout1_24 Vdout1_24ck142 = 0 time = 715
.meas tran vdout1_24ck142 FIND v(dout1_24) AT=715.025n

* CHECK dout1_25 Vdout1_25ck142 = 0 time = 715
.meas tran vdout1_25ck142 FIND v(dout1_25) AT=715.025n

* CHECK dout1_26 Vdout1_26ck142 = 0.9 time = 715
.meas tran vdout1_26ck142 FIND v(dout1_26) AT=715.025n

* CHECK dout1_27 Vdout1_27ck142 = 0.9 time = 715
.meas tran vdout1_27ck142 FIND v(dout1_27) AT=715.025n

* CHECK dout1_28 Vdout1_28ck142 = 0 time = 715
.meas tran vdout1_28ck142 FIND v(dout1_28) AT=715.025n

* CHECK dout1_29 Vdout1_29ck142 = 0 time = 715
.meas tran vdout1_29ck142 FIND v(dout1_29) AT=715.025n

* CHECK dout1_30 Vdout1_30ck142 = 0 time = 715
.meas tran vdout1_30ck142 FIND v(dout1_30) AT=715.025n

* CHECK dout1_31 Vdout1_31ck142 = 0 time = 715
.meas tran vdout1_31ck142 FIND v(dout1_31) AT=715.025n

* CHECK dout1_32 Vdout1_32ck142 = 0.9 time = 715
.meas tran vdout1_32ck142 FIND v(dout1_32) AT=715.025n

* CHECK dout1_33 Vdout1_33ck142 = 0.9 time = 715
.meas tran vdout1_33ck142 FIND v(dout1_33) AT=715.025n

* CHECK dout1_34 Vdout1_34ck142 = 0.9 time = 715
.meas tran vdout1_34ck142 FIND v(dout1_34) AT=715.025n

* CHECK dout1_35 Vdout1_35ck142 = 0.9 time = 715
.meas tran vdout1_35ck142 FIND v(dout1_35) AT=715.025n

* CHECK dout1_36 Vdout1_36ck142 = 0.9 time = 715
.meas tran vdout1_36ck142 FIND v(dout1_36) AT=715.025n

* CHECK dout1_37 Vdout1_37ck142 = 0 time = 715
.meas tran vdout1_37ck142 FIND v(dout1_37) AT=715.025n

* CHECK dout1_38 Vdout1_38ck142 = 0.9 time = 715
.meas tran vdout1_38ck142 FIND v(dout1_38) AT=715.025n

* CHECK dout1_39 Vdout1_39ck142 = 0 time = 715
.meas tran vdout1_39ck142 FIND v(dout1_39) AT=715.025n

* CHECK dout1_40 Vdout1_40ck142 = 0 time = 715
.meas tran vdout1_40ck142 FIND v(dout1_40) AT=715.025n

* CHECK dout1_41 Vdout1_41ck142 = 0 time = 715
.meas tran vdout1_41ck142 FIND v(dout1_41) AT=715.025n

* CHECK dout1_42 Vdout1_42ck142 = 0.9 time = 715
.meas tran vdout1_42ck142 FIND v(dout1_42) AT=715.025n

* CHECK dout1_43 Vdout1_43ck142 = 0 time = 715
.meas tran vdout1_43ck142 FIND v(dout1_43) AT=715.025n

* CHECK dout1_44 Vdout1_44ck142 = 0 time = 715
.meas tran vdout1_44ck142 FIND v(dout1_44) AT=715.025n

* CHECK dout1_45 Vdout1_45ck142 = 0 time = 715
.meas tran vdout1_45ck142 FIND v(dout1_45) AT=715.025n

* CHECK dout1_46 Vdout1_46ck142 = 0 time = 715
.meas tran vdout1_46ck142 FIND v(dout1_46) AT=715.025n

* CHECK dout1_47 Vdout1_47ck142 = 0.9 time = 715
.meas tran vdout1_47ck142 FIND v(dout1_47) AT=715.025n

* CHECK dout1_48 Vdout1_48ck142 = 0.9 time = 715
.meas tran vdout1_48ck142 FIND v(dout1_48) AT=715.025n

* CHECK dout1_49 Vdout1_49ck142 = 0.9 time = 715
.meas tran vdout1_49ck142 FIND v(dout1_49) AT=715.025n

* CHECK dout1_50 Vdout1_50ck142 = 0.9 time = 715
.meas tran vdout1_50ck142 FIND v(dout1_50) AT=715.025n

* CHECK dout1_51 Vdout1_51ck142 = 0 time = 715
.meas tran vdout1_51ck142 FIND v(dout1_51) AT=715.025n

* CHECK dout1_52 Vdout1_52ck142 = 0.9 time = 715
.meas tran vdout1_52ck142 FIND v(dout1_52) AT=715.025n

* CHECK dout1_53 Vdout1_53ck142 = 0 time = 715
.meas tran vdout1_53ck142 FIND v(dout1_53) AT=715.025n

* CHECK dout1_54 Vdout1_54ck142 = 0 time = 715
.meas tran vdout1_54ck142 FIND v(dout1_54) AT=715.025n

* CHECK dout1_55 Vdout1_55ck142 = 0 time = 715
.meas tran vdout1_55ck142 FIND v(dout1_55) AT=715.025n

* CHECK dout1_0 Vdout1_0ck146 = 0.9 time = 735
.meas tran vdout1_0ck146 FIND v(dout1_0) AT=735.025n

* CHECK dout1_1 Vdout1_1ck146 = 0 time = 735
.meas tran vdout1_1ck146 FIND v(dout1_1) AT=735.025n

* CHECK dout1_2 Vdout1_2ck146 = 0.9 time = 735
.meas tran vdout1_2ck146 FIND v(dout1_2) AT=735.025n

* CHECK dout1_3 Vdout1_3ck146 = 0 time = 735
.meas tran vdout1_3ck146 FIND v(dout1_3) AT=735.025n

* CHECK dout1_4 Vdout1_4ck146 = 0.9 time = 735
.meas tran vdout1_4ck146 FIND v(dout1_4) AT=735.025n

* CHECK dout1_5 Vdout1_5ck146 = 0 time = 735
.meas tran vdout1_5ck146 FIND v(dout1_5) AT=735.025n

* CHECK dout1_6 Vdout1_6ck146 = 0.9 time = 735
.meas tran vdout1_6ck146 FIND v(dout1_6) AT=735.025n

* CHECK dout1_7 Vdout1_7ck146 = 0 time = 735
.meas tran vdout1_7ck146 FIND v(dout1_7) AT=735.025n

* CHECK dout1_8 Vdout1_8ck146 = 0.9 time = 735
.meas tran vdout1_8ck146 FIND v(dout1_8) AT=735.025n

* CHECK dout1_9 Vdout1_9ck146 = 0.9 time = 735
.meas tran vdout1_9ck146 FIND v(dout1_9) AT=735.025n

* CHECK dout1_10 Vdout1_10ck146 = 0 time = 735
.meas tran vdout1_10ck146 FIND v(dout1_10) AT=735.025n

* CHECK dout1_11 Vdout1_11ck146 = 0 time = 735
.meas tran vdout1_11ck146 FIND v(dout1_11) AT=735.025n

* CHECK dout1_12 Vdout1_12ck146 = 0 time = 735
.meas tran vdout1_12ck146 FIND v(dout1_12) AT=735.025n

* CHECK dout1_13 Vdout1_13ck146 = 0.9 time = 735
.meas tran vdout1_13ck146 FIND v(dout1_13) AT=735.025n

* CHECK dout1_14 Vdout1_14ck146 = 0 time = 735
.meas tran vdout1_14ck146 FIND v(dout1_14) AT=735.025n

* CHECK dout1_15 Vdout1_15ck146 = 0 time = 735
.meas tran vdout1_15ck146 FIND v(dout1_15) AT=735.025n

* CHECK dout1_16 Vdout1_16ck146 = 0 time = 735
.meas tran vdout1_16ck146 FIND v(dout1_16) AT=735.025n

* CHECK dout1_17 Vdout1_17ck146 = 0.9 time = 735
.meas tran vdout1_17ck146 FIND v(dout1_17) AT=735.025n

* CHECK dout1_18 Vdout1_18ck146 = 0 time = 735
.meas tran vdout1_18ck146 FIND v(dout1_18) AT=735.025n

* CHECK dout1_19 Vdout1_19ck146 = 0.9 time = 735
.meas tran vdout1_19ck146 FIND v(dout1_19) AT=735.025n

* CHECK dout1_20 Vdout1_20ck146 = 0 time = 735
.meas tran vdout1_20ck146 FIND v(dout1_20) AT=735.025n

* CHECK dout1_21 Vdout1_21ck146 = 0 time = 735
.meas tran vdout1_21ck146 FIND v(dout1_21) AT=735.025n

* CHECK dout1_22 Vdout1_22ck146 = 0 time = 735
.meas tran vdout1_22ck146 FIND v(dout1_22) AT=735.025n

* CHECK dout1_23 Vdout1_23ck146 = 0.9 time = 735
.meas tran vdout1_23ck146 FIND v(dout1_23) AT=735.025n

* CHECK dout1_24 Vdout1_24ck146 = 0 time = 735
.meas tran vdout1_24ck146 FIND v(dout1_24) AT=735.025n

* CHECK dout1_25 Vdout1_25ck146 = 0.9 time = 735
.meas tran vdout1_25ck146 FIND v(dout1_25) AT=735.025n

* CHECK dout1_26 Vdout1_26ck146 = 0.9 time = 735
.meas tran vdout1_26ck146 FIND v(dout1_26) AT=735.025n

* CHECK dout1_27 Vdout1_27ck146 = 0 time = 735
.meas tran vdout1_27ck146 FIND v(dout1_27) AT=735.025n

* CHECK dout1_28 Vdout1_28ck146 = 0.9 time = 735
.meas tran vdout1_28ck146 FIND v(dout1_28) AT=735.025n

* CHECK dout1_29 Vdout1_29ck146 = 0 time = 735
.meas tran vdout1_29ck146 FIND v(dout1_29) AT=735.025n

* CHECK dout1_30 Vdout1_30ck146 = 0 time = 735
.meas tran vdout1_30ck146 FIND v(dout1_30) AT=735.025n

* CHECK dout1_31 Vdout1_31ck146 = 0 time = 735
.meas tran vdout1_31ck146 FIND v(dout1_31) AT=735.025n

* CHECK dout1_32 Vdout1_32ck146 = 0.9 time = 735
.meas tran vdout1_32ck146 FIND v(dout1_32) AT=735.025n

* CHECK dout1_33 Vdout1_33ck146 = 0 time = 735
.meas tran vdout1_33ck146 FIND v(dout1_33) AT=735.025n

* CHECK dout1_34 Vdout1_34ck146 = 0.9 time = 735
.meas tran vdout1_34ck146 FIND v(dout1_34) AT=735.025n

* CHECK dout1_35 Vdout1_35ck146 = 0 time = 735
.meas tran vdout1_35ck146 FIND v(dout1_35) AT=735.025n

* CHECK dout1_36 Vdout1_36ck146 = 0.9 time = 735
.meas tran vdout1_36ck146 FIND v(dout1_36) AT=735.025n

* CHECK dout1_37 Vdout1_37ck146 = 0 time = 735
.meas tran vdout1_37ck146 FIND v(dout1_37) AT=735.025n

* CHECK dout1_38 Vdout1_38ck146 = 0 time = 735
.meas tran vdout1_38ck146 FIND v(dout1_38) AT=735.025n

* CHECK dout1_39 Vdout1_39ck146 = 0 time = 735
.meas tran vdout1_39ck146 FIND v(dout1_39) AT=735.025n

* CHECK dout1_40 Vdout1_40ck146 = 0 time = 735
.meas tran vdout1_40ck146 FIND v(dout1_40) AT=735.025n

* CHECK dout1_41 Vdout1_41ck146 = 0 time = 735
.meas tran vdout1_41ck146 FIND v(dout1_41) AT=735.025n

* CHECK dout1_42 Vdout1_42ck146 = 0 time = 735
.meas tran vdout1_42ck146 FIND v(dout1_42) AT=735.025n

* CHECK dout1_43 Vdout1_43ck146 = 0 time = 735
.meas tran vdout1_43ck146 FIND v(dout1_43) AT=735.025n

* CHECK dout1_44 Vdout1_44ck146 = 0 time = 735
.meas tran vdout1_44ck146 FIND v(dout1_44) AT=735.025n

* CHECK dout1_45 Vdout1_45ck146 = 0 time = 735
.meas tran vdout1_45ck146 FIND v(dout1_45) AT=735.025n

* CHECK dout1_46 Vdout1_46ck146 = 0.9 time = 735
.meas tran vdout1_46ck146 FIND v(dout1_46) AT=735.025n

* CHECK dout1_47 Vdout1_47ck146 = 0.9 time = 735
.meas tran vdout1_47ck146 FIND v(dout1_47) AT=735.025n

* CHECK dout1_48 Vdout1_48ck146 = 0 time = 735
.meas tran vdout1_48ck146 FIND v(dout1_48) AT=735.025n

* CHECK dout1_49 Vdout1_49ck146 = 0 time = 735
.meas tran vdout1_49ck146 FIND v(dout1_49) AT=735.025n

* CHECK dout1_50 Vdout1_50ck146 = 0 time = 735
.meas tran vdout1_50ck146 FIND v(dout1_50) AT=735.025n

* CHECK dout1_51 Vdout1_51ck146 = 0.9 time = 735
.meas tran vdout1_51ck146 FIND v(dout1_51) AT=735.025n

* CHECK dout1_52 Vdout1_52ck146 = 0 time = 735
.meas tran vdout1_52ck146 FIND v(dout1_52) AT=735.025n

* CHECK dout1_53 Vdout1_53ck146 = 0 time = 735
.meas tran vdout1_53ck146 FIND v(dout1_53) AT=735.025n

* CHECK dout1_54 Vdout1_54ck146 = 0 time = 735
.meas tran vdout1_54ck146 FIND v(dout1_54) AT=735.025n

* CHECK dout1_55 Vdout1_55ck146 = 0.9 time = 735
.meas tran vdout1_55ck146 FIND v(dout1_55) AT=735.025n

* CHECK dout1_0 Vdout1_0ck147 = 0.9 time = 740
.meas tran vdout1_0ck147 FIND v(dout1_0) AT=740.025n

* CHECK dout1_1 Vdout1_1ck147 = 0 time = 740
.meas tran vdout1_1ck147 FIND v(dout1_1) AT=740.025n

* CHECK dout1_2 Vdout1_2ck147 = 0.9 time = 740
.meas tran vdout1_2ck147 FIND v(dout1_2) AT=740.025n

* CHECK dout1_3 Vdout1_3ck147 = 0 time = 740
.meas tran vdout1_3ck147 FIND v(dout1_3) AT=740.025n

* CHECK dout1_4 Vdout1_4ck147 = 0.9 time = 740
.meas tran vdout1_4ck147 FIND v(dout1_4) AT=740.025n

* CHECK dout1_5 Vdout1_5ck147 = 0.9 time = 740
.meas tran vdout1_5ck147 FIND v(dout1_5) AT=740.025n

* CHECK dout1_6 Vdout1_6ck147 = 0 time = 740
.meas tran vdout1_6ck147 FIND v(dout1_6) AT=740.025n

* CHECK dout1_7 Vdout1_7ck147 = 0 time = 740
.meas tran vdout1_7ck147 FIND v(dout1_7) AT=740.025n

* CHECK dout1_8 Vdout1_8ck147 = 0.9 time = 740
.meas tran vdout1_8ck147 FIND v(dout1_8) AT=740.025n

* CHECK dout1_9 Vdout1_9ck147 = 0 time = 740
.meas tran vdout1_9ck147 FIND v(dout1_9) AT=740.025n

* CHECK dout1_10 Vdout1_10ck147 = 0 time = 740
.meas tran vdout1_10ck147 FIND v(dout1_10) AT=740.025n

* CHECK dout1_11 Vdout1_11ck147 = 0.9 time = 740
.meas tran vdout1_11ck147 FIND v(dout1_11) AT=740.025n

* CHECK dout1_12 Vdout1_12ck147 = 0 time = 740
.meas tran vdout1_12ck147 FIND v(dout1_12) AT=740.025n

* CHECK dout1_13 Vdout1_13ck147 = 0 time = 740
.meas tran vdout1_13ck147 FIND v(dout1_13) AT=740.025n

* CHECK dout1_14 Vdout1_14ck147 = 0.9 time = 740
.meas tran vdout1_14ck147 FIND v(dout1_14) AT=740.025n

* CHECK dout1_15 Vdout1_15ck147 = 0.9 time = 740
.meas tran vdout1_15ck147 FIND v(dout1_15) AT=740.025n

* CHECK dout1_16 Vdout1_16ck147 = 0.9 time = 740
.meas tran vdout1_16ck147 FIND v(dout1_16) AT=740.025n

* CHECK dout1_17 Vdout1_17ck147 = 0 time = 740
.meas tran vdout1_17ck147 FIND v(dout1_17) AT=740.025n

* CHECK dout1_18 Vdout1_18ck147 = 0.9 time = 740
.meas tran vdout1_18ck147 FIND v(dout1_18) AT=740.025n

* CHECK dout1_19 Vdout1_19ck147 = 0.9 time = 740
.meas tran vdout1_19ck147 FIND v(dout1_19) AT=740.025n

* CHECK dout1_20 Vdout1_20ck147 = 0.9 time = 740
.meas tran vdout1_20ck147 FIND v(dout1_20) AT=740.025n

* CHECK dout1_21 Vdout1_21ck147 = 0.9 time = 740
.meas tran vdout1_21ck147 FIND v(dout1_21) AT=740.025n

* CHECK dout1_22 Vdout1_22ck147 = 0.9 time = 740
.meas tran vdout1_22ck147 FIND v(dout1_22) AT=740.025n

* CHECK dout1_23 Vdout1_23ck147 = 0 time = 740
.meas tran vdout1_23ck147 FIND v(dout1_23) AT=740.025n

* CHECK dout1_24 Vdout1_24ck147 = 0.9 time = 740
.meas tran vdout1_24ck147 FIND v(dout1_24) AT=740.025n

* CHECK dout1_25 Vdout1_25ck147 = 0 time = 740
.meas tran vdout1_25ck147 FIND v(dout1_25) AT=740.025n

* CHECK dout1_26 Vdout1_26ck147 = 0.9 time = 740
.meas tran vdout1_26ck147 FIND v(dout1_26) AT=740.025n

* CHECK dout1_27 Vdout1_27ck147 = 0 time = 740
.meas tran vdout1_27ck147 FIND v(dout1_27) AT=740.025n

* CHECK dout1_28 Vdout1_28ck147 = 0 time = 740
.meas tran vdout1_28ck147 FIND v(dout1_28) AT=740.025n

* CHECK dout1_29 Vdout1_29ck147 = 0.9 time = 740
.meas tran vdout1_29ck147 FIND v(dout1_29) AT=740.025n

* CHECK dout1_30 Vdout1_30ck147 = 0.9 time = 740
.meas tran vdout1_30ck147 FIND v(dout1_30) AT=740.025n

* CHECK dout1_31 Vdout1_31ck147 = 0.9 time = 740
.meas tran vdout1_31ck147 FIND v(dout1_31) AT=740.025n

* CHECK dout1_32 Vdout1_32ck147 = 0.9 time = 740
.meas tran vdout1_32ck147 FIND v(dout1_32) AT=740.025n

* CHECK dout1_33 Vdout1_33ck147 = 0 time = 740
.meas tran vdout1_33ck147 FIND v(dout1_33) AT=740.025n

* CHECK dout1_34 Vdout1_34ck147 = 0.9 time = 740
.meas tran vdout1_34ck147 FIND v(dout1_34) AT=740.025n

* CHECK dout1_35 Vdout1_35ck147 = 0 time = 740
.meas tran vdout1_35ck147 FIND v(dout1_35) AT=740.025n

* CHECK dout1_36 Vdout1_36ck147 = 0 time = 740
.meas tran vdout1_36ck147 FIND v(dout1_36) AT=740.025n

* CHECK dout1_37 Vdout1_37ck147 = 0.9 time = 740
.meas tran vdout1_37ck147 FIND v(dout1_37) AT=740.025n

* CHECK dout1_38 Vdout1_38ck147 = 0.9 time = 740
.meas tran vdout1_38ck147 FIND v(dout1_38) AT=740.025n

* CHECK dout1_39 Vdout1_39ck147 = 0.9 time = 740
.meas tran vdout1_39ck147 FIND v(dout1_39) AT=740.025n

* CHECK dout1_40 Vdout1_40ck147 = 0.9 time = 740
.meas tran vdout1_40ck147 FIND v(dout1_40) AT=740.025n

* CHECK dout1_41 Vdout1_41ck147 = 0.9 time = 740
.meas tran vdout1_41ck147 FIND v(dout1_41) AT=740.025n

* CHECK dout1_42 Vdout1_42ck147 = 0.9 time = 740
.meas tran vdout1_42ck147 FIND v(dout1_42) AT=740.025n

* CHECK dout1_43 Vdout1_43ck147 = 0 time = 740
.meas tran vdout1_43ck147 FIND v(dout1_43) AT=740.025n

* CHECK dout1_44 Vdout1_44ck147 = 0 time = 740
.meas tran vdout1_44ck147 FIND v(dout1_44) AT=740.025n

* CHECK dout1_45 Vdout1_45ck147 = 0 time = 740
.meas tran vdout1_45ck147 FIND v(dout1_45) AT=740.025n

* CHECK dout1_46 Vdout1_46ck147 = 0.9 time = 740
.meas tran vdout1_46ck147 FIND v(dout1_46) AT=740.025n

* CHECK dout1_47 Vdout1_47ck147 = 0.9 time = 740
.meas tran vdout1_47ck147 FIND v(dout1_47) AT=740.025n

* CHECK dout1_48 Vdout1_48ck147 = 0 time = 740
.meas tran vdout1_48ck147 FIND v(dout1_48) AT=740.025n

* CHECK dout1_49 Vdout1_49ck147 = 0.9 time = 740
.meas tran vdout1_49ck147 FIND v(dout1_49) AT=740.025n

* CHECK dout1_50 Vdout1_50ck147 = 0.9 time = 740
.meas tran vdout1_50ck147 FIND v(dout1_50) AT=740.025n

* CHECK dout1_51 Vdout1_51ck147 = 0 time = 740
.meas tran vdout1_51ck147 FIND v(dout1_51) AT=740.025n

* CHECK dout1_52 Vdout1_52ck147 = 0.9 time = 740
.meas tran vdout1_52ck147 FIND v(dout1_52) AT=740.025n

* CHECK dout1_53 Vdout1_53ck147 = 0.9 time = 740
.meas tran vdout1_53ck147 FIND v(dout1_53) AT=740.025n

* CHECK dout1_54 Vdout1_54ck147 = 0 time = 740
.meas tran vdout1_54ck147 FIND v(dout1_54) AT=740.025n

* CHECK dout1_55 Vdout1_55ck147 = 0.9 time = 740
.meas tran vdout1_55ck147 FIND v(dout1_55) AT=740.025n

* CHECK dout1_0 Vdout1_0ck148 = 0.9 time = 745
.meas tran vdout1_0ck148 FIND v(dout1_0) AT=745.025n

* CHECK dout1_1 Vdout1_1ck148 = 0 time = 745
.meas tran vdout1_1ck148 FIND v(dout1_1) AT=745.025n

* CHECK dout1_2 Vdout1_2ck148 = 0.9 time = 745
.meas tran vdout1_2ck148 FIND v(dout1_2) AT=745.025n

* CHECK dout1_3 Vdout1_3ck148 = 0 time = 745
.meas tran vdout1_3ck148 FIND v(dout1_3) AT=745.025n

* CHECK dout1_4 Vdout1_4ck148 = 0.9 time = 745
.meas tran vdout1_4ck148 FIND v(dout1_4) AT=745.025n

* CHECK dout1_5 Vdout1_5ck148 = 0.9 time = 745
.meas tran vdout1_5ck148 FIND v(dout1_5) AT=745.025n

* CHECK dout1_6 Vdout1_6ck148 = 0 time = 745
.meas tran vdout1_6ck148 FIND v(dout1_6) AT=745.025n

* CHECK dout1_7 Vdout1_7ck148 = 0 time = 745
.meas tran vdout1_7ck148 FIND v(dout1_7) AT=745.025n

* CHECK dout1_8 Vdout1_8ck148 = 0.9 time = 745
.meas tran vdout1_8ck148 FIND v(dout1_8) AT=745.025n

* CHECK dout1_9 Vdout1_9ck148 = 0 time = 745
.meas tran vdout1_9ck148 FIND v(dout1_9) AT=745.025n

* CHECK dout1_10 Vdout1_10ck148 = 0 time = 745
.meas tran vdout1_10ck148 FIND v(dout1_10) AT=745.025n

* CHECK dout1_11 Vdout1_11ck148 = 0.9 time = 745
.meas tran vdout1_11ck148 FIND v(dout1_11) AT=745.025n

* CHECK dout1_12 Vdout1_12ck148 = 0 time = 745
.meas tran vdout1_12ck148 FIND v(dout1_12) AT=745.025n

* CHECK dout1_13 Vdout1_13ck148 = 0 time = 745
.meas tran vdout1_13ck148 FIND v(dout1_13) AT=745.025n

* CHECK dout1_14 Vdout1_14ck148 = 0.9 time = 745
.meas tran vdout1_14ck148 FIND v(dout1_14) AT=745.025n

* CHECK dout1_15 Vdout1_15ck148 = 0.9 time = 745
.meas tran vdout1_15ck148 FIND v(dout1_15) AT=745.025n

* CHECK dout1_16 Vdout1_16ck148 = 0.9 time = 745
.meas tran vdout1_16ck148 FIND v(dout1_16) AT=745.025n

* CHECK dout1_17 Vdout1_17ck148 = 0 time = 745
.meas tran vdout1_17ck148 FIND v(dout1_17) AT=745.025n

* CHECK dout1_18 Vdout1_18ck148 = 0.9 time = 745
.meas tran vdout1_18ck148 FIND v(dout1_18) AT=745.025n

* CHECK dout1_19 Vdout1_19ck148 = 0.9 time = 745
.meas tran vdout1_19ck148 FIND v(dout1_19) AT=745.025n

* CHECK dout1_20 Vdout1_20ck148 = 0.9 time = 745
.meas tran vdout1_20ck148 FIND v(dout1_20) AT=745.025n

* CHECK dout1_21 Vdout1_21ck148 = 0.9 time = 745
.meas tran vdout1_21ck148 FIND v(dout1_21) AT=745.025n

* CHECK dout1_22 Vdout1_22ck148 = 0.9 time = 745
.meas tran vdout1_22ck148 FIND v(dout1_22) AT=745.025n

* CHECK dout1_23 Vdout1_23ck148 = 0 time = 745
.meas tran vdout1_23ck148 FIND v(dout1_23) AT=745.025n

* CHECK dout1_24 Vdout1_24ck148 = 0.9 time = 745
.meas tran vdout1_24ck148 FIND v(dout1_24) AT=745.025n

* CHECK dout1_25 Vdout1_25ck148 = 0 time = 745
.meas tran vdout1_25ck148 FIND v(dout1_25) AT=745.025n

* CHECK dout1_26 Vdout1_26ck148 = 0.9 time = 745
.meas tran vdout1_26ck148 FIND v(dout1_26) AT=745.025n

* CHECK dout1_27 Vdout1_27ck148 = 0 time = 745
.meas tran vdout1_27ck148 FIND v(dout1_27) AT=745.025n

* CHECK dout1_28 Vdout1_28ck148 = 0 time = 745
.meas tran vdout1_28ck148 FIND v(dout1_28) AT=745.025n

* CHECK dout1_29 Vdout1_29ck148 = 0.9 time = 745
.meas tran vdout1_29ck148 FIND v(dout1_29) AT=745.025n

* CHECK dout1_30 Vdout1_30ck148 = 0.9 time = 745
.meas tran vdout1_30ck148 FIND v(dout1_30) AT=745.025n

* CHECK dout1_31 Vdout1_31ck148 = 0.9 time = 745
.meas tran vdout1_31ck148 FIND v(dout1_31) AT=745.025n

* CHECK dout1_32 Vdout1_32ck148 = 0.9 time = 745
.meas tran vdout1_32ck148 FIND v(dout1_32) AT=745.025n

* CHECK dout1_33 Vdout1_33ck148 = 0 time = 745
.meas tran vdout1_33ck148 FIND v(dout1_33) AT=745.025n

* CHECK dout1_34 Vdout1_34ck148 = 0.9 time = 745
.meas tran vdout1_34ck148 FIND v(dout1_34) AT=745.025n

* CHECK dout1_35 Vdout1_35ck148 = 0 time = 745
.meas tran vdout1_35ck148 FIND v(dout1_35) AT=745.025n

* CHECK dout1_36 Vdout1_36ck148 = 0 time = 745
.meas tran vdout1_36ck148 FIND v(dout1_36) AT=745.025n

* CHECK dout1_37 Vdout1_37ck148 = 0.9 time = 745
.meas tran vdout1_37ck148 FIND v(dout1_37) AT=745.025n

* CHECK dout1_38 Vdout1_38ck148 = 0.9 time = 745
.meas tran vdout1_38ck148 FIND v(dout1_38) AT=745.025n

* CHECK dout1_39 Vdout1_39ck148 = 0.9 time = 745
.meas tran vdout1_39ck148 FIND v(dout1_39) AT=745.025n

* CHECK dout1_40 Vdout1_40ck148 = 0.9 time = 745
.meas tran vdout1_40ck148 FIND v(dout1_40) AT=745.025n

* CHECK dout1_41 Vdout1_41ck148 = 0.9 time = 745
.meas tran vdout1_41ck148 FIND v(dout1_41) AT=745.025n

* CHECK dout1_42 Vdout1_42ck148 = 0.9 time = 745
.meas tran vdout1_42ck148 FIND v(dout1_42) AT=745.025n

* CHECK dout1_43 Vdout1_43ck148 = 0 time = 745
.meas tran vdout1_43ck148 FIND v(dout1_43) AT=745.025n

* CHECK dout1_44 Vdout1_44ck148 = 0 time = 745
.meas tran vdout1_44ck148 FIND v(dout1_44) AT=745.025n

* CHECK dout1_45 Vdout1_45ck148 = 0 time = 745
.meas tran vdout1_45ck148 FIND v(dout1_45) AT=745.025n

* CHECK dout1_46 Vdout1_46ck148 = 0.9 time = 745
.meas tran vdout1_46ck148 FIND v(dout1_46) AT=745.025n

* CHECK dout1_47 Vdout1_47ck148 = 0.9 time = 745
.meas tran vdout1_47ck148 FIND v(dout1_47) AT=745.025n

* CHECK dout1_48 Vdout1_48ck148 = 0 time = 745
.meas tran vdout1_48ck148 FIND v(dout1_48) AT=745.025n

* CHECK dout1_49 Vdout1_49ck148 = 0.9 time = 745
.meas tran vdout1_49ck148 FIND v(dout1_49) AT=745.025n

* CHECK dout1_50 Vdout1_50ck148 = 0.9 time = 745
.meas tran vdout1_50ck148 FIND v(dout1_50) AT=745.025n

* CHECK dout1_51 Vdout1_51ck148 = 0 time = 745
.meas tran vdout1_51ck148 FIND v(dout1_51) AT=745.025n

* CHECK dout1_52 Vdout1_52ck148 = 0.9 time = 745
.meas tran vdout1_52ck148 FIND v(dout1_52) AT=745.025n

* CHECK dout1_53 Vdout1_53ck148 = 0.9 time = 745
.meas tran vdout1_53ck148 FIND v(dout1_53) AT=745.025n

* CHECK dout1_54 Vdout1_54ck148 = 0 time = 745
.meas tran vdout1_54ck148 FIND v(dout1_54) AT=745.025n

* CHECK dout1_55 Vdout1_55ck148 = 0.9 time = 745
.meas tran vdout1_55ck148 FIND v(dout1_55) AT=745.025n

* CHECK dout1_0 Vdout1_0ck149 = 0.9 time = 750
.meas tran vdout1_0ck149 FIND v(dout1_0) AT=750.025n

* CHECK dout1_1 Vdout1_1ck149 = 0 time = 750
.meas tran vdout1_1ck149 FIND v(dout1_1) AT=750.025n

* CHECK dout1_2 Vdout1_2ck149 = 0.9 time = 750
.meas tran vdout1_2ck149 FIND v(dout1_2) AT=750.025n

* CHECK dout1_3 Vdout1_3ck149 = 0 time = 750
.meas tran vdout1_3ck149 FIND v(dout1_3) AT=750.025n

* CHECK dout1_4 Vdout1_4ck149 = 0.9 time = 750
.meas tran vdout1_4ck149 FIND v(dout1_4) AT=750.025n

* CHECK dout1_5 Vdout1_5ck149 = 0 time = 750
.meas tran vdout1_5ck149 FIND v(dout1_5) AT=750.025n

* CHECK dout1_6 Vdout1_6ck149 = 0.9 time = 750
.meas tran vdout1_6ck149 FIND v(dout1_6) AT=750.025n

* CHECK dout1_7 Vdout1_7ck149 = 0 time = 750
.meas tran vdout1_7ck149 FIND v(dout1_7) AT=750.025n

* CHECK dout1_8 Vdout1_8ck149 = 0.9 time = 750
.meas tran vdout1_8ck149 FIND v(dout1_8) AT=750.025n

* CHECK dout1_9 Vdout1_9ck149 = 0.9 time = 750
.meas tran vdout1_9ck149 FIND v(dout1_9) AT=750.025n

* CHECK dout1_10 Vdout1_10ck149 = 0 time = 750
.meas tran vdout1_10ck149 FIND v(dout1_10) AT=750.025n

* CHECK dout1_11 Vdout1_11ck149 = 0 time = 750
.meas tran vdout1_11ck149 FIND v(dout1_11) AT=750.025n

* CHECK dout1_12 Vdout1_12ck149 = 0 time = 750
.meas tran vdout1_12ck149 FIND v(dout1_12) AT=750.025n

* CHECK dout1_13 Vdout1_13ck149 = 0.9 time = 750
.meas tran vdout1_13ck149 FIND v(dout1_13) AT=750.025n

* CHECK dout1_14 Vdout1_14ck149 = 0 time = 750
.meas tran vdout1_14ck149 FIND v(dout1_14) AT=750.025n

* CHECK dout1_15 Vdout1_15ck149 = 0 time = 750
.meas tran vdout1_15ck149 FIND v(dout1_15) AT=750.025n

* CHECK dout1_16 Vdout1_16ck149 = 0 time = 750
.meas tran vdout1_16ck149 FIND v(dout1_16) AT=750.025n

* CHECK dout1_17 Vdout1_17ck149 = 0.9 time = 750
.meas tran vdout1_17ck149 FIND v(dout1_17) AT=750.025n

* CHECK dout1_18 Vdout1_18ck149 = 0 time = 750
.meas tran vdout1_18ck149 FIND v(dout1_18) AT=750.025n

* CHECK dout1_19 Vdout1_19ck149 = 0.9 time = 750
.meas tran vdout1_19ck149 FIND v(dout1_19) AT=750.025n

* CHECK dout1_20 Vdout1_20ck149 = 0 time = 750
.meas tran vdout1_20ck149 FIND v(dout1_20) AT=750.025n

* CHECK dout1_21 Vdout1_21ck149 = 0 time = 750
.meas tran vdout1_21ck149 FIND v(dout1_21) AT=750.025n

* CHECK dout1_22 Vdout1_22ck149 = 0 time = 750
.meas tran vdout1_22ck149 FIND v(dout1_22) AT=750.025n

* CHECK dout1_23 Vdout1_23ck149 = 0.9 time = 750
.meas tran vdout1_23ck149 FIND v(dout1_23) AT=750.025n

* CHECK dout1_24 Vdout1_24ck149 = 0 time = 750
.meas tran vdout1_24ck149 FIND v(dout1_24) AT=750.025n

* CHECK dout1_25 Vdout1_25ck149 = 0.9 time = 750
.meas tran vdout1_25ck149 FIND v(dout1_25) AT=750.025n

* CHECK dout1_26 Vdout1_26ck149 = 0.9 time = 750
.meas tran vdout1_26ck149 FIND v(dout1_26) AT=750.025n

* CHECK dout1_27 Vdout1_27ck149 = 0 time = 750
.meas tran vdout1_27ck149 FIND v(dout1_27) AT=750.025n

* CHECK dout1_28 Vdout1_28ck149 = 0.9 time = 750
.meas tran vdout1_28ck149 FIND v(dout1_28) AT=750.025n

* CHECK dout1_29 Vdout1_29ck149 = 0 time = 750
.meas tran vdout1_29ck149 FIND v(dout1_29) AT=750.025n

* CHECK dout1_30 Vdout1_30ck149 = 0 time = 750
.meas tran vdout1_30ck149 FIND v(dout1_30) AT=750.025n

* CHECK dout1_31 Vdout1_31ck149 = 0 time = 750
.meas tran vdout1_31ck149 FIND v(dout1_31) AT=750.025n

* CHECK dout1_32 Vdout1_32ck149 = 0.9 time = 750
.meas tran vdout1_32ck149 FIND v(dout1_32) AT=750.025n

* CHECK dout1_33 Vdout1_33ck149 = 0 time = 750
.meas tran vdout1_33ck149 FIND v(dout1_33) AT=750.025n

* CHECK dout1_34 Vdout1_34ck149 = 0.9 time = 750
.meas tran vdout1_34ck149 FIND v(dout1_34) AT=750.025n

* CHECK dout1_35 Vdout1_35ck149 = 0 time = 750
.meas tran vdout1_35ck149 FIND v(dout1_35) AT=750.025n

* CHECK dout1_36 Vdout1_36ck149 = 0.9 time = 750
.meas tran vdout1_36ck149 FIND v(dout1_36) AT=750.025n

* CHECK dout1_37 Vdout1_37ck149 = 0 time = 750
.meas tran vdout1_37ck149 FIND v(dout1_37) AT=750.025n

* CHECK dout1_38 Vdout1_38ck149 = 0 time = 750
.meas tran vdout1_38ck149 FIND v(dout1_38) AT=750.025n

* CHECK dout1_39 Vdout1_39ck149 = 0 time = 750
.meas tran vdout1_39ck149 FIND v(dout1_39) AT=750.025n

* CHECK dout1_40 Vdout1_40ck149 = 0 time = 750
.meas tran vdout1_40ck149 FIND v(dout1_40) AT=750.025n

* CHECK dout1_41 Vdout1_41ck149 = 0 time = 750
.meas tran vdout1_41ck149 FIND v(dout1_41) AT=750.025n

* CHECK dout1_42 Vdout1_42ck149 = 0 time = 750
.meas tran vdout1_42ck149 FIND v(dout1_42) AT=750.025n

* CHECK dout1_43 Vdout1_43ck149 = 0 time = 750
.meas tran vdout1_43ck149 FIND v(dout1_43) AT=750.025n

* CHECK dout1_44 Vdout1_44ck149 = 0 time = 750
.meas tran vdout1_44ck149 FIND v(dout1_44) AT=750.025n

* CHECK dout1_45 Vdout1_45ck149 = 0 time = 750
.meas tran vdout1_45ck149 FIND v(dout1_45) AT=750.025n

* CHECK dout1_46 Vdout1_46ck149 = 0.9 time = 750
.meas tran vdout1_46ck149 FIND v(dout1_46) AT=750.025n

* CHECK dout1_47 Vdout1_47ck149 = 0.9 time = 750
.meas tran vdout1_47ck149 FIND v(dout1_47) AT=750.025n

* CHECK dout1_48 Vdout1_48ck149 = 0 time = 750
.meas tran vdout1_48ck149 FIND v(dout1_48) AT=750.025n

* CHECK dout1_49 Vdout1_49ck149 = 0 time = 750
.meas tran vdout1_49ck149 FIND v(dout1_49) AT=750.025n

* CHECK dout1_50 Vdout1_50ck149 = 0 time = 750
.meas tran vdout1_50ck149 FIND v(dout1_50) AT=750.025n

* CHECK dout1_51 Vdout1_51ck149 = 0.9 time = 750
.meas tran vdout1_51ck149 FIND v(dout1_51) AT=750.025n

* CHECK dout1_52 Vdout1_52ck149 = 0 time = 750
.meas tran vdout1_52ck149 FIND v(dout1_52) AT=750.025n

* CHECK dout1_53 Vdout1_53ck149 = 0 time = 750
.meas tran vdout1_53ck149 FIND v(dout1_53) AT=750.025n

* CHECK dout1_54 Vdout1_54ck149 = 0 time = 750
.meas tran vdout1_54ck149 FIND v(dout1_54) AT=750.025n

* CHECK dout1_55 Vdout1_55ck149 = 0.9 time = 750
.meas tran vdout1_55ck149 FIND v(dout1_55) AT=750.025n

* CHECK dout1_0 Vdout1_0ck152 = 0 time = 765
.meas tran vdout1_0ck152 FIND v(dout1_0) AT=765.025n

* CHECK dout1_1 Vdout1_1ck152 = 0 time = 765
.meas tran vdout1_1ck152 FIND v(dout1_1) AT=765.025n

* CHECK dout1_2 Vdout1_2ck152 = 0.9 time = 765
.meas tran vdout1_2ck152 FIND v(dout1_2) AT=765.025n

* CHECK dout1_3 Vdout1_3ck152 = 0.9 time = 765
.meas tran vdout1_3ck152 FIND v(dout1_3) AT=765.025n

* CHECK dout1_4 Vdout1_4ck152 = 0.9 time = 765
.meas tran vdout1_4ck152 FIND v(dout1_4) AT=765.025n

* CHECK dout1_5 Vdout1_5ck152 = 0 time = 765
.meas tran vdout1_5ck152 FIND v(dout1_5) AT=765.025n

* CHECK dout1_6 Vdout1_6ck152 = 0.9 time = 765
.meas tran vdout1_6ck152 FIND v(dout1_6) AT=765.025n

* CHECK dout1_7 Vdout1_7ck152 = 0 time = 765
.meas tran vdout1_7ck152 FIND v(dout1_7) AT=765.025n

* CHECK dout1_8 Vdout1_8ck152 = 0 time = 765
.meas tran vdout1_8ck152 FIND v(dout1_8) AT=765.025n

* CHECK dout1_9 Vdout1_9ck152 = 0.9 time = 765
.meas tran vdout1_9ck152 FIND v(dout1_9) AT=765.025n

* CHECK dout1_10 Vdout1_10ck152 = 0.9 time = 765
.meas tran vdout1_10ck152 FIND v(dout1_10) AT=765.025n

* CHECK dout1_11 Vdout1_11ck152 = 0 time = 765
.meas tran vdout1_11ck152 FIND v(dout1_11) AT=765.025n

* CHECK dout1_12 Vdout1_12ck152 = 0.9 time = 765
.meas tran vdout1_12ck152 FIND v(dout1_12) AT=765.025n

* CHECK dout1_13 Vdout1_13ck152 = 0.9 time = 765
.meas tran vdout1_13ck152 FIND v(dout1_13) AT=765.025n

* CHECK dout1_14 Vdout1_14ck152 = 0 time = 765
.meas tran vdout1_14ck152 FIND v(dout1_14) AT=765.025n

* CHECK dout1_15 Vdout1_15ck152 = 0 time = 765
.meas tran vdout1_15ck152 FIND v(dout1_15) AT=765.025n

* CHECK dout1_16 Vdout1_16ck152 = 0 time = 765
.meas tran vdout1_16ck152 FIND v(dout1_16) AT=765.025n

* CHECK dout1_17 Vdout1_17ck152 = 0 time = 765
.meas tran vdout1_17ck152 FIND v(dout1_17) AT=765.025n

* CHECK dout1_18 Vdout1_18ck152 = 0 time = 765
.meas tran vdout1_18ck152 FIND v(dout1_18) AT=765.025n

* CHECK dout1_19 Vdout1_19ck152 = 0.9 time = 765
.meas tran vdout1_19ck152 FIND v(dout1_19) AT=765.025n

* CHECK dout1_20 Vdout1_20ck152 = 0 time = 765
.meas tran vdout1_20ck152 FIND v(dout1_20) AT=765.025n

* CHECK dout1_21 Vdout1_21ck152 = 0 time = 765
.meas tran vdout1_21ck152 FIND v(dout1_21) AT=765.025n

* CHECK dout1_22 Vdout1_22ck152 = 0.9 time = 765
.meas tran vdout1_22ck152 FIND v(dout1_22) AT=765.025n

* CHECK dout1_23 Vdout1_23ck152 = 0 time = 765
.meas tran vdout1_23ck152 FIND v(dout1_23) AT=765.025n

* CHECK dout1_24 Vdout1_24ck152 = 0 time = 765
.meas tran vdout1_24ck152 FIND v(dout1_24) AT=765.025n

* CHECK dout1_25 Vdout1_25ck152 = 0 time = 765
.meas tran vdout1_25ck152 FIND v(dout1_25) AT=765.025n

* CHECK dout1_26 Vdout1_26ck152 = 0 time = 765
.meas tran vdout1_26ck152 FIND v(dout1_26) AT=765.025n

* CHECK dout1_27 Vdout1_27ck152 = 0.9 time = 765
.meas tran vdout1_27ck152 FIND v(dout1_27) AT=765.025n

* CHECK dout1_28 Vdout1_28ck152 = 0.9 time = 765
.meas tran vdout1_28ck152 FIND v(dout1_28) AT=765.025n

* CHECK dout1_29 Vdout1_29ck152 = 0.9 time = 765
.meas tran vdout1_29ck152 FIND v(dout1_29) AT=765.025n

* CHECK dout1_30 Vdout1_30ck152 = 0.9 time = 765
.meas tran vdout1_30ck152 FIND v(dout1_30) AT=765.025n

* CHECK dout1_31 Vdout1_31ck152 = 0 time = 765
.meas tran vdout1_31ck152 FIND v(dout1_31) AT=765.025n

* CHECK dout1_32 Vdout1_32ck152 = 0 time = 765
.meas tran vdout1_32ck152 FIND v(dout1_32) AT=765.025n

* CHECK dout1_33 Vdout1_33ck152 = 0 time = 765
.meas tran vdout1_33ck152 FIND v(dout1_33) AT=765.025n

* CHECK dout1_34 Vdout1_34ck152 = 0 time = 765
.meas tran vdout1_34ck152 FIND v(dout1_34) AT=765.025n

* CHECK dout1_35 Vdout1_35ck152 = 0.9 time = 765
.meas tran vdout1_35ck152 FIND v(dout1_35) AT=765.025n

* CHECK dout1_36 Vdout1_36ck152 = 0 time = 765
.meas tran vdout1_36ck152 FIND v(dout1_36) AT=765.025n

* CHECK dout1_37 Vdout1_37ck152 = 0.9 time = 765
.meas tran vdout1_37ck152 FIND v(dout1_37) AT=765.025n

* CHECK dout1_38 Vdout1_38ck152 = 0.9 time = 765
.meas tran vdout1_38ck152 FIND v(dout1_38) AT=765.025n

* CHECK dout1_39 Vdout1_39ck152 = 0 time = 765
.meas tran vdout1_39ck152 FIND v(dout1_39) AT=765.025n

* CHECK dout1_40 Vdout1_40ck152 = 0.9 time = 765
.meas tran vdout1_40ck152 FIND v(dout1_40) AT=765.025n

* CHECK dout1_41 Vdout1_41ck152 = 0 time = 765
.meas tran vdout1_41ck152 FIND v(dout1_41) AT=765.025n

* CHECK dout1_42 Vdout1_42ck152 = 0.9 time = 765
.meas tran vdout1_42ck152 FIND v(dout1_42) AT=765.025n

* CHECK dout1_43 Vdout1_43ck152 = 0 time = 765
.meas tran vdout1_43ck152 FIND v(dout1_43) AT=765.025n

* CHECK dout1_44 Vdout1_44ck152 = 0.9 time = 765
.meas tran vdout1_44ck152 FIND v(dout1_44) AT=765.025n

* CHECK dout1_45 Vdout1_45ck152 = 0 time = 765
.meas tran vdout1_45ck152 FIND v(dout1_45) AT=765.025n

* CHECK dout1_46 Vdout1_46ck152 = 0 time = 765
.meas tran vdout1_46ck152 FIND v(dout1_46) AT=765.025n

* CHECK dout1_47 Vdout1_47ck152 = 0 time = 765
.meas tran vdout1_47ck152 FIND v(dout1_47) AT=765.025n

* CHECK dout1_48 Vdout1_48ck152 = 0 time = 765
.meas tran vdout1_48ck152 FIND v(dout1_48) AT=765.025n

* CHECK dout1_49 Vdout1_49ck152 = 0 time = 765
.meas tran vdout1_49ck152 FIND v(dout1_49) AT=765.025n

* CHECK dout1_50 Vdout1_50ck152 = 0.9 time = 765
.meas tran vdout1_50ck152 FIND v(dout1_50) AT=765.025n

* CHECK dout1_51 Vdout1_51ck152 = 0.9 time = 765
.meas tran vdout1_51ck152 FIND v(dout1_51) AT=765.025n

* CHECK dout1_52 Vdout1_52ck152 = 0 time = 765
.meas tran vdout1_52ck152 FIND v(dout1_52) AT=765.025n

* CHECK dout1_53 Vdout1_53ck152 = 0 time = 765
.meas tran vdout1_53ck152 FIND v(dout1_53) AT=765.025n

* CHECK dout1_54 Vdout1_54ck152 = 0 time = 765
.meas tran vdout1_54ck152 FIND v(dout1_54) AT=765.025n

* CHECK dout1_55 Vdout1_55ck152 = 0 time = 765
.meas tran vdout1_55ck152 FIND v(dout1_55) AT=765.025n

* CHECK dout1_0 Vdout1_0ck153 = 0 time = 770
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=770.025n

* CHECK dout1_1 Vdout1_1ck153 = 0 time = 770
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=770.025n

* CHECK dout1_2 Vdout1_2ck153 = 0.9 time = 770
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=770.025n

* CHECK dout1_3 Vdout1_3ck153 = 0.9 time = 770
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=770.025n

* CHECK dout1_4 Vdout1_4ck153 = 0.9 time = 770
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=770.025n

* CHECK dout1_5 Vdout1_5ck153 = 0 time = 770
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=770.025n

* CHECK dout1_6 Vdout1_6ck153 = 0.9 time = 770
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=770.025n

* CHECK dout1_7 Vdout1_7ck153 = 0 time = 770
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=770.025n

* CHECK dout1_8 Vdout1_8ck153 = 0 time = 770
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=770.025n

* CHECK dout1_9 Vdout1_9ck153 = 0.9 time = 770
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=770.025n

* CHECK dout1_10 Vdout1_10ck153 = 0.9 time = 770
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=770.025n

* CHECK dout1_11 Vdout1_11ck153 = 0 time = 770
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=770.025n

* CHECK dout1_12 Vdout1_12ck153 = 0.9 time = 770
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=770.025n

* CHECK dout1_13 Vdout1_13ck153 = 0.9 time = 770
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=770.025n

* CHECK dout1_14 Vdout1_14ck153 = 0 time = 770
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=770.025n

* CHECK dout1_15 Vdout1_15ck153 = 0 time = 770
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=770.025n

* CHECK dout1_16 Vdout1_16ck153 = 0 time = 770
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=770.025n

* CHECK dout1_17 Vdout1_17ck153 = 0 time = 770
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=770.025n

* CHECK dout1_18 Vdout1_18ck153 = 0 time = 770
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=770.025n

* CHECK dout1_19 Vdout1_19ck153 = 0.9 time = 770
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=770.025n

* CHECK dout1_20 Vdout1_20ck153 = 0 time = 770
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=770.025n

* CHECK dout1_21 Vdout1_21ck153 = 0 time = 770
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=770.025n

* CHECK dout1_22 Vdout1_22ck153 = 0.9 time = 770
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=770.025n

* CHECK dout1_23 Vdout1_23ck153 = 0 time = 770
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=770.025n

* CHECK dout1_24 Vdout1_24ck153 = 0 time = 770
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=770.025n

* CHECK dout1_25 Vdout1_25ck153 = 0 time = 770
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=770.025n

* CHECK dout1_26 Vdout1_26ck153 = 0 time = 770
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=770.025n

* CHECK dout1_27 Vdout1_27ck153 = 0.9 time = 770
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=770.025n

* CHECK dout1_28 Vdout1_28ck153 = 0.9 time = 770
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=770.025n

* CHECK dout1_29 Vdout1_29ck153 = 0.9 time = 770
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=770.025n

* CHECK dout1_30 Vdout1_30ck153 = 0.9 time = 770
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=770.025n

* CHECK dout1_31 Vdout1_31ck153 = 0 time = 770
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=770.025n

* CHECK dout1_32 Vdout1_32ck153 = 0 time = 770
.meas tran vdout1_32ck153 FIND v(dout1_32) AT=770.025n

* CHECK dout1_33 Vdout1_33ck153 = 0 time = 770
.meas tran vdout1_33ck153 FIND v(dout1_33) AT=770.025n

* CHECK dout1_34 Vdout1_34ck153 = 0 time = 770
.meas tran vdout1_34ck153 FIND v(dout1_34) AT=770.025n

* CHECK dout1_35 Vdout1_35ck153 = 0.9 time = 770
.meas tran vdout1_35ck153 FIND v(dout1_35) AT=770.025n

* CHECK dout1_36 Vdout1_36ck153 = 0 time = 770
.meas tran vdout1_36ck153 FIND v(dout1_36) AT=770.025n

* CHECK dout1_37 Vdout1_37ck153 = 0.9 time = 770
.meas tran vdout1_37ck153 FIND v(dout1_37) AT=770.025n

* CHECK dout1_38 Vdout1_38ck153 = 0.9 time = 770
.meas tran vdout1_38ck153 FIND v(dout1_38) AT=770.025n

* CHECK dout1_39 Vdout1_39ck153 = 0 time = 770
.meas tran vdout1_39ck153 FIND v(dout1_39) AT=770.025n

* CHECK dout1_40 Vdout1_40ck153 = 0.9 time = 770
.meas tran vdout1_40ck153 FIND v(dout1_40) AT=770.025n

* CHECK dout1_41 Vdout1_41ck153 = 0 time = 770
.meas tran vdout1_41ck153 FIND v(dout1_41) AT=770.025n

* CHECK dout1_42 Vdout1_42ck153 = 0.9 time = 770
.meas tran vdout1_42ck153 FIND v(dout1_42) AT=770.025n

* CHECK dout1_43 Vdout1_43ck153 = 0 time = 770
.meas tran vdout1_43ck153 FIND v(dout1_43) AT=770.025n

* CHECK dout1_44 Vdout1_44ck153 = 0.9 time = 770
.meas tran vdout1_44ck153 FIND v(dout1_44) AT=770.025n

* CHECK dout1_45 Vdout1_45ck153 = 0 time = 770
.meas tran vdout1_45ck153 FIND v(dout1_45) AT=770.025n

* CHECK dout1_46 Vdout1_46ck153 = 0 time = 770
.meas tran vdout1_46ck153 FIND v(dout1_46) AT=770.025n

* CHECK dout1_47 Vdout1_47ck153 = 0 time = 770
.meas tran vdout1_47ck153 FIND v(dout1_47) AT=770.025n

* CHECK dout1_48 Vdout1_48ck153 = 0 time = 770
.meas tran vdout1_48ck153 FIND v(dout1_48) AT=770.025n

* CHECK dout1_49 Vdout1_49ck153 = 0 time = 770
.meas tran vdout1_49ck153 FIND v(dout1_49) AT=770.025n

* CHECK dout1_50 Vdout1_50ck153 = 0.9 time = 770
.meas tran vdout1_50ck153 FIND v(dout1_50) AT=770.025n

* CHECK dout1_51 Vdout1_51ck153 = 0.9 time = 770
.meas tran vdout1_51ck153 FIND v(dout1_51) AT=770.025n

* CHECK dout1_52 Vdout1_52ck153 = 0 time = 770
.meas tran vdout1_52ck153 FIND v(dout1_52) AT=770.025n

* CHECK dout1_53 Vdout1_53ck153 = 0 time = 770
.meas tran vdout1_53ck153 FIND v(dout1_53) AT=770.025n

* CHECK dout1_54 Vdout1_54ck153 = 0 time = 770
.meas tran vdout1_54ck153 FIND v(dout1_54) AT=770.025n

* CHECK dout1_55 Vdout1_55ck153 = 0 time = 770
.meas tran vdout1_55ck153 FIND v(dout1_55) AT=770.025n

* CHECK dout1_0 Vdout1_0ck154 = 0 time = 775
.meas tran vdout1_0ck154 FIND v(dout1_0) AT=775.025n

* CHECK dout1_1 Vdout1_1ck154 = 0 time = 775
.meas tran vdout1_1ck154 FIND v(dout1_1) AT=775.025n

* CHECK dout1_2 Vdout1_2ck154 = 0.9 time = 775
.meas tran vdout1_2ck154 FIND v(dout1_2) AT=775.025n

* CHECK dout1_3 Vdout1_3ck154 = 0.9 time = 775
.meas tran vdout1_3ck154 FIND v(dout1_3) AT=775.025n

* CHECK dout1_4 Vdout1_4ck154 = 0.9 time = 775
.meas tran vdout1_4ck154 FIND v(dout1_4) AT=775.025n

* CHECK dout1_5 Vdout1_5ck154 = 0 time = 775
.meas tran vdout1_5ck154 FIND v(dout1_5) AT=775.025n

* CHECK dout1_6 Vdout1_6ck154 = 0.9 time = 775
.meas tran vdout1_6ck154 FIND v(dout1_6) AT=775.025n

* CHECK dout1_7 Vdout1_7ck154 = 0 time = 775
.meas tran vdout1_7ck154 FIND v(dout1_7) AT=775.025n

* CHECK dout1_8 Vdout1_8ck154 = 0 time = 775
.meas tran vdout1_8ck154 FIND v(dout1_8) AT=775.025n

* CHECK dout1_9 Vdout1_9ck154 = 0.9 time = 775
.meas tran vdout1_9ck154 FIND v(dout1_9) AT=775.025n

* CHECK dout1_10 Vdout1_10ck154 = 0.9 time = 775
.meas tran vdout1_10ck154 FIND v(dout1_10) AT=775.025n

* CHECK dout1_11 Vdout1_11ck154 = 0 time = 775
.meas tran vdout1_11ck154 FIND v(dout1_11) AT=775.025n

* CHECK dout1_12 Vdout1_12ck154 = 0.9 time = 775
.meas tran vdout1_12ck154 FIND v(dout1_12) AT=775.025n

* CHECK dout1_13 Vdout1_13ck154 = 0.9 time = 775
.meas tran vdout1_13ck154 FIND v(dout1_13) AT=775.025n

* CHECK dout1_14 Vdout1_14ck154 = 0 time = 775
.meas tran vdout1_14ck154 FIND v(dout1_14) AT=775.025n

* CHECK dout1_15 Vdout1_15ck154 = 0 time = 775
.meas tran vdout1_15ck154 FIND v(dout1_15) AT=775.025n

* CHECK dout1_16 Vdout1_16ck154 = 0 time = 775
.meas tran vdout1_16ck154 FIND v(dout1_16) AT=775.025n

* CHECK dout1_17 Vdout1_17ck154 = 0 time = 775
.meas tran vdout1_17ck154 FIND v(dout1_17) AT=775.025n

* CHECK dout1_18 Vdout1_18ck154 = 0 time = 775
.meas tran vdout1_18ck154 FIND v(dout1_18) AT=775.025n

* CHECK dout1_19 Vdout1_19ck154 = 0.9 time = 775
.meas tran vdout1_19ck154 FIND v(dout1_19) AT=775.025n

* CHECK dout1_20 Vdout1_20ck154 = 0 time = 775
.meas tran vdout1_20ck154 FIND v(dout1_20) AT=775.025n

* CHECK dout1_21 Vdout1_21ck154 = 0 time = 775
.meas tran vdout1_21ck154 FIND v(dout1_21) AT=775.025n

* CHECK dout1_22 Vdout1_22ck154 = 0.9 time = 775
.meas tran vdout1_22ck154 FIND v(dout1_22) AT=775.025n

* CHECK dout1_23 Vdout1_23ck154 = 0 time = 775
.meas tran vdout1_23ck154 FIND v(dout1_23) AT=775.025n

* CHECK dout1_24 Vdout1_24ck154 = 0 time = 775
.meas tran vdout1_24ck154 FIND v(dout1_24) AT=775.025n

* CHECK dout1_25 Vdout1_25ck154 = 0 time = 775
.meas tran vdout1_25ck154 FIND v(dout1_25) AT=775.025n

* CHECK dout1_26 Vdout1_26ck154 = 0 time = 775
.meas tran vdout1_26ck154 FIND v(dout1_26) AT=775.025n

* CHECK dout1_27 Vdout1_27ck154 = 0.9 time = 775
.meas tran vdout1_27ck154 FIND v(dout1_27) AT=775.025n

* CHECK dout1_28 Vdout1_28ck154 = 0.9 time = 775
.meas tran vdout1_28ck154 FIND v(dout1_28) AT=775.025n

* CHECK dout1_29 Vdout1_29ck154 = 0.9 time = 775
.meas tran vdout1_29ck154 FIND v(dout1_29) AT=775.025n

* CHECK dout1_30 Vdout1_30ck154 = 0.9 time = 775
.meas tran vdout1_30ck154 FIND v(dout1_30) AT=775.025n

* CHECK dout1_31 Vdout1_31ck154 = 0 time = 775
.meas tran vdout1_31ck154 FIND v(dout1_31) AT=775.025n

* CHECK dout1_32 Vdout1_32ck154 = 0 time = 775
.meas tran vdout1_32ck154 FIND v(dout1_32) AT=775.025n

* CHECK dout1_33 Vdout1_33ck154 = 0 time = 775
.meas tran vdout1_33ck154 FIND v(dout1_33) AT=775.025n

* CHECK dout1_34 Vdout1_34ck154 = 0 time = 775
.meas tran vdout1_34ck154 FIND v(dout1_34) AT=775.025n

* CHECK dout1_35 Vdout1_35ck154 = 0.9 time = 775
.meas tran vdout1_35ck154 FIND v(dout1_35) AT=775.025n

* CHECK dout1_36 Vdout1_36ck154 = 0 time = 775
.meas tran vdout1_36ck154 FIND v(dout1_36) AT=775.025n

* CHECK dout1_37 Vdout1_37ck154 = 0.9 time = 775
.meas tran vdout1_37ck154 FIND v(dout1_37) AT=775.025n

* CHECK dout1_38 Vdout1_38ck154 = 0.9 time = 775
.meas tran vdout1_38ck154 FIND v(dout1_38) AT=775.025n

* CHECK dout1_39 Vdout1_39ck154 = 0 time = 775
.meas tran vdout1_39ck154 FIND v(dout1_39) AT=775.025n

* CHECK dout1_40 Vdout1_40ck154 = 0.9 time = 775
.meas tran vdout1_40ck154 FIND v(dout1_40) AT=775.025n

* CHECK dout1_41 Vdout1_41ck154 = 0 time = 775
.meas tran vdout1_41ck154 FIND v(dout1_41) AT=775.025n

* CHECK dout1_42 Vdout1_42ck154 = 0.9 time = 775
.meas tran vdout1_42ck154 FIND v(dout1_42) AT=775.025n

* CHECK dout1_43 Vdout1_43ck154 = 0 time = 775
.meas tran vdout1_43ck154 FIND v(dout1_43) AT=775.025n

* CHECK dout1_44 Vdout1_44ck154 = 0.9 time = 775
.meas tran vdout1_44ck154 FIND v(dout1_44) AT=775.025n

* CHECK dout1_45 Vdout1_45ck154 = 0 time = 775
.meas tran vdout1_45ck154 FIND v(dout1_45) AT=775.025n

* CHECK dout1_46 Vdout1_46ck154 = 0 time = 775
.meas tran vdout1_46ck154 FIND v(dout1_46) AT=775.025n

* CHECK dout1_47 Vdout1_47ck154 = 0 time = 775
.meas tran vdout1_47ck154 FIND v(dout1_47) AT=775.025n

* CHECK dout1_48 Vdout1_48ck154 = 0 time = 775
.meas tran vdout1_48ck154 FIND v(dout1_48) AT=775.025n

* CHECK dout1_49 Vdout1_49ck154 = 0 time = 775
.meas tran vdout1_49ck154 FIND v(dout1_49) AT=775.025n

* CHECK dout1_50 Vdout1_50ck154 = 0.9 time = 775
.meas tran vdout1_50ck154 FIND v(dout1_50) AT=775.025n

* CHECK dout1_51 Vdout1_51ck154 = 0.9 time = 775
.meas tran vdout1_51ck154 FIND v(dout1_51) AT=775.025n

* CHECK dout1_52 Vdout1_52ck154 = 0 time = 775
.meas tran vdout1_52ck154 FIND v(dout1_52) AT=775.025n

* CHECK dout1_53 Vdout1_53ck154 = 0 time = 775
.meas tran vdout1_53ck154 FIND v(dout1_53) AT=775.025n

* CHECK dout1_54 Vdout1_54ck154 = 0 time = 775
.meas tran vdout1_54ck154 FIND v(dout1_54) AT=775.025n

* CHECK dout1_55 Vdout1_55ck154 = 0 time = 775
.meas tran vdout1_55ck154 FIND v(dout1_55) AT=775.025n

* CHECK dout1_0 Vdout1_0ck155 = 0.9 time = 780
.meas tran vdout1_0ck155 FIND v(dout1_0) AT=780.025n

* CHECK dout1_1 Vdout1_1ck155 = 0 time = 780
.meas tran vdout1_1ck155 FIND v(dout1_1) AT=780.025n

* CHECK dout1_2 Vdout1_2ck155 = 0.9 time = 780
.meas tran vdout1_2ck155 FIND v(dout1_2) AT=780.025n

* CHECK dout1_3 Vdout1_3ck155 = 0.9 time = 780
.meas tran vdout1_3ck155 FIND v(dout1_3) AT=780.025n

* CHECK dout1_4 Vdout1_4ck155 = 0 time = 780
.meas tran vdout1_4ck155 FIND v(dout1_4) AT=780.025n

* CHECK dout1_5 Vdout1_5ck155 = 0 time = 780
.meas tran vdout1_5ck155 FIND v(dout1_5) AT=780.025n

* CHECK dout1_6 Vdout1_6ck155 = 0 time = 780
.meas tran vdout1_6ck155 FIND v(dout1_6) AT=780.025n

* CHECK dout1_7 Vdout1_7ck155 = 0 time = 780
.meas tran vdout1_7ck155 FIND v(dout1_7) AT=780.025n

* CHECK dout1_8 Vdout1_8ck155 = 0 time = 780
.meas tran vdout1_8ck155 FIND v(dout1_8) AT=780.025n

* CHECK dout1_9 Vdout1_9ck155 = 0.9 time = 780
.meas tran vdout1_9ck155 FIND v(dout1_9) AT=780.025n

* CHECK dout1_10 Vdout1_10ck155 = 0.9 time = 780
.meas tran vdout1_10ck155 FIND v(dout1_10) AT=780.025n

* CHECK dout1_11 Vdout1_11ck155 = 0.9 time = 780
.meas tran vdout1_11ck155 FIND v(dout1_11) AT=780.025n

* CHECK dout1_12 Vdout1_12ck155 = 0 time = 780
.meas tran vdout1_12ck155 FIND v(dout1_12) AT=780.025n

* CHECK dout1_13 Vdout1_13ck155 = 0.9 time = 780
.meas tran vdout1_13ck155 FIND v(dout1_13) AT=780.025n

* CHECK dout1_14 Vdout1_14ck155 = 0 time = 780
.meas tran vdout1_14ck155 FIND v(dout1_14) AT=780.025n

* CHECK dout1_15 Vdout1_15ck155 = 0 time = 780
.meas tran vdout1_15ck155 FIND v(dout1_15) AT=780.025n

* CHECK dout1_16 Vdout1_16ck155 = 0 time = 780
.meas tran vdout1_16ck155 FIND v(dout1_16) AT=780.025n

* CHECK dout1_17 Vdout1_17ck155 = 0.9 time = 780
.meas tran vdout1_17ck155 FIND v(dout1_17) AT=780.025n

* CHECK dout1_18 Vdout1_18ck155 = 0 time = 780
.meas tran vdout1_18ck155 FIND v(dout1_18) AT=780.025n

* CHECK dout1_19 Vdout1_19ck155 = 0.9 time = 780
.meas tran vdout1_19ck155 FIND v(dout1_19) AT=780.025n

* CHECK dout1_20 Vdout1_20ck155 = 0 time = 780
.meas tran vdout1_20ck155 FIND v(dout1_20) AT=780.025n

* CHECK dout1_21 Vdout1_21ck155 = 0 time = 780
.meas tran vdout1_21ck155 FIND v(dout1_21) AT=780.025n

* CHECK dout1_22 Vdout1_22ck155 = 0.9 time = 780
.meas tran vdout1_22ck155 FIND v(dout1_22) AT=780.025n

* CHECK dout1_23 Vdout1_23ck155 = 0 time = 780
.meas tran vdout1_23ck155 FIND v(dout1_23) AT=780.025n

* CHECK dout1_24 Vdout1_24ck155 = 0.9 time = 780
.meas tran vdout1_24ck155 FIND v(dout1_24) AT=780.025n

* CHECK dout1_25 Vdout1_25ck155 = 0 time = 780
.meas tran vdout1_25ck155 FIND v(dout1_25) AT=780.025n

* CHECK dout1_26 Vdout1_26ck155 = 0.9 time = 780
.meas tran vdout1_26ck155 FIND v(dout1_26) AT=780.025n

* CHECK dout1_27 Vdout1_27ck155 = 0 time = 780
.meas tran vdout1_27ck155 FIND v(dout1_27) AT=780.025n

* CHECK dout1_28 Vdout1_28ck155 = 0 time = 780
.meas tran vdout1_28ck155 FIND v(dout1_28) AT=780.025n

* CHECK dout1_29 Vdout1_29ck155 = 0 time = 780
.meas tran vdout1_29ck155 FIND v(dout1_29) AT=780.025n

* CHECK dout1_30 Vdout1_30ck155 = 0 time = 780
.meas tran vdout1_30ck155 FIND v(dout1_30) AT=780.025n

* CHECK dout1_31 Vdout1_31ck155 = 0 time = 780
.meas tran vdout1_31ck155 FIND v(dout1_31) AT=780.025n

* CHECK dout1_32 Vdout1_32ck155 = 0.9 time = 780
.meas tran vdout1_32ck155 FIND v(dout1_32) AT=780.025n

* CHECK dout1_33 Vdout1_33ck155 = 0.9 time = 780
.meas tran vdout1_33ck155 FIND v(dout1_33) AT=780.025n

* CHECK dout1_34 Vdout1_34ck155 = 0.9 time = 780
.meas tran vdout1_34ck155 FIND v(dout1_34) AT=780.025n

* CHECK dout1_35 Vdout1_35ck155 = 0.9 time = 780
.meas tran vdout1_35ck155 FIND v(dout1_35) AT=780.025n

* CHECK dout1_36 Vdout1_36ck155 = 0.9 time = 780
.meas tran vdout1_36ck155 FIND v(dout1_36) AT=780.025n

* CHECK dout1_37 Vdout1_37ck155 = 0 time = 780
.meas tran vdout1_37ck155 FIND v(dout1_37) AT=780.025n

* CHECK dout1_38 Vdout1_38ck155 = 0 time = 780
.meas tran vdout1_38ck155 FIND v(dout1_38) AT=780.025n

* CHECK dout1_39 Vdout1_39ck155 = 0 time = 780
.meas tran vdout1_39ck155 FIND v(dout1_39) AT=780.025n

* CHECK dout1_40 Vdout1_40ck155 = 0 time = 780
.meas tran vdout1_40ck155 FIND v(dout1_40) AT=780.025n

* CHECK dout1_41 Vdout1_41ck155 = 0 time = 780
.meas tran vdout1_41ck155 FIND v(dout1_41) AT=780.025n

* CHECK dout1_42 Vdout1_42ck155 = 0 time = 780
.meas tran vdout1_42ck155 FIND v(dout1_42) AT=780.025n

* CHECK dout1_43 Vdout1_43ck155 = 0 time = 780
.meas tran vdout1_43ck155 FIND v(dout1_43) AT=780.025n

* CHECK dout1_44 Vdout1_44ck155 = 0.9 time = 780
.meas tran vdout1_44ck155 FIND v(dout1_44) AT=780.025n

* CHECK dout1_45 Vdout1_45ck155 = 0.9 time = 780
.meas tran vdout1_45ck155 FIND v(dout1_45) AT=780.025n

* CHECK dout1_46 Vdout1_46ck155 = 0.9 time = 780
.meas tran vdout1_46ck155 FIND v(dout1_46) AT=780.025n

* CHECK dout1_47 Vdout1_47ck155 = 0.9 time = 780
.meas tran vdout1_47ck155 FIND v(dout1_47) AT=780.025n

* CHECK dout1_48 Vdout1_48ck155 = 0 time = 780
.meas tran vdout1_48ck155 FIND v(dout1_48) AT=780.025n

* CHECK dout1_49 Vdout1_49ck155 = 0 time = 780
.meas tran vdout1_49ck155 FIND v(dout1_49) AT=780.025n

* CHECK dout1_50 Vdout1_50ck155 = 0.9 time = 780
.meas tran vdout1_50ck155 FIND v(dout1_50) AT=780.025n

* CHECK dout1_51 Vdout1_51ck155 = 0 time = 780
.meas tran vdout1_51ck155 FIND v(dout1_51) AT=780.025n

* CHECK dout1_52 Vdout1_52ck155 = 0 time = 780
.meas tran vdout1_52ck155 FIND v(dout1_52) AT=780.025n

* CHECK dout1_53 Vdout1_53ck155 = 0 time = 780
.meas tran vdout1_53ck155 FIND v(dout1_53) AT=780.025n

* CHECK dout1_54 Vdout1_54ck155 = 0 time = 780
.meas tran vdout1_54ck155 FIND v(dout1_54) AT=780.025n

* CHECK dout1_55 Vdout1_55ck155 = 0.9 time = 780
.meas tran vdout1_55ck155 FIND v(dout1_55) AT=780.025n

* CHECK dout1_0 Vdout1_0ck157 = 0.9 time = 790
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=790.025n

* CHECK dout1_1 Vdout1_1ck157 = 0 time = 790
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=790.025n

* CHECK dout1_2 Vdout1_2ck157 = 0.9 time = 790
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=790.025n

* CHECK dout1_3 Vdout1_3ck157 = 0.9 time = 790
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=790.025n

* CHECK dout1_4 Vdout1_4ck157 = 0 time = 790
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=790.025n

* CHECK dout1_5 Vdout1_5ck157 = 0 time = 790
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=790.025n

* CHECK dout1_6 Vdout1_6ck157 = 0 time = 790
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=790.025n

* CHECK dout1_7 Vdout1_7ck157 = 0 time = 790
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=790.025n

* CHECK dout1_8 Vdout1_8ck157 = 0 time = 790
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=790.025n

* CHECK dout1_9 Vdout1_9ck157 = 0.9 time = 790
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=790.025n

* CHECK dout1_10 Vdout1_10ck157 = 0.9 time = 790
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=790.025n

* CHECK dout1_11 Vdout1_11ck157 = 0.9 time = 790
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=790.025n

* CHECK dout1_12 Vdout1_12ck157 = 0 time = 790
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=790.025n

* CHECK dout1_13 Vdout1_13ck157 = 0.9 time = 790
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=790.025n

* CHECK dout1_14 Vdout1_14ck157 = 0 time = 790
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=790.025n

* CHECK dout1_15 Vdout1_15ck157 = 0 time = 790
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=790.025n

* CHECK dout1_16 Vdout1_16ck157 = 0 time = 790
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=790.025n

* CHECK dout1_17 Vdout1_17ck157 = 0.9 time = 790
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=790.025n

* CHECK dout1_18 Vdout1_18ck157 = 0 time = 790
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=790.025n

* CHECK dout1_19 Vdout1_19ck157 = 0.9 time = 790
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=790.025n

* CHECK dout1_20 Vdout1_20ck157 = 0 time = 790
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=790.025n

* CHECK dout1_21 Vdout1_21ck157 = 0 time = 790
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=790.025n

* CHECK dout1_22 Vdout1_22ck157 = 0.9 time = 790
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=790.025n

* CHECK dout1_23 Vdout1_23ck157 = 0 time = 790
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=790.025n

* CHECK dout1_24 Vdout1_24ck157 = 0.9 time = 790
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=790.025n

* CHECK dout1_25 Vdout1_25ck157 = 0 time = 790
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=790.025n

* CHECK dout1_26 Vdout1_26ck157 = 0.9 time = 790
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=790.025n

* CHECK dout1_27 Vdout1_27ck157 = 0 time = 790
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=790.025n

* CHECK dout1_28 Vdout1_28ck157 = 0 time = 790
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=790.025n

* CHECK dout1_29 Vdout1_29ck157 = 0 time = 790
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=790.025n

* CHECK dout1_30 Vdout1_30ck157 = 0 time = 790
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=790.025n

* CHECK dout1_31 Vdout1_31ck157 = 0 time = 790
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=790.025n

* CHECK dout1_32 Vdout1_32ck157 = 0.9 time = 790
.meas tran vdout1_32ck157 FIND v(dout1_32) AT=790.025n

* CHECK dout1_33 Vdout1_33ck157 = 0.9 time = 790
.meas tran vdout1_33ck157 FIND v(dout1_33) AT=790.025n

* CHECK dout1_34 Vdout1_34ck157 = 0.9 time = 790
.meas tran vdout1_34ck157 FIND v(dout1_34) AT=790.025n

* CHECK dout1_35 Vdout1_35ck157 = 0.9 time = 790
.meas tran vdout1_35ck157 FIND v(dout1_35) AT=790.025n

* CHECK dout1_36 Vdout1_36ck157 = 0.9 time = 790
.meas tran vdout1_36ck157 FIND v(dout1_36) AT=790.025n

* CHECK dout1_37 Vdout1_37ck157 = 0 time = 790
.meas tran vdout1_37ck157 FIND v(dout1_37) AT=790.025n

* CHECK dout1_38 Vdout1_38ck157 = 0 time = 790
.meas tran vdout1_38ck157 FIND v(dout1_38) AT=790.025n

* CHECK dout1_39 Vdout1_39ck157 = 0 time = 790
.meas tran vdout1_39ck157 FIND v(dout1_39) AT=790.025n

* CHECK dout1_40 Vdout1_40ck157 = 0 time = 790
.meas tran vdout1_40ck157 FIND v(dout1_40) AT=790.025n

* CHECK dout1_41 Vdout1_41ck157 = 0 time = 790
.meas tran vdout1_41ck157 FIND v(dout1_41) AT=790.025n

* CHECK dout1_42 Vdout1_42ck157 = 0 time = 790
.meas tran vdout1_42ck157 FIND v(dout1_42) AT=790.025n

* CHECK dout1_43 Vdout1_43ck157 = 0 time = 790
.meas tran vdout1_43ck157 FIND v(dout1_43) AT=790.025n

* CHECK dout1_44 Vdout1_44ck157 = 0.9 time = 790
.meas tran vdout1_44ck157 FIND v(dout1_44) AT=790.025n

* CHECK dout1_45 Vdout1_45ck157 = 0.9 time = 790
.meas tran vdout1_45ck157 FIND v(dout1_45) AT=790.025n

* CHECK dout1_46 Vdout1_46ck157 = 0.9 time = 790
.meas tran vdout1_46ck157 FIND v(dout1_46) AT=790.025n

* CHECK dout1_47 Vdout1_47ck157 = 0.9 time = 790
.meas tran vdout1_47ck157 FIND v(dout1_47) AT=790.025n

* CHECK dout1_48 Vdout1_48ck157 = 0 time = 790
.meas tran vdout1_48ck157 FIND v(dout1_48) AT=790.025n

* CHECK dout1_49 Vdout1_49ck157 = 0 time = 790
.meas tran vdout1_49ck157 FIND v(dout1_49) AT=790.025n

* CHECK dout1_50 Vdout1_50ck157 = 0.9 time = 790
.meas tran vdout1_50ck157 FIND v(dout1_50) AT=790.025n

* CHECK dout1_51 Vdout1_51ck157 = 0 time = 790
.meas tran vdout1_51ck157 FIND v(dout1_51) AT=790.025n

* CHECK dout1_52 Vdout1_52ck157 = 0 time = 790
.meas tran vdout1_52ck157 FIND v(dout1_52) AT=790.025n

* CHECK dout1_53 Vdout1_53ck157 = 0 time = 790
.meas tran vdout1_53ck157 FIND v(dout1_53) AT=790.025n

* CHECK dout1_54 Vdout1_54ck157 = 0 time = 790
.meas tran vdout1_54ck157 FIND v(dout1_54) AT=790.025n

* CHECK dout1_55 Vdout1_55ck157 = 0.9 time = 790
.meas tran vdout1_55ck157 FIND v(dout1_55) AT=790.025n

* CHECK dout1_0 Vdout1_0ck159 = 0 time = 800
.meas tran vdout1_0ck159 FIND v(dout1_0) AT=800.025n

* CHECK dout1_1 Vdout1_1ck159 = 0 time = 800
.meas tran vdout1_1ck159 FIND v(dout1_1) AT=800.025n

* CHECK dout1_2 Vdout1_2ck159 = 0.9 time = 800
.meas tran vdout1_2ck159 FIND v(dout1_2) AT=800.025n

* CHECK dout1_3 Vdout1_3ck159 = 0.9 time = 800
.meas tran vdout1_3ck159 FIND v(dout1_3) AT=800.025n

* CHECK dout1_4 Vdout1_4ck159 = 0.9 time = 800
.meas tran vdout1_4ck159 FIND v(dout1_4) AT=800.025n

* CHECK dout1_5 Vdout1_5ck159 = 0 time = 800
.meas tran vdout1_5ck159 FIND v(dout1_5) AT=800.025n

* CHECK dout1_6 Vdout1_6ck159 = 0.9 time = 800
.meas tran vdout1_6ck159 FIND v(dout1_6) AT=800.025n

* CHECK dout1_7 Vdout1_7ck159 = 0 time = 800
.meas tran vdout1_7ck159 FIND v(dout1_7) AT=800.025n

* CHECK dout1_8 Vdout1_8ck159 = 0 time = 800
.meas tran vdout1_8ck159 FIND v(dout1_8) AT=800.025n

* CHECK dout1_9 Vdout1_9ck159 = 0 time = 800
.meas tran vdout1_9ck159 FIND v(dout1_9) AT=800.025n

* CHECK dout1_10 Vdout1_10ck159 = 0 time = 800
.meas tran vdout1_10ck159 FIND v(dout1_10) AT=800.025n

* CHECK dout1_11 Vdout1_11ck159 = 0.9 time = 800
.meas tran vdout1_11ck159 FIND v(dout1_11) AT=800.025n

* CHECK dout1_12 Vdout1_12ck159 = 0.9 time = 800
.meas tran vdout1_12ck159 FIND v(dout1_12) AT=800.025n

* CHECK dout1_13 Vdout1_13ck159 = 0.9 time = 800
.meas tran vdout1_13ck159 FIND v(dout1_13) AT=800.025n

* CHECK dout1_14 Vdout1_14ck159 = 0.9 time = 800
.meas tran vdout1_14ck159 FIND v(dout1_14) AT=800.025n

* CHECK dout1_15 Vdout1_15ck159 = 0.9 time = 800
.meas tran vdout1_15ck159 FIND v(dout1_15) AT=800.025n

* CHECK dout1_16 Vdout1_16ck159 = 0.9 time = 800
.meas tran vdout1_16ck159 FIND v(dout1_16) AT=800.025n

* CHECK dout1_17 Vdout1_17ck159 = 0 time = 800
.meas tran vdout1_17ck159 FIND v(dout1_17) AT=800.025n

* CHECK dout1_18 Vdout1_18ck159 = 0.9 time = 800
.meas tran vdout1_18ck159 FIND v(dout1_18) AT=800.025n

* CHECK dout1_19 Vdout1_19ck159 = 0 time = 800
.meas tran vdout1_19ck159 FIND v(dout1_19) AT=800.025n

* CHECK dout1_20 Vdout1_20ck159 = 0.9 time = 800
.meas tran vdout1_20ck159 FIND v(dout1_20) AT=800.025n

* CHECK dout1_21 Vdout1_21ck159 = 0 time = 800
.meas tran vdout1_21ck159 FIND v(dout1_21) AT=800.025n

* CHECK dout1_22 Vdout1_22ck159 = 0.9 time = 800
.meas tran vdout1_22ck159 FIND v(dout1_22) AT=800.025n

* CHECK dout1_23 Vdout1_23ck159 = 0.9 time = 800
.meas tran vdout1_23ck159 FIND v(dout1_23) AT=800.025n

* CHECK dout1_24 Vdout1_24ck159 = 0 time = 800
.meas tran vdout1_24ck159 FIND v(dout1_24) AT=800.025n

* CHECK dout1_25 Vdout1_25ck159 = 0.9 time = 800
.meas tran vdout1_25ck159 FIND v(dout1_25) AT=800.025n

* CHECK dout1_26 Vdout1_26ck159 = 0 time = 800
.meas tran vdout1_26ck159 FIND v(dout1_26) AT=800.025n

* CHECK dout1_27 Vdout1_27ck159 = 0.9 time = 800
.meas tran vdout1_27ck159 FIND v(dout1_27) AT=800.025n

* CHECK dout1_28 Vdout1_28ck159 = 0 time = 800
.meas tran vdout1_28ck159 FIND v(dout1_28) AT=800.025n

* CHECK dout1_29 Vdout1_29ck159 = 0 time = 800
.meas tran vdout1_29ck159 FIND v(dout1_29) AT=800.025n

* CHECK dout1_30 Vdout1_30ck159 = 0.9 time = 800
.meas tran vdout1_30ck159 FIND v(dout1_30) AT=800.025n

* CHECK dout1_31 Vdout1_31ck159 = 0 time = 800
.meas tran vdout1_31ck159 FIND v(dout1_31) AT=800.025n

* CHECK dout1_32 Vdout1_32ck159 = 0.9 time = 800
.meas tran vdout1_32ck159 FIND v(dout1_32) AT=800.025n

* CHECK dout1_33 Vdout1_33ck159 = 0 time = 800
.meas tran vdout1_33ck159 FIND v(dout1_33) AT=800.025n

* CHECK dout1_34 Vdout1_34ck159 = 0.9 time = 800
.meas tran vdout1_34ck159 FIND v(dout1_34) AT=800.025n

* CHECK dout1_35 Vdout1_35ck159 = 0 time = 800
.meas tran vdout1_35ck159 FIND v(dout1_35) AT=800.025n

* CHECK dout1_36 Vdout1_36ck159 = 0.9 time = 800
.meas tran vdout1_36ck159 FIND v(dout1_36) AT=800.025n

* CHECK dout1_37 Vdout1_37ck159 = 0 time = 800
.meas tran vdout1_37ck159 FIND v(dout1_37) AT=800.025n

* CHECK dout1_38 Vdout1_38ck159 = 0.9 time = 800
.meas tran vdout1_38ck159 FIND v(dout1_38) AT=800.025n

* CHECK dout1_39 Vdout1_39ck159 = 0.9 time = 800
.meas tran vdout1_39ck159 FIND v(dout1_39) AT=800.025n

* CHECK dout1_40 Vdout1_40ck159 = 0.9 time = 800
.meas tran vdout1_40ck159 FIND v(dout1_40) AT=800.025n

* CHECK dout1_41 Vdout1_41ck159 = 0 time = 800
.meas tran vdout1_41ck159 FIND v(dout1_41) AT=800.025n

* CHECK dout1_42 Vdout1_42ck159 = 0 time = 800
.meas tran vdout1_42ck159 FIND v(dout1_42) AT=800.025n

* CHECK dout1_43 Vdout1_43ck159 = 0 time = 800
.meas tran vdout1_43ck159 FIND v(dout1_43) AT=800.025n

* CHECK dout1_44 Vdout1_44ck159 = 0 time = 800
.meas tran vdout1_44ck159 FIND v(dout1_44) AT=800.025n

* CHECK dout1_45 Vdout1_45ck159 = 0.9 time = 800
.meas tran vdout1_45ck159 FIND v(dout1_45) AT=800.025n

* CHECK dout1_46 Vdout1_46ck159 = 0 time = 800
.meas tran vdout1_46ck159 FIND v(dout1_46) AT=800.025n

* CHECK dout1_47 Vdout1_47ck159 = 0 time = 800
.meas tran vdout1_47ck159 FIND v(dout1_47) AT=800.025n

* CHECK dout1_48 Vdout1_48ck159 = 0 time = 800
.meas tran vdout1_48ck159 FIND v(dout1_48) AT=800.025n

* CHECK dout1_49 Vdout1_49ck159 = 0 time = 800
.meas tran vdout1_49ck159 FIND v(dout1_49) AT=800.025n

* CHECK dout1_50 Vdout1_50ck159 = 0 time = 800
.meas tran vdout1_50ck159 FIND v(dout1_50) AT=800.025n

* CHECK dout1_51 Vdout1_51ck159 = 0.9 time = 800
.meas tran vdout1_51ck159 FIND v(dout1_51) AT=800.025n

* CHECK dout1_52 Vdout1_52ck159 = 0.9 time = 800
.meas tran vdout1_52ck159 FIND v(dout1_52) AT=800.025n

* CHECK dout1_53 Vdout1_53ck159 = 0 time = 800
.meas tran vdout1_53ck159 FIND v(dout1_53) AT=800.025n

* CHECK dout1_54 Vdout1_54ck159 = 0 time = 800
.meas tran vdout1_54ck159 FIND v(dout1_54) AT=800.025n

* CHECK dout1_55 Vdout1_55ck159 = 0 time = 800
.meas tran vdout1_55ck159 FIND v(dout1_55) AT=800.025n

* CHECK dout1_0 Vdout1_0ck160 = 0 time = 805
.meas tran vdout1_0ck160 FIND v(dout1_0) AT=805.025n

* CHECK dout1_1 Vdout1_1ck160 = 0 time = 805
.meas tran vdout1_1ck160 FIND v(dout1_1) AT=805.025n

* CHECK dout1_2 Vdout1_2ck160 = 0.9 time = 805
.meas tran vdout1_2ck160 FIND v(dout1_2) AT=805.025n

* CHECK dout1_3 Vdout1_3ck160 = 0.9 time = 805
.meas tran vdout1_3ck160 FIND v(dout1_3) AT=805.025n

* CHECK dout1_4 Vdout1_4ck160 = 0.9 time = 805
.meas tran vdout1_4ck160 FIND v(dout1_4) AT=805.025n

* CHECK dout1_5 Vdout1_5ck160 = 0 time = 805
.meas tran vdout1_5ck160 FIND v(dout1_5) AT=805.025n

* CHECK dout1_6 Vdout1_6ck160 = 0.9 time = 805
.meas tran vdout1_6ck160 FIND v(dout1_6) AT=805.025n

* CHECK dout1_7 Vdout1_7ck160 = 0 time = 805
.meas tran vdout1_7ck160 FIND v(dout1_7) AT=805.025n

* CHECK dout1_8 Vdout1_8ck160 = 0 time = 805
.meas tran vdout1_8ck160 FIND v(dout1_8) AT=805.025n

* CHECK dout1_9 Vdout1_9ck160 = 0.9 time = 805
.meas tran vdout1_9ck160 FIND v(dout1_9) AT=805.025n

* CHECK dout1_10 Vdout1_10ck160 = 0.9 time = 805
.meas tran vdout1_10ck160 FIND v(dout1_10) AT=805.025n

* CHECK dout1_11 Vdout1_11ck160 = 0 time = 805
.meas tran vdout1_11ck160 FIND v(dout1_11) AT=805.025n

* CHECK dout1_12 Vdout1_12ck160 = 0.9 time = 805
.meas tran vdout1_12ck160 FIND v(dout1_12) AT=805.025n

* CHECK dout1_13 Vdout1_13ck160 = 0.9 time = 805
.meas tran vdout1_13ck160 FIND v(dout1_13) AT=805.025n

* CHECK dout1_14 Vdout1_14ck160 = 0 time = 805
.meas tran vdout1_14ck160 FIND v(dout1_14) AT=805.025n

* CHECK dout1_15 Vdout1_15ck160 = 0 time = 805
.meas tran vdout1_15ck160 FIND v(dout1_15) AT=805.025n

* CHECK dout1_16 Vdout1_16ck160 = 0 time = 805
.meas tran vdout1_16ck160 FIND v(dout1_16) AT=805.025n

* CHECK dout1_17 Vdout1_17ck160 = 0 time = 805
.meas tran vdout1_17ck160 FIND v(dout1_17) AT=805.025n

* CHECK dout1_18 Vdout1_18ck160 = 0 time = 805
.meas tran vdout1_18ck160 FIND v(dout1_18) AT=805.025n

* CHECK dout1_19 Vdout1_19ck160 = 0.9 time = 805
.meas tran vdout1_19ck160 FIND v(dout1_19) AT=805.025n

* CHECK dout1_20 Vdout1_20ck160 = 0.9 time = 805
.meas tran vdout1_20ck160 FIND v(dout1_20) AT=805.025n

* CHECK dout1_21 Vdout1_21ck160 = 0.9 time = 805
.meas tran vdout1_21ck160 FIND v(dout1_21) AT=805.025n

* CHECK dout1_22 Vdout1_22ck160 = 0 time = 805
.meas tran vdout1_22ck160 FIND v(dout1_22) AT=805.025n

* CHECK dout1_23 Vdout1_23ck160 = 0.9 time = 805
.meas tran vdout1_23ck160 FIND v(dout1_23) AT=805.025n

* CHECK dout1_24 Vdout1_24ck160 = 0 time = 805
.meas tran vdout1_24ck160 FIND v(dout1_24) AT=805.025n

* CHECK dout1_25 Vdout1_25ck160 = 0 time = 805
.meas tran vdout1_25ck160 FIND v(dout1_25) AT=805.025n

* CHECK dout1_26 Vdout1_26ck160 = 0 time = 805
.meas tran vdout1_26ck160 FIND v(dout1_26) AT=805.025n

* CHECK dout1_27 Vdout1_27ck160 = 0 time = 805
.meas tran vdout1_27ck160 FIND v(dout1_27) AT=805.025n

* CHECK dout1_28 Vdout1_28ck160 = 0 time = 805
.meas tran vdout1_28ck160 FIND v(dout1_28) AT=805.025n

* CHECK dout1_29 Vdout1_29ck160 = 0.9 time = 805
.meas tran vdout1_29ck160 FIND v(dout1_29) AT=805.025n

* CHECK dout1_30 Vdout1_30ck160 = 0.9 time = 805
.meas tran vdout1_30ck160 FIND v(dout1_30) AT=805.025n

* CHECK dout1_31 Vdout1_31ck160 = 0.9 time = 805
.meas tran vdout1_31ck160 FIND v(dout1_31) AT=805.025n

* CHECK dout1_32 Vdout1_32ck160 = 0 time = 805
.meas tran vdout1_32ck160 FIND v(dout1_32) AT=805.025n

* CHECK dout1_33 Vdout1_33ck160 = 0.9 time = 805
.meas tran vdout1_33ck160 FIND v(dout1_33) AT=805.025n

* CHECK dout1_34 Vdout1_34ck160 = 0.9 time = 805
.meas tran vdout1_34ck160 FIND v(dout1_34) AT=805.025n

* CHECK dout1_35 Vdout1_35ck160 = 0 time = 805
.meas tran vdout1_35ck160 FIND v(dout1_35) AT=805.025n

* CHECK dout1_36 Vdout1_36ck160 = 0.9 time = 805
.meas tran vdout1_36ck160 FIND v(dout1_36) AT=805.025n

* CHECK dout1_37 Vdout1_37ck160 = 0 time = 805
.meas tran vdout1_37ck160 FIND v(dout1_37) AT=805.025n

* CHECK dout1_38 Vdout1_38ck160 = 0 time = 805
.meas tran vdout1_38ck160 FIND v(dout1_38) AT=805.025n

* CHECK dout1_39 Vdout1_39ck160 = 0.9 time = 805
.meas tran vdout1_39ck160 FIND v(dout1_39) AT=805.025n

* CHECK dout1_40 Vdout1_40ck160 = 0.9 time = 805
.meas tran vdout1_40ck160 FIND v(dout1_40) AT=805.025n

* CHECK dout1_41 Vdout1_41ck160 = 0 time = 805
.meas tran vdout1_41ck160 FIND v(dout1_41) AT=805.025n

* CHECK dout1_42 Vdout1_42ck160 = 0.9 time = 805
.meas tran vdout1_42ck160 FIND v(dout1_42) AT=805.025n

* CHECK dout1_43 Vdout1_43ck160 = 0 time = 805
.meas tran vdout1_43ck160 FIND v(dout1_43) AT=805.025n

* CHECK dout1_44 Vdout1_44ck160 = 0.9 time = 805
.meas tran vdout1_44ck160 FIND v(dout1_44) AT=805.025n

* CHECK dout1_45 Vdout1_45ck160 = 0 time = 805
.meas tran vdout1_45ck160 FIND v(dout1_45) AT=805.025n

* CHECK dout1_46 Vdout1_46ck160 = 0 time = 805
.meas tran vdout1_46ck160 FIND v(dout1_46) AT=805.025n

* CHECK dout1_47 Vdout1_47ck160 = 0 time = 805
.meas tran vdout1_47ck160 FIND v(dout1_47) AT=805.025n

* CHECK dout1_48 Vdout1_48ck160 = 0 time = 805
.meas tran vdout1_48ck160 FIND v(dout1_48) AT=805.025n

* CHECK dout1_49 Vdout1_49ck160 = 0 time = 805
.meas tran vdout1_49ck160 FIND v(dout1_49) AT=805.025n

* CHECK dout1_50 Vdout1_50ck160 = 0.9 time = 805
.meas tran vdout1_50ck160 FIND v(dout1_50) AT=805.025n

* CHECK dout1_51 Vdout1_51ck160 = 0.9 time = 805
.meas tran vdout1_51ck160 FIND v(dout1_51) AT=805.025n

* CHECK dout1_52 Vdout1_52ck160 = 0 time = 805
.meas tran vdout1_52ck160 FIND v(dout1_52) AT=805.025n

* CHECK dout1_53 Vdout1_53ck160 = 0 time = 805
.meas tran vdout1_53ck160 FIND v(dout1_53) AT=805.025n

* CHECK dout1_54 Vdout1_54ck160 = 0 time = 805
.meas tran vdout1_54ck160 FIND v(dout1_54) AT=805.025n

* CHECK dout1_55 Vdout1_55ck160 = 0 time = 805
.meas tran vdout1_55ck160 FIND v(dout1_55) AT=805.025n

* CHECK dout1_0 Vdout1_0ck161 = 0 time = 810
.meas tran vdout1_0ck161 FIND v(dout1_0) AT=810.025n

* CHECK dout1_1 Vdout1_1ck161 = 0.9 time = 810
.meas tran vdout1_1ck161 FIND v(dout1_1) AT=810.025n

* CHECK dout1_2 Vdout1_2ck161 = 0.9 time = 810
.meas tran vdout1_2ck161 FIND v(dout1_2) AT=810.025n

* CHECK dout1_3 Vdout1_3ck161 = 0.9 time = 810
.meas tran vdout1_3ck161 FIND v(dout1_3) AT=810.025n

* CHECK dout1_4 Vdout1_4ck161 = 0.9 time = 810
.meas tran vdout1_4ck161 FIND v(dout1_4) AT=810.025n

* CHECK dout1_5 Vdout1_5ck161 = 0.9 time = 810
.meas tran vdout1_5ck161 FIND v(dout1_5) AT=810.025n

* CHECK dout1_6 Vdout1_6ck161 = 0.9 time = 810
.meas tran vdout1_6ck161 FIND v(dout1_6) AT=810.025n

* CHECK dout1_7 Vdout1_7ck161 = 0 time = 810
.meas tran vdout1_7ck161 FIND v(dout1_7) AT=810.025n

* CHECK dout1_8 Vdout1_8ck161 = 0 time = 810
.meas tran vdout1_8ck161 FIND v(dout1_8) AT=810.025n

* CHECK dout1_9 Vdout1_9ck161 = 0 time = 810
.meas tran vdout1_9ck161 FIND v(dout1_9) AT=810.025n

* CHECK dout1_10 Vdout1_10ck161 = 0.9 time = 810
.meas tran vdout1_10ck161 FIND v(dout1_10) AT=810.025n

* CHECK dout1_11 Vdout1_11ck161 = 0.9 time = 810
.meas tran vdout1_11ck161 FIND v(dout1_11) AT=810.025n

* CHECK dout1_12 Vdout1_12ck161 = 0 time = 810
.meas tran vdout1_12ck161 FIND v(dout1_12) AT=810.025n

* CHECK dout1_13 Vdout1_13ck161 = 0 time = 810
.meas tran vdout1_13ck161 FIND v(dout1_13) AT=810.025n

* CHECK dout1_14 Vdout1_14ck161 = 0.9 time = 810
.meas tran vdout1_14ck161 FIND v(dout1_14) AT=810.025n

* CHECK dout1_15 Vdout1_15ck161 = 0 time = 810
.meas tran vdout1_15ck161 FIND v(dout1_15) AT=810.025n

* CHECK dout1_16 Vdout1_16ck161 = 0 time = 810
.meas tran vdout1_16ck161 FIND v(dout1_16) AT=810.025n

* CHECK dout1_17 Vdout1_17ck161 = 0 time = 810
.meas tran vdout1_17ck161 FIND v(dout1_17) AT=810.025n

* CHECK dout1_18 Vdout1_18ck161 = 0 time = 810
.meas tran vdout1_18ck161 FIND v(dout1_18) AT=810.025n

* CHECK dout1_19 Vdout1_19ck161 = 0.9 time = 810
.meas tran vdout1_19ck161 FIND v(dout1_19) AT=810.025n

* CHECK dout1_20 Vdout1_20ck161 = 0.9 time = 810
.meas tran vdout1_20ck161 FIND v(dout1_20) AT=810.025n

* CHECK dout1_21 Vdout1_21ck161 = 0.9 time = 810
.meas tran vdout1_21ck161 FIND v(dout1_21) AT=810.025n

* CHECK dout1_22 Vdout1_22ck161 = 0 time = 810
.meas tran vdout1_22ck161 FIND v(dout1_22) AT=810.025n

* CHECK dout1_23 Vdout1_23ck161 = 0.9 time = 810
.meas tran vdout1_23ck161 FIND v(dout1_23) AT=810.025n

* CHECK dout1_24 Vdout1_24ck161 = 0 time = 810
.meas tran vdout1_24ck161 FIND v(dout1_24) AT=810.025n

* CHECK dout1_25 Vdout1_25ck161 = 0 time = 810
.meas tran vdout1_25ck161 FIND v(dout1_25) AT=810.025n

* CHECK dout1_26 Vdout1_26ck161 = 0.9 time = 810
.meas tran vdout1_26ck161 FIND v(dout1_26) AT=810.025n

* CHECK dout1_27 Vdout1_27ck161 = 0.9 time = 810
.meas tran vdout1_27ck161 FIND v(dout1_27) AT=810.025n

* CHECK dout1_28 Vdout1_28ck161 = 0.9 time = 810
.meas tran vdout1_28ck161 FIND v(dout1_28) AT=810.025n

* CHECK dout1_29 Vdout1_29ck161 = 0 time = 810
.meas tran vdout1_29ck161 FIND v(dout1_29) AT=810.025n

* CHECK dout1_30 Vdout1_30ck161 = 0.9 time = 810
.meas tran vdout1_30ck161 FIND v(dout1_30) AT=810.025n

* CHECK dout1_31 Vdout1_31ck161 = 0.9 time = 810
.meas tran vdout1_31ck161 FIND v(dout1_31) AT=810.025n

* CHECK dout1_32 Vdout1_32ck161 = 0.9 time = 810
.meas tran vdout1_32ck161 FIND v(dout1_32) AT=810.025n

* CHECK dout1_33 Vdout1_33ck161 = 0 time = 810
.meas tran vdout1_33ck161 FIND v(dout1_33) AT=810.025n

* CHECK dout1_34 Vdout1_34ck161 = 0.9 time = 810
.meas tran vdout1_34ck161 FIND v(dout1_34) AT=810.025n

* CHECK dout1_35 Vdout1_35ck161 = 0 time = 810
.meas tran vdout1_35ck161 FIND v(dout1_35) AT=810.025n

* CHECK dout1_36 Vdout1_36ck161 = 0 time = 810
.meas tran vdout1_36ck161 FIND v(dout1_36) AT=810.025n

* CHECK dout1_37 Vdout1_37ck161 = 0 time = 810
.meas tran vdout1_37ck161 FIND v(dout1_37) AT=810.025n

* CHECK dout1_38 Vdout1_38ck161 = 0 time = 810
.meas tran vdout1_38ck161 FIND v(dout1_38) AT=810.025n

* CHECK dout1_39 Vdout1_39ck161 = 0 time = 810
.meas tran vdout1_39ck161 FIND v(dout1_39) AT=810.025n

* CHECK dout1_40 Vdout1_40ck161 = 0.9 time = 810
.meas tran vdout1_40ck161 FIND v(dout1_40) AT=810.025n

* CHECK dout1_41 Vdout1_41ck161 = 0 time = 810
.meas tran vdout1_41ck161 FIND v(dout1_41) AT=810.025n

* CHECK dout1_42 Vdout1_42ck161 = 0 time = 810
.meas tran vdout1_42ck161 FIND v(dout1_42) AT=810.025n

* CHECK dout1_43 Vdout1_43ck161 = 0 time = 810
.meas tran vdout1_43ck161 FIND v(dout1_43) AT=810.025n

* CHECK dout1_44 Vdout1_44ck161 = 0.9 time = 810
.meas tran vdout1_44ck161 FIND v(dout1_44) AT=810.025n

* CHECK dout1_45 Vdout1_45ck161 = 0.9 time = 810
.meas tran vdout1_45ck161 FIND v(dout1_45) AT=810.025n

* CHECK dout1_46 Vdout1_46ck161 = 0.9 time = 810
.meas tran vdout1_46ck161 FIND v(dout1_46) AT=810.025n

* CHECK dout1_47 Vdout1_47ck161 = 0 time = 810
.meas tran vdout1_47ck161 FIND v(dout1_47) AT=810.025n

* CHECK dout1_48 Vdout1_48ck161 = 0.9 time = 810
.meas tran vdout1_48ck161 FIND v(dout1_48) AT=810.025n

* CHECK dout1_49 Vdout1_49ck161 = 0 time = 810
.meas tran vdout1_49ck161 FIND v(dout1_49) AT=810.025n

* CHECK dout1_50 Vdout1_50ck161 = 0.9 time = 810
.meas tran vdout1_50ck161 FIND v(dout1_50) AT=810.025n

* CHECK dout1_51 Vdout1_51ck161 = 0.9 time = 810
.meas tran vdout1_51ck161 FIND v(dout1_51) AT=810.025n

* CHECK dout1_52 Vdout1_52ck161 = 0.9 time = 810
.meas tran vdout1_52ck161 FIND v(dout1_52) AT=810.025n

* CHECK dout1_53 Vdout1_53ck161 = 0.9 time = 810
.meas tran vdout1_53ck161 FIND v(dout1_53) AT=810.025n

* CHECK dout1_54 Vdout1_54ck161 = 0 time = 810
.meas tran vdout1_54ck161 FIND v(dout1_54) AT=810.025n

* CHECK dout1_55 Vdout1_55ck161 = 0 time = 810
.meas tran vdout1_55ck161 FIND v(dout1_55) AT=810.025n

* CHECK dout1_0 Vdout1_0ck163 = 0 time = 820
.meas tran vdout1_0ck163 FIND v(dout1_0) AT=820.025n

* CHECK dout1_1 Vdout1_1ck163 = 0.9 time = 820
.meas tran vdout1_1ck163 FIND v(dout1_1) AT=820.025n

* CHECK dout1_2 Vdout1_2ck163 = 0.9 time = 820
.meas tran vdout1_2ck163 FIND v(dout1_2) AT=820.025n

* CHECK dout1_3 Vdout1_3ck163 = 0.9 time = 820
.meas tran vdout1_3ck163 FIND v(dout1_3) AT=820.025n

* CHECK dout1_4 Vdout1_4ck163 = 0.9 time = 820
.meas tran vdout1_4ck163 FIND v(dout1_4) AT=820.025n

* CHECK dout1_5 Vdout1_5ck163 = 0.9 time = 820
.meas tran vdout1_5ck163 FIND v(dout1_5) AT=820.025n

* CHECK dout1_6 Vdout1_6ck163 = 0.9 time = 820
.meas tran vdout1_6ck163 FIND v(dout1_6) AT=820.025n

* CHECK dout1_7 Vdout1_7ck163 = 0 time = 820
.meas tran vdout1_7ck163 FIND v(dout1_7) AT=820.025n

* CHECK dout1_8 Vdout1_8ck163 = 0 time = 820
.meas tran vdout1_8ck163 FIND v(dout1_8) AT=820.025n

* CHECK dout1_9 Vdout1_9ck163 = 0 time = 820
.meas tran vdout1_9ck163 FIND v(dout1_9) AT=820.025n

* CHECK dout1_10 Vdout1_10ck163 = 0.9 time = 820
.meas tran vdout1_10ck163 FIND v(dout1_10) AT=820.025n

* CHECK dout1_11 Vdout1_11ck163 = 0.9 time = 820
.meas tran vdout1_11ck163 FIND v(dout1_11) AT=820.025n

* CHECK dout1_12 Vdout1_12ck163 = 0 time = 820
.meas tran vdout1_12ck163 FIND v(dout1_12) AT=820.025n

* CHECK dout1_13 Vdout1_13ck163 = 0 time = 820
.meas tran vdout1_13ck163 FIND v(dout1_13) AT=820.025n

* CHECK dout1_14 Vdout1_14ck163 = 0.9 time = 820
.meas tran vdout1_14ck163 FIND v(dout1_14) AT=820.025n

* CHECK dout1_15 Vdout1_15ck163 = 0 time = 820
.meas tran vdout1_15ck163 FIND v(dout1_15) AT=820.025n

* CHECK dout1_16 Vdout1_16ck163 = 0 time = 820
.meas tran vdout1_16ck163 FIND v(dout1_16) AT=820.025n

* CHECK dout1_17 Vdout1_17ck163 = 0 time = 820
.meas tran vdout1_17ck163 FIND v(dout1_17) AT=820.025n

* CHECK dout1_18 Vdout1_18ck163 = 0 time = 820
.meas tran vdout1_18ck163 FIND v(dout1_18) AT=820.025n

* CHECK dout1_19 Vdout1_19ck163 = 0.9 time = 820
.meas tran vdout1_19ck163 FIND v(dout1_19) AT=820.025n

* CHECK dout1_20 Vdout1_20ck163 = 0.9 time = 820
.meas tran vdout1_20ck163 FIND v(dout1_20) AT=820.025n

* CHECK dout1_21 Vdout1_21ck163 = 0.9 time = 820
.meas tran vdout1_21ck163 FIND v(dout1_21) AT=820.025n

* CHECK dout1_22 Vdout1_22ck163 = 0 time = 820
.meas tran vdout1_22ck163 FIND v(dout1_22) AT=820.025n

* CHECK dout1_23 Vdout1_23ck163 = 0.9 time = 820
.meas tran vdout1_23ck163 FIND v(dout1_23) AT=820.025n

* CHECK dout1_24 Vdout1_24ck163 = 0 time = 820
.meas tran vdout1_24ck163 FIND v(dout1_24) AT=820.025n

* CHECK dout1_25 Vdout1_25ck163 = 0 time = 820
.meas tran vdout1_25ck163 FIND v(dout1_25) AT=820.025n

* CHECK dout1_26 Vdout1_26ck163 = 0.9 time = 820
.meas tran vdout1_26ck163 FIND v(dout1_26) AT=820.025n

* CHECK dout1_27 Vdout1_27ck163 = 0.9 time = 820
.meas tran vdout1_27ck163 FIND v(dout1_27) AT=820.025n

* CHECK dout1_28 Vdout1_28ck163 = 0.9 time = 820
.meas tran vdout1_28ck163 FIND v(dout1_28) AT=820.025n

* CHECK dout1_29 Vdout1_29ck163 = 0 time = 820
.meas tran vdout1_29ck163 FIND v(dout1_29) AT=820.025n

* CHECK dout1_30 Vdout1_30ck163 = 0.9 time = 820
.meas tran vdout1_30ck163 FIND v(dout1_30) AT=820.025n

* CHECK dout1_31 Vdout1_31ck163 = 0.9 time = 820
.meas tran vdout1_31ck163 FIND v(dout1_31) AT=820.025n

* CHECK dout1_32 Vdout1_32ck163 = 0.9 time = 820
.meas tran vdout1_32ck163 FIND v(dout1_32) AT=820.025n

* CHECK dout1_33 Vdout1_33ck163 = 0 time = 820
.meas tran vdout1_33ck163 FIND v(dout1_33) AT=820.025n

* CHECK dout1_34 Vdout1_34ck163 = 0.9 time = 820
.meas tran vdout1_34ck163 FIND v(dout1_34) AT=820.025n

* CHECK dout1_35 Vdout1_35ck163 = 0 time = 820
.meas tran vdout1_35ck163 FIND v(dout1_35) AT=820.025n

* CHECK dout1_36 Vdout1_36ck163 = 0 time = 820
.meas tran vdout1_36ck163 FIND v(dout1_36) AT=820.025n

* CHECK dout1_37 Vdout1_37ck163 = 0 time = 820
.meas tran vdout1_37ck163 FIND v(dout1_37) AT=820.025n

* CHECK dout1_38 Vdout1_38ck163 = 0 time = 820
.meas tran vdout1_38ck163 FIND v(dout1_38) AT=820.025n

* CHECK dout1_39 Vdout1_39ck163 = 0 time = 820
.meas tran vdout1_39ck163 FIND v(dout1_39) AT=820.025n

* CHECK dout1_40 Vdout1_40ck163 = 0.9 time = 820
.meas tran vdout1_40ck163 FIND v(dout1_40) AT=820.025n

* CHECK dout1_41 Vdout1_41ck163 = 0 time = 820
.meas tran vdout1_41ck163 FIND v(dout1_41) AT=820.025n

* CHECK dout1_42 Vdout1_42ck163 = 0 time = 820
.meas tran vdout1_42ck163 FIND v(dout1_42) AT=820.025n

* CHECK dout1_43 Vdout1_43ck163 = 0 time = 820
.meas tran vdout1_43ck163 FIND v(dout1_43) AT=820.025n

* CHECK dout1_44 Vdout1_44ck163 = 0.9 time = 820
.meas tran vdout1_44ck163 FIND v(dout1_44) AT=820.025n

* CHECK dout1_45 Vdout1_45ck163 = 0.9 time = 820
.meas tran vdout1_45ck163 FIND v(dout1_45) AT=820.025n

* CHECK dout1_46 Vdout1_46ck163 = 0.9 time = 820
.meas tran vdout1_46ck163 FIND v(dout1_46) AT=820.025n

* CHECK dout1_47 Vdout1_47ck163 = 0 time = 820
.meas tran vdout1_47ck163 FIND v(dout1_47) AT=820.025n

* CHECK dout1_48 Vdout1_48ck163 = 0.9 time = 820
.meas tran vdout1_48ck163 FIND v(dout1_48) AT=820.025n

* CHECK dout1_49 Vdout1_49ck163 = 0 time = 820
.meas tran vdout1_49ck163 FIND v(dout1_49) AT=820.025n

* CHECK dout1_50 Vdout1_50ck163 = 0.9 time = 820
.meas tran vdout1_50ck163 FIND v(dout1_50) AT=820.025n

* CHECK dout1_51 Vdout1_51ck163 = 0.9 time = 820
.meas tran vdout1_51ck163 FIND v(dout1_51) AT=820.025n

* CHECK dout1_52 Vdout1_52ck163 = 0.9 time = 820
.meas tran vdout1_52ck163 FIND v(dout1_52) AT=820.025n

* CHECK dout1_53 Vdout1_53ck163 = 0.9 time = 820
.meas tran vdout1_53ck163 FIND v(dout1_53) AT=820.025n

* CHECK dout1_54 Vdout1_54ck163 = 0 time = 820
.meas tran vdout1_54ck163 FIND v(dout1_54) AT=820.025n

* CHECK dout1_55 Vdout1_55ck163 = 0 time = 820
.meas tran vdout1_55ck163 FIND v(dout1_55) AT=820.025n

* CHECK dout1_0 Vdout1_0ck164 = 0 time = 825
.meas tran vdout1_0ck164 FIND v(dout1_0) AT=825.025n

* CHECK dout1_1 Vdout1_1ck164 = 0.9 time = 825
.meas tran vdout1_1ck164 FIND v(dout1_1) AT=825.025n

* CHECK dout1_2 Vdout1_2ck164 = 0.9 time = 825
.meas tran vdout1_2ck164 FIND v(dout1_2) AT=825.025n

* CHECK dout1_3 Vdout1_3ck164 = 0.9 time = 825
.meas tran vdout1_3ck164 FIND v(dout1_3) AT=825.025n

* CHECK dout1_4 Vdout1_4ck164 = 0.9 time = 825
.meas tran vdout1_4ck164 FIND v(dout1_4) AT=825.025n

* CHECK dout1_5 Vdout1_5ck164 = 0.9 time = 825
.meas tran vdout1_5ck164 FIND v(dout1_5) AT=825.025n

* CHECK dout1_6 Vdout1_6ck164 = 0.9 time = 825
.meas tran vdout1_6ck164 FIND v(dout1_6) AT=825.025n

* CHECK dout1_7 Vdout1_7ck164 = 0 time = 825
.meas tran vdout1_7ck164 FIND v(dout1_7) AT=825.025n

* CHECK dout1_8 Vdout1_8ck164 = 0 time = 825
.meas tran vdout1_8ck164 FIND v(dout1_8) AT=825.025n

* CHECK dout1_9 Vdout1_9ck164 = 0 time = 825
.meas tran vdout1_9ck164 FIND v(dout1_9) AT=825.025n

* CHECK dout1_10 Vdout1_10ck164 = 0.9 time = 825
.meas tran vdout1_10ck164 FIND v(dout1_10) AT=825.025n

* CHECK dout1_11 Vdout1_11ck164 = 0.9 time = 825
.meas tran vdout1_11ck164 FIND v(dout1_11) AT=825.025n

* CHECK dout1_12 Vdout1_12ck164 = 0 time = 825
.meas tran vdout1_12ck164 FIND v(dout1_12) AT=825.025n

* CHECK dout1_13 Vdout1_13ck164 = 0 time = 825
.meas tran vdout1_13ck164 FIND v(dout1_13) AT=825.025n

* CHECK dout1_14 Vdout1_14ck164 = 0.9 time = 825
.meas tran vdout1_14ck164 FIND v(dout1_14) AT=825.025n

* CHECK dout1_15 Vdout1_15ck164 = 0 time = 825
.meas tran vdout1_15ck164 FIND v(dout1_15) AT=825.025n

* CHECK dout1_16 Vdout1_16ck164 = 0 time = 825
.meas tran vdout1_16ck164 FIND v(dout1_16) AT=825.025n

* CHECK dout1_17 Vdout1_17ck164 = 0 time = 825
.meas tran vdout1_17ck164 FIND v(dout1_17) AT=825.025n

* CHECK dout1_18 Vdout1_18ck164 = 0 time = 825
.meas tran vdout1_18ck164 FIND v(dout1_18) AT=825.025n

* CHECK dout1_19 Vdout1_19ck164 = 0.9 time = 825
.meas tran vdout1_19ck164 FIND v(dout1_19) AT=825.025n

* CHECK dout1_20 Vdout1_20ck164 = 0.9 time = 825
.meas tran vdout1_20ck164 FIND v(dout1_20) AT=825.025n

* CHECK dout1_21 Vdout1_21ck164 = 0.9 time = 825
.meas tran vdout1_21ck164 FIND v(dout1_21) AT=825.025n

* CHECK dout1_22 Vdout1_22ck164 = 0 time = 825
.meas tran vdout1_22ck164 FIND v(dout1_22) AT=825.025n

* CHECK dout1_23 Vdout1_23ck164 = 0.9 time = 825
.meas tran vdout1_23ck164 FIND v(dout1_23) AT=825.025n

* CHECK dout1_24 Vdout1_24ck164 = 0 time = 825
.meas tran vdout1_24ck164 FIND v(dout1_24) AT=825.025n

* CHECK dout1_25 Vdout1_25ck164 = 0 time = 825
.meas tran vdout1_25ck164 FIND v(dout1_25) AT=825.025n

* CHECK dout1_26 Vdout1_26ck164 = 0.9 time = 825
.meas tran vdout1_26ck164 FIND v(dout1_26) AT=825.025n

* CHECK dout1_27 Vdout1_27ck164 = 0.9 time = 825
.meas tran vdout1_27ck164 FIND v(dout1_27) AT=825.025n

* CHECK dout1_28 Vdout1_28ck164 = 0.9 time = 825
.meas tran vdout1_28ck164 FIND v(dout1_28) AT=825.025n

* CHECK dout1_29 Vdout1_29ck164 = 0 time = 825
.meas tran vdout1_29ck164 FIND v(dout1_29) AT=825.025n

* CHECK dout1_30 Vdout1_30ck164 = 0.9 time = 825
.meas tran vdout1_30ck164 FIND v(dout1_30) AT=825.025n

* CHECK dout1_31 Vdout1_31ck164 = 0.9 time = 825
.meas tran vdout1_31ck164 FIND v(dout1_31) AT=825.025n

* CHECK dout1_32 Vdout1_32ck164 = 0.9 time = 825
.meas tran vdout1_32ck164 FIND v(dout1_32) AT=825.025n

* CHECK dout1_33 Vdout1_33ck164 = 0 time = 825
.meas tran vdout1_33ck164 FIND v(dout1_33) AT=825.025n

* CHECK dout1_34 Vdout1_34ck164 = 0.9 time = 825
.meas tran vdout1_34ck164 FIND v(dout1_34) AT=825.025n

* CHECK dout1_35 Vdout1_35ck164 = 0 time = 825
.meas tran vdout1_35ck164 FIND v(dout1_35) AT=825.025n

* CHECK dout1_36 Vdout1_36ck164 = 0 time = 825
.meas tran vdout1_36ck164 FIND v(dout1_36) AT=825.025n

* CHECK dout1_37 Vdout1_37ck164 = 0 time = 825
.meas tran vdout1_37ck164 FIND v(dout1_37) AT=825.025n

* CHECK dout1_38 Vdout1_38ck164 = 0 time = 825
.meas tran vdout1_38ck164 FIND v(dout1_38) AT=825.025n

* CHECK dout1_39 Vdout1_39ck164 = 0 time = 825
.meas tran vdout1_39ck164 FIND v(dout1_39) AT=825.025n

* CHECK dout1_40 Vdout1_40ck164 = 0.9 time = 825
.meas tran vdout1_40ck164 FIND v(dout1_40) AT=825.025n

* CHECK dout1_41 Vdout1_41ck164 = 0 time = 825
.meas tran vdout1_41ck164 FIND v(dout1_41) AT=825.025n

* CHECK dout1_42 Vdout1_42ck164 = 0 time = 825
.meas tran vdout1_42ck164 FIND v(dout1_42) AT=825.025n

* CHECK dout1_43 Vdout1_43ck164 = 0 time = 825
.meas tran vdout1_43ck164 FIND v(dout1_43) AT=825.025n

* CHECK dout1_44 Vdout1_44ck164 = 0.9 time = 825
.meas tran vdout1_44ck164 FIND v(dout1_44) AT=825.025n

* CHECK dout1_45 Vdout1_45ck164 = 0.9 time = 825
.meas tran vdout1_45ck164 FIND v(dout1_45) AT=825.025n

* CHECK dout1_46 Vdout1_46ck164 = 0.9 time = 825
.meas tran vdout1_46ck164 FIND v(dout1_46) AT=825.025n

* CHECK dout1_47 Vdout1_47ck164 = 0 time = 825
.meas tran vdout1_47ck164 FIND v(dout1_47) AT=825.025n

* CHECK dout1_48 Vdout1_48ck164 = 0.9 time = 825
.meas tran vdout1_48ck164 FIND v(dout1_48) AT=825.025n

* CHECK dout1_49 Vdout1_49ck164 = 0 time = 825
.meas tran vdout1_49ck164 FIND v(dout1_49) AT=825.025n

* CHECK dout1_50 Vdout1_50ck164 = 0.9 time = 825
.meas tran vdout1_50ck164 FIND v(dout1_50) AT=825.025n

* CHECK dout1_51 Vdout1_51ck164 = 0.9 time = 825
.meas tran vdout1_51ck164 FIND v(dout1_51) AT=825.025n

* CHECK dout1_52 Vdout1_52ck164 = 0.9 time = 825
.meas tran vdout1_52ck164 FIND v(dout1_52) AT=825.025n

* CHECK dout1_53 Vdout1_53ck164 = 0.9 time = 825
.meas tran vdout1_53ck164 FIND v(dout1_53) AT=825.025n

* CHECK dout1_54 Vdout1_54ck164 = 0 time = 825
.meas tran vdout1_54ck164 FIND v(dout1_54) AT=825.025n

* CHECK dout1_55 Vdout1_55ck164 = 0 time = 825
.meas tran vdout1_55ck164 FIND v(dout1_55) AT=825.025n

* CHECK dout1_0 Vdout1_0ck165 = 0.9 time = 830
.meas tran vdout1_0ck165 FIND v(dout1_0) AT=830.025n

* CHECK dout1_1 Vdout1_1ck165 = 0 time = 830
.meas tran vdout1_1ck165 FIND v(dout1_1) AT=830.025n

* CHECK dout1_2 Vdout1_2ck165 = 0.9 time = 830
.meas tran vdout1_2ck165 FIND v(dout1_2) AT=830.025n

* CHECK dout1_3 Vdout1_3ck165 = 0.9 time = 830
.meas tran vdout1_3ck165 FIND v(dout1_3) AT=830.025n

* CHECK dout1_4 Vdout1_4ck165 = 0.9 time = 830
.meas tran vdout1_4ck165 FIND v(dout1_4) AT=830.025n

* CHECK dout1_5 Vdout1_5ck165 = 0 time = 830
.meas tran vdout1_5ck165 FIND v(dout1_5) AT=830.025n

* CHECK dout1_6 Vdout1_6ck165 = 0 time = 830
.meas tran vdout1_6ck165 FIND v(dout1_6) AT=830.025n

* CHECK dout1_7 Vdout1_7ck165 = 0 time = 830
.meas tran vdout1_7ck165 FIND v(dout1_7) AT=830.025n

* CHECK dout1_8 Vdout1_8ck165 = 0 time = 830
.meas tran vdout1_8ck165 FIND v(dout1_8) AT=830.025n

* CHECK dout1_9 Vdout1_9ck165 = 0 time = 830
.meas tran vdout1_9ck165 FIND v(dout1_9) AT=830.025n

* CHECK dout1_10 Vdout1_10ck165 = 0.9 time = 830
.meas tran vdout1_10ck165 FIND v(dout1_10) AT=830.025n

* CHECK dout1_11 Vdout1_11ck165 = 0 time = 830
.meas tran vdout1_11ck165 FIND v(dout1_11) AT=830.025n

* CHECK dout1_12 Vdout1_12ck165 = 0 time = 830
.meas tran vdout1_12ck165 FIND v(dout1_12) AT=830.025n

* CHECK dout1_13 Vdout1_13ck165 = 0 time = 830
.meas tran vdout1_13ck165 FIND v(dout1_13) AT=830.025n

* CHECK dout1_14 Vdout1_14ck165 = 0.9 time = 830
.meas tran vdout1_14ck165 FIND v(dout1_14) AT=830.025n

* CHECK dout1_15 Vdout1_15ck165 = 0 time = 830
.meas tran vdout1_15ck165 FIND v(dout1_15) AT=830.025n

* CHECK dout1_16 Vdout1_16ck165 = 0 time = 830
.meas tran vdout1_16ck165 FIND v(dout1_16) AT=830.025n

* CHECK dout1_17 Vdout1_17ck165 = 0 time = 830
.meas tran vdout1_17ck165 FIND v(dout1_17) AT=830.025n

* CHECK dout1_18 Vdout1_18ck165 = 0.9 time = 830
.meas tran vdout1_18ck165 FIND v(dout1_18) AT=830.025n

* CHECK dout1_19 Vdout1_19ck165 = 0.9 time = 830
.meas tran vdout1_19ck165 FIND v(dout1_19) AT=830.025n

* CHECK dout1_20 Vdout1_20ck165 = 0.9 time = 830
.meas tran vdout1_20ck165 FIND v(dout1_20) AT=830.025n

* CHECK dout1_21 Vdout1_21ck165 = 0.9 time = 830
.meas tran vdout1_21ck165 FIND v(dout1_21) AT=830.025n

* CHECK dout1_22 Vdout1_22ck165 = 0.9 time = 830
.meas tran vdout1_22ck165 FIND v(dout1_22) AT=830.025n

* CHECK dout1_23 Vdout1_23ck165 = 0.9 time = 830
.meas tran vdout1_23ck165 FIND v(dout1_23) AT=830.025n

* CHECK dout1_24 Vdout1_24ck165 = 0 time = 830
.meas tran vdout1_24ck165 FIND v(dout1_24) AT=830.025n

* CHECK dout1_25 Vdout1_25ck165 = 0.9 time = 830
.meas tran vdout1_25ck165 FIND v(dout1_25) AT=830.025n

* CHECK dout1_26 Vdout1_26ck165 = 0.9 time = 830
.meas tran vdout1_26ck165 FIND v(dout1_26) AT=830.025n

* CHECK dout1_27 Vdout1_27ck165 = 0.9 time = 830
.meas tran vdout1_27ck165 FIND v(dout1_27) AT=830.025n

* CHECK dout1_28 Vdout1_28ck165 = 0.9 time = 830
.meas tran vdout1_28ck165 FIND v(dout1_28) AT=830.025n

* CHECK dout1_29 Vdout1_29ck165 = 0 time = 830
.meas tran vdout1_29ck165 FIND v(dout1_29) AT=830.025n

* CHECK dout1_30 Vdout1_30ck165 = 0.9 time = 830
.meas tran vdout1_30ck165 FIND v(dout1_30) AT=830.025n

* CHECK dout1_31 Vdout1_31ck165 = 0.9 time = 830
.meas tran vdout1_31ck165 FIND v(dout1_31) AT=830.025n

* CHECK dout1_32 Vdout1_32ck165 = 0 time = 830
.meas tran vdout1_32ck165 FIND v(dout1_32) AT=830.025n

* CHECK dout1_33 Vdout1_33ck165 = 0 time = 830
.meas tran vdout1_33ck165 FIND v(dout1_33) AT=830.025n

* CHECK dout1_34 Vdout1_34ck165 = 0 time = 830
.meas tran vdout1_34ck165 FIND v(dout1_34) AT=830.025n

* CHECK dout1_35 Vdout1_35ck165 = 0 time = 830
.meas tran vdout1_35ck165 FIND v(dout1_35) AT=830.025n

* CHECK dout1_36 Vdout1_36ck165 = 0 time = 830
.meas tran vdout1_36ck165 FIND v(dout1_36) AT=830.025n

* CHECK dout1_37 Vdout1_37ck165 = 0 time = 830
.meas tran vdout1_37ck165 FIND v(dout1_37) AT=830.025n

* CHECK dout1_38 Vdout1_38ck165 = 0.9 time = 830
.meas tran vdout1_38ck165 FIND v(dout1_38) AT=830.025n

* CHECK dout1_39 Vdout1_39ck165 = 0 time = 830
.meas tran vdout1_39ck165 FIND v(dout1_39) AT=830.025n

* CHECK dout1_40 Vdout1_40ck165 = 0 time = 830
.meas tran vdout1_40ck165 FIND v(dout1_40) AT=830.025n

* CHECK dout1_41 Vdout1_41ck165 = 0.9 time = 830
.meas tran vdout1_41ck165 FIND v(dout1_41) AT=830.025n

* CHECK dout1_42 Vdout1_42ck165 = 0 time = 830
.meas tran vdout1_42ck165 FIND v(dout1_42) AT=830.025n

* CHECK dout1_43 Vdout1_43ck165 = 0.9 time = 830
.meas tran vdout1_43ck165 FIND v(dout1_43) AT=830.025n

* CHECK dout1_44 Vdout1_44ck165 = 0.9 time = 830
.meas tran vdout1_44ck165 FIND v(dout1_44) AT=830.025n

* CHECK dout1_45 Vdout1_45ck165 = 0 time = 830
.meas tran vdout1_45ck165 FIND v(dout1_45) AT=830.025n

* CHECK dout1_46 Vdout1_46ck165 = 0 time = 830
.meas tran vdout1_46ck165 FIND v(dout1_46) AT=830.025n

* CHECK dout1_47 Vdout1_47ck165 = 0.9 time = 830
.meas tran vdout1_47ck165 FIND v(dout1_47) AT=830.025n

* CHECK dout1_48 Vdout1_48ck165 = 0.9 time = 830
.meas tran vdout1_48ck165 FIND v(dout1_48) AT=830.025n

* CHECK dout1_49 Vdout1_49ck165 = 0.9 time = 830
.meas tran vdout1_49ck165 FIND v(dout1_49) AT=830.025n

* CHECK dout1_50 Vdout1_50ck165 = 0.9 time = 830
.meas tran vdout1_50ck165 FIND v(dout1_50) AT=830.025n

* CHECK dout1_51 Vdout1_51ck165 = 0.9 time = 830
.meas tran vdout1_51ck165 FIND v(dout1_51) AT=830.025n

* CHECK dout1_52 Vdout1_52ck165 = 0.9 time = 830
.meas tran vdout1_52ck165 FIND v(dout1_52) AT=830.025n

* CHECK dout1_53 Vdout1_53ck165 = 0.9 time = 830
.meas tran vdout1_53ck165 FIND v(dout1_53) AT=830.025n

* CHECK dout1_54 Vdout1_54ck165 = 0.9 time = 830
.meas tran vdout1_54ck165 FIND v(dout1_54) AT=830.025n

* CHECK dout1_55 Vdout1_55ck165 = 0 time = 830
.meas tran vdout1_55ck165 FIND v(dout1_55) AT=830.025n

* CHECK dout1_0 Vdout1_0ck168 = 0 time = 845
.meas tran vdout1_0ck168 FIND v(dout1_0) AT=845.025n

* CHECK dout1_1 Vdout1_1ck168 = 0 time = 845
.meas tran vdout1_1ck168 FIND v(dout1_1) AT=845.025n

* CHECK dout1_2 Vdout1_2ck168 = 0.9 time = 845
.meas tran vdout1_2ck168 FIND v(dout1_2) AT=845.025n

* CHECK dout1_3 Vdout1_3ck168 = 0.9 time = 845
.meas tran vdout1_3ck168 FIND v(dout1_3) AT=845.025n

* CHECK dout1_4 Vdout1_4ck168 = 0.9 time = 845
.meas tran vdout1_4ck168 FIND v(dout1_4) AT=845.025n

* CHECK dout1_5 Vdout1_5ck168 = 0 time = 845
.meas tran vdout1_5ck168 FIND v(dout1_5) AT=845.025n

* CHECK dout1_6 Vdout1_6ck168 = 0.9 time = 845
.meas tran vdout1_6ck168 FIND v(dout1_6) AT=845.025n

* CHECK dout1_7 Vdout1_7ck168 = 0 time = 845
.meas tran vdout1_7ck168 FIND v(dout1_7) AT=845.025n

* CHECK dout1_8 Vdout1_8ck168 = 0 time = 845
.meas tran vdout1_8ck168 FIND v(dout1_8) AT=845.025n

* CHECK dout1_9 Vdout1_9ck168 = 0.9 time = 845
.meas tran vdout1_9ck168 FIND v(dout1_9) AT=845.025n

* CHECK dout1_10 Vdout1_10ck168 = 0.9 time = 845
.meas tran vdout1_10ck168 FIND v(dout1_10) AT=845.025n

* CHECK dout1_11 Vdout1_11ck168 = 0 time = 845
.meas tran vdout1_11ck168 FIND v(dout1_11) AT=845.025n

* CHECK dout1_12 Vdout1_12ck168 = 0.9 time = 845
.meas tran vdout1_12ck168 FIND v(dout1_12) AT=845.025n

* CHECK dout1_13 Vdout1_13ck168 = 0.9 time = 845
.meas tran vdout1_13ck168 FIND v(dout1_13) AT=845.025n

* CHECK dout1_14 Vdout1_14ck168 = 0 time = 845
.meas tran vdout1_14ck168 FIND v(dout1_14) AT=845.025n

* CHECK dout1_15 Vdout1_15ck168 = 0 time = 845
.meas tran vdout1_15ck168 FIND v(dout1_15) AT=845.025n

* CHECK dout1_16 Vdout1_16ck168 = 0 time = 845
.meas tran vdout1_16ck168 FIND v(dout1_16) AT=845.025n

* CHECK dout1_17 Vdout1_17ck168 = 0 time = 845
.meas tran vdout1_17ck168 FIND v(dout1_17) AT=845.025n

* CHECK dout1_18 Vdout1_18ck168 = 0 time = 845
.meas tran vdout1_18ck168 FIND v(dout1_18) AT=845.025n

* CHECK dout1_19 Vdout1_19ck168 = 0.9 time = 845
.meas tran vdout1_19ck168 FIND v(dout1_19) AT=845.025n

* CHECK dout1_20 Vdout1_20ck168 = 0.9 time = 845
.meas tran vdout1_20ck168 FIND v(dout1_20) AT=845.025n

* CHECK dout1_21 Vdout1_21ck168 = 0.9 time = 845
.meas tran vdout1_21ck168 FIND v(dout1_21) AT=845.025n

* CHECK dout1_22 Vdout1_22ck168 = 0 time = 845
.meas tran vdout1_22ck168 FIND v(dout1_22) AT=845.025n

* CHECK dout1_23 Vdout1_23ck168 = 0.9 time = 845
.meas tran vdout1_23ck168 FIND v(dout1_23) AT=845.025n

* CHECK dout1_24 Vdout1_24ck168 = 0 time = 845
.meas tran vdout1_24ck168 FIND v(dout1_24) AT=845.025n

* CHECK dout1_25 Vdout1_25ck168 = 0 time = 845
.meas tran vdout1_25ck168 FIND v(dout1_25) AT=845.025n

* CHECK dout1_26 Vdout1_26ck168 = 0 time = 845
.meas tran vdout1_26ck168 FIND v(dout1_26) AT=845.025n

* CHECK dout1_27 Vdout1_27ck168 = 0 time = 845
.meas tran vdout1_27ck168 FIND v(dout1_27) AT=845.025n

* CHECK dout1_28 Vdout1_28ck168 = 0 time = 845
.meas tran vdout1_28ck168 FIND v(dout1_28) AT=845.025n

* CHECK dout1_29 Vdout1_29ck168 = 0.9 time = 845
.meas tran vdout1_29ck168 FIND v(dout1_29) AT=845.025n

* CHECK dout1_30 Vdout1_30ck168 = 0.9 time = 845
.meas tran vdout1_30ck168 FIND v(dout1_30) AT=845.025n

* CHECK dout1_31 Vdout1_31ck168 = 0.9 time = 845
.meas tran vdout1_31ck168 FIND v(dout1_31) AT=845.025n

* CHECK dout1_32 Vdout1_32ck168 = 0 time = 845
.meas tran vdout1_32ck168 FIND v(dout1_32) AT=845.025n

* CHECK dout1_33 Vdout1_33ck168 = 0.9 time = 845
.meas tran vdout1_33ck168 FIND v(dout1_33) AT=845.025n

* CHECK dout1_34 Vdout1_34ck168 = 0.9 time = 845
.meas tran vdout1_34ck168 FIND v(dout1_34) AT=845.025n

* CHECK dout1_35 Vdout1_35ck168 = 0 time = 845
.meas tran vdout1_35ck168 FIND v(dout1_35) AT=845.025n

* CHECK dout1_36 Vdout1_36ck168 = 0.9 time = 845
.meas tran vdout1_36ck168 FIND v(dout1_36) AT=845.025n

* CHECK dout1_37 Vdout1_37ck168 = 0 time = 845
.meas tran vdout1_37ck168 FIND v(dout1_37) AT=845.025n

* CHECK dout1_38 Vdout1_38ck168 = 0 time = 845
.meas tran vdout1_38ck168 FIND v(dout1_38) AT=845.025n

* CHECK dout1_39 Vdout1_39ck168 = 0.9 time = 845
.meas tran vdout1_39ck168 FIND v(dout1_39) AT=845.025n

* CHECK dout1_40 Vdout1_40ck168 = 0.9 time = 845
.meas tran vdout1_40ck168 FIND v(dout1_40) AT=845.025n

* CHECK dout1_41 Vdout1_41ck168 = 0 time = 845
.meas tran vdout1_41ck168 FIND v(dout1_41) AT=845.025n

* CHECK dout1_42 Vdout1_42ck168 = 0.9 time = 845
.meas tran vdout1_42ck168 FIND v(dout1_42) AT=845.025n

* CHECK dout1_43 Vdout1_43ck168 = 0 time = 845
.meas tran vdout1_43ck168 FIND v(dout1_43) AT=845.025n

* CHECK dout1_44 Vdout1_44ck168 = 0.9 time = 845
.meas tran vdout1_44ck168 FIND v(dout1_44) AT=845.025n

* CHECK dout1_45 Vdout1_45ck168 = 0 time = 845
.meas tran vdout1_45ck168 FIND v(dout1_45) AT=845.025n

* CHECK dout1_46 Vdout1_46ck168 = 0 time = 845
.meas tran vdout1_46ck168 FIND v(dout1_46) AT=845.025n

* CHECK dout1_47 Vdout1_47ck168 = 0 time = 845
.meas tran vdout1_47ck168 FIND v(dout1_47) AT=845.025n

* CHECK dout1_48 Vdout1_48ck168 = 0 time = 845
.meas tran vdout1_48ck168 FIND v(dout1_48) AT=845.025n

* CHECK dout1_49 Vdout1_49ck168 = 0 time = 845
.meas tran vdout1_49ck168 FIND v(dout1_49) AT=845.025n

* CHECK dout1_50 Vdout1_50ck168 = 0.9 time = 845
.meas tran vdout1_50ck168 FIND v(dout1_50) AT=845.025n

* CHECK dout1_51 Vdout1_51ck168 = 0.9 time = 845
.meas tran vdout1_51ck168 FIND v(dout1_51) AT=845.025n

* CHECK dout1_52 Vdout1_52ck168 = 0 time = 845
.meas tran vdout1_52ck168 FIND v(dout1_52) AT=845.025n

* CHECK dout1_53 Vdout1_53ck168 = 0 time = 845
.meas tran vdout1_53ck168 FIND v(dout1_53) AT=845.025n

* CHECK dout1_54 Vdout1_54ck168 = 0 time = 845
.meas tran vdout1_54ck168 FIND v(dout1_54) AT=845.025n

* CHECK dout1_55 Vdout1_55ck168 = 0 time = 845
.meas tran vdout1_55ck168 FIND v(dout1_55) AT=845.025n

* CHECK dout1_0 Vdout1_0ck169 = 0.9 time = 850
.meas tran vdout1_0ck169 FIND v(dout1_0) AT=850.025n

* CHECK dout1_1 Vdout1_1ck169 = 0.9 time = 850
.meas tran vdout1_1ck169 FIND v(dout1_1) AT=850.025n

* CHECK dout1_2 Vdout1_2ck169 = 0 time = 850
.meas tran vdout1_2ck169 FIND v(dout1_2) AT=850.025n

* CHECK dout1_3 Vdout1_3ck169 = 0 time = 850
.meas tran vdout1_3ck169 FIND v(dout1_3) AT=850.025n

* CHECK dout1_4 Vdout1_4ck169 = 0 time = 850
.meas tran vdout1_4ck169 FIND v(dout1_4) AT=850.025n

* CHECK dout1_5 Vdout1_5ck169 = 0.9 time = 850
.meas tran vdout1_5ck169 FIND v(dout1_5) AT=850.025n

* CHECK dout1_6 Vdout1_6ck169 = 0 time = 850
.meas tran vdout1_6ck169 FIND v(dout1_6) AT=850.025n

* CHECK dout1_7 Vdout1_7ck169 = 0 time = 850
.meas tran vdout1_7ck169 FIND v(dout1_7) AT=850.025n

* CHECK dout1_8 Vdout1_8ck169 = 0.9 time = 850
.meas tran vdout1_8ck169 FIND v(dout1_8) AT=850.025n

* CHECK dout1_9 Vdout1_9ck169 = 0.9 time = 850
.meas tran vdout1_9ck169 FIND v(dout1_9) AT=850.025n

* CHECK dout1_10 Vdout1_10ck169 = 0 time = 850
.meas tran vdout1_10ck169 FIND v(dout1_10) AT=850.025n

* CHECK dout1_11 Vdout1_11ck169 = 0 time = 850
.meas tran vdout1_11ck169 FIND v(dout1_11) AT=850.025n

* CHECK dout1_12 Vdout1_12ck169 = 0.9 time = 850
.meas tran vdout1_12ck169 FIND v(dout1_12) AT=850.025n

* CHECK dout1_13 Vdout1_13ck169 = 0.9 time = 850
.meas tran vdout1_13ck169 FIND v(dout1_13) AT=850.025n

* CHECK dout1_14 Vdout1_14ck169 = 0.9 time = 850
.meas tran vdout1_14ck169 FIND v(dout1_14) AT=850.025n

* CHECK dout1_15 Vdout1_15ck169 = 0 time = 850
.meas tran vdout1_15ck169 FIND v(dout1_15) AT=850.025n

* CHECK dout1_16 Vdout1_16ck169 = 0.9 time = 850
.meas tran vdout1_16ck169 FIND v(dout1_16) AT=850.025n

* CHECK dout1_17 Vdout1_17ck169 = 0.9 time = 850
.meas tran vdout1_17ck169 FIND v(dout1_17) AT=850.025n

* CHECK dout1_18 Vdout1_18ck169 = 0 time = 850
.meas tran vdout1_18ck169 FIND v(dout1_18) AT=850.025n

* CHECK dout1_19 Vdout1_19ck169 = 0.9 time = 850
.meas tran vdout1_19ck169 FIND v(dout1_19) AT=850.025n

* CHECK dout1_20 Vdout1_20ck169 = 0 time = 850
.meas tran vdout1_20ck169 FIND v(dout1_20) AT=850.025n

* CHECK dout1_21 Vdout1_21ck169 = 0.9 time = 850
.meas tran vdout1_21ck169 FIND v(dout1_21) AT=850.025n

* CHECK dout1_22 Vdout1_22ck169 = 0 time = 850
.meas tran vdout1_22ck169 FIND v(dout1_22) AT=850.025n

* CHECK dout1_23 Vdout1_23ck169 = 0 time = 850
.meas tran vdout1_23ck169 FIND v(dout1_23) AT=850.025n

* CHECK dout1_24 Vdout1_24ck169 = 0 time = 850
.meas tran vdout1_24ck169 FIND v(dout1_24) AT=850.025n

* CHECK dout1_25 Vdout1_25ck169 = 0 time = 850
.meas tran vdout1_25ck169 FIND v(dout1_25) AT=850.025n

* CHECK dout1_26 Vdout1_26ck169 = 0 time = 850
.meas tran vdout1_26ck169 FIND v(dout1_26) AT=850.025n

* CHECK dout1_27 Vdout1_27ck169 = 0 time = 850
.meas tran vdout1_27ck169 FIND v(dout1_27) AT=850.025n

* CHECK dout1_28 Vdout1_28ck169 = 0 time = 850
.meas tran vdout1_28ck169 FIND v(dout1_28) AT=850.025n

* CHECK dout1_29 Vdout1_29ck169 = 0 time = 850
.meas tran vdout1_29ck169 FIND v(dout1_29) AT=850.025n

* CHECK dout1_30 Vdout1_30ck169 = 0 time = 850
.meas tran vdout1_30ck169 FIND v(dout1_30) AT=850.025n

* CHECK dout1_31 Vdout1_31ck169 = 0 time = 850
.meas tran vdout1_31ck169 FIND v(dout1_31) AT=850.025n

* CHECK dout1_32 Vdout1_32ck169 = 0.9 time = 850
.meas tran vdout1_32ck169 FIND v(dout1_32) AT=850.025n

* CHECK dout1_33 Vdout1_33ck169 = 0 time = 850
.meas tran vdout1_33ck169 FIND v(dout1_33) AT=850.025n

* CHECK dout1_34 Vdout1_34ck169 = 0 time = 850
.meas tran vdout1_34ck169 FIND v(dout1_34) AT=850.025n

* CHECK dout1_35 Vdout1_35ck169 = 0.9 time = 850
.meas tran vdout1_35ck169 FIND v(dout1_35) AT=850.025n

* CHECK dout1_36 Vdout1_36ck169 = 0.9 time = 850
.meas tran vdout1_36ck169 FIND v(dout1_36) AT=850.025n

* CHECK dout1_37 Vdout1_37ck169 = 0.9 time = 850
.meas tran vdout1_37ck169 FIND v(dout1_37) AT=850.025n

* CHECK dout1_38 Vdout1_38ck169 = 0 time = 850
.meas tran vdout1_38ck169 FIND v(dout1_38) AT=850.025n

* CHECK dout1_39 Vdout1_39ck169 = 0.9 time = 850
.meas tran vdout1_39ck169 FIND v(dout1_39) AT=850.025n

* CHECK dout1_40 Vdout1_40ck169 = 0.9 time = 850
.meas tran vdout1_40ck169 FIND v(dout1_40) AT=850.025n

* CHECK dout1_41 Vdout1_41ck169 = 0 time = 850
.meas tran vdout1_41ck169 FIND v(dout1_41) AT=850.025n

* CHECK dout1_42 Vdout1_42ck169 = 0 time = 850
.meas tran vdout1_42ck169 FIND v(dout1_42) AT=850.025n

* CHECK dout1_43 Vdout1_43ck169 = 0.9 time = 850
.meas tran vdout1_43ck169 FIND v(dout1_43) AT=850.025n

* CHECK dout1_44 Vdout1_44ck169 = 0 time = 850
.meas tran vdout1_44ck169 FIND v(dout1_44) AT=850.025n

* CHECK dout1_45 Vdout1_45ck169 = 0 time = 850
.meas tran vdout1_45ck169 FIND v(dout1_45) AT=850.025n

* CHECK dout1_46 Vdout1_46ck169 = 0.9 time = 850
.meas tran vdout1_46ck169 FIND v(dout1_46) AT=850.025n

* CHECK dout1_47 Vdout1_47ck169 = 0 time = 850
.meas tran vdout1_47ck169 FIND v(dout1_47) AT=850.025n

* CHECK dout1_48 Vdout1_48ck169 = 0.9 time = 850
.meas tran vdout1_48ck169 FIND v(dout1_48) AT=850.025n

* CHECK dout1_49 Vdout1_49ck169 = 0 time = 850
.meas tran vdout1_49ck169 FIND v(dout1_49) AT=850.025n

* CHECK dout1_50 Vdout1_50ck169 = 0 time = 850
.meas tran vdout1_50ck169 FIND v(dout1_50) AT=850.025n

* CHECK dout1_51 Vdout1_51ck169 = 0 time = 850
.meas tran vdout1_51ck169 FIND v(dout1_51) AT=850.025n

* CHECK dout1_52 Vdout1_52ck169 = 0.9 time = 850
.meas tran vdout1_52ck169 FIND v(dout1_52) AT=850.025n

* CHECK dout1_53 Vdout1_53ck169 = 0.9 time = 850
.meas tran vdout1_53ck169 FIND v(dout1_53) AT=850.025n

* CHECK dout1_54 Vdout1_54ck169 = 0 time = 850
.meas tran vdout1_54ck169 FIND v(dout1_54) AT=850.025n

* CHECK dout1_55 Vdout1_55ck169 = 0 time = 850
.meas tran vdout1_55ck169 FIND v(dout1_55) AT=850.025n

* CHECK dout1_0 Vdout1_0ck170 = 0 time = 855
.meas tran vdout1_0ck170 FIND v(dout1_0) AT=855.025n

* CHECK dout1_1 Vdout1_1ck170 = 0 time = 855
.meas tran vdout1_1ck170 FIND v(dout1_1) AT=855.025n

* CHECK dout1_2 Vdout1_2ck170 = 0.9 time = 855
.meas tran vdout1_2ck170 FIND v(dout1_2) AT=855.025n

* CHECK dout1_3 Vdout1_3ck170 = 0.9 time = 855
.meas tran vdout1_3ck170 FIND v(dout1_3) AT=855.025n

* CHECK dout1_4 Vdout1_4ck170 = 0.9 time = 855
.meas tran vdout1_4ck170 FIND v(dout1_4) AT=855.025n

* CHECK dout1_5 Vdout1_5ck170 = 0 time = 855
.meas tran vdout1_5ck170 FIND v(dout1_5) AT=855.025n

* CHECK dout1_6 Vdout1_6ck170 = 0.9 time = 855
.meas tran vdout1_6ck170 FIND v(dout1_6) AT=855.025n

* CHECK dout1_7 Vdout1_7ck170 = 0 time = 855
.meas tran vdout1_7ck170 FIND v(dout1_7) AT=855.025n

* CHECK dout1_8 Vdout1_8ck170 = 0 time = 855
.meas tran vdout1_8ck170 FIND v(dout1_8) AT=855.025n

* CHECK dout1_9 Vdout1_9ck170 = 0.9 time = 855
.meas tran vdout1_9ck170 FIND v(dout1_9) AT=855.025n

* CHECK dout1_10 Vdout1_10ck170 = 0.9 time = 855
.meas tran vdout1_10ck170 FIND v(dout1_10) AT=855.025n

* CHECK dout1_11 Vdout1_11ck170 = 0 time = 855
.meas tran vdout1_11ck170 FIND v(dout1_11) AT=855.025n

* CHECK dout1_12 Vdout1_12ck170 = 0.9 time = 855
.meas tran vdout1_12ck170 FIND v(dout1_12) AT=855.025n

* CHECK dout1_13 Vdout1_13ck170 = 0.9 time = 855
.meas tran vdout1_13ck170 FIND v(dout1_13) AT=855.025n

* CHECK dout1_14 Vdout1_14ck170 = 0 time = 855
.meas tran vdout1_14ck170 FIND v(dout1_14) AT=855.025n

* CHECK dout1_15 Vdout1_15ck170 = 0 time = 855
.meas tran vdout1_15ck170 FIND v(dout1_15) AT=855.025n

* CHECK dout1_16 Vdout1_16ck170 = 0 time = 855
.meas tran vdout1_16ck170 FIND v(dout1_16) AT=855.025n

* CHECK dout1_17 Vdout1_17ck170 = 0 time = 855
.meas tran vdout1_17ck170 FIND v(dout1_17) AT=855.025n

* CHECK dout1_18 Vdout1_18ck170 = 0 time = 855
.meas tran vdout1_18ck170 FIND v(dout1_18) AT=855.025n

* CHECK dout1_19 Vdout1_19ck170 = 0.9 time = 855
.meas tran vdout1_19ck170 FIND v(dout1_19) AT=855.025n

* CHECK dout1_20 Vdout1_20ck170 = 0.9 time = 855
.meas tran vdout1_20ck170 FIND v(dout1_20) AT=855.025n

* CHECK dout1_21 Vdout1_21ck170 = 0.9 time = 855
.meas tran vdout1_21ck170 FIND v(dout1_21) AT=855.025n

* CHECK dout1_22 Vdout1_22ck170 = 0 time = 855
.meas tran vdout1_22ck170 FIND v(dout1_22) AT=855.025n

* CHECK dout1_23 Vdout1_23ck170 = 0.9 time = 855
.meas tran vdout1_23ck170 FIND v(dout1_23) AT=855.025n

* CHECK dout1_24 Vdout1_24ck170 = 0 time = 855
.meas tran vdout1_24ck170 FIND v(dout1_24) AT=855.025n

* CHECK dout1_25 Vdout1_25ck170 = 0 time = 855
.meas tran vdout1_25ck170 FIND v(dout1_25) AT=855.025n

* CHECK dout1_26 Vdout1_26ck170 = 0 time = 855
.meas tran vdout1_26ck170 FIND v(dout1_26) AT=855.025n

* CHECK dout1_27 Vdout1_27ck170 = 0 time = 855
.meas tran vdout1_27ck170 FIND v(dout1_27) AT=855.025n

* CHECK dout1_28 Vdout1_28ck170 = 0 time = 855
.meas tran vdout1_28ck170 FIND v(dout1_28) AT=855.025n

* CHECK dout1_29 Vdout1_29ck170 = 0.9 time = 855
.meas tran vdout1_29ck170 FIND v(dout1_29) AT=855.025n

* CHECK dout1_30 Vdout1_30ck170 = 0.9 time = 855
.meas tran vdout1_30ck170 FIND v(dout1_30) AT=855.025n

* CHECK dout1_31 Vdout1_31ck170 = 0.9 time = 855
.meas tran vdout1_31ck170 FIND v(dout1_31) AT=855.025n

* CHECK dout1_32 Vdout1_32ck170 = 0 time = 855
.meas tran vdout1_32ck170 FIND v(dout1_32) AT=855.025n

* CHECK dout1_33 Vdout1_33ck170 = 0.9 time = 855
.meas tran vdout1_33ck170 FIND v(dout1_33) AT=855.025n

* CHECK dout1_34 Vdout1_34ck170 = 0.9 time = 855
.meas tran vdout1_34ck170 FIND v(dout1_34) AT=855.025n

* CHECK dout1_35 Vdout1_35ck170 = 0 time = 855
.meas tran vdout1_35ck170 FIND v(dout1_35) AT=855.025n

* CHECK dout1_36 Vdout1_36ck170 = 0.9 time = 855
.meas tran vdout1_36ck170 FIND v(dout1_36) AT=855.025n

* CHECK dout1_37 Vdout1_37ck170 = 0 time = 855
.meas tran vdout1_37ck170 FIND v(dout1_37) AT=855.025n

* CHECK dout1_38 Vdout1_38ck170 = 0 time = 855
.meas tran vdout1_38ck170 FIND v(dout1_38) AT=855.025n

* CHECK dout1_39 Vdout1_39ck170 = 0.9 time = 855
.meas tran vdout1_39ck170 FIND v(dout1_39) AT=855.025n

* CHECK dout1_40 Vdout1_40ck170 = 0.9 time = 855
.meas tran vdout1_40ck170 FIND v(dout1_40) AT=855.025n

* CHECK dout1_41 Vdout1_41ck170 = 0 time = 855
.meas tran vdout1_41ck170 FIND v(dout1_41) AT=855.025n

* CHECK dout1_42 Vdout1_42ck170 = 0.9 time = 855
.meas tran vdout1_42ck170 FIND v(dout1_42) AT=855.025n

* CHECK dout1_43 Vdout1_43ck170 = 0 time = 855
.meas tran vdout1_43ck170 FIND v(dout1_43) AT=855.025n

* CHECK dout1_44 Vdout1_44ck170 = 0.9 time = 855
.meas tran vdout1_44ck170 FIND v(dout1_44) AT=855.025n

* CHECK dout1_45 Vdout1_45ck170 = 0 time = 855
.meas tran vdout1_45ck170 FIND v(dout1_45) AT=855.025n

* CHECK dout1_46 Vdout1_46ck170 = 0 time = 855
.meas tran vdout1_46ck170 FIND v(dout1_46) AT=855.025n

* CHECK dout1_47 Vdout1_47ck170 = 0 time = 855
.meas tran vdout1_47ck170 FIND v(dout1_47) AT=855.025n

* CHECK dout1_48 Vdout1_48ck170 = 0 time = 855
.meas tran vdout1_48ck170 FIND v(dout1_48) AT=855.025n

* CHECK dout1_49 Vdout1_49ck170 = 0 time = 855
.meas tran vdout1_49ck170 FIND v(dout1_49) AT=855.025n

* CHECK dout1_50 Vdout1_50ck170 = 0.9 time = 855
.meas tran vdout1_50ck170 FIND v(dout1_50) AT=855.025n

* CHECK dout1_51 Vdout1_51ck170 = 0.9 time = 855
.meas tran vdout1_51ck170 FIND v(dout1_51) AT=855.025n

* CHECK dout1_52 Vdout1_52ck170 = 0 time = 855
.meas tran vdout1_52ck170 FIND v(dout1_52) AT=855.025n

* CHECK dout1_53 Vdout1_53ck170 = 0 time = 855
.meas tran vdout1_53ck170 FIND v(dout1_53) AT=855.025n

* CHECK dout1_54 Vdout1_54ck170 = 0 time = 855
.meas tran vdout1_54ck170 FIND v(dout1_54) AT=855.025n

* CHECK dout1_55 Vdout1_55ck170 = 0 time = 855
.meas tran vdout1_55ck170 FIND v(dout1_55) AT=855.025n

* CHECK dout1_0 Vdout1_0ck171 = 0.9 time = 860
.meas tran vdout1_0ck171 FIND v(dout1_0) AT=860.025n

* CHECK dout1_1 Vdout1_1ck171 = 0 time = 860
.meas tran vdout1_1ck171 FIND v(dout1_1) AT=860.025n

* CHECK dout1_2 Vdout1_2ck171 = 0 time = 860
.meas tran vdout1_2ck171 FIND v(dout1_2) AT=860.025n

* CHECK dout1_3 Vdout1_3ck171 = 0 time = 860
.meas tran vdout1_3ck171 FIND v(dout1_3) AT=860.025n

* CHECK dout1_4 Vdout1_4ck171 = 0.9 time = 860
.meas tran vdout1_4ck171 FIND v(dout1_4) AT=860.025n

* CHECK dout1_5 Vdout1_5ck171 = 0.9 time = 860
.meas tran vdout1_5ck171 FIND v(dout1_5) AT=860.025n

* CHECK dout1_6 Vdout1_6ck171 = 0.9 time = 860
.meas tran vdout1_6ck171 FIND v(dout1_6) AT=860.025n

* CHECK dout1_7 Vdout1_7ck171 = 0 time = 860
.meas tran vdout1_7ck171 FIND v(dout1_7) AT=860.025n

* CHECK dout1_8 Vdout1_8ck171 = 0.9 time = 860
.meas tran vdout1_8ck171 FIND v(dout1_8) AT=860.025n

* CHECK dout1_9 Vdout1_9ck171 = 0.9 time = 860
.meas tran vdout1_9ck171 FIND v(dout1_9) AT=860.025n

* CHECK dout1_10 Vdout1_10ck171 = 0.9 time = 860
.meas tran vdout1_10ck171 FIND v(dout1_10) AT=860.025n

* CHECK dout1_11 Vdout1_11ck171 = 0 time = 860
.meas tran vdout1_11ck171 FIND v(dout1_11) AT=860.025n

* CHECK dout1_12 Vdout1_12ck171 = 0 time = 860
.meas tran vdout1_12ck171 FIND v(dout1_12) AT=860.025n

* CHECK dout1_13 Vdout1_13ck171 = 0.9 time = 860
.meas tran vdout1_13ck171 FIND v(dout1_13) AT=860.025n

* CHECK dout1_14 Vdout1_14ck171 = 0 time = 860
.meas tran vdout1_14ck171 FIND v(dout1_14) AT=860.025n

* CHECK dout1_15 Vdout1_15ck171 = 0 time = 860
.meas tran vdout1_15ck171 FIND v(dout1_15) AT=860.025n

* CHECK dout1_16 Vdout1_16ck171 = 0 time = 860
.meas tran vdout1_16ck171 FIND v(dout1_16) AT=860.025n

* CHECK dout1_17 Vdout1_17ck171 = 0 time = 860
.meas tran vdout1_17ck171 FIND v(dout1_17) AT=860.025n

* CHECK dout1_18 Vdout1_18ck171 = 0.9 time = 860
.meas tran vdout1_18ck171 FIND v(dout1_18) AT=860.025n

* CHECK dout1_19 Vdout1_19ck171 = 0 time = 860
.meas tran vdout1_19ck171 FIND v(dout1_19) AT=860.025n

* CHECK dout1_20 Vdout1_20ck171 = 0 time = 860
.meas tran vdout1_20ck171 FIND v(dout1_20) AT=860.025n

* CHECK dout1_21 Vdout1_21ck171 = 0.9 time = 860
.meas tran vdout1_21ck171 FIND v(dout1_21) AT=860.025n

* CHECK dout1_22 Vdout1_22ck171 = 0.9 time = 860
.meas tran vdout1_22ck171 FIND v(dout1_22) AT=860.025n

* CHECK dout1_23 Vdout1_23ck171 = 0.9 time = 860
.meas tran vdout1_23ck171 FIND v(dout1_23) AT=860.025n

* CHECK dout1_24 Vdout1_24ck171 = 0 time = 860
.meas tran vdout1_24ck171 FIND v(dout1_24) AT=860.025n

* CHECK dout1_25 Vdout1_25ck171 = 0.9 time = 860
.meas tran vdout1_25ck171 FIND v(dout1_25) AT=860.025n

* CHECK dout1_26 Vdout1_26ck171 = 0 time = 860
.meas tran vdout1_26ck171 FIND v(dout1_26) AT=860.025n

* CHECK dout1_27 Vdout1_27ck171 = 0 time = 860
.meas tran vdout1_27ck171 FIND v(dout1_27) AT=860.025n

* CHECK dout1_28 Vdout1_28ck171 = 0 time = 860
.meas tran vdout1_28ck171 FIND v(dout1_28) AT=860.025n

* CHECK dout1_29 Vdout1_29ck171 = 0.9 time = 860
.meas tran vdout1_29ck171 FIND v(dout1_29) AT=860.025n

* CHECK dout1_30 Vdout1_30ck171 = 0.9 time = 860
.meas tran vdout1_30ck171 FIND v(dout1_30) AT=860.025n

* CHECK dout1_31 Vdout1_31ck171 = 0 time = 860
.meas tran vdout1_31ck171 FIND v(dout1_31) AT=860.025n

* CHECK dout1_32 Vdout1_32ck171 = 0.9 time = 860
.meas tran vdout1_32ck171 FIND v(dout1_32) AT=860.025n

* CHECK dout1_33 Vdout1_33ck171 = 0 time = 860
.meas tran vdout1_33ck171 FIND v(dout1_33) AT=860.025n

* CHECK dout1_34 Vdout1_34ck171 = 0.9 time = 860
.meas tran vdout1_34ck171 FIND v(dout1_34) AT=860.025n

* CHECK dout1_35 Vdout1_35ck171 = 0 time = 860
.meas tran vdout1_35ck171 FIND v(dout1_35) AT=860.025n

* CHECK dout1_36 Vdout1_36ck171 = 0 time = 860
.meas tran vdout1_36ck171 FIND v(dout1_36) AT=860.025n

* CHECK dout1_37 Vdout1_37ck171 = 0 time = 860
.meas tran vdout1_37ck171 FIND v(dout1_37) AT=860.025n

* CHECK dout1_38 Vdout1_38ck171 = 0 time = 860
.meas tran vdout1_38ck171 FIND v(dout1_38) AT=860.025n

* CHECK dout1_39 Vdout1_39ck171 = 0 time = 860
.meas tran vdout1_39ck171 FIND v(dout1_39) AT=860.025n

* CHECK dout1_40 Vdout1_40ck171 = 0.9 time = 860
.meas tran vdout1_40ck171 FIND v(dout1_40) AT=860.025n

* CHECK dout1_41 Vdout1_41ck171 = 0 time = 860
.meas tran vdout1_41ck171 FIND v(dout1_41) AT=860.025n

* CHECK dout1_42 Vdout1_42ck171 = 0 time = 860
.meas tran vdout1_42ck171 FIND v(dout1_42) AT=860.025n

* CHECK dout1_43 Vdout1_43ck171 = 0 time = 860
.meas tran vdout1_43ck171 FIND v(dout1_43) AT=860.025n

* CHECK dout1_44 Vdout1_44ck171 = 0.9 time = 860
.meas tran vdout1_44ck171 FIND v(dout1_44) AT=860.025n

* CHECK dout1_45 Vdout1_45ck171 = 0.9 time = 860
.meas tran vdout1_45ck171 FIND v(dout1_45) AT=860.025n

* CHECK dout1_46 Vdout1_46ck171 = 0 time = 860
.meas tran vdout1_46ck171 FIND v(dout1_46) AT=860.025n

* CHECK dout1_47 Vdout1_47ck171 = 0.9 time = 860
.meas tran vdout1_47ck171 FIND v(dout1_47) AT=860.025n

* CHECK dout1_48 Vdout1_48ck171 = 0 time = 860
.meas tran vdout1_48ck171 FIND v(dout1_48) AT=860.025n

* CHECK dout1_49 Vdout1_49ck171 = 0 time = 860
.meas tran vdout1_49ck171 FIND v(dout1_49) AT=860.025n

* CHECK dout1_50 Vdout1_50ck171 = 0 time = 860
.meas tran vdout1_50ck171 FIND v(dout1_50) AT=860.025n

* CHECK dout1_51 Vdout1_51ck171 = 0 time = 860
.meas tran vdout1_51ck171 FIND v(dout1_51) AT=860.025n

* CHECK dout1_52 Vdout1_52ck171 = 0.9 time = 860
.meas tran vdout1_52ck171 FIND v(dout1_52) AT=860.025n

* CHECK dout1_53 Vdout1_53ck171 = 0 time = 860
.meas tran vdout1_53ck171 FIND v(dout1_53) AT=860.025n

* CHECK dout1_54 Vdout1_54ck171 = 0.9 time = 860
.meas tran vdout1_54ck171 FIND v(dout1_54) AT=860.025n

* CHECK dout1_55 Vdout1_55ck171 = 0.9 time = 860
.meas tran vdout1_55ck171 FIND v(dout1_55) AT=860.025n

* CHECK dout1_0 Vdout1_0ck174 = 0.9 time = 875
.meas tran vdout1_0ck174 FIND v(dout1_0) AT=875.025n

* CHECK dout1_1 Vdout1_1ck174 = 0.9 time = 875
.meas tran vdout1_1ck174 FIND v(dout1_1) AT=875.025n

* CHECK dout1_2 Vdout1_2ck174 = 0.9 time = 875
.meas tran vdout1_2ck174 FIND v(dout1_2) AT=875.025n

* CHECK dout1_3 Vdout1_3ck174 = 0 time = 875
.meas tran vdout1_3ck174 FIND v(dout1_3) AT=875.025n

* CHECK dout1_4 Vdout1_4ck174 = 0 time = 875
.meas tran vdout1_4ck174 FIND v(dout1_4) AT=875.025n

* CHECK dout1_5 Vdout1_5ck174 = 0 time = 875
.meas tran vdout1_5ck174 FIND v(dout1_5) AT=875.025n

* CHECK dout1_6 Vdout1_6ck174 = 0.9 time = 875
.meas tran vdout1_6ck174 FIND v(dout1_6) AT=875.025n

* CHECK dout1_7 Vdout1_7ck174 = 0.9 time = 875
.meas tran vdout1_7ck174 FIND v(dout1_7) AT=875.025n

* CHECK dout1_8 Vdout1_8ck174 = 0 time = 875
.meas tran vdout1_8ck174 FIND v(dout1_8) AT=875.025n

* CHECK dout1_9 Vdout1_9ck174 = 0 time = 875
.meas tran vdout1_9ck174 FIND v(dout1_9) AT=875.025n

* CHECK dout1_10 Vdout1_10ck174 = 0 time = 875
.meas tran vdout1_10ck174 FIND v(dout1_10) AT=875.025n

* CHECK dout1_11 Vdout1_11ck174 = 0 time = 875
.meas tran vdout1_11ck174 FIND v(dout1_11) AT=875.025n

* CHECK dout1_12 Vdout1_12ck174 = 0 time = 875
.meas tran vdout1_12ck174 FIND v(dout1_12) AT=875.025n

* CHECK dout1_13 Vdout1_13ck174 = 0 time = 875
.meas tran vdout1_13ck174 FIND v(dout1_13) AT=875.025n

* CHECK dout1_14 Vdout1_14ck174 = 0.9 time = 875
.meas tran vdout1_14ck174 FIND v(dout1_14) AT=875.025n

* CHECK dout1_15 Vdout1_15ck174 = 0 time = 875
.meas tran vdout1_15ck174 FIND v(dout1_15) AT=875.025n

* CHECK dout1_16 Vdout1_16ck174 = 0.9 time = 875
.meas tran vdout1_16ck174 FIND v(dout1_16) AT=875.025n

* CHECK dout1_17 Vdout1_17ck174 = 0 time = 875
.meas tran vdout1_17ck174 FIND v(dout1_17) AT=875.025n

* CHECK dout1_18 Vdout1_18ck174 = 0 time = 875
.meas tran vdout1_18ck174 FIND v(dout1_18) AT=875.025n

* CHECK dout1_19 Vdout1_19ck174 = 0 time = 875
.meas tran vdout1_19ck174 FIND v(dout1_19) AT=875.025n

* CHECK dout1_20 Vdout1_20ck174 = 0.9 time = 875
.meas tran vdout1_20ck174 FIND v(dout1_20) AT=875.025n

* CHECK dout1_21 Vdout1_21ck174 = 0 time = 875
.meas tran vdout1_21ck174 FIND v(dout1_21) AT=875.025n

* CHECK dout1_22 Vdout1_22ck174 = 0.9 time = 875
.meas tran vdout1_22ck174 FIND v(dout1_22) AT=875.025n

* CHECK dout1_23 Vdout1_23ck174 = 0 time = 875
.meas tran vdout1_23ck174 FIND v(dout1_23) AT=875.025n

* CHECK dout1_24 Vdout1_24ck174 = 0 time = 875
.meas tran vdout1_24ck174 FIND v(dout1_24) AT=875.025n

* CHECK dout1_25 Vdout1_25ck174 = 0.9 time = 875
.meas tran vdout1_25ck174 FIND v(dout1_25) AT=875.025n

* CHECK dout1_26 Vdout1_26ck174 = 0 time = 875
.meas tran vdout1_26ck174 FIND v(dout1_26) AT=875.025n

* CHECK dout1_27 Vdout1_27ck174 = 0 time = 875
.meas tran vdout1_27ck174 FIND v(dout1_27) AT=875.025n

* CHECK dout1_28 Vdout1_28ck174 = 0.9 time = 875
.meas tran vdout1_28ck174 FIND v(dout1_28) AT=875.025n

* CHECK dout1_29 Vdout1_29ck174 = 0.9 time = 875
.meas tran vdout1_29ck174 FIND v(dout1_29) AT=875.025n

* CHECK dout1_30 Vdout1_30ck174 = 0 time = 875
.meas tran vdout1_30ck174 FIND v(dout1_30) AT=875.025n

* CHECK dout1_31 Vdout1_31ck174 = 0 time = 875
.meas tran vdout1_31ck174 FIND v(dout1_31) AT=875.025n

* CHECK dout1_32 Vdout1_32ck174 = 0 time = 875
.meas tran vdout1_32ck174 FIND v(dout1_32) AT=875.025n

* CHECK dout1_33 Vdout1_33ck174 = 0.9 time = 875
.meas tran vdout1_33ck174 FIND v(dout1_33) AT=875.025n

* CHECK dout1_34 Vdout1_34ck174 = 0.9 time = 875
.meas tran vdout1_34ck174 FIND v(dout1_34) AT=875.025n

* CHECK dout1_35 Vdout1_35ck174 = 0.9 time = 875
.meas tran vdout1_35ck174 FIND v(dout1_35) AT=875.025n

* CHECK dout1_36 Vdout1_36ck174 = 0.9 time = 875
.meas tran vdout1_36ck174 FIND v(dout1_36) AT=875.025n

* CHECK dout1_37 Vdout1_37ck174 = 0.9 time = 875
.meas tran vdout1_37ck174 FIND v(dout1_37) AT=875.025n

* CHECK dout1_38 Vdout1_38ck174 = 0 time = 875
.meas tran vdout1_38ck174 FIND v(dout1_38) AT=875.025n

* CHECK dout1_39 Vdout1_39ck174 = 0.9 time = 875
.meas tran vdout1_39ck174 FIND v(dout1_39) AT=875.025n

* CHECK dout1_40 Vdout1_40ck174 = 0.9 time = 875
.meas tran vdout1_40ck174 FIND v(dout1_40) AT=875.025n

* CHECK dout1_41 Vdout1_41ck174 = 0.9 time = 875
.meas tran vdout1_41ck174 FIND v(dout1_41) AT=875.025n

* CHECK dout1_42 Vdout1_42ck174 = 0.9 time = 875
.meas tran vdout1_42ck174 FIND v(dout1_42) AT=875.025n

* CHECK dout1_43 Vdout1_43ck174 = 0 time = 875
.meas tran vdout1_43ck174 FIND v(dout1_43) AT=875.025n

* CHECK dout1_44 Vdout1_44ck174 = 0 time = 875
.meas tran vdout1_44ck174 FIND v(dout1_44) AT=875.025n

* CHECK dout1_45 Vdout1_45ck174 = 0 time = 875
.meas tran vdout1_45ck174 FIND v(dout1_45) AT=875.025n

* CHECK dout1_46 Vdout1_46ck174 = 0.9 time = 875
.meas tran vdout1_46ck174 FIND v(dout1_46) AT=875.025n

* CHECK dout1_47 Vdout1_47ck174 = 0 time = 875
.meas tran vdout1_47ck174 FIND v(dout1_47) AT=875.025n

* CHECK dout1_48 Vdout1_48ck174 = 0.9 time = 875
.meas tran vdout1_48ck174 FIND v(dout1_48) AT=875.025n

* CHECK dout1_49 Vdout1_49ck174 = 0 time = 875
.meas tran vdout1_49ck174 FIND v(dout1_49) AT=875.025n

* CHECK dout1_50 Vdout1_50ck174 = 0 time = 875
.meas tran vdout1_50ck174 FIND v(dout1_50) AT=875.025n

* CHECK dout1_51 Vdout1_51ck174 = 0 time = 875
.meas tran vdout1_51ck174 FIND v(dout1_51) AT=875.025n

* CHECK dout1_52 Vdout1_52ck174 = 0.9 time = 875
.meas tran vdout1_52ck174 FIND v(dout1_52) AT=875.025n

* CHECK dout1_53 Vdout1_53ck174 = 0.9 time = 875
.meas tran vdout1_53ck174 FIND v(dout1_53) AT=875.025n

* CHECK dout1_54 Vdout1_54ck174 = 0.9 time = 875
.meas tran vdout1_54ck174 FIND v(dout1_54) AT=875.025n

* CHECK dout1_55 Vdout1_55ck174 = 0 time = 875
.meas tran vdout1_55ck174 FIND v(dout1_55) AT=875.025n

* CHECK dout1_0 Vdout1_0ck175 = 0.9 time = 880
.meas tran vdout1_0ck175 FIND v(dout1_0) AT=880.025n

* CHECK dout1_1 Vdout1_1ck175 = 0.9 time = 880
.meas tran vdout1_1ck175 FIND v(dout1_1) AT=880.025n

* CHECK dout1_2 Vdout1_2ck175 = 0.9 time = 880
.meas tran vdout1_2ck175 FIND v(dout1_2) AT=880.025n

* CHECK dout1_3 Vdout1_3ck175 = 0 time = 880
.meas tran vdout1_3ck175 FIND v(dout1_3) AT=880.025n

* CHECK dout1_4 Vdout1_4ck175 = 0 time = 880
.meas tran vdout1_4ck175 FIND v(dout1_4) AT=880.025n

* CHECK dout1_5 Vdout1_5ck175 = 0 time = 880
.meas tran vdout1_5ck175 FIND v(dout1_5) AT=880.025n

* CHECK dout1_6 Vdout1_6ck175 = 0.9 time = 880
.meas tran vdout1_6ck175 FIND v(dout1_6) AT=880.025n

* CHECK dout1_7 Vdout1_7ck175 = 0.9 time = 880
.meas tran vdout1_7ck175 FIND v(dout1_7) AT=880.025n

* CHECK dout1_8 Vdout1_8ck175 = 0 time = 880
.meas tran vdout1_8ck175 FIND v(dout1_8) AT=880.025n

* CHECK dout1_9 Vdout1_9ck175 = 0 time = 880
.meas tran vdout1_9ck175 FIND v(dout1_9) AT=880.025n

* CHECK dout1_10 Vdout1_10ck175 = 0 time = 880
.meas tran vdout1_10ck175 FIND v(dout1_10) AT=880.025n

* CHECK dout1_11 Vdout1_11ck175 = 0 time = 880
.meas tran vdout1_11ck175 FIND v(dout1_11) AT=880.025n

* CHECK dout1_12 Vdout1_12ck175 = 0 time = 880
.meas tran vdout1_12ck175 FIND v(dout1_12) AT=880.025n

* CHECK dout1_13 Vdout1_13ck175 = 0 time = 880
.meas tran vdout1_13ck175 FIND v(dout1_13) AT=880.025n

* CHECK dout1_14 Vdout1_14ck175 = 0.9 time = 880
.meas tran vdout1_14ck175 FIND v(dout1_14) AT=880.025n

* CHECK dout1_15 Vdout1_15ck175 = 0 time = 880
.meas tran vdout1_15ck175 FIND v(dout1_15) AT=880.025n

* CHECK dout1_16 Vdout1_16ck175 = 0.9 time = 880
.meas tran vdout1_16ck175 FIND v(dout1_16) AT=880.025n

* CHECK dout1_17 Vdout1_17ck175 = 0 time = 880
.meas tran vdout1_17ck175 FIND v(dout1_17) AT=880.025n

* CHECK dout1_18 Vdout1_18ck175 = 0 time = 880
.meas tran vdout1_18ck175 FIND v(dout1_18) AT=880.025n

* CHECK dout1_19 Vdout1_19ck175 = 0 time = 880
.meas tran vdout1_19ck175 FIND v(dout1_19) AT=880.025n

* CHECK dout1_20 Vdout1_20ck175 = 0.9 time = 880
.meas tran vdout1_20ck175 FIND v(dout1_20) AT=880.025n

* CHECK dout1_21 Vdout1_21ck175 = 0 time = 880
.meas tran vdout1_21ck175 FIND v(dout1_21) AT=880.025n

* CHECK dout1_22 Vdout1_22ck175 = 0.9 time = 880
.meas tran vdout1_22ck175 FIND v(dout1_22) AT=880.025n

* CHECK dout1_23 Vdout1_23ck175 = 0 time = 880
.meas tran vdout1_23ck175 FIND v(dout1_23) AT=880.025n

* CHECK dout1_24 Vdout1_24ck175 = 0 time = 880
.meas tran vdout1_24ck175 FIND v(dout1_24) AT=880.025n

* CHECK dout1_25 Vdout1_25ck175 = 0.9 time = 880
.meas tran vdout1_25ck175 FIND v(dout1_25) AT=880.025n

* CHECK dout1_26 Vdout1_26ck175 = 0 time = 880
.meas tran vdout1_26ck175 FIND v(dout1_26) AT=880.025n

* CHECK dout1_27 Vdout1_27ck175 = 0 time = 880
.meas tran vdout1_27ck175 FIND v(dout1_27) AT=880.025n

* CHECK dout1_28 Vdout1_28ck175 = 0.9 time = 880
.meas tran vdout1_28ck175 FIND v(dout1_28) AT=880.025n

* CHECK dout1_29 Vdout1_29ck175 = 0.9 time = 880
.meas tran vdout1_29ck175 FIND v(dout1_29) AT=880.025n

* CHECK dout1_30 Vdout1_30ck175 = 0 time = 880
.meas tran vdout1_30ck175 FIND v(dout1_30) AT=880.025n

* CHECK dout1_31 Vdout1_31ck175 = 0 time = 880
.meas tran vdout1_31ck175 FIND v(dout1_31) AT=880.025n

* CHECK dout1_32 Vdout1_32ck175 = 0 time = 880
.meas tran vdout1_32ck175 FIND v(dout1_32) AT=880.025n

* CHECK dout1_33 Vdout1_33ck175 = 0.9 time = 880
.meas tran vdout1_33ck175 FIND v(dout1_33) AT=880.025n

* CHECK dout1_34 Vdout1_34ck175 = 0.9 time = 880
.meas tran vdout1_34ck175 FIND v(dout1_34) AT=880.025n

* CHECK dout1_35 Vdout1_35ck175 = 0.9 time = 880
.meas tran vdout1_35ck175 FIND v(dout1_35) AT=880.025n

* CHECK dout1_36 Vdout1_36ck175 = 0.9 time = 880
.meas tran vdout1_36ck175 FIND v(dout1_36) AT=880.025n

* CHECK dout1_37 Vdout1_37ck175 = 0.9 time = 880
.meas tran vdout1_37ck175 FIND v(dout1_37) AT=880.025n

* CHECK dout1_38 Vdout1_38ck175 = 0 time = 880
.meas tran vdout1_38ck175 FIND v(dout1_38) AT=880.025n

* CHECK dout1_39 Vdout1_39ck175 = 0.9 time = 880
.meas tran vdout1_39ck175 FIND v(dout1_39) AT=880.025n

* CHECK dout1_40 Vdout1_40ck175 = 0.9 time = 880
.meas tran vdout1_40ck175 FIND v(dout1_40) AT=880.025n

* CHECK dout1_41 Vdout1_41ck175 = 0.9 time = 880
.meas tran vdout1_41ck175 FIND v(dout1_41) AT=880.025n

* CHECK dout1_42 Vdout1_42ck175 = 0.9 time = 880
.meas tran vdout1_42ck175 FIND v(dout1_42) AT=880.025n

* CHECK dout1_43 Vdout1_43ck175 = 0 time = 880
.meas tran vdout1_43ck175 FIND v(dout1_43) AT=880.025n

* CHECK dout1_44 Vdout1_44ck175 = 0 time = 880
.meas tran vdout1_44ck175 FIND v(dout1_44) AT=880.025n

* CHECK dout1_45 Vdout1_45ck175 = 0 time = 880
.meas tran vdout1_45ck175 FIND v(dout1_45) AT=880.025n

* CHECK dout1_46 Vdout1_46ck175 = 0.9 time = 880
.meas tran vdout1_46ck175 FIND v(dout1_46) AT=880.025n

* CHECK dout1_47 Vdout1_47ck175 = 0 time = 880
.meas tran vdout1_47ck175 FIND v(dout1_47) AT=880.025n

* CHECK dout1_48 Vdout1_48ck175 = 0.9 time = 880
.meas tran vdout1_48ck175 FIND v(dout1_48) AT=880.025n

* CHECK dout1_49 Vdout1_49ck175 = 0 time = 880
.meas tran vdout1_49ck175 FIND v(dout1_49) AT=880.025n

* CHECK dout1_50 Vdout1_50ck175 = 0 time = 880
.meas tran vdout1_50ck175 FIND v(dout1_50) AT=880.025n

* CHECK dout1_51 Vdout1_51ck175 = 0 time = 880
.meas tran vdout1_51ck175 FIND v(dout1_51) AT=880.025n

* CHECK dout1_52 Vdout1_52ck175 = 0.9 time = 880
.meas tran vdout1_52ck175 FIND v(dout1_52) AT=880.025n

* CHECK dout1_53 Vdout1_53ck175 = 0.9 time = 880
.meas tran vdout1_53ck175 FIND v(dout1_53) AT=880.025n

* CHECK dout1_54 Vdout1_54ck175 = 0.9 time = 880
.meas tran vdout1_54ck175 FIND v(dout1_54) AT=880.025n

* CHECK dout1_55 Vdout1_55ck175 = 0 time = 880
.meas tran vdout1_55ck175 FIND v(dout1_55) AT=880.025n

* CHECK dout1_0 Vdout1_0ck176 = 0 time = 885
.meas tran vdout1_0ck176 FIND v(dout1_0) AT=885.025n

* CHECK dout1_1 Vdout1_1ck176 = 0.9 time = 885
.meas tran vdout1_1ck176 FIND v(dout1_1) AT=885.025n

* CHECK dout1_2 Vdout1_2ck176 = 0.9 time = 885
.meas tran vdout1_2ck176 FIND v(dout1_2) AT=885.025n

* CHECK dout1_3 Vdout1_3ck176 = 0.9 time = 885
.meas tran vdout1_3ck176 FIND v(dout1_3) AT=885.025n

* CHECK dout1_4 Vdout1_4ck176 = 0 time = 885
.meas tran vdout1_4ck176 FIND v(dout1_4) AT=885.025n

* CHECK dout1_5 Vdout1_5ck176 = 0.9 time = 885
.meas tran vdout1_5ck176 FIND v(dout1_5) AT=885.025n

* CHECK dout1_6 Vdout1_6ck176 = 0.9 time = 885
.meas tran vdout1_6ck176 FIND v(dout1_6) AT=885.025n

* CHECK dout1_7 Vdout1_7ck176 = 0.9 time = 885
.meas tran vdout1_7ck176 FIND v(dout1_7) AT=885.025n

* CHECK dout1_8 Vdout1_8ck176 = 0 time = 885
.meas tran vdout1_8ck176 FIND v(dout1_8) AT=885.025n

* CHECK dout1_9 Vdout1_9ck176 = 0 time = 885
.meas tran vdout1_9ck176 FIND v(dout1_9) AT=885.025n

* CHECK dout1_10 Vdout1_10ck176 = 0.9 time = 885
.meas tran vdout1_10ck176 FIND v(dout1_10) AT=885.025n

* CHECK dout1_11 Vdout1_11ck176 = 0 time = 885
.meas tran vdout1_11ck176 FIND v(dout1_11) AT=885.025n

* CHECK dout1_12 Vdout1_12ck176 = 0 time = 885
.meas tran vdout1_12ck176 FIND v(dout1_12) AT=885.025n

* CHECK dout1_13 Vdout1_13ck176 = 0 time = 885
.meas tran vdout1_13ck176 FIND v(dout1_13) AT=885.025n

* CHECK dout1_14 Vdout1_14ck176 = 0.9 time = 885
.meas tran vdout1_14ck176 FIND v(dout1_14) AT=885.025n

* CHECK dout1_15 Vdout1_15ck176 = 0 time = 885
.meas tran vdout1_15ck176 FIND v(dout1_15) AT=885.025n

* CHECK dout1_16 Vdout1_16ck176 = 0.9 time = 885
.meas tran vdout1_16ck176 FIND v(dout1_16) AT=885.025n

* CHECK dout1_17 Vdout1_17ck176 = 0 time = 885
.meas tran vdout1_17ck176 FIND v(dout1_17) AT=885.025n

* CHECK dout1_18 Vdout1_18ck176 = 0 time = 885
.meas tran vdout1_18ck176 FIND v(dout1_18) AT=885.025n

* CHECK dout1_19 Vdout1_19ck176 = 0 time = 885
.meas tran vdout1_19ck176 FIND v(dout1_19) AT=885.025n

* CHECK dout1_20 Vdout1_20ck176 = 0.9 time = 885
.meas tran vdout1_20ck176 FIND v(dout1_20) AT=885.025n

* CHECK dout1_21 Vdout1_21ck176 = 0.9 time = 885
.meas tran vdout1_21ck176 FIND v(dout1_21) AT=885.025n

* CHECK dout1_22 Vdout1_22ck176 = 0 time = 885
.meas tran vdout1_22ck176 FIND v(dout1_22) AT=885.025n

* CHECK dout1_23 Vdout1_23ck176 = 0.9 time = 885
.meas tran vdout1_23ck176 FIND v(dout1_23) AT=885.025n

* CHECK dout1_24 Vdout1_24ck176 = 0.9 time = 885
.meas tran vdout1_24ck176 FIND v(dout1_24) AT=885.025n

* CHECK dout1_25 Vdout1_25ck176 = 0 time = 885
.meas tran vdout1_25ck176 FIND v(dout1_25) AT=885.025n

* CHECK dout1_26 Vdout1_26ck176 = 0 time = 885
.meas tran vdout1_26ck176 FIND v(dout1_26) AT=885.025n

* CHECK dout1_27 Vdout1_27ck176 = 0.9 time = 885
.meas tran vdout1_27ck176 FIND v(dout1_27) AT=885.025n

* CHECK dout1_28 Vdout1_28ck176 = 0.9 time = 885
.meas tran vdout1_28ck176 FIND v(dout1_28) AT=885.025n

* CHECK dout1_29 Vdout1_29ck176 = 0 time = 885
.meas tran vdout1_29ck176 FIND v(dout1_29) AT=885.025n

* CHECK dout1_30 Vdout1_30ck176 = 0 time = 885
.meas tran vdout1_30ck176 FIND v(dout1_30) AT=885.025n

* CHECK dout1_31 Vdout1_31ck176 = 0 time = 885
.meas tran vdout1_31ck176 FIND v(dout1_31) AT=885.025n

* CHECK dout1_32 Vdout1_32ck176 = 0 time = 885
.meas tran vdout1_32ck176 FIND v(dout1_32) AT=885.025n

* CHECK dout1_33 Vdout1_33ck176 = 0 time = 885
.meas tran vdout1_33ck176 FIND v(dout1_33) AT=885.025n

* CHECK dout1_34 Vdout1_34ck176 = 0.9 time = 885
.meas tran vdout1_34ck176 FIND v(dout1_34) AT=885.025n

* CHECK dout1_35 Vdout1_35ck176 = 0 time = 885
.meas tran vdout1_35ck176 FIND v(dout1_35) AT=885.025n

* CHECK dout1_36 Vdout1_36ck176 = 0.9 time = 885
.meas tran vdout1_36ck176 FIND v(dout1_36) AT=885.025n

* CHECK dout1_37 Vdout1_37ck176 = 0 time = 885
.meas tran vdout1_37ck176 FIND v(dout1_37) AT=885.025n

* CHECK dout1_38 Vdout1_38ck176 = 0 time = 885
.meas tran vdout1_38ck176 FIND v(dout1_38) AT=885.025n

* CHECK dout1_39 Vdout1_39ck176 = 0 time = 885
.meas tran vdout1_39ck176 FIND v(dout1_39) AT=885.025n

* CHECK dout1_40 Vdout1_40ck176 = 0 time = 885
.meas tran vdout1_40ck176 FIND v(dout1_40) AT=885.025n

* CHECK dout1_41 Vdout1_41ck176 = 0 time = 885
.meas tran vdout1_41ck176 FIND v(dout1_41) AT=885.025n

* CHECK dout1_42 Vdout1_42ck176 = 0 time = 885
.meas tran vdout1_42ck176 FIND v(dout1_42) AT=885.025n

* CHECK dout1_43 Vdout1_43ck176 = 0 time = 885
.meas tran vdout1_43ck176 FIND v(dout1_43) AT=885.025n

* CHECK dout1_44 Vdout1_44ck176 = 0.9 time = 885
.meas tran vdout1_44ck176 FIND v(dout1_44) AT=885.025n

* CHECK dout1_45 Vdout1_45ck176 = 0 time = 885
.meas tran vdout1_45ck176 FIND v(dout1_45) AT=885.025n

* CHECK dout1_46 Vdout1_46ck176 = 0.9 time = 885
.meas tran vdout1_46ck176 FIND v(dout1_46) AT=885.025n

* CHECK dout1_47 Vdout1_47ck176 = 0.9 time = 885
.meas tran vdout1_47ck176 FIND v(dout1_47) AT=885.025n

* CHECK dout1_48 Vdout1_48ck176 = 0.9 time = 885
.meas tran vdout1_48ck176 FIND v(dout1_48) AT=885.025n

* CHECK dout1_49 Vdout1_49ck176 = 0.9 time = 885
.meas tran vdout1_49ck176 FIND v(dout1_49) AT=885.025n

* CHECK dout1_50 Vdout1_50ck176 = 0 time = 885
.meas tran vdout1_50ck176 FIND v(dout1_50) AT=885.025n

* CHECK dout1_51 Vdout1_51ck176 = 0 time = 885
.meas tran vdout1_51ck176 FIND v(dout1_51) AT=885.025n

* CHECK dout1_52 Vdout1_52ck176 = 0 time = 885
.meas tran vdout1_52ck176 FIND v(dout1_52) AT=885.025n

* CHECK dout1_53 Vdout1_53ck176 = 0.9 time = 885
.meas tran vdout1_53ck176 FIND v(dout1_53) AT=885.025n

* CHECK dout1_54 Vdout1_54ck176 = 0.9 time = 885
.meas tran vdout1_54ck176 FIND v(dout1_54) AT=885.025n

* CHECK dout1_55 Vdout1_55ck176 = 0 time = 885
.meas tran vdout1_55ck176 FIND v(dout1_55) AT=885.025n

* CHECK dout1_0 Vdout1_0ck186 = 0.9 time = 935
.meas tran vdout1_0ck186 FIND v(dout1_0) AT=935.025n

* CHECK dout1_1 Vdout1_1ck186 = 0.9 time = 935
.meas tran vdout1_1ck186 FIND v(dout1_1) AT=935.025n

* CHECK dout1_2 Vdout1_2ck186 = 0 time = 935
.meas tran vdout1_2ck186 FIND v(dout1_2) AT=935.025n

* CHECK dout1_3 Vdout1_3ck186 = 0 time = 935
.meas tran vdout1_3ck186 FIND v(dout1_3) AT=935.025n

* CHECK dout1_4 Vdout1_4ck186 = 0.9 time = 935
.meas tran vdout1_4ck186 FIND v(dout1_4) AT=935.025n

* CHECK dout1_5 Vdout1_5ck186 = 0.9 time = 935
.meas tran vdout1_5ck186 FIND v(dout1_5) AT=935.025n

* CHECK dout1_6 Vdout1_6ck186 = 0.9 time = 935
.meas tran vdout1_6ck186 FIND v(dout1_6) AT=935.025n

* CHECK dout1_7 Vdout1_7ck186 = 0.9 time = 935
.meas tran vdout1_7ck186 FIND v(dout1_7) AT=935.025n

* CHECK dout1_8 Vdout1_8ck186 = 0 time = 935
.meas tran vdout1_8ck186 FIND v(dout1_8) AT=935.025n

* CHECK dout1_9 Vdout1_9ck186 = 0.9 time = 935
.meas tran vdout1_9ck186 FIND v(dout1_9) AT=935.025n

* CHECK dout1_10 Vdout1_10ck186 = 0.9 time = 935
.meas tran vdout1_10ck186 FIND v(dout1_10) AT=935.025n

* CHECK dout1_11 Vdout1_11ck186 = 0 time = 935
.meas tran vdout1_11ck186 FIND v(dout1_11) AT=935.025n

* CHECK dout1_12 Vdout1_12ck186 = 0 time = 935
.meas tran vdout1_12ck186 FIND v(dout1_12) AT=935.025n

* CHECK dout1_13 Vdout1_13ck186 = 0 time = 935
.meas tran vdout1_13ck186 FIND v(dout1_13) AT=935.025n

* CHECK dout1_14 Vdout1_14ck186 = 0 time = 935
.meas tran vdout1_14ck186 FIND v(dout1_14) AT=935.025n

* CHECK dout1_15 Vdout1_15ck186 = 0.9 time = 935
.meas tran vdout1_15ck186 FIND v(dout1_15) AT=935.025n

* CHECK dout1_16 Vdout1_16ck186 = 0.9 time = 935
.meas tran vdout1_16ck186 FIND v(dout1_16) AT=935.025n

* CHECK dout1_17 Vdout1_17ck186 = 0 time = 935
.meas tran vdout1_17ck186 FIND v(dout1_17) AT=935.025n

* CHECK dout1_18 Vdout1_18ck186 = 0 time = 935
.meas tran vdout1_18ck186 FIND v(dout1_18) AT=935.025n

* CHECK dout1_19 Vdout1_19ck186 = 0.9 time = 935
.meas tran vdout1_19ck186 FIND v(dout1_19) AT=935.025n

* CHECK dout1_20 Vdout1_20ck186 = 0.9 time = 935
.meas tran vdout1_20ck186 FIND v(dout1_20) AT=935.025n

* CHECK dout1_21 Vdout1_21ck186 = 0.9 time = 935
.meas tran vdout1_21ck186 FIND v(dout1_21) AT=935.025n

* CHECK dout1_22 Vdout1_22ck186 = 0 time = 935
.meas tran vdout1_22ck186 FIND v(dout1_22) AT=935.025n

* CHECK dout1_23 Vdout1_23ck186 = 0 time = 935
.meas tran vdout1_23ck186 FIND v(dout1_23) AT=935.025n

* CHECK dout1_24 Vdout1_24ck186 = 0 time = 935
.meas tran vdout1_24ck186 FIND v(dout1_24) AT=935.025n

* CHECK dout1_25 Vdout1_25ck186 = 0.9 time = 935
.meas tran vdout1_25ck186 FIND v(dout1_25) AT=935.025n

* CHECK dout1_26 Vdout1_26ck186 = 0 time = 935
.meas tran vdout1_26ck186 FIND v(dout1_26) AT=935.025n

* CHECK dout1_27 Vdout1_27ck186 = 0.9 time = 935
.meas tran vdout1_27ck186 FIND v(dout1_27) AT=935.025n

* CHECK dout1_28 Vdout1_28ck186 = 0.9 time = 935
.meas tran vdout1_28ck186 FIND v(dout1_28) AT=935.025n

* CHECK dout1_29 Vdout1_29ck186 = 0.9 time = 935
.meas tran vdout1_29ck186 FIND v(dout1_29) AT=935.025n

* CHECK dout1_30 Vdout1_30ck186 = 0.9 time = 935
.meas tran vdout1_30ck186 FIND v(dout1_30) AT=935.025n

* CHECK dout1_31 Vdout1_31ck186 = 0 time = 935
.meas tran vdout1_31ck186 FIND v(dout1_31) AT=935.025n

* CHECK dout1_32 Vdout1_32ck186 = 0.9 time = 935
.meas tran vdout1_32ck186 FIND v(dout1_32) AT=935.025n

* CHECK dout1_33 Vdout1_33ck186 = 0 time = 935
.meas tran vdout1_33ck186 FIND v(dout1_33) AT=935.025n

* CHECK dout1_34 Vdout1_34ck186 = 0.9 time = 935
.meas tran vdout1_34ck186 FIND v(dout1_34) AT=935.025n

* CHECK dout1_35 Vdout1_35ck186 = 0.9 time = 935
.meas tran vdout1_35ck186 FIND v(dout1_35) AT=935.025n

* CHECK dout1_36 Vdout1_36ck186 = 0 time = 935
.meas tran vdout1_36ck186 FIND v(dout1_36) AT=935.025n

* CHECK dout1_37 Vdout1_37ck186 = 0.9 time = 935
.meas tran vdout1_37ck186 FIND v(dout1_37) AT=935.025n

* CHECK dout1_38 Vdout1_38ck186 = 0.9 time = 935
.meas tran vdout1_38ck186 FIND v(dout1_38) AT=935.025n

* CHECK dout1_39 Vdout1_39ck186 = 0.9 time = 935
.meas tran vdout1_39ck186 FIND v(dout1_39) AT=935.025n

* CHECK dout1_40 Vdout1_40ck186 = 0.9 time = 935
.meas tran vdout1_40ck186 FIND v(dout1_40) AT=935.025n

* CHECK dout1_41 Vdout1_41ck186 = 0 time = 935
.meas tran vdout1_41ck186 FIND v(dout1_41) AT=935.025n

* CHECK dout1_42 Vdout1_42ck186 = 0.9 time = 935
.meas tran vdout1_42ck186 FIND v(dout1_42) AT=935.025n

* CHECK dout1_43 Vdout1_43ck186 = 0 time = 935
.meas tran vdout1_43ck186 FIND v(dout1_43) AT=935.025n

* CHECK dout1_44 Vdout1_44ck186 = 0 time = 935
.meas tran vdout1_44ck186 FIND v(dout1_44) AT=935.025n

* CHECK dout1_45 Vdout1_45ck186 = 0 time = 935
.meas tran vdout1_45ck186 FIND v(dout1_45) AT=935.025n

* CHECK dout1_46 Vdout1_46ck186 = 0 time = 935
.meas tran vdout1_46ck186 FIND v(dout1_46) AT=935.025n

* CHECK dout1_47 Vdout1_47ck186 = 0.9 time = 935
.meas tran vdout1_47ck186 FIND v(dout1_47) AT=935.025n

* CHECK dout1_48 Vdout1_48ck186 = 0.9 time = 935
.meas tran vdout1_48ck186 FIND v(dout1_48) AT=935.025n

* CHECK dout1_49 Vdout1_49ck186 = 0.9 time = 935
.meas tran vdout1_49ck186 FIND v(dout1_49) AT=935.025n

* CHECK dout1_50 Vdout1_50ck186 = 0 time = 935
.meas tran vdout1_50ck186 FIND v(dout1_50) AT=935.025n

* CHECK dout1_51 Vdout1_51ck186 = 0.9 time = 935
.meas tran vdout1_51ck186 FIND v(dout1_51) AT=935.025n

* CHECK dout1_52 Vdout1_52ck186 = 0.9 time = 935
.meas tran vdout1_52ck186 FIND v(dout1_52) AT=935.025n

* CHECK dout1_53 Vdout1_53ck186 = 0.9 time = 935
.meas tran vdout1_53ck186 FIND v(dout1_53) AT=935.025n

* CHECK dout1_54 Vdout1_54ck186 = 0.9 time = 935
.meas tran vdout1_54ck186 FIND v(dout1_54) AT=935.025n

* CHECK dout1_55 Vdout1_55ck186 = 0.9 time = 935
.meas tran vdout1_55ck186 FIND v(dout1_55) AT=935.025n

* CHECK dout1_0 Vdout1_0ck189 = 0.9 time = 950
.meas tran vdout1_0ck189 FIND v(dout1_0) AT=950.025n

* CHECK dout1_1 Vdout1_1ck189 = 0.9 time = 950
.meas tran vdout1_1ck189 FIND v(dout1_1) AT=950.025n

* CHECK dout1_2 Vdout1_2ck189 = 0.9 time = 950
.meas tran vdout1_2ck189 FIND v(dout1_2) AT=950.025n

* CHECK dout1_3 Vdout1_3ck189 = 0 time = 950
.meas tran vdout1_3ck189 FIND v(dout1_3) AT=950.025n

* CHECK dout1_4 Vdout1_4ck189 = 0 time = 950
.meas tran vdout1_4ck189 FIND v(dout1_4) AT=950.025n

* CHECK dout1_5 Vdout1_5ck189 = 0 time = 950
.meas tran vdout1_5ck189 FIND v(dout1_5) AT=950.025n

* CHECK dout1_6 Vdout1_6ck189 = 0.9 time = 950
.meas tran vdout1_6ck189 FIND v(dout1_6) AT=950.025n

* CHECK dout1_7 Vdout1_7ck189 = 0.9 time = 950
.meas tran vdout1_7ck189 FIND v(dout1_7) AT=950.025n

* CHECK dout1_8 Vdout1_8ck189 = 0 time = 950
.meas tran vdout1_8ck189 FIND v(dout1_8) AT=950.025n

* CHECK dout1_9 Vdout1_9ck189 = 0 time = 950
.meas tran vdout1_9ck189 FIND v(dout1_9) AT=950.025n

* CHECK dout1_10 Vdout1_10ck189 = 0 time = 950
.meas tran vdout1_10ck189 FIND v(dout1_10) AT=950.025n

* CHECK dout1_11 Vdout1_11ck189 = 0 time = 950
.meas tran vdout1_11ck189 FIND v(dout1_11) AT=950.025n

* CHECK dout1_12 Vdout1_12ck189 = 0 time = 950
.meas tran vdout1_12ck189 FIND v(dout1_12) AT=950.025n

* CHECK dout1_13 Vdout1_13ck189 = 0 time = 950
.meas tran vdout1_13ck189 FIND v(dout1_13) AT=950.025n

* CHECK dout1_14 Vdout1_14ck189 = 0.9 time = 950
.meas tran vdout1_14ck189 FIND v(dout1_14) AT=950.025n

* CHECK dout1_15 Vdout1_15ck189 = 0 time = 950
.meas tran vdout1_15ck189 FIND v(dout1_15) AT=950.025n

* CHECK dout1_16 Vdout1_16ck189 = 0.9 time = 950
.meas tran vdout1_16ck189 FIND v(dout1_16) AT=950.025n

* CHECK dout1_17 Vdout1_17ck189 = 0 time = 950
.meas tran vdout1_17ck189 FIND v(dout1_17) AT=950.025n

* CHECK dout1_18 Vdout1_18ck189 = 0 time = 950
.meas tran vdout1_18ck189 FIND v(dout1_18) AT=950.025n

* CHECK dout1_19 Vdout1_19ck189 = 0 time = 950
.meas tran vdout1_19ck189 FIND v(dout1_19) AT=950.025n

* CHECK dout1_20 Vdout1_20ck189 = 0.9 time = 950
.meas tran vdout1_20ck189 FIND v(dout1_20) AT=950.025n

* CHECK dout1_21 Vdout1_21ck189 = 0 time = 950
.meas tran vdout1_21ck189 FIND v(dout1_21) AT=950.025n

* CHECK dout1_22 Vdout1_22ck189 = 0.9 time = 950
.meas tran vdout1_22ck189 FIND v(dout1_22) AT=950.025n

* CHECK dout1_23 Vdout1_23ck189 = 0 time = 950
.meas tran vdout1_23ck189 FIND v(dout1_23) AT=950.025n

* CHECK dout1_24 Vdout1_24ck189 = 0 time = 950
.meas tran vdout1_24ck189 FIND v(dout1_24) AT=950.025n

* CHECK dout1_25 Vdout1_25ck189 = 0.9 time = 950
.meas tran vdout1_25ck189 FIND v(dout1_25) AT=950.025n

* CHECK dout1_26 Vdout1_26ck189 = 0 time = 950
.meas tran vdout1_26ck189 FIND v(dout1_26) AT=950.025n

* CHECK dout1_27 Vdout1_27ck189 = 0 time = 950
.meas tran vdout1_27ck189 FIND v(dout1_27) AT=950.025n

* CHECK dout1_28 Vdout1_28ck189 = 0.9 time = 950
.meas tran vdout1_28ck189 FIND v(dout1_28) AT=950.025n

* CHECK dout1_29 Vdout1_29ck189 = 0.9 time = 950
.meas tran vdout1_29ck189 FIND v(dout1_29) AT=950.025n

* CHECK dout1_30 Vdout1_30ck189 = 0 time = 950
.meas tran vdout1_30ck189 FIND v(dout1_30) AT=950.025n

* CHECK dout1_31 Vdout1_31ck189 = 0 time = 950
.meas tran vdout1_31ck189 FIND v(dout1_31) AT=950.025n

* CHECK dout1_32 Vdout1_32ck189 = 0 time = 950
.meas tran vdout1_32ck189 FIND v(dout1_32) AT=950.025n

* CHECK dout1_33 Vdout1_33ck189 = 0.9 time = 950
.meas tran vdout1_33ck189 FIND v(dout1_33) AT=950.025n

* CHECK dout1_34 Vdout1_34ck189 = 0.9 time = 950
.meas tran vdout1_34ck189 FIND v(dout1_34) AT=950.025n

* CHECK dout1_35 Vdout1_35ck189 = 0.9 time = 950
.meas tran vdout1_35ck189 FIND v(dout1_35) AT=950.025n

* CHECK dout1_36 Vdout1_36ck189 = 0.9 time = 950
.meas tran vdout1_36ck189 FIND v(dout1_36) AT=950.025n

* CHECK dout1_37 Vdout1_37ck189 = 0.9 time = 950
.meas tran vdout1_37ck189 FIND v(dout1_37) AT=950.025n

* CHECK dout1_38 Vdout1_38ck189 = 0 time = 950
.meas tran vdout1_38ck189 FIND v(dout1_38) AT=950.025n

* CHECK dout1_39 Vdout1_39ck189 = 0.9 time = 950
.meas tran vdout1_39ck189 FIND v(dout1_39) AT=950.025n

* CHECK dout1_40 Vdout1_40ck189 = 0.9 time = 950
.meas tran vdout1_40ck189 FIND v(dout1_40) AT=950.025n

* CHECK dout1_41 Vdout1_41ck189 = 0.9 time = 950
.meas tran vdout1_41ck189 FIND v(dout1_41) AT=950.025n

* CHECK dout1_42 Vdout1_42ck189 = 0.9 time = 950
.meas tran vdout1_42ck189 FIND v(dout1_42) AT=950.025n

* CHECK dout1_43 Vdout1_43ck189 = 0 time = 950
.meas tran vdout1_43ck189 FIND v(dout1_43) AT=950.025n

* CHECK dout1_44 Vdout1_44ck189 = 0 time = 950
.meas tran vdout1_44ck189 FIND v(dout1_44) AT=950.025n

* CHECK dout1_45 Vdout1_45ck189 = 0 time = 950
.meas tran vdout1_45ck189 FIND v(dout1_45) AT=950.025n

* CHECK dout1_46 Vdout1_46ck189 = 0.9 time = 950
.meas tran vdout1_46ck189 FIND v(dout1_46) AT=950.025n

* CHECK dout1_47 Vdout1_47ck189 = 0 time = 950
.meas tran vdout1_47ck189 FIND v(dout1_47) AT=950.025n

* CHECK dout1_48 Vdout1_48ck189 = 0.9 time = 950
.meas tran vdout1_48ck189 FIND v(dout1_48) AT=950.025n

* CHECK dout1_49 Vdout1_49ck189 = 0 time = 950
.meas tran vdout1_49ck189 FIND v(dout1_49) AT=950.025n

* CHECK dout1_50 Vdout1_50ck189 = 0 time = 950
.meas tran vdout1_50ck189 FIND v(dout1_50) AT=950.025n

* CHECK dout1_51 Vdout1_51ck189 = 0 time = 950
.meas tran vdout1_51ck189 FIND v(dout1_51) AT=950.025n

* CHECK dout1_52 Vdout1_52ck189 = 0.9 time = 950
.meas tran vdout1_52ck189 FIND v(dout1_52) AT=950.025n

* CHECK dout1_53 Vdout1_53ck189 = 0.9 time = 950
.meas tran vdout1_53ck189 FIND v(dout1_53) AT=950.025n

* CHECK dout1_54 Vdout1_54ck189 = 0.9 time = 950
.meas tran vdout1_54ck189 FIND v(dout1_54) AT=950.025n

* CHECK dout1_55 Vdout1_55ck189 = 0 time = 950
.meas tran vdout1_55ck189 FIND v(dout1_55) AT=950.025n

* CHECK dout1_0 Vdout1_0ck191 = 0.9 time = 960
.meas tran vdout1_0ck191 FIND v(dout1_0) AT=960.025n

* CHECK dout1_1 Vdout1_1ck191 = 0 time = 960
.meas tran vdout1_1ck191 FIND v(dout1_1) AT=960.025n

* CHECK dout1_2 Vdout1_2ck191 = 0.9 time = 960
.meas tran vdout1_2ck191 FIND v(dout1_2) AT=960.025n

* CHECK dout1_3 Vdout1_3ck191 = 0.9 time = 960
.meas tran vdout1_3ck191 FIND v(dout1_3) AT=960.025n

* CHECK dout1_4 Vdout1_4ck191 = 0 time = 960
.meas tran vdout1_4ck191 FIND v(dout1_4) AT=960.025n

* CHECK dout1_5 Vdout1_5ck191 = 0 time = 960
.meas tran vdout1_5ck191 FIND v(dout1_5) AT=960.025n

* CHECK dout1_6 Vdout1_6ck191 = 0.9 time = 960
.meas tran vdout1_6ck191 FIND v(dout1_6) AT=960.025n

* CHECK dout1_7 Vdout1_7ck191 = 0.9 time = 960
.meas tran vdout1_7ck191 FIND v(dout1_7) AT=960.025n

* CHECK dout1_8 Vdout1_8ck191 = 0.9 time = 960
.meas tran vdout1_8ck191 FIND v(dout1_8) AT=960.025n

* CHECK dout1_9 Vdout1_9ck191 = 0 time = 960
.meas tran vdout1_9ck191 FIND v(dout1_9) AT=960.025n

* CHECK dout1_10 Vdout1_10ck191 = 0.9 time = 960
.meas tran vdout1_10ck191 FIND v(dout1_10) AT=960.025n

* CHECK dout1_11 Vdout1_11ck191 = 0 time = 960
.meas tran vdout1_11ck191 FIND v(dout1_11) AT=960.025n

* CHECK dout1_12 Vdout1_12ck191 = 0 time = 960
.meas tran vdout1_12ck191 FIND v(dout1_12) AT=960.025n

* CHECK dout1_13 Vdout1_13ck191 = 0 time = 960
.meas tran vdout1_13ck191 FIND v(dout1_13) AT=960.025n

* CHECK dout1_14 Vdout1_14ck191 = 0.9 time = 960
.meas tran vdout1_14ck191 FIND v(dout1_14) AT=960.025n

* CHECK dout1_15 Vdout1_15ck191 = 0 time = 960
.meas tran vdout1_15ck191 FIND v(dout1_15) AT=960.025n

* CHECK dout1_16 Vdout1_16ck191 = 0.9 time = 960
.meas tran vdout1_16ck191 FIND v(dout1_16) AT=960.025n

* CHECK dout1_17 Vdout1_17ck191 = 0 time = 960
.meas tran vdout1_17ck191 FIND v(dout1_17) AT=960.025n

* CHECK dout1_18 Vdout1_18ck191 = 0 time = 960
.meas tran vdout1_18ck191 FIND v(dout1_18) AT=960.025n

* CHECK dout1_19 Vdout1_19ck191 = 0 time = 960
.meas tran vdout1_19ck191 FIND v(dout1_19) AT=960.025n

* CHECK dout1_20 Vdout1_20ck191 = 0.9 time = 960
.meas tran vdout1_20ck191 FIND v(dout1_20) AT=960.025n

* CHECK dout1_21 Vdout1_21ck191 = 0.9 time = 960
.meas tran vdout1_21ck191 FIND v(dout1_21) AT=960.025n

* CHECK dout1_22 Vdout1_22ck191 = 0 time = 960
.meas tran vdout1_22ck191 FIND v(dout1_22) AT=960.025n

* CHECK dout1_23 Vdout1_23ck191 = 0.9 time = 960
.meas tran vdout1_23ck191 FIND v(dout1_23) AT=960.025n

* CHECK dout1_24 Vdout1_24ck191 = 0.9 time = 960
.meas tran vdout1_24ck191 FIND v(dout1_24) AT=960.025n

* CHECK dout1_25 Vdout1_25ck191 = 0 time = 960
.meas tran vdout1_25ck191 FIND v(dout1_25) AT=960.025n

* CHECK dout1_26 Vdout1_26ck191 = 0 time = 960
.meas tran vdout1_26ck191 FIND v(dout1_26) AT=960.025n

* CHECK dout1_27 Vdout1_27ck191 = 0.9 time = 960
.meas tran vdout1_27ck191 FIND v(dout1_27) AT=960.025n

* CHECK dout1_28 Vdout1_28ck191 = 0.9 time = 960
.meas tran vdout1_28ck191 FIND v(dout1_28) AT=960.025n

* CHECK dout1_29 Vdout1_29ck191 = 0 time = 960
.meas tran vdout1_29ck191 FIND v(dout1_29) AT=960.025n

* CHECK dout1_30 Vdout1_30ck191 = 0 time = 960
.meas tran vdout1_30ck191 FIND v(dout1_30) AT=960.025n

* CHECK dout1_31 Vdout1_31ck191 = 0 time = 960
.meas tran vdout1_31ck191 FIND v(dout1_31) AT=960.025n

* CHECK dout1_32 Vdout1_32ck191 = 0 time = 960
.meas tran vdout1_32ck191 FIND v(dout1_32) AT=960.025n

* CHECK dout1_33 Vdout1_33ck191 = 0 time = 960
.meas tran vdout1_33ck191 FIND v(dout1_33) AT=960.025n

* CHECK dout1_34 Vdout1_34ck191 = 0.9 time = 960
.meas tran vdout1_34ck191 FIND v(dout1_34) AT=960.025n

* CHECK dout1_35 Vdout1_35ck191 = 0 time = 960
.meas tran vdout1_35ck191 FIND v(dout1_35) AT=960.025n

* CHECK dout1_36 Vdout1_36ck191 = 0.9 time = 960
.meas tran vdout1_36ck191 FIND v(dout1_36) AT=960.025n

* CHECK dout1_37 Vdout1_37ck191 = 0 time = 960
.meas tran vdout1_37ck191 FIND v(dout1_37) AT=960.025n

* CHECK dout1_38 Vdout1_38ck191 = 0 time = 960
.meas tran vdout1_38ck191 FIND v(dout1_38) AT=960.025n

* CHECK dout1_39 Vdout1_39ck191 = 0 time = 960
.meas tran vdout1_39ck191 FIND v(dout1_39) AT=960.025n

* CHECK dout1_40 Vdout1_40ck191 = 0 time = 960
.meas tran vdout1_40ck191 FIND v(dout1_40) AT=960.025n

* CHECK dout1_41 Vdout1_41ck191 = 0 time = 960
.meas tran vdout1_41ck191 FIND v(dout1_41) AT=960.025n

* CHECK dout1_42 Vdout1_42ck191 = 0 time = 960
.meas tran vdout1_42ck191 FIND v(dout1_42) AT=960.025n

* CHECK dout1_43 Vdout1_43ck191 = 0 time = 960
.meas tran vdout1_43ck191 FIND v(dout1_43) AT=960.025n

* CHECK dout1_44 Vdout1_44ck191 = 0.9 time = 960
.meas tran vdout1_44ck191 FIND v(dout1_44) AT=960.025n

* CHECK dout1_45 Vdout1_45ck191 = 0 time = 960
.meas tran vdout1_45ck191 FIND v(dout1_45) AT=960.025n

* CHECK dout1_46 Vdout1_46ck191 = 0.9 time = 960
.meas tran vdout1_46ck191 FIND v(dout1_46) AT=960.025n

* CHECK dout1_47 Vdout1_47ck191 = 0.9 time = 960
.meas tran vdout1_47ck191 FIND v(dout1_47) AT=960.025n

* CHECK dout1_48 Vdout1_48ck191 = 0.9 time = 960
.meas tran vdout1_48ck191 FIND v(dout1_48) AT=960.025n

* CHECK dout1_49 Vdout1_49ck191 = 0.9 time = 960
.meas tran vdout1_49ck191 FIND v(dout1_49) AT=960.025n

* CHECK dout1_50 Vdout1_50ck191 = 0 time = 960
.meas tran vdout1_50ck191 FIND v(dout1_50) AT=960.025n

* CHECK dout1_51 Vdout1_51ck191 = 0 time = 960
.meas tran vdout1_51ck191 FIND v(dout1_51) AT=960.025n

* CHECK dout1_52 Vdout1_52ck191 = 0 time = 960
.meas tran vdout1_52ck191 FIND v(dout1_52) AT=960.025n

* CHECK dout1_53 Vdout1_53ck191 = 0.9 time = 960
.meas tran vdout1_53ck191 FIND v(dout1_53) AT=960.025n

* CHECK dout1_54 Vdout1_54ck191 = 0.9 time = 960
.meas tran vdout1_54ck191 FIND v(dout1_54) AT=960.025n

* CHECK dout1_55 Vdout1_55ck191 = 0 time = 960
.meas tran vdout1_55ck191 FIND v(dout1_55) AT=960.025n

* CHECK dout1_0 Vdout1_0ck193 = 0 time = 970
.meas tran vdout1_0ck193 FIND v(dout1_0) AT=970.025n

* CHECK dout1_1 Vdout1_1ck193 = 0 time = 970
.meas tran vdout1_1ck193 FIND v(dout1_1) AT=970.025n

* CHECK dout1_2 Vdout1_2ck193 = 0.9 time = 970
.meas tran vdout1_2ck193 FIND v(dout1_2) AT=970.025n

* CHECK dout1_3 Vdout1_3ck193 = 0.9 time = 970
.meas tran vdout1_3ck193 FIND v(dout1_3) AT=970.025n

* CHECK dout1_4 Vdout1_4ck193 = 0.9 time = 970
.meas tran vdout1_4ck193 FIND v(dout1_4) AT=970.025n

* CHECK dout1_5 Vdout1_5ck193 = 0.9 time = 970
.meas tran vdout1_5ck193 FIND v(dout1_5) AT=970.025n

* CHECK dout1_6 Vdout1_6ck193 = 0.9 time = 970
.meas tran vdout1_6ck193 FIND v(dout1_6) AT=970.025n

* CHECK dout1_7 Vdout1_7ck193 = 0.9 time = 970
.meas tran vdout1_7ck193 FIND v(dout1_7) AT=970.025n

* CHECK dout1_8 Vdout1_8ck193 = 0.9 time = 970
.meas tran vdout1_8ck193 FIND v(dout1_8) AT=970.025n

* CHECK dout1_9 Vdout1_9ck193 = 0 time = 970
.meas tran vdout1_9ck193 FIND v(dout1_9) AT=970.025n

* CHECK dout1_10 Vdout1_10ck193 = 0.9 time = 970
.meas tran vdout1_10ck193 FIND v(dout1_10) AT=970.025n

* CHECK dout1_11 Vdout1_11ck193 = 0 time = 970
.meas tran vdout1_11ck193 FIND v(dout1_11) AT=970.025n

* CHECK dout1_12 Vdout1_12ck193 = 0 time = 970
.meas tran vdout1_12ck193 FIND v(dout1_12) AT=970.025n

* CHECK dout1_13 Vdout1_13ck193 = 0 time = 970
.meas tran vdout1_13ck193 FIND v(dout1_13) AT=970.025n

* CHECK dout1_14 Vdout1_14ck193 = 0 time = 970
.meas tran vdout1_14ck193 FIND v(dout1_14) AT=970.025n

* CHECK dout1_15 Vdout1_15ck193 = 0 time = 970
.meas tran vdout1_15ck193 FIND v(dout1_15) AT=970.025n

* CHECK dout1_16 Vdout1_16ck193 = 0 time = 970
.meas tran vdout1_16ck193 FIND v(dout1_16) AT=970.025n

* CHECK dout1_17 Vdout1_17ck193 = 0.9 time = 970
.meas tran vdout1_17ck193 FIND v(dout1_17) AT=970.025n

* CHECK dout1_18 Vdout1_18ck193 = 0.9 time = 970
.meas tran vdout1_18ck193 FIND v(dout1_18) AT=970.025n

* CHECK dout1_19 Vdout1_19ck193 = 0.9 time = 970
.meas tran vdout1_19ck193 FIND v(dout1_19) AT=970.025n

* CHECK dout1_20 Vdout1_20ck193 = 0 time = 970
.meas tran vdout1_20ck193 FIND v(dout1_20) AT=970.025n

* CHECK dout1_21 Vdout1_21ck193 = 0 time = 970
.meas tran vdout1_21ck193 FIND v(dout1_21) AT=970.025n

* CHECK dout1_22 Vdout1_22ck193 = 0.9 time = 970
.meas tran vdout1_22ck193 FIND v(dout1_22) AT=970.025n

* CHECK dout1_23 Vdout1_23ck193 = 0.9 time = 970
.meas tran vdout1_23ck193 FIND v(dout1_23) AT=970.025n

* CHECK dout1_24 Vdout1_24ck193 = 0.9 time = 970
.meas tran vdout1_24ck193 FIND v(dout1_24) AT=970.025n

* CHECK dout1_25 Vdout1_25ck193 = 0.9 time = 970
.meas tran vdout1_25ck193 FIND v(dout1_25) AT=970.025n

* CHECK dout1_26 Vdout1_26ck193 = 0 time = 970
.meas tran vdout1_26ck193 FIND v(dout1_26) AT=970.025n

* CHECK dout1_27 Vdout1_27ck193 = 0 time = 970
.meas tran vdout1_27ck193 FIND v(dout1_27) AT=970.025n

* CHECK dout1_28 Vdout1_28ck193 = 0.9 time = 970
.meas tran vdout1_28ck193 FIND v(dout1_28) AT=970.025n

* CHECK dout1_29 Vdout1_29ck193 = 0 time = 970
.meas tran vdout1_29ck193 FIND v(dout1_29) AT=970.025n

* CHECK dout1_30 Vdout1_30ck193 = 0.9 time = 970
.meas tran vdout1_30ck193 FIND v(dout1_30) AT=970.025n

* CHECK dout1_31 Vdout1_31ck193 = 0.9 time = 970
.meas tran vdout1_31ck193 FIND v(dout1_31) AT=970.025n

* CHECK dout1_32 Vdout1_32ck193 = 0 time = 970
.meas tran vdout1_32ck193 FIND v(dout1_32) AT=970.025n

* CHECK dout1_33 Vdout1_33ck193 = 0.9 time = 970
.meas tran vdout1_33ck193 FIND v(dout1_33) AT=970.025n

* CHECK dout1_34 Vdout1_34ck193 = 0.9 time = 970
.meas tran vdout1_34ck193 FIND v(dout1_34) AT=970.025n

* CHECK dout1_35 Vdout1_35ck193 = 0 time = 970
.meas tran vdout1_35ck193 FIND v(dout1_35) AT=970.025n

* CHECK dout1_36 Vdout1_36ck193 = 0 time = 970
.meas tran vdout1_36ck193 FIND v(dout1_36) AT=970.025n

* CHECK dout1_37 Vdout1_37ck193 = 0 time = 970
.meas tran vdout1_37ck193 FIND v(dout1_37) AT=970.025n

* CHECK dout1_38 Vdout1_38ck193 = 0.9 time = 970
.meas tran vdout1_38ck193 FIND v(dout1_38) AT=970.025n

* CHECK dout1_39 Vdout1_39ck193 = 0 time = 970
.meas tran vdout1_39ck193 FIND v(dout1_39) AT=970.025n

* CHECK dout1_40 Vdout1_40ck193 = 0.9 time = 970
.meas tran vdout1_40ck193 FIND v(dout1_40) AT=970.025n

* CHECK dout1_41 Vdout1_41ck193 = 0 time = 970
.meas tran vdout1_41ck193 FIND v(dout1_41) AT=970.025n

* CHECK dout1_42 Vdout1_42ck193 = 0.9 time = 970
.meas tran vdout1_42ck193 FIND v(dout1_42) AT=970.025n

* CHECK dout1_43 Vdout1_43ck193 = 0.9 time = 970
.meas tran vdout1_43ck193 FIND v(dout1_43) AT=970.025n

* CHECK dout1_44 Vdout1_44ck193 = 0.9 time = 970
.meas tran vdout1_44ck193 FIND v(dout1_44) AT=970.025n

* CHECK dout1_45 Vdout1_45ck193 = 0 time = 970
.meas tran vdout1_45ck193 FIND v(dout1_45) AT=970.025n

* CHECK dout1_46 Vdout1_46ck193 = 0 time = 970
.meas tran vdout1_46ck193 FIND v(dout1_46) AT=970.025n

* CHECK dout1_47 Vdout1_47ck193 = 0 time = 970
.meas tran vdout1_47ck193 FIND v(dout1_47) AT=970.025n

* CHECK dout1_48 Vdout1_48ck193 = 0.9 time = 970
.meas tran vdout1_48ck193 FIND v(dout1_48) AT=970.025n

* CHECK dout1_49 Vdout1_49ck193 = 0 time = 970
.meas tran vdout1_49ck193 FIND v(dout1_49) AT=970.025n

* CHECK dout1_50 Vdout1_50ck193 = 0.9 time = 970
.meas tran vdout1_50ck193 FIND v(dout1_50) AT=970.025n

* CHECK dout1_51 Vdout1_51ck193 = 0.9 time = 970
.meas tran vdout1_51ck193 FIND v(dout1_51) AT=970.025n

* CHECK dout1_52 Vdout1_52ck193 = 0 time = 970
.meas tran vdout1_52ck193 FIND v(dout1_52) AT=970.025n

* CHECK dout1_53 Vdout1_53ck193 = 0.9 time = 970
.meas tran vdout1_53ck193 FIND v(dout1_53) AT=970.025n

* CHECK dout1_54 Vdout1_54ck193 = 0.9 time = 970
.meas tran vdout1_54ck193 FIND v(dout1_54) AT=970.025n

* CHECK dout1_55 Vdout1_55ck193 = 0 time = 970
.meas tran vdout1_55ck193 FIND v(dout1_55) AT=970.025n

* CHECK dout1_0 Vdout1_0ck195 = 0.9 time = 980
.meas tran vdout1_0ck195 FIND v(dout1_0) AT=980.025n

* CHECK dout1_1 Vdout1_1ck195 = 0.9 time = 980
.meas tran vdout1_1ck195 FIND v(dout1_1) AT=980.025n

* CHECK dout1_2 Vdout1_2ck195 = 0.9 time = 980
.meas tran vdout1_2ck195 FIND v(dout1_2) AT=980.025n

* CHECK dout1_3 Vdout1_3ck195 = 0 time = 980
.meas tran vdout1_3ck195 FIND v(dout1_3) AT=980.025n

* CHECK dout1_4 Vdout1_4ck195 = 0 time = 980
.meas tran vdout1_4ck195 FIND v(dout1_4) AT=980.025n

* CHECK dout1_5 Vdout1_5ck195 = 0 time = 980
.meas tran vdout1_5ck195 FIND v(dout1_5) AT=980.025n

* CHECK dout1_6 Vdout1_6ck195 = 0.9 time = 980
.meas tran vdout1_6ck195 FIND v(dout1_6) AT=980.025n

* CHECK dout1_7 Vdout1_7ck195 = 0.9 time = 980
.meas tran vdout1_7ck195 FIND v(dout1_7) AT=980.025n

* CHECK dout1_8 Vdout1_8ck195 = 0 time = 980
.meas tran vdout1_8ck195 FIND v(dout1_8) AT=980.025n

* CHECK dout1_9 Vdout1_9ck195 = 0 time = 980
.meas tran vdout1_9ck195 FIND v(dout1_9) AT=980.025n

* CHECK dout1_10 Vdout1_10ck195 = 0 time = 980
.meas tran vdout1_10ck195 FIND v(dout1_10) AT=980.025n

* CHECK dout1_11 Vdout1_11ck195 = 0 time = 980
.meas tran vdout1_11ck195 FIND v(dout1_11) AT=980.025n

* CHECK dout1_12 Vdout1_12ck195 = 0 time = 980
.meas tran vdout1_12ck195 FIND v(dout1_12) AT=980.025n

* CHECK dout1_13 Vdout1_13ck195 = 0 time = 980
.meas tran vdout1_13ck195 FIND v(dout1_13) AT=980.025n

* CHECK dout1_14 Vdout1_14ck195 = 0.9 time = 980
.meas tran vdout1_14ck195 FIND v(dout1_14) AT=980.025n

* CHECK dout1_15 Vdout1_15ck195 = 0 time = 980
.meas tran vdout1_15ck195 FIND v(dout1_15) AT=980.025n

* CHECK dout1_16 Vdout1_16ck195 = 0.9 time = 980
.meas tran vdout1_16ck195 FIND v(dout1_16) AT=980.025n

* CHECK dout1_17 Vdout1_17ck195 = 0 time = 980
.meas tran vdout1_17ck195 FIND v(dout1_17) AT=980.025n

* CHECK dout1_18 Vdout1_18ck195 = 0 time = 980
.meas tran vdout1_18ck195 FIND v(dout1_18) AT=980.025n

* CHECK dout1_19 Vdout1_19ck195 = 0 time = 980
.meas tran vdout1_19ck195 FIND v(dout1_19) AT=980.025n

* CHECK dout1_20 Vdout1_20ck195 = 0.9 time = 980
.meas tran vdout1_20ck195 FIND v(dout1_20) AT=980.025n

* CHECK dout1_21 Vdout1_21ck195 = 0 time = 980
.meas tran vdout1_21ck195 FIND v(dout1_21) AT=980.025n

* CHECK dout1_22 Vdout1_22ck195 = 0.9 time = 980
.meas tran vdout1_22ck195 FIND v(dout1_22) AT=980.025n

* CHECK dout1_23 Vdout1_23ck195 = 0 time = 980
.meas tran vdout1_23ck195 FIND v(dout1_23) AT=980.025n

* CHECK dout1_24 Vdout1_24ck195 = 0 time = 980
.meas tran vdout1_24ck195 FIND v(dout1_24) AT=980.025n

* CHECK dout1_25 Vdout1_25ck195 = 0.9 time = 980
.meas tran vdout1_25ck195 FIND v(dout1_25) AT=980.025n

* CHECK dout1_26 Vdout1_26ck195 = 0 time = 980
.meas tran vdout1_26ck195 FIND v(dout1_26) AT=980.025n

* CHECK dout1_27 Vdout1_27ck195 = 0 time = 980
.meas tran vdout1_27ck195 FIND v(dout1_27) AT=980.025n

* CHECK dout1_28 Vdout1_28ck195 = 0.9 time = 980
.meas tran vdout1_28ck195 FIND v(dout1_28) AT=980.025n

* CHECK dout1_29 Vdout1_29ck195 = 0.9 time = 980
.meas tran vdout1_29ck195 FIND v(dout1_29) AT=980.025n

* CHECK dout1_30 Vdout1_30ck195 = 0 time = 980
.meas tran vdout1_30ck195 FIND v(dout1_30) AT=980.025n

* CHECK dout1_31 Vdout1_31ck195 = 0 time = 980
.meas tran vdout1_31ck195 FIND v(dout1_31) AT=980.025n

* CHECK dout1_32 Vdout1_32ck195 = 0 time = 980
.meas tran vdout1_32ck195 FIND v(dout1_32) AT=980.025n

* CHECK dout1_33 Vdout1_33ck195 = 0.9 time = 980
.meas tran vdout1_33ck195 FIND v(dout1_33) AT=980.025n

* CHECK dout1_34 Vdout1_34ck195 = 0.9 time = 980
.meas tran vdout1_34ck195 FIND v(dout1_34) AT=980.025n

* CHECK dout1_35 Vdout1_35ck195 = 0.9 time = 980
.meas tran vdout1_35ck195 FIND v(dout1_35) AT=980.025n

* CHECK dout1_36 Vdout1_36ck195 = 0.9 time = 980
.meas tran vdout1_36ck195 FIND v(dout1_36) AT=980.025n

* CHECK dout1_37 Vdout1_37ck195 = 0.9 time = 980
.meas tran vdout1_37ck195 FIND v(dout1_37) AT=980.025n

* CHECK dout1_38 Vdout1_38ck195 = 0 time = 980
.meas tran vdout1_38ck195 FIND v(dout1_38) AT=980.025n

* CHECK dout1_39 Vdout1_39ck195 = 0.9 time = 980
.meas tran vdout1_39ck195 FIND v(dout1_39) AT=980.025n

* CHECK dout1_40 Vdout1_40ck195 = 0.9 time = 980
.meas tran vdout1_40ck195 FIND v(dout1_40) AT=980.025n

* CHECK dout1_41 Vdout1_41ck195 = 0.9 time = 980
.meas tran vdout1_41ck195 FIND v(dout1_41) AT=980.025n

* CHECK dout1_42 Vdout1_42ck195 = 0.9 time = 980
.meas tran vdout1_42ck195 FIND v(dout1_42) AT=980.025n

* CHECK dout1_43 Vdout1_43ck195 = 0 time = 980
.meas tran vdout1_43ck195 FIND v(dout1_43) AT=980.025n

* CHECK dout1_44 Vdout1_44ck195 = 0 time = 980
.meas tran vdout1_44ck195 FIND v(dout1_44) AT=980.025n

* CHECK dout1_45 Vdout1_45ck195 = 0 time = 980
.meas tran vdout1_45ck195 FIND v(dout1_45) AT=980.025n

* CHECK dout1_46 Vdout1_46ck195 = 0.9 time = 980
.meas tran vdout1_46ck195 FIND v(dout1_46) AT=980.025n

* CHECK dout1_47 Vdout1_47ck195 = 0 time = 980
.meas tran vdout1_47ck195 FIND v(dout1_47) AT=980.025n

* CHECK dout1_48 Vdout1_48ck195 = 0.9 time = 980
.meas tran vdout1_48ck195 FIND v(dout1_48) AT=980.025n

* CHECK dout1_49 Vdout1_49ck195 = 0 time = 980
.meas tran vdout1_49ck195 FIND v(dout1_49) AT=980.025n

* CHECK dout1_50 Vdout1_50ck195 = 0 time = 980
.meas tran vdout1_50ck195 FIND v(dout1_50) AT=980.025n

* CHECK dout1_51 Vdout1_51ck195 = 0 time = 980
.meas tran vdout1_51ck195 FIND v(dout1_51) AT=980.025n

* CHECK dout1_52 Vdout1_52ck195 = 0.9 time = 980
.meas tran vdout1_52ck195 FIND v(dout1_52) AT=980.025n

* CHECK dout1_53 Vdout1_53ck195 = 0.9 time = 980
.meas tran vdout1_53ck195 FIND v(dout1_53) AT=980.025n

* CHECK dout1_54 Vdout1_54ck195 = 0.9 time = 980
.meas tran vdout1_54ck195 FIND v(dout1_54) AT=980.025n

* CHECK dout1_55 Vdout1_55ck195 = 0 time = 980
.meas tran vdout1_55ck195 FIND v(dout1_55) AT=980.025n

* CHECK dout1_0 Vdout1_0ck197 = 0 time = 990
.meas tran vdout1_0ck197 FIND v(dout1_0) AT=990.025n

* CHECK dout1_1 Vdout1_1ck197 = 0 time = 990
.meas tran vdout1_1ck197 FIND v(dout1_1) AT=990.025n

* CHECK dout1_2 Vdout1_2ck197 = 0.9 time = 990
.meas tran vdout1_2ck197 FIND v(dout1_2) AT=990.025n

* CHECK dout1_3 Vdout1_3ck197 = 0.9 time = 990
.meas tran vdout1_3ck197 FIND v(dout1_3) AT=990.025n

* CHECK dout1_4 Vdout1_4ck197 = 0.9 time = 990
.meas tran vdout1_4ck197 FIND v(dout1_4) AT=990.025n

* CHECK dout1_5 Vdout1_5ck197 = 0.9 time = 990
.meas tran vdout1_5ck197 FIND v(dout1_5) AT=990.025n

* CHECK dout1_6 Vdout1_6ck197 = 0.9 time = 990
.meas tran vdout1_6ck197 FIND v(dout1_6) AT=990.025n

* CHECK dout1_7 Vdout1_7ck197 = 0.9 time = 990
.meas tran vdout1_7ck197 FIND v(dout1_7) AT=990.025n

* CHECK dout1_8 Vdout1_8ck197 = 0.9 time = 990
.meas tran vdout1_8ck197 FIND v(dout1_8) AT=990.025n

* CHECK dout1_9 Vdout1_9ck197 = 0 time = 990
.meas tran vdout1_9ck197 FIND v(dout1_9) AT=990.025n

* CHECK dout1_10 Vdout1_10ck197 = 0.9 time = 990
.meas tran vdout1_10ck197 FIND v(dout1_10) AT=990.025n

* CHECK dout1_11 Vdout1_11ck197 = 0 time = 990
.meas tran vdout1_11ck197 FIND v(dout1_11) AT=990.025n

* CHECK dout1_12 Vdout1_12ck197 = 0 time = 990
.meas tran vdout1_12ck197 FIND v(dout1_12) AT=990.025n

* CHECK dout1_13 Vdout1_13ck197 = 0 time = 990
.meas tran vdout1_13ck197 FIND v(dout1_13) AT=990.025n

* CHECK dout1_14 Vdout1_14ck197 = 0 time = 990
.meas tran vdout1_14ck197 FIND v(dout1_14) AT=990.025n

* CHECK dout1_15 Vdout1_15ck197 = 0 time = 990
.meas tran vdout1_15ck197 FIND v(dout1_15) AT=990.025n

* CHECK dout1_16 Vdout1_16ck197 = 0 time = 990
.meas tran vdout1_16ck197 FIND v(dout1_16) AT=990.025n

* CHECK dout1_17 Vdout1_17ck197 = 0.9 time = 990
.meas tran vdout1_17ck197 FIND v(dout1_17) AT=990.025n

* CHECK dout1_18 Vdout1_18ck197 = 0.9 time = 990
.meas tran vdout1_18ck197 FIND v(dout1_18) AT=990.025n

* CHECK dout1_19 Vdout1_19ck197 = 0.9 time = 990
.meas tran vdout1_19ck197 FIND v(dout1_19) AT=990.025n

* CHECK dout1_20 Vdout1_20ck197 = 0 time = 990
.meas tran vdout1_20ck197 FIND v(dout1_20) AT=990.025n

* CHECK dout1_21 Vdout1_21ck197 = 0 time = 990
.meas tran vdout1_21ck197 FIND v(dout1_21) AT=990.025n

* CHECK dout1_22 Vdout1_22ck197 = 0.9 time = 990
.meas tran vdout1_22ck197 FIND v(dout1_22) AT=990.025n

* CHECK dout1_23 Vdout1_23ck197 = 0.9 time = 990
.meas tran vdout1_23ck197 FIND v(dout1_23) AT=990.025n

* CHECK dout1_24 Vdout1_24ck197 = 0.9 time = 990
.meas tran vdout1_24ck197 FIND v(dout1_24) AT=990.025n

* CHECK dout1_25 Vdout1_25ck197 = 0.9 time = 990
.meas tran vdout1_25ck197 FIND v(dout1_25) AT=990.025n

* CHECK dout1_26 Vdout1_26ck197 = 0 time = 990
.meas tran vdout1_26ck197 FIND v(dout1_26) AT=990.025n

* CHECK dout1_27 Vdout1_27ck197 = 0 time = 990
.meas tran vdout1_27ck197 FIND v(dout1_27) AT=990.025n

* CHECK dout1_28 Vdout1_28ck197 = 0.9 time = 990
.meas tran vdout1_28ck197 FIND v(dout1_28) AT=990.025n

* CHECK dout1_29 Vdout1_29ck197 = 0 time = 990
.meas tran vdout1_29ck197 FIND v(dout1_29) AT=990.025n

* CHECK dout1_30 Vdout1_30ck197 = 0.9 time = 990
.meas tran vdout1_30ck197 FIND v(dout1_30) AT=990.025n

* CHECK dout1_31 Vdout1_31ck197 = 0.9 time = 990
.meas tran vdout1_31ck197 FIND v(dout1_31) AT=990.025n

* CHECK dout1_32 Vdout1_32ck197 = 0 time = 990
.meas tran vdout1_32ck197 FIND v(dout1_32) AT=990.025n

* CHECK dout1_33 Vdout1_33ck197 = 0.9 time = 990
.meas tran vdout1_33ck197 FIND v(dout1_33) AT=990.025n

* CHECK dout1_34 Vdout1_34ck197 = 0.9 time = 990
.meas tran vdout1_34ck197 FIND v(dout1_34) AT=990.025n

* CHECK dout1_35 Vdout1_35ck197 = 0 time = 990
.meas tran vdout1_35ck197 FIND v(dout1_35) AT=990.025n

* CHECK dout1_36 Vdout1_36ck197 = 0 time = 990
.meas tran vdout1_36ck197 FIND v(dout1_36) AT=990.025n

* CHECK dout1_37 Vdout1_37ck197 = 0 time = 990
.meas tran vdout1_37ck197 FIND v(dout1_37) AT=990.025n

* CHECK dout1_38 Vdout1_38ck197 = 0.9 time = 990
.meas tran vdout1_38ck197 FIND v(dout1_38) AT=990.025n

* CHECK dout1_39 Vdout1_39ck197 = 0 time = 990
.meas tran vdout1_39ck197 FIND v(dout1_39) AT=990.025n

* CHECK dout1_40 Vdout1_40ck197 = 0.9 time = 990
.meas tran vdout1_40ck197 FIND v(dout1_40) AT=990.025n

* CHECK dout1_41 Vdout1_41ck197 = 0 time = 990
.meas tran vdout1_41ck197 FIND v(dout1_41) AT=990.025n

* CHECK dout1_42 Vdout1_42ck197 = 0.9 time = 990
.meas tran vdout1_42ck197 FIND v(dout1_42) AT=990.025n

* CHECK dout1_43 Vdout1_43ck197 = 0.9 time = 990
.meas tran vdout1_43ck197 FIND v(dout1_43) AT=990.025n

* CHECK dout1_44 Vdout1_44ck197 = 0.9 time = 990
.meas tran vdout1_44ck197 FIND v(dout1_44) AT=990.025n

* CHECK dout1_45 Vdout1_45ck197 = 0 time = 990
.meas tran vdout1_45ck197 FIND v(dout1_45) AT=990.025n

* CHECK dout1_46 Vdout1_46ck197 = 0 time = 990
.meas tran vdout1_46ck197 FIND v(dout1_46) AT=990.025n

* CHECK dout1_47 Vdout1_47ck197 = 0 time = 990
.meas tran vdout1_47ck197 FIND v(dout1_47) AT=990.025n

* CHECK dout1_48 Vdout1_48ck197 = 0.9 time = 990
.meas tran vdout1_48ck197 FIND v(dout1_48) AT=990.025n

* CHECK dout1_49 Vdout1_49ck197 = 0 time = 990
.meas tran vdout1_49ck197 FIND v(dout1_49) AT=990.025n

* CHECK dout1_50 Vdout1_50ck197 = 0.9 time = 990
.meas tran vdout1_50ck197 FIND v(dout1_50) AT=990.025n

* CHECK dout1_51 Vdout1_51ck197 = 0.9 time = 990
.meas tran vdout1_51ck197 FIND v(dout1_51) AT=990.025n

* CHECK dout1_52 Vdout1_52ck197 = 0 time = 990
.meas tran vdout1_52ck197 FIND v(dout1_52) AT=990.025n

* CHECK dout1_53 Vdout1_53ck197 = 0.9 time = 990
.meas tran vdout1_53ck197 FIND v(dout1_53) AT=990.025n

* CHECK dout1_54 Vdout1_54ck197 = 0.9 time = 990
.meas tran vdout1_54ck197 FIND v(dout1_54) AT=990.025n

* CHECK dout1_55 Vdout1_55ck197 = 0 time = 990
.meas tran vdout1_55ck197 FIND v(dout1_55) AT=990.025n

* CHECK dout1_0 Vdout1_0ck199 = 0.9 time = 1000
.meas tran vdout1_0ck199 FIND v(dout1_0) AT=1000.025n

* CHECK dout1_1 Vdout1_1ck199 = 0.9 time = 1000
.meas tran vdout1_1ck199 FIND v(dout1_1) AT=1000.025n

* CHECK dout1_2 Vdout1_2ck199 = 0.9 time = 1000
.meas tran vdout1_2ck199 FIND v(dout1_2) AT=1000.025n

* CHECK dout1_3 Vdout1_3ck199 = 0 time = 1000
.meas tran vdout1_3ck199 FIND v(dout1_3) AT=1000.025n

* CHECK dout1_4 Vdout1_4ck199 = 0 time = 1000
.meas tran vdout1_4ck199 FIND v(dout1_4) AT=1000.025n

* CHECK dout1_5 Vdout1_5ck199 = 0 time = 1000
.meas tran vdout1_5ck199 FIND v(dout1_5) AT=1000.025n

* CHECK dout1_6 Vdout1_6ck199 = 0.9 time = 1000
.meas tran vdout1_6ck199 FIND v(dout1_6) AT=1000.025n

* CHECK dout1_7 Vdout1_7ck199 = 0.9 time = 1000
.meas tran vdout1_7ck199 FIND v(dout1_7) AT=1000.025n

* CHECK dout1_8 Vdout1_8ck199 = 0 time = 1000
.meas tran vdout1_8ck199 FIND v(dout1_8) AT=1000.025n

* CHECK dout1_9 Vdout1_9ck199 = 0 time = 1000
.meas tran vdout1_9ck199 FIND v(dout1_9) AT=1000.025n

* CHECK dout1_10 Vdout1_10ck199 = 0 time = 1000
.meas tran vdout1_10ck199 FIND v(dout1_10) AT=1000.025n

* CHECK dout1_11 Vdout1_11ck199 = 0 time = 1000
.meas tran vdout1_11ck199 FIND v(dout1_11) AT=1000.025n

* CHECK dout1_12 Vdout1_12ck199 = 0 time = 1000
.meas tran vdout1_12ck199 FIND v(dout1_12) AT=1000.025n

* CHECK dout1_13 Vdout1_13ck199 = 0 time = 1000
.meas tran vdout1_13ck199 FIND v(dout1_13) AT=1000.025n

* CHECK dout1_14 Vdout1_14ck199 = 0.9 time = 1000
.meas tran vdout1_14ck199 FIND v(dout1_14) AT=1000.025n

* CHECK dout1_15 Vdout1_15ck199 = 0 time = 1000
.meas tran vdout1_15ck199 FIND v(dout1_15) AT=1000.025n

* CHECK dout1_16 Vdout1_16ck199 = 0.9 time = 1000
.meas tran vdout1_16ck199 FIND v(dout1_16) AT=1000.025n

* CHECK dout1_17 Vdout1_17ck199 = 0 time = 1000
.meas tran vdout1_17ck199 FIND v(dout1_17) AT=1000.025n

* CHECK dout1_18 Vdout1_18ck199 = 0 time = 1000
.meas tran vdout1_18ck199 FIND v(dout1_18) AT=1000.025n

* CHECK dout1_19 Vdout1_19ck199 = 0 time = 1000
.meas tran vdout1_19ck199 FIND v(dout1_19) AT=1000.025n

* CHECK dout1_20 Vdout1_20ck199 = 0.9 time = 1000
.meas tran vdout1_20ck199 FIND v(dout1_20) AT=1000.025n

* CHECK dout1_21 Vdout1_21ck199 = 0 time = 1000
.meas tran vdout1_21ck199 FIND v(dout1_21) AT=1000.025n

* CHECK dout1_22 Vdout1_22ck199 = 0.9 time = 1000
.meas tran vdout1_22ck199 FIND v(dout1_22) AT=1000.025n

* CHECK dout1_23 Vdout1_23ck199 = 0 time = 1000
.meas tran vdout1_23ck199 FIND v(dout1_23) AT=1000.025n

* CHECK dout1_24 Vdout1_24ck199 = 0 time = 1000
.meas tran vdout1_24ck199 FIND v(dout1_24) AT=1000.025n

* CHECK dout1_25 Vdout1_25ck199 = 0.9 time = 1000
.meas tran vdout1_25ck199 FIND v(dout1_25) AT=1000.025n

* CHECK dout1_26 Vdout1_26ck199 = 0 time = 1000
.meas tran vdout1_26ck199 FIND v(dout1_26) AT=1000.025n

* CHECK dout1_27 Vdout1_27ck199 = 0 time = 1000
.meas tran vdout1_27ck199 FIND v(dout1_27) AT=1000.025n

* CHECK dout1_28 Vdout1_28ck199 = 0.9 time = 1000
.meas tran vdout1_28ck199 FIND v(dout1_28) AT=1000.025n

* CHECK dout1_29 Vdout1_29ck199 = 0.9 time = 1000
.meas tran vdout1_29ck199 FIND v(dout1_29) AT=1000.025n

* CHECK dout1_30 Vdout1_30ck199 = 0 time = 1000
.meas tran vdout1_30ck199 FIND v(dout1_30) AT=1000.025n

* CHECK dout1_31 Vdout1_31ck199 = 0 time = 1000
.meas tran vdout1_31ck199 FIND v(dout1_31) AT=1000.025n

* CHECK dout1_32 Vdout1_32ck199 = 0 time = 1000
.meas tran vdout1_32ck199 FIND v(dout1_32) AT=1000.025n

* CHECK dout1_33 Vdout1_33ck199 = 0.9 time = 1000
.meas tran vdout1_33ck199 FIND v(dout1_33) AT=1000.025n

* CHECK dout1_34 Vdout1_34ck199 = 0.9 time = 1000
.meas tran vdout1_34ck199 FIND v(dout1_34) AT=1000.025n

* CHECK dout1_35 Vdout1_35ck199 = 0.9 time = 1000
.meas tran vdout1_35ck199 FIND v(dout1_35) AT=1000.025n

* CHECK dout1_36 Vdout1_36ck199 = 0.9 time = 1000
.meas tran vdout1_36ck199 FIND v(dout1_36) AT=1000.025n

* CHECK dout1_37 Vdout1_37ck199 = 0.9 time = 1000
.meas tran vdout1_37ck199 FIND v(dout1_37) AT=1000.025n

* CHECK dout1_38 Vdout1_38ck199 = 0 time = 1000
.meas tran vdout1_38ck199 FIND v(dout1_38) AT=1000.025n

* CHECK dout1_39 Vdout1_39ck199 = 0.9 time = 1000
.meas tran vdout1_39ck199 FIND v(dout1_39) AT=1000.025n

* CHECK dout1_40 Vdout1_40ck199 = 0.9 time = 1000
.meas tran vdout1_40ck199 FIND v(dout1_40) AT=1000.025n

* CHECK dout1_41 Vdout1_41ck199 = 0.9 time = 1000
.meas tran vdout1_41ck199 FIND v(dout1_41) AT=1000.025n

* CHECK dout1_42 Vdout1_42ck199 = 0.9 time = 1000
.meas tran vdout1_42ck199 FIND v(dout1_42) AT=1000.025n

* CHECK dout1_43 Vdout1_43ck199 = 0 time = 1000
.meas tran vdout1_43ck199 FIND v(dout1_43) AT=1000.025n

* CHECK dout1_44 Vdout1_44ck199 = 0 time = 1000
.meas tran vdout1_44ck199 FIND v(dout1_44) AT=1000.025n

* CHECK dout1_45 Vdout1_45ck199 = 0 time = 1000
.meas tran vdout1_45ck199 FIND v(dout1_45) AT=1000.025n

* CHECK dout1_46 Vdout1_46ck199 = 0.9 time = 1000
.meas tran vdout1_46ck199 FIND v(dout1_46) AT=1000.025n

* CHECK dout1_47 Vdout1_47ck199 = 0 time = 1000
.meas tran vdout1_47ck199 FIND v(dout1_47) AT=1000.025n

* CHECK dout1_48 Vdout1_48ck199 = 0.9 time = 1000
.meas tran vdout1_48ck199 FIND v(dout1_48) AT=1000.025n

* CHECK dout1_49 Vdout1_49ck199 = 0 time = 1000
.meas tran vdout1_49ck199 FIND v(dout1_49) AT=1000.025n

* CHECK dout1_50 Vdout1_50ck199 = 0 time = 1000
.meas tran vdout1_50ck199 FIND v(dout1_50) AT=1000.025n

* CHECK dout1_51 Vdout1_51ck199 = 0 time = 1000
.meas tran vdout1_51ck199 FIND v(dout1_51) AT=1000.025n

* CHECK dout1_52 Vdout1_52ck199 = 0.9 time = 1000
.meas tran vdout1_52ck199 FIND v(dout1_52) AT=1000.025n

* CHECK dout1_53 Vdout1_53ck199 = 0.9 time = 1000
.meas tran vdout1_53ck199 FIND v(dout1_53) AT=1000.025n

* CHECK dout1_54 Vdout1_54ck199 = 0.9 time = 1000
.meas tran vdout1_54ck199 FIND v(dout1_54) AT=1000.025n

* CHECK dout1_55 Vdout1_55ck199 = 0 time = 1000
.meas tran vdout1_55ck199 FIND v(dout1_55) AT=1000.025n

* CHECK dout1_0 Vdout1_0ck200 = 0.9 time = 1005
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=1005.025n

* CHECK dout1_1 Vdout1_1ck200 = 0.9 time = 1005
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=1005.025n

* CHECK dout1_2 Vdout1_2ck200 = 0.9 time = 1005
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=1005.025n

* CHECK dout1_3 Vdout1_3ck200 = 0 time = 1005
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=1005.025n

* CHECK dout1_4 Vdout1_4ck200 = 0 time = 1005
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=1005.025n

* CHECK dout1_5 Vdout1_5ck200 = 0 time = 1005
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=1005.025n

* CHECK dout1_6 Vdout1_6ck200 = 0.9 time = 1005
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=1005.025n

* CHECK dout1_7 Vdout1_7ck200 = 0.9 time = 1005
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=1005.025n

* CHECK dout1_8 Vdout1_8ck200 = 0 time = 1005
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=1005.025n

* CHECK dout1_9 Vdout1_9ck200 = 0 time = 1005
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=1005.025n

* CHECK dout1_10 Vdout1_10ck200 = 0 time = 1005
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=1005.025n

* CHECK dout1_11 Vdout1_11ck200 = 0 time = 1005
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=1005.025n

* CHECK dout1_12 Vdout1_12ck200 = 0 time = 1005
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=1005.025n

* CHECK dout1_13 Vdout1_13ck200 = 0 time = 1005
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=1005.025n

* CHECK dout1_14 Vdout1_14ck200 = 0.9 time = 1005
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=1005.025n

* CHECK dout1_15 Vdout1_15ck200 = 0 time = 1005
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=1005.025n

* CHECK dout1_16 Vdout1_16ck200 = 0.9 time = 1005
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=1005.025n

* CHECK dout1_17 Vdout1_17ck200 = 0 time = 1005
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=1005.025n

* CHECK dout1_18 Vdout1_18ck200 = 0 time = 1005
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=1005.025n

* CHECK dout1_19 Vdout1_19ck200 = 0 time = 1005
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=1005.025n

* CHECK dout1_20 Vdout1_20ck200 = 0.9 time = 1005
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=1005.025n

* CHECK dout1_21 Vdout1_21ck200 = 0 time = 1005
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=1005.025n

* CHECK dout1_22 Vdout1_22ck200 = 0.9 time = 1005
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=1005.025n

* CHECK dout1_23 Vdout1_23ck200 = 0 time = 1005
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=1005.025n

* CHECK dout1_24 Vdout1_24ck200 = 0 time = 1005
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=1005.025n

* CHECK dout1_25 Vdout1_25ck200 = 0.9 time = 1005
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=1005.025n

* CHECK dout1_26 Vdout1_26ck200 = 0 time = 1005
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=1005.025n

* CHECK dout1_27 Vdout1_27ck200 = 0 time = 1005
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=1005.025n

* CHECK dout1_28 Vdout1_28ck200 = 0.9 time = 1005
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=1005.025n

* CHECK dout1_29 Vdout1_29ck200 = 0.9 time = 1005
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=1005.025n

* CHECK dout1_30 Vdout1_30ck200 = 0 time = 1005
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=1005.025n

* CHECK dout1_31 Vdout1_31ck200 = 0 time = 1005
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=1005.025n

* CHECK dout1_32 Vdout1_32ck200 = 0 time = 1005
.meas tran vdout1_32ck200 FIND v(dout1_32) AT=1005.025n

* CHECK dout1_33 Vdout1_33ck200 = 0.9 time = 1005
.meas tran vdout1_33ck200 FIND v(dout1_33) AT=1005.025n

* CHECK dout1_34 Vdout1_34ck200 = 0.9 time = 1005
.meas tran vdout1_34ck200 FIND v(dout1_34) AT=1005.025n

* CHECK dout1_35 Vdout1_35ck200 = 0.9 time = 1005
.meas tran vdout1_35ck200 FIND v(dout1_35) AT=1005.025n

* CHECK dout1_36 Vdout1_36ck200 = 0.9 time = 1005
.meas tran vdout1_36ck200 FIND v(dout1_36) AT=1005.025n

* CHECK dout1_37 Vdout1_37ck200 = 0.9 time = 1005
.meas tran vdout1_37ck200 FIND v(dout1_37) AT=1005.025n

* CHECK dout1_38 Vdout1_38ck200 = 0 time = 1005
.meas tran vdout1_38ck200 FIND v(dout1_38) AT=1005.025n

* CHECK dout1_39 Vdout1_39ck200 = 0.9 time = 1005
.meas tran vdout1_39ck200 FIND v(dout1_39) AT=1005.025n

* CHECK dout1_40 Vdout1_40ck200 = 0.9 time = 1005
.meas tran vdout1_40ck200 FIND v(dout1_40) AT=1005.025n

* CHECK dout1_41 Vdout1_41ck200 = 0.9 time = 1005
.meas tran vdout1_41ck200 FIND v(dout1_41) AT=1005.025n

* CHECK dout1_42 Vdout1_42ck200 = 0.9 time = 1005
.meas tran vdout1_42ck200 FIND v(dout1_42) AT=1005.025n

* CHECK dout1_43 Vdout1_43ck200 = 0 time = 1005
.meas tran vdout1_43ck200 FIND v(dout1_43) AT=1005.025n

* CHECK dout1_44 Vdout1_44ck200 = 0 time = 1005
.meas tran vdout1_44ck200 FIND v(dout1_44) AT=1005.025n

* CHECK dout1_45 Vdout1_45ck200 = 0 time = 1005
.meas tran vdout1_45ck200 FIND v(dout1_45) AT=1005.025n

* CHECK dout1_46 Vdout1_46ck200 = 0.9 time = 1005
.meas tran vdout1_46ck200 FIND v(dout1_46) AT=1005.025n

* CHECK dout1_47 Vdout1_47ck200 = 0 time = 1005
.meas tran vdout1_47ck200 FIND v(dout1_47) AT=1005.025n

* CHECK dout1_48 Vdout1_48ck200 = 0.9 time = 1005
.meas tran vdout1_48ck200 FIND v(dout1_48) AT=1005.025n

* CHECK dout1_49 Vdout1_49ck200 = 0 time = 1005
.meas tran vdout1_49ck200 FIND v(dout1_49) AT=1005.025n

* CHECK dout1_50 Vdout1_50ck200 = 0 time = 1005
.meas tran vdout1_50ck200 FIND v(dout1_50) AT=1005.025n

* CHECK dout1_51 Vdout1_51ck200 = 0 time = 1005
.meas tran vdout1_51ck200 FIND v(dout1_51) AT=1005.025n

* CHECK dout1_52 Vdout1_52ck200 = 0.9 time = 1005
.meas tran vdout1_52ck200 FIND v(dout1_52) AT=1005.025n

* CHECK dout1_53 Vdout1_53ck200 = 0.9 time = 1005
.meas tran vdout1_53ck200 FIND v(dout1_53) AT=1005.025n

* CHECK dout1_54 Vdout1_54ck200 = 0.9 time = 1005
.meas tran vdout1_54ck200 FIND v(dout1_54) AT=1005.025n

* CHECK dout1_55 Vdout1_55ck200 = 0 time = 1005
.meas tran vdout1_55ck200 FIND v(dout1_55) AT=1005.025n

* CHECK dout1_0 Vdout1_0ck204 = 0.9 time = 1025
.meas tran vdout1_0ck204 FIND v(dout1_0) AT=1025.025n

* CHECK dout1_1 Vdout1_1ck204 = 0.9 time = 1025
.meas tran vdout1_1ck204 FIND v(dout1_1) AT=1025.025n

* CHECK dout1_2 Vdout1_2ck204 = 0.9 time = 1025
.meas tran vdout1_2ck204 FIND v(dout1_2) AT=1025.025n

* CHECK dout1_3 Vdout1_3ck204 = 0 time = 1025
.meas tran vdout1_3ck204 FIND v(dout1_3) AT=1025.025n

* CHECK dout1_4 Vdout1_4ck204 = 0 time = 1025
.meas tran vdout1_4ck204 FIND v(dout1_4) AT=1025.025n

* CHECK dout1_5 Vdout1_5ck204 = 0 time = 1025
.meas tran vdout1_5ck204 FIND v(dout1_5) AT=1025.025n

* CHECK dout1_6 Vdout1_6ck204 = 0.9 time = 1025
.meas tran vdout1_6ck204 FIND v(dout1_6) AT=1025.025n

* CHECK dout1_7 Vdout1_7ck204 = 0.9 time = 1025
.meas tran vdout1_7ck204 FIND v(dout1_7) AT=1025.025n

* CHECK dout1_8 Vdout1_8ck204 = 0 time = 1025
.meas tran vdout1_8ck204 FIND v(dout1_8) AT=1025.025n

* CHECK dout1_9 Vdout1_9ck204 = 0 time = 1025
.meas tran vdout1_9ck204 FIND v(dout1_9) AT=1025.025n

* CHECK dout1_10 Vdout1_10ck204 = 0 time = 1025
.meas tran vdout1_10ck204 FIND v(dout1_10) AT=1025.025n

* CHECK dout1_11 Vdout1_11ck204 = 0 time = 1025
.meas tran vdout1_11ck204 FIND v(dout1_11) AT=1025.025n

* CHECK dout1_12 Vdout1_12ck204 = 0 time = 1025
.meas tran vdout1_12ck204 FIND v(dout1_12) AT=1025.025n

* CHECK dout1_13 Vdout1_13ck204 = 0 time = 1025
.meas tran vdout1_13ck204 FIND v(dout1_13) AT=1025.025n

* CHECK dout1_14 Vdout1_14ck204 = 0.9 time = 1025
.meas tran vdout1_14ck204 FIND v(dout1_14) AT=1025.025n

* CHECK dout1_15 Vdout1_15ck204 = 0 time = 1025
.meas tran vdout1_15ck204 FIND v(dout1_15) AT=1025.025n

* CHECK dout1_16 Vdout1_16ck204 = 0.9 time = 1025
.meas tran vdout1_16ck204 FIND v(dout1_16) AT=1025.025n

* CHECK dout1_17 Vdout1_17ck204 = 0 time = 1025
.meas tran vdout1_17ck204 FIND v(dout1_17) AT=1025.025n

* CHECK dout1_18 Vdout1_18ck204 = 0 time = 1025
.meas tran vdout1_18ck204 FIND v(dout1_18) AT=1025.025n

* CHECK dout1_19 Vdout1_19ck204 = 0 time = 1025
.meas tran vdout1_19ck204 FIND v(dout1_19) AT=1025.025n

* CHECK dout1_20 Vdout1_20ck204 = 0.9 time = 1025
.meas tran vdout1_20ck204 FIND v(dout1_20) AT=1025.025n

* CHECK dout1_21 Vdout1_21ck204 = 0 time = 1025
.meas tran vdout1_21ck204 FIND v(dout1_21) AT=1025.025n

* CHECK dout1_22 Vdout1_22ck204 = 0.9 time = 1025
.meas tran vdout1_22ck204 FIND v(dout1_22) AT=1025.025n

* CHECK dout1_23 Vdout1_23ck204 = 0 time = 1025
.meas tran vdout1_23ck204 FIND v(dout1_23) AT=1025.025n

* CHECK dout1_24 Vdout1_24ck204 = 0 time = 1025
.meas tran vdout1_24ck204 FIND v(dout1_24) AT=1025.025n

* CHECK dout1_25 Vdout1_25ck204 = 0.9 time = 1025
.meas tran vdout1_25ck204 FIND v(dout1_25) AT=1025.025n

* CHECK dout1_26 Vdout1_26ck204 = 0 time = 1025
.meas tran vdout1_26ck204 FIND v(dout1_26) AT=1025.025n

* CHECK dout1_27 Vdout1_27ck204 = 0 time = 1025
.meas tran vdout1_27ck204 FIND v(dout1_27) AT=1025.025n

* CHECK dout1_28 Vdout1_28ck204 = 0.9 time = 1025
.meas tran vdout1_28ck204 FIND v(dout1_28) AT=1025.025n

* CHECK dout1_29 Vdout1_29ck204 = 0.9 time = 1025
.meas tran vdout1_29ck204 FIND v(dout1_29) AT=1025.025n

* CHECK dout1_30 Vdout1_30ck204 = 0 time = 1025
.meas tran vdout1_30ck204 FIND v(dout1_30) AT=1025.025n

* CHECK dout1_31 Vdout1_31ck204 = 0 time = 1025
.meas tran vdout1_31ck204 FIND v(dout1_31) AT=1025.025n

* CHECK dout1_32 Vdout1_32ck204 = 0 time = 1025
.meas tran vdout1_32ck204 FIND v(dout1_32) AT=1025.025n

* CHECK dout1_33 Vdout1_33ck204 = 0.9 time = 1025
.meas tran vdout1_33ck204 FIND v(dout1_33) AT=1025.025n

* CHECK dout1_34 Vdout1_34ck204 = 0.9 time = 1025
.meas tran vdout1_34ck204 FIND v(dout1_34) AT=1025.025n

* CHECK dout1_35 Vdout1_35ck204 = 0.9 time = 1025
.meas tran vdout1_35ck204 FIND v(dout1_35) AT=1025.025n

* CHECK dout1_36 Vdout1_36ck204 = 0.9 time = 1025
.meas tran vdout1_36ck204 FIND v(dout1_36) AT=1025.025n

* CHECK dout1_37 Vdout1_37ck204 = 0.9 time = 1025
.meas tran vdout1_37ck204 FIND v(dout1_37) AT=1025.025n

* CHECK dout1_38 Vdout1_38ck204 = 0 time = 1025
.meas tran vdout1_38ck204 FIND v(dout1_38) AT=1025.025n

* CHECK dout1_39 Vdout1_39ck204 = 0.9 time = 1025
.meas tran vdout1_39ck204 FIND v(dout1_39) AT=1025.025n

* CHECK dout1_40 Vdout1_40ck204 = 0.9 time = 1025
.meas tran vdout1_40ck204 FIND v(dout1_40) AT=1025.025n

* CHECK dout1_41 Vdout1_41ck204 = 0.9 time = 1025
.meas tran vdout1_41ck204 FIND v(dout1_41) AT=1025.025n

* CHECK dout1_42 Vdout1_42ck204 = 0.9 time = 1025
.meas tran vdout1_42ck204 FIND v(dout1_42) AT=1025.025n

* CHECK dout1_43 Vdout1_43ck204 = 0 time = 1025
.meas tran vdout1_43ck204 FIND v(dout1_43) AT=1025.025n

* CHECK dout1_44 Vdout1_44ck204 = 0 time = 1025
.meas tran vdout1_44ck204 FIND v(dout1_44) AT=1025.025n

* CHECK dout1_45 Vdout1_45ck204 = 0 time = 1025
.meas tran vdout1_45ck204 FIND v(dout1_45) AT=1025.025n

* CHECK dout1_46 Vdout1_46ck204 = 0.9 time = 1025
.meas tran vdout1_46ck204 FIND v(dout1_46) AT=1025.025n

* CHECK dout1_47 Vdout1_47ck204 = 0 time = 1025
.meas tran vdout1_47ck204 FIND v(dout1_47) AT=1025.025n

* CHECK dout1_48 Vdout1_48ck204 = 0.9 time = 1025
.meas tran vdout1_48ck204 FIND v(dout1_48) AT=1025.025n

* CHECK dout1_49 Vdout1_49ck204 = 0 time = 1025
.meas tran vdout1_49ck204 FIND v(dout1_49) AT=1025.025n

* CHECK dout1_50 Vdout1_50ck204 = 0 time = 1025
.meas tran vdout1_50ck204 FIND v(dout1_50) AT=1025.025n

* CHECK dout1_51 Vdout1_51ck204 = 0 time = 1025
.meas tran vdout1_51ck204 FIND v(dout1_51) AT=1025.025n

* CHECK dout1_52 Vdout1_52ck204 = 0.9 time = 1025
.meas tran vdout1_52ck204 FIND v(dout1_52) AT=1025.025n

* CHECK dout1_53 Vdout1_53ck204 = 0.9 time = 1025
.meas tran vdout1_53ck204 FIND v(dout1_53) AT=1025.025n

* CHECK dout1_54 Vdout1_54ck204 = 0.9 time = 1025
.meas tran vdout1_54ck204 FIND v(dout1_54) AT=1025.025n

* CHECK dout1_55 Vdout1_55ck204 = 0 time = 1025
.meas tran vdout1_55ck204 FIND v(dout1_55) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
