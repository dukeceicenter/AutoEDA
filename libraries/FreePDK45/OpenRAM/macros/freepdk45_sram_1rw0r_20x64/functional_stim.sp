* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_20x64.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_20x64 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 a0_0 a0_1 a0_2 a0_3 a0_4 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 vdd gnd freepdk45_sram_1rw0r_20x64

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f
CD040 dout0_40  0 0.8364f
CD041 dout0_41  0 0.8364f
CD042 dout0_42  0 0.8364f
CD043 dout0_43  0 0.8364f
CD044 dout0_44  0 0.8364f
CD045 dout0_45  0 0.8364f
CD046 dout0_46  0 0.8364f
CD047 dout0_47  0 0.8364f
CD048 dout0_48  0 0.8364f
CD049 dout0_49  0 0.8364f
CD050 dout0_50  0 0.8364f
CD051 dout0_51  0 0.8364f
CD052 dout0_52  0 0.8364f
CD053 dout0_53  0 0.8364f
CD054 dout0_54  0 0.8364f
CD055 dout0_55  0 0.8364f
CD056 dout0_56  0 0.8364f
CD057 dout0_57  0 0.8364f
CD058 dout0_58  0 0.8364f
CD059 dout0_59  0 0.8364f
CD060 dout0_60  0 0.8364f
CD061 dout0_61  0 0.8364f
CD062 dout0_62  0 0.8364f
CD063 dout0_63  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_20x64.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_20x64.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_20x64.s_en
* q:	xfreepdk45_sram_1rw0r_20x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_20x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 0011100100100010010111100011001111000000100111110000110101010111  to  address 00000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 0001000011000101101111010101100001011110001000001010010110100001  to  address 00000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 0111001101100010101101110010111010101101010001101101101001110101  to  address 10010 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 0001000011000101101111010101100001011110001000001010010110100001 from address 00000 (from port 0) during cycle 4 (20ns - 25ns)
*	Reading 0111001101100010101101110010111010101101010001101101101001110101 from address 10010 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 0111001101100010101101110010111010101101010001101101101001110101 from address 10010 (from port 0) during cycle 6 (30ns - 35ns)
*	Reading 0001000011000101101111010101100001011110001000001010010110100001 from address 00000 (from port 0) during cycle 8 (40ns - 45ns)
*	Reading 0001000011000101101111010101100001011110001000001010010110100001 from address 00000 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing 1001000010110100110101101000010010100001101111110000011100111101  to  address 00000 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 1001000010110100110101101000010010100001101111110000011100111101 from address 00000 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 1001000010110100110101101000010010100001101111110000011100111101 from address 00000 (from port 0) during cycle 13 (65ns - 70ns)
*	Reading 0111001101100010101101110010111010101101010001101101101001110101 from address 10010 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 0111001101100010101101110010111010101101010001101101101001110101 from address 10010 (from port 0) during cycle 15 (75ns - 80ns)
*	Reading 0111001101100010101101110010111010101101010001101101101001110101 from address 10010 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 1001000010110100110101101000010010100001101111110000011100111101 from address 00000 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 1001000010110100110101101000010010100001101111110000011100111101 from address 00000 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 0111001101100010101101110010111010101101010001101101101001110101 from address 10010 (from port 0) during cycle 20 (100ns - 105ns)
*	Writing 1010011001000010011011011111000000000000100100101111011111101111  to  address 00000 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 0101101101010110101000010101011110000000011001110011111100011001  to  address 10010 (from port 0) during cycle 23 (115ns - 120ns)
*	Writing 0111111110011011001001100100110111000100100101111100010011011110  to  address 10010 (from port 0) during cycle 24 (120ns - 125ns)
*	Writing 1010011010100000001111100100001110010101010001010100000101111100  to  address 10010 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 1010011001000010011011011111000000000000100100101111011111101111 from address 00000 (from port 0) during cycle 29 (145ns - 150ns)
*	Writing 0111100000011011001011010000000001000001100010010001111100110111  to  address 10010 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 1010011001000010011011011111000000000000100100101111011111101111 from address 00000 (from port 0) during cycle 31 (155ns - 160ns)
*	Writing 1001001111000111010001100001100011111100011001111110110111111100  to  address 10010 (from port 0) during cycle 32 (160ns - 165ns)
*	Writing 0001000001101010110101011110001100011100001100101111011011111011  to  address 10010 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 1010011001000010011011011111000000000000100100101111011111101111 from address 00000 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 1010011001000010011011011111000000000000100100101111011111101111 from address 00000 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 0101110000111110011100000110100011011101011000001000010010001111  to  address 10010 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 1010011001000010011011011111000000000000100100101111011111101111 from address 00000 (from port 0) during cycle 37 (185ns - 190ns)
*	Reading 1010011001000010011011011111000000000000100100101111011111101111 from address 00000 (from port 0) during cycle 39 (195ns - 200ns)
*	Writing 0001110001000110010100010111110110101100011110111111001011101101  to  address 00000 (from port 0) during cycle 40 (200ns - 205ns)
*	Writing 1001100010111011010111110100011010101010000000100110010100000011  to  address 10010 (from port 0) during cycle 41 (205ns - 210ns)
*	Reading 0001110001000110010100010111110110101100011110111111001011101101 from address 00000 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing 0100000110010000100010010001110010010100100010010010001001100100  to  address 00000 (from port 0) during cycle 43 (215ns - 220ns)
*	Reading 0100000110010000100010010001110010010100100010010010001001100100 from address 00000 (from port 0) during cycle 44 (220ns - 225ns)
*	Reading 1001100010111011010111110100011010101010000000100110010100000011 from address 10010 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 0100000110010000100010010001110010010100100010010010001001100100 from address 00000 (from port 0) during cycle 46 (230ns - 235ns)
*	Writing 1001100010001111101100111011111101100010110110001000110100110101  to  address 00000 (from port 0) during cycle 47 (235ns - 240ns)
*	Writing 0010100100100111010100010100010011001101100110010100011110100000  to  address 00000 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing 0001111111111110101111000011000101011100110001001110011010010001  to  address 10010 (from port 0) during cycle 50 (250ns - 255ns)
*	Writing 1111010111000101100111111010101001110001010111010111000100000101  to  address 10010 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing 1100010000001110101011110111100111011111111010010110110010100010  to  address 10010 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 1100010000001110101011110111100111011111111010010110110010100010 from address 10010 (from port 0) during cycle 53 (265ns - 270ns)
*	Reading 1100010000001110101011110111100111011111111010010110110010100010 from address 10010 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing 0110111011010110011101010000000000010010000110011101000111011010  to  address 10010 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 0010100100100111010100010100010011001101100110010100011110100000 from address 00000 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing 1011010100100010011110110111100100100010010001101001011011111101  to  address 10010 (from port 0) during cycle 58 (290ns - 295ns)
*	Reading 0010100100100111010100010100010011001101100110010100011110100000 from address 00000 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 1001001110001110001011110001111011001000111100111110000001000000  to  address 10010 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 0010100100100111010100010100010011001101100110010100011110100000 from address 00000 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 0010100100100111010100010100010011001101100110010100011110100000 from address 00000 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 0011001000100110100100111001000110001001000110000000111000110001  to  address 00000 (from port 0) during cycle 63 (315ns - 320ns)
*	Reading 0011001000100110100100111001000110001001000110000000111000110001 from address 00000 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 67 (335ns - 340ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 0011001000100110100100111001000110001001000110000000111000110001 from address 00000 (from port 0) during cycle 69 (345ns - 350ns)
*	Reading 0011001000100110100100111001000110001001000110000000111000110001 from address 00000 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 0011001000100110100100111001000110001001000110000000111000110001 from address 00000 (from port 0) during cycle 71 (355ns - 360ns)
*	Reading 0011001000100110100100111001000110001001000110000000111000110001 from address 00000 (from port 0) during cycle 72 (360ns - 365ns)
*	Reading 0011001000100110100100111001000110001001000110000000111000110001 from address 00000 (from port 0) during cycle 73 (365ns - 370ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 75 (375ns - 380ns)
*	Writing 0010010001001000001011000110101001010000101000011010011011011010  to  address 00000 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 77 (385ns - 390ns)
*	Reading 0010010001001000001011000110101001010000101000011010011011011010 from address 00000 (from port 0) during cycle 78 (390ns - 395ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 81 (405ns - 410ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing 0010100010000111001111101101100101100101011110101101101001101001  to  address 00000 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing 1000110111011101010000100110100110100010110101101010001111000111  to  address 00000 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 1001001110001110001011110001111011001000111100111110000001000000 from address 10010 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing 0000101001001001001101011101000110110110000110011001100101101101  to  address 10010 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 0000101001001001001101011101000110110110000110011001100101101101 from address 10010 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 1100100100010001111001111010110010111000001100111101100010010010  to  address 10010 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 1000110111011101010000100110100110100010110101101010001111000111 from address 00000 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 1100100100010001111001111010110010111000001100111101100010010010 from address 10010 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 1000110111011101010000100110100110100010110101101010001111000111 from address 00000 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 1100100100010001111001111010110010111000001100111101100010010010 from address 10010 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 1000110111011101010000100110100110100010110101101010001111000111 from address 00000 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 1100100100010001111001111010110010111000001100111101100010010010 from address 10010 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 1000110111011101010000100110100110100010110101101010001111000111 from address 00000 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 1000110111011101010000100110100110100010110101101010001111000111 from address 00000 (from port 0) during cycle 102 (510ns - 515ns)
*	Writing 1110101000111100110001000001110100011110010011101000101000001101  to  address 10010 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 1110101000111100110001000001110100011110010011101000101000001101 from address 10010 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 1110101000111100110001000001110100011110010011101000101000001101 from address 10010 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 1110101000111100110001000001110100011110010011101000101000001101 from address 10010 (from port 0) during cycle 108 (540ns - 545ns)
*	Writing 0001110111111000011110001010011110011010100000010100001011110010  to  address 00000 (from port 0) during cycle 112 (560ns - 565ns)
*	Writing 1101110101101100010110011000011011001001001011010111101010110011  to  address 10010 (from port 0) during cycle 116 (580ns - 585ns)
*	Reading 0001110111111000011110001010011110011010100000010100001011110010 from address 00000 (from port 0) during cycle 117 (585ns - 590ns)
*	Writing 1001110000101010100010000011000010101110110011001011100111101001  to  address 10010 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 1001110000101010100010000011000010101110110011001011100111101001 from address 10010 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 0001110111111000011110001010011110011010100000010100001011110010 from address 00000 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 1001110000101010100010000011000010101110110011001011100111101001 from address 10010 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 1001110000101010100010000011000010101110110011001011100111101001 from address 10010 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 0001110111111000011110001010011110011010100000010100001011110010 from address 00000 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 1001101001010000100010011010111001101010000001100001111110010011  to  address 10010 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 0001110111111000011110001010011110011010100000010100001011110010 from address 00000 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing 0001000011101000110111011100011110010110010110000010001010000001  to  address 00000 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 1001101001010000100010011010111001101010000001100001111110010011 from address 10010 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 1001101001010000100010011010111001101010000001100001111110010011 from address 10010 (from port 0) during cycle 133 (665ns - 670ns)
*	Reading 1001101001010000100010011010111001101010000001100001111110010011 from address 10010 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 1001101001010000100010011010111001101010000001100001111110010011 from address 10010 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 0001000011101000110111011100011110010110010110000010001010000001 from address 00000 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 0001000011101000110111011100011110010110010110000010001010000001 from address 00000 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 1001101001010000100010011010111001101010000001100001111110010011 from address 10010 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 1111001100111011001111001101101000100000011010101110101110100011  to  address 10010 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 0001000011101000110111011100011110010110010110000010001010000001 from address 00000 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 0011000001001110010110001110101001101000100000100110100000111101  to  address 00000 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 1111001100111011001111001101101000100000011010101110101110100011 from address 10010 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 0011000001001110010110001110101001101000100000100110100000111101 from address 00000 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 1111001100111011001111001101101000100000011010101110101110100011 from address 10010 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 0011000001001110010110001110101001101000100000100110100000111101 from address 00000 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 1111001100111011001111001101101000100000011010101110101110100011 from address 10010 (from port 0) during cycle 151 (755ns - 760ns)
*	Writing 1101101100011010010000011010000001000011100101110000001111111010  to  address 00000 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 154 (770ns - 775ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 155 (775ns - 780ns)
*	Writing 1100110000000110101011000101011101010000111111011101111010100001  to  address 10010 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 1100110000000110101011000101011101010000111111011101111010100001 from address 10010 (from port 0) during cycle 157 (785ns - 790ns)
*	Writing 0000010000100000110010000010110110110011010100011001000010100101  to  address 10010 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 159 (795ns - 800ns)
*	Writing 1000000110111101101101001110000101000111001111111011110111011011  to  address 10010 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 167 (835ns - 840ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 177 (885ns - 890ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 181 (905ns - 910ns)
*	Reading 1101101100011010010000011010000001000011100101110000001111111010 from address 00000 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 0011011011110001100111110010000101011011000100100110101100100000  to  address 00000 (from port 0) during cycle 183 (915ns - 920ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 0011011011110001100111110010000101011011000100100110101100100000 from address 00000 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 0011011011110001100111110010000101011011000100100110101100100000 from address 00000 (from port 0) during cycle 186 (930ns - 935ns)
*	Reading 0011011011110001100111110010000101011011000100100110101100100000 from address 00000 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 0011010001110011111110010111000111110000101101010111010001101111  to  address 00000 (from port 0) during cycle 189 (945ns - 950ns)
*	Reading 0011010001110011111110010111000111110000101101010111010001101111 from address 00000 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 0000010010001110010011011101110001011101110001000000011100000010  to  address 00000 (from port 0) during cycle 191 (955ns - 960ns)
*	Reading 0000010010001110010011011101110001011101110001000000011100000010 from address 00000 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing 0111101010100111111011001000010010101100011010111000011011111100  to  address 00000 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 0111101010100111111011001000010010101100011010111000011011111100 from address 00000 (from port 0) during cycle 195 (975ns - 980ns)
*	Writing 0010001111011111010010000011011000111001011101100010010110000101  to  address 00000 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Reading 0010001111011111010010000011011000111001011101100010010110000101 from address 00000 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 1000000110111101101101001110000101000111001111111011110111011011 from address 10010 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0.9 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0.9 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0.9 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0.9 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0.9 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0.9 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0.9 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0.9 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0.9 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0.9 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0.9 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0.9 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0.9 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0.9 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0.9 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0.9 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_40 Vdout0_40ck4 = 0.9 time = 25
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=25.025n

* CHECK dout0_41 Vdout0_41ck4 = 0 time = 25
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=25.025n

* CHECK dout0_42 Vdout0_42ck4 = 0.9 time = 25
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=25.025n

* CHECK dout0_43 Vdout0_43ck4 = 0.9 time = 25
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=25.025n

* CHECK dout0_44 Vdout0_44ck4 = 0.9 time = 25
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=25.025n

* CHECK dout0_45 Vdout0_45ck4 = 0.9 time = 25
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=25.025n

* CHECK dout0_46 Vdout0_46ck4 = 0 time = 25
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=25.025n

* CHECK dout0_47 Vdout0_47ck4 = 0.9 time = 25
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=25.025n

* CHECK dout0_48 Vdout0_48ck4 = 0.9 time = 25
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=25.025n

* CHECK dout0_49 Vdout0_49ck4 = 0 time = 25
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=25.025n

* CHECK dout0_50 Vdout0_50ck4 = 0.9 time = 25
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=25.025n

* CHECK dout0_51 Vdout0_51ck4 = 0 time = 25
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=25.025n

* CHECK dout0_52 Vdout0_52ck4 = 0 time = 25
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=25.025n

* CHECK dout0_53 Vdout0_53ck4 = 0 time = 25
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=25.025n

* CHECK dout0_54 Vdout0_54ck4 = 0.9 time = 25
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=25.025n

* CHECK dout0_55 Vdout0_55ck4 = 0.9 time = 25
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=25.025n

* CHECK dout0_56 Vdout0_56ck4 = 0 time = 25
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=25.025n

* CHECK dout0_57 Vdout0_57ck4 = 0 time = 25
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=25.025n

* CHECK dout0_58 Vdout0_58ck4 = 0 time = 25
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=25.025n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 25
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=25.025n

* CHECK dout0_60 Vdout0_60ck4 = 0.9 time = 25
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=25.025n

* CHECK dout0_61 Vdout0_61ck4 = 0 time = 25
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=25.025n

* CHECK dout0_62 Vdout0_62ck4 = 0 time = 25
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=25.025n

* CHECK dout0_63 Vdout0_63ck4 = 0 time = 25
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=25.025n

* CHECK dout0_0 Vdout0_0ck5 = 0.9 time = 30
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=30.025n

* CHECK dout0_1 Vdout0_1ck5 = 0 time = 30
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=30.025n

* CHECK dout0_2 Vdout0_2ck5 = 0.9 time = 30
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=30.025n

* CHECK dout0_3 Vdout0_3ck5 = 0 time = 30
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=30.025n

* CHECK dout0_4 Vdout0_4ck5 = 0.9 time = 30
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=30.025n

* CHECK dout0_5 Vdout0_5ck5 = 0.9 time = 30
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=30.025n

* CHECK dout0_6 Vdout0_6ck5 = 0.9 time = 30
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=30.025n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 30
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=30.025n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 30
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=30.025n

* CHECK dout0_9 Vdout0_9ck5 = 0.9 time = 30
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=30.025n

* CHECK dout0_10 Vdout0_10ck5 = 0 time = 30
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=30.025n

* CHECK dout0_11 Vdout0_11ck5 = 0.9 time = 30
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=30.025n

* CHECK dout0_12 Vdout0_12ck5 = 0.9 time = 30
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=30.025n

* CHECK dout0_13 Vdout0_13ck5 = 0 time = 30
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=30.025n

* CHECK dout0_14 Vdout0_14ck5 = 0.9 time = 30
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=30.025n

* CHECK dout0_15 Vdout0_15ck5 = 0.9 time = 30
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=30.025n

* CHECK dout0_16 Vdout0_16ck5 = 0 time = 30
.meas tran vdout0_16ck5 FIND v(dout0_16) AT=30.025n

* CHECK dout0_17 Vdout0_17ck5 = 0.9 time = 30
.meas tran vdout0_17ck5 FIND v(dout0_17) AT=30.025n

* CHECK dout0_18 Vdout0_18ck5 = 0.9 time = 30
.meas tran vdout0_18ck5 FIND v(dout0_18) AT=30.025n

* CHECK dout0_19 Vdout0_19ck5 = 0 time = 30
.meas tran vdout0_19ck5 FIND v(dout0_19) AT=30.025n

* CHECK dout0_20 Vdout0_20ck5 = 0 time = 30
.meas tran vdout0_20ck5 FIND v(dout0_20) AT=30.025n

* CHECK dout0_21 Vdout0_21ck5 = 0 time = 30
.meas tran vdout0_21ck5 FIND v(dout0_21) AT=30.025n

* CHECK dout0_22 Vdout0_22ck5 = 0.9 time = 30
.meas tran vdout0_22ck5 FIND v(dout0_22) AT=30.025n

* CHECK dout0_23 Vdout0_23ck5 = 0 time = 30
.meas tran vdout0_23ck5 FIND v(dout0_23) AT=30.025n

* CHECK dout0_24 Vdout0_24ck5 = 0.9 time = 30
.meas tran vdout0_24ck5 FIND v(dout0_24) AT=30.025n

* CHECK dout0_25 Vdout0_25ck5 = 0 time = 30
.meas tran vdout0_25ck5 FIND v(dout0_25) AT=30.025n

* CHECK dout0_26 Vdout0_26ck5 = 0.9 time = 30
.meas tran vdout0_26ck5 FIND v(dout0_26) AT=30.025n

* CHECK dout0_27 Vdout0_27ck5 = 0.9 time = 30
.meas tran vdout0_27ck5 FIND v(dout0_27) AT=30.025n

* CHECK dout0_28 Vdout0_28ck5 = 0 time = 30
.meas tran vdout0_28ck5 FIND v(dout0_28) AT=30.025n

* CHECK dout0_29 Vdout0_29ck5 = 0.9 time = 30
.meas tran vdout0_29ck5 FIND v(dout0_29) AT=30.025n

* CHECK dout0_30 Vdout0_30ck5 = 0 time = 30
.meas tran vdout0_30ck5 FIND v(dout0_30) AT=30.025n

* CHECK dout0_31 Vdout0_31ck5 = 0.9 time = 30
.meas tran vdout0_31ck5 FIND v(dout0_31) AT=30.025n

* CHECK dout0_32 Vdout0_32ck5 = 0 time = 30
.meas tran vdout0_32ck5 FIND v(dout0_32) AT=30.025n

* CHECK dout0_33 Vdout0_33ck5 = 0.9 time = 30
.meas tran vdout0_33ck5 FIND v(dout0_33) AT=30.025n

* CHECK dout0_34 Vdout0_34ck5 = 0.9 time = 30
.meas tran vdout0_34ck5 FIND v(dout0_34) AT=30.025n

* CHECK dout0_35 Vdout0_35ck5 = 0.9 time = 30
.meas tran vdout0_35ck5 FIND v(dout0_35) AT=30.025n

* CHECK dout0_36 Vdout0_36ck5 = 0 time = 30
.meas tran vdout0_36ck5 FIND v(dout0_36) AT=30.025n

* CHECK dout0_37 Vdout0_37ck5 = 0.9 time = 30
.meas tran vdout0_37ck5 FIND v(dout0_37) AT=30.025n

* CHECK dout0_38 Vdout0_38ck5 = 0 time = 30
.meas tran vdout0_38ck5 FIND v(dout0_38) AT=30.025n

* CHECK dout0_39 Vdout0_39ck5 = 0 time = 30
.meas tran vdout0_39ck5 FIND v(dout0_39) AT=30.025n

* CHECK dout0_40 Vdout0_40ck5 = 0.9 time = 30
.meas tran vdout0_40ck5 FIND v(dout0_40) AT=30.025n

* CHECK dout0_41 Vdout0_41ck5 = 0.9 time = 30
.meas tran vdout0_41ck5 FIND v(dout0_41) AT=30.025n

* CHECK dout0_42 Vdout0_42ck5 = 0.9 time = 30
.meas tran vdout0_42ck5 FIND v(dout0_42) AT=30.025n

* CHECK dout0_43 Vdout0_43ck5 = 0 time = 30
.meas tran vdout0_43ck5 FIND v(dout0_43) AT=30.025n

* CHECK dout0_44 Vdout0_44ck5 = 0.9 time = 30
.meas tran vdout0_44ck5 FIND v(dout0_44) AT=30.025n

* CHECK dout0_45 Vdout0_45ck5 = 0.9 time = 30
.meas tran vdout0_45ck5 FIND v(dout0_45) AT=30.025n

* CHECK dout0_46 Vdout0_46ck5 = 0 time = 30
.meas tran vdout0_46ck5 FIND v(dout0_46) AT=30.025n

* CHECK dout0_47 Vdout0_47ck5 = 0.9 time = 30
.meas tran vdout0_47ck5 FIND v(dout0_47) AT=30.025n

* CHECK dout0_48 Vdout0_48ck5 = 0 time = 30
.meas tran vdout0_48ck5 FIND v(dout0_48) AT=30.025n

* CHECK dout0_49 Vdout0_49ck5 = 0.9 time = 30
.meas tran vdout0_49ck5 FIND v(dout0_49) AT=30.025n

* CHECK dout0_50 Vdout0_50ck5 = 0 time = 30
.meas tran vdout0_50ck5 FIND v(dout0_50) AT=30.025n

* CHECK dout0_51 Vdout0_51ck5 = 0 time = 30
.meas tran vdout0_51ck5 FIND v(dout0_51) AT=30.025n

* CHECK dout0_52 Vdout0_52ck5 = 0 time = 30
.meas tran vdout0_52ck5 FIND v(dout0_52) AT=30.025n

* CHECK dout0_53 Vdout0_53ck5 = 0.9 time = 30
.meas tran vdout0_53ck5 FIND v(dout0_53) AT=30.025n

* CHECK dout0_54 Vdout0_54ck5 = 0.9 time = 30
.meas tran vdout0_54ck5 FIND v(dout0_54) AT=30.025n

* CHECK dout0_55 Vdout0_55ck5 = 0 time = 30
.meas tran vdout0_55ck5 FIND v(dout0_55) AT=30.025n

* CHECK dout0_56 Vdout0_56ck5 = 0.9 time = 30
.meas tran vdout0_56ck5 FIND v(dout0_56) AT=30.025n

* CHECK dout0_57 Vdout0_57ck5 = 0.9 time = 30
.meas tran vdout0_57ck5 FIND v(dout0_57) AT=30.025n

* CHECK dout0_58 Vdout0_58ck5 = 0 time = 30
.meas tran vdout0_58ck5 FIND v(dout0_58) AT=30.025n

* CHECK dout0_59 Vdout0_59ck5 = 0 time = 30
.meas tran vdout0_59ck5 FIND v(dout0_59) AT=30.025n

* CHECK dout0_60 Vdout0_60ck5 = 0.9 time = 30
.meas tran vdout0_60ck5 FIND v(dout0_60) AT=30.025n

* CHECK dout0_61 Vdout0_61ck5 = 0.9 time = 30
.meas tran vdout0_61ck5 FIND v(dout0_61) AT=30.025n

* CHECK dout0_62 Vdout0_62ck5 = 0.9 time = 30
.meas tran vdout0_62ck5 FIND v(dout0_62) AT=30.025n

* CHECK dout0_63 Vdout0_63ck5 = 0 time = 30
.meas tran vdout0_63ck5 FIND v(dout0_63) AT=30.025n

* CHECK dout0_0 Vdout0_0ck6 = 0.9 time = 35
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=35.025n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 35
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=35.025n

* CHECK dout0_2 Vdout0_2ck6 = 0.9 time = 35
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=35.025n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 35
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=35.025n

* CHECK dout0_4 Vdout0_4ck6 = 0.9 time = 35
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=35.025n

* CHECK dout0_5 Vdout0_5ck6 = 0.9 time = 35
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=35.025n

* CHECK dout0_6 Vdout0_6ck6 = 0.9 time = 35
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=35.025n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 35
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=35.025n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 35
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=35.025n

* CHECK dout0_9 Vdout0_9ck6 = 0.9 time = 35
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=35.025n

* CHECK dout0_10 Vdout0_10ck6 = 0 time = 35
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=35.025n

* CHECK dout0_11 Vdout0_11ck6 = 0.9 time = 35
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=35.025n

* CHECK dout0_12 Vdout0_12ck6 = 0.9 time = 35
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=35.025n

* CHECK dout0_13 Vdout0_13ck6 = 0 time = 35
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=35.025n

* CHECK dout0_14 Vdout0_14ck6 = 0.9 time = 35
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=35.025n

* CHECK dout0_15 Vdout0_15ck6 = 0.9 time = 35
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=35.025n

* CHECK dout0_16 Vdout0_16ck6 = 0 time = 35
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=35.025n

* CHECK dout0_17 Vdout0_17ck6 = 0.9 time = 35
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=35.025n

* CHECK dout0_18 Vdout0_18ck6 = 0.9 time = 35
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=35.025n

* CHECK dout0_19 Vdout0_19ck6 = 0 time = 35
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=35.025n

* CHECK dout0_20 Vdout0_20ck6 = 0 time = 35
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=35.025n

* CHECK dout0_21 Vdout0_21ck6 = 0 time = 35
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=35.025n

* CHECK dout0_22 Vdout0_22ck6 = 0.9 time = 35
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=35.025n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 35
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=35.025n

* CHECK dout0_24 Vdout0_24ck6 = 0.9 time = 35
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=35.025n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 35
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=35.025n

* CHECK dout0_26 Vdout0_26ck6 = 0.9 time = 35
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=35.025n

* CHECK dout0_27 Vdout0_27ck6 = 0.9 time = 35
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=35.025n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 35
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=35.025n

* CHECK dout0_29 Vdout0_29ck6 = 0.9 time = 35
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=35.025n

* CHECK dout0_30 Vdout0_30ck6 = 0 time = 35
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=35.025n

* CHECK dout0_31 Vdout0_31ck6 = 0.9 time = 35
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=35.025n

* CHECK dout0_32 Vdout0_32ck6 = 0 time = 35
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=35.025n

* CHECK dout0_33 Vdout0_33ck6 = 0.9 time = 35
.meas tran vdout0_33ck6 FIND v(dout0_33) AT=35.025n

* CHECK dout0_34 Vdout0_34ck6 = 0.9 time = 35
.meas tran vdout0_34ck6 FIND v(dout0_34) AT=35.025n

* CHECK dout0_35 Vdout0_35ck6 = 0.9 time = 35
.meas tran vdout0_35ck6 FIND v(dout0_35) AT=35.025n

* CHECK dout0_36 Vdout0_36ck6 = 0 time = 35
.meas tran vdout0_36ck6 FIND v(dout0_36) AT=35.025n

* CHECK dout0_37 Vdout0_37ck6 = 0.9 time = 35
.meas tran vdout0_37ck6 FIND v(dout0_37) AT=35.025n

* CHECK dout0_38 Vdout0_38ck6 = 0 time = 35
.meas tran vdout0_38ck6 FIND v(dout0_38) AT=35.025n

* CHECK dout0_39 Vdout0_39ck6 = 0 time = 35
.meas tran vdout0_39ck6 FIND v(dout0_39) AT=35.025n

* CHECK dout0_40 Vdout0_40ck6 = 0.9 time = 35
.meas tran vdout0_40ck6 FIND v(dout0_40) AT=35.025n

* CHECK dout0_41 Vdout0_41ck6 = 0.9 time = 35
.meas tran vdout0_41ck6 FIND v(dout0_41) AT=35.025n

* CHECK dout0_42 Vdout0_42ck6 = 0.9 time = 35
.meas tran vdout0_42ck6 FIND v(dout0_42) AT=35.025n

* CHECK dout0_43 Vdout0_43ck6 = 0 time = 35
.meas tran vdout0_43ck6 FIND v(dout0_43) AT=35.025n

* CHECK dout0_44 Vdout0_44ck6 = 0.9 time = 35
.meas tran vdout0_44ck6 FIND v(dout0_44) AT=35.025n

* CHECK dout0_45 Vdout0_45ck6 = 0.9 time = 35
.meas tran vdout0_45ck6 FIND v(dout0_45) AT=35.025n

* CHECK dout0_46 Vdout0_46ck6 = 0 time = 35
.meas tran vdout0_46ck6 FIND v(dout0_46) AT=35.025n

* CHECK dout0_47 Vdout0_47ck6 = 0.9 time = 35
.meas tran vdout0_47ck6 FIND v(dout0_47) AT=35.025n

* CHECK dout0_48 Vdout0_48ck6 = 0 time = 35
.meas tran vdout0_48ck6 FIND v(dout0_48) AT=35.025n

* CHECK dout0_49 Vdout0_49ck6 = 0.9 time = 35
.meas tran vdout0_49ck6 FIND v(dout0_49) AT=35.025n

* CHECK dout0_50 Vdout0_50ck6 = 0 time = 35
.meas tran vdout0_50ck6 FIND v(dout0_50) AT=35.025n

* CHECK dout0_51 Vdout0_51ck6 = 0 time = 35
.meas tran vdout0_51ck6 FIND v(dout0_51) AT=35.025n

* CHECK dout0_52 Vdout0_52ck6 = 0 time = 35
.meas tran vdout0_52ck6 FIND v(dout0_52) AT=35.025n

* CHECK dout0_53 Vdout0_53ck6 = 0.9 time = 35
.meas tran vdout0_53ck6 FIND v(dout0_53) AT=35.025n

* CHECK dout0_54 Vdout0_54ck6 = 0.9 time = 35
.meas tran vdout0_54ck6 FIND v(dout0_54) AT=35.025n

* CHECK dout0_55 Vdout0_55ck6 = 0 time = 35
.meas tran vdout0_55ck6 FIND v(dout0_55) AT=35.025n

* CHECK dout0_56 Vdout0_56ck6 = 0.9 time = 35
.meas tran vdout0_56ck6 FIND v(dout0_56) AT=35.025n

* CHECK dout0_57 Vdout0_57ck6 = 0.9 time = 35
.meas tran vdout0_57ck6 FIND v(dout0_57) AT=35.025n

* CHECK dout0_58 Vdout0_58ck6 = 0 time = 35
.meas tran vdout0_58ck6 FIND v(dout0_58) AT=35.025n

* CHECK dout0_59 Vdout0_59ck6 = 0 time = 35
.meas tran vdout0_59ck6 FIND v(dout0_59) AT=35.025n

* CHECK dout0_60 Vdout0_60ck6 = 0.9 time = 35
.meas tran vdout0_60ck6 FIND v(dout0_60) AT=35.025n

* CHECK dout0_61 Vdout0_61ck6 = 0.9 time = 35
.meas tran vdout0_61ck6 FIND v(dout0_61) AT=35.025n

* CHECK dout0_62 Vdout0_62ck6 = 0.9 time = 35
.meas tran vdout0_62ck6 FIND v(dout0_62) AT=35.025n

* CHECK dout0_63 Vdout0_63ck6 = 0 time = 35
.meas tran vdout0_63ck6 FIND v(dout0_63) AT=35.025n

* CHECK dout0_0 Vdout0_0ck8 = 0.9 time = 45
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=45.025n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 45
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=45.025n

* CHECK dout0_2 Vdout0_2ck8 = 0 time = 45
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=45.025n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 45
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=45.025n

* CHECK dout0_4 Vdout0_4ck8 = 0 time = 45
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=45.025n

* CHECK dout0_5 Vdout0_5ck8 = 0.9 time = 45
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=45.025n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 45
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=45.025n

* CHECK dout0_7 Vdout0_7ck8 = 0.9 time = 45
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=45.025n

* CHECK dout0_8 Vdout0_8ck8 = 0.9 time = 45
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=45.025n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 45
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=45.025n

* CHECK dout0_10 Vdout0_10ck8 = 0.9 time = 45
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=45.025n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 45
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=45.025n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 45
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=45.025n

* CHECK dout0_13 Vdout0_13ck8 = 0.9 time = 45
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=45.025n

* CHECK dout0_14 Vdout0_14ck8 = 0 time = 45
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=45.025n

* CHECK dout0_15 Vdout0_15ck8 = 0.9 time = 45
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=45.025n

* CHECK dout0_16 Vdout0_16ck8 = 0 time = 45
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=45.025n

* CHECK dout0_17 Vdout0_17ck8 = 0 time = 45
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=45.025n

* CHECK dout0_18 Vdout0_18ck8 = 0 time = 45
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=45.025n

* CHECK dout0_19 Vdout0_19ck8 = 0 time = 45
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=45.025n

* CHECK dout0_20 Vdout0_20ck8 = 0 time = 45
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=45.025n

* CHECK dout0_21 Vdout0_21ck8 = 0.9 time = 45
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=45.025n

* CHECK dout0_22 Vdout0_22ck8 = 0 time = 45
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=45.025n

* CHECK dout0_23 Vdout0_23ck8 = 0 time = 45
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=45.025n

* CHECK dout0_24 Vdout0_24ck8 = 0 time = 45
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=45.025n

* CHECK dout0_25 Vdout0_25ck8 = 0.9 time = 45
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=45.025n

* CHECK dout0_26 Vdout0_26ck8 = 0.9 time = 45
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=45.025n

* CHECK dout0_27 Vdout0_27ck8 = 0.9 time = 45
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=45.025n

* CHECK dout0_28 Vdout0_28ck8 = 0.9 time = 45
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=45.025n

* CHECK dout0_29 Vdout0_29ck8 = 0 time = 45
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=45.025n

* CHECK dout0_30 Vdout0_30ck8 = 0.9 time = 45
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=45.025n

* CHECK dout0_31 Vdout0_31ck8 = 0 time = 45
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=45.025n

* CHECK dout0_32 Vdout0_32ck8 = 0 time = 45
.meas tran vdout0_32ck8 FIND v(dout0_32) AT=45.025n

* CHECK dout0_33 Vdout0_33ck8 = 0 time = 45
.meas tran vdout0_33ck8 FIND v(dout0_33) AT=45.025n

* CHECK dout0_34 Vdout0_34ck8 = 0 time = 45
.meas tran vdout0_34ck8 FIND v(dout0_34) AT=45.025n

* CHECK dout0_35 Vdout0_35ck8 = 0.9 time = 45
.meas tran vdout0_35ck8 FIND v(dout0_35) AT=45.025n

* CHECK dout0_36 Vdout0_36ck8 = 0.9 time = 45
.meas tran vdout0_36ck8 FIND v(dout0_36) AT=45.025n

* CHECK dout0_37 Vdout0_37ck8 = 0 time = 45
.meas tran vdout0_37ck8 FIND v(dout0_37) AT=45.025n

* CHECK dout0_38 Vdout0_38ck8 = 0.9 time = 45
.meas tran vdout0_38ck8 FIND v(dout0_38) AT=45.025n

* CHECK dout0_39 Vdout0_39ck8 = 0 time = 45
.meas tran vdout0_39ck8 FIND v(dout0_39) AT=45.025n

* CHECK dout0_40 Vdout0_40ck8 = 0.9 time = 45
.meas tran vdout0_40ck8 FIND v(dout0_40) AT=45.025n

* CHECK dout0_41 Vdout0_41ck8 = 0 time = 45
.meas tran vdout0_41ck8 FIND v(dout0_41) AT=45.025n

* CHECK dout0_42 Vdout0_42ck8 = 0.9 time = 45
.meas tran vdout0_42ck8 FIND v(dout0_42) AT=45.025n

* CHECK dout0_43 Vdout0_43ck8 = 0.9 time = 45
.meas tran vdout0_43ck8 FIND v(dout0_43) AT=45.025n

* CHECK dout0_44 Vdout0_44ck8 = 0.9 time = 45
.meas tran vdout0_44ck8 FIND v(dout0_44) AT=45.025n

* CHECK dout0_45 Vdout0_45ck8 = 0.9 time = 45
.meas tran vdout0_45ck8 FIND v(dout0_45) AT=45.025n

* CHECK dout0_46 Vdout0_46ck8 = 0 time = 45
.meas tran vdout0_46ck8 FIND v(dout0_46) AT=45.025n

* CHECK dout0_47 Vdout0_47ck8 = 0.9 time = 45
.meas tran vdout0_47ck8 FIND v(dout0_47) AT=45.025n

* CHECK dout0_48 Vdout0_48ck8 = 0.9 time = 45
.meas tran vdout0_48ck8 FIND v(dout0_48) AT=45.025n

* CHECK dout0_49 Vdout0_49ck8 = 0 time = 45
.meas tran vdout0_49ck8 FIND v(dout0_49) AT=45.025n

* CHECK dout0_50 Vdout0_50ck8 = 0.9 time = 45
.meas tran vdout0_50ck8 FIND v(dout0_50) AT=45.025n

* CHECK dout0_51 Vdout0_51ck8 = 0 time = 45
.meas tran vdout0_51ck8 FIND v(dout0_51) AT=45.025n

* CHECK dout0_52 Vdout0_52ck8 = 0 time = 45
.meas tran vdout0_52ck8 FIND v(dout0_52) AT=45.025n

* CHECK dout0_53 Vdout0_53ck8 = 0 time = 45
.meas tran vdout0_53ck8 FIND v(dout0_53) AT=45.025n

* CHECK dout0_54 Vdout0_54ck8 = 0.9 time = 45
.meas tran vdout0_54ck8 FIND v(dout0_54) AT=45.025n

* CHECK dout0_55 Vdout0_55ck8 = 0.9 time = 45
.meas tran vdout0_55ck8 FIND v(dout0_55) AT=45.025n

* CHECK dout0_56 Vdout0_56ck8 = 0 time = 45
.meas tran vdout0_56ck8 FIND v(dout0_56) AT=45.025n

* CHECK dout0_57 Vdout0_57ck8 = 0 time = 45
.meas tran vdout0_57ck8 FIND v(dout0_57) AT=45.025n

* CHECK dout0_58 Vdout0_58ck8 = 0 time = 45
.meas tran vdout0_58ck8 FIND v(dout0_58) AT=45.025n

* CHECK dout0_59 Vdout0_59ck8 = 0 time = 45
.meas tran vdout0_59ck8 FIND v(dout0_59) AT=45.025n

* CHECK dout0_60 Vdout0_60ck8 = 0.9 time = 45
.meas tran vdout0_60ck8 FIND v(dout0_60) AT=45.025n

* CHECK dout0_61 Vdout0_61ck8 = 0 time = 45
.meas tran vdout0_61ck8 FIND v(dout0_61) AT=45.025n

* CHECK dout0_62 Vdout0_62ck8 = 0 time = 45
.meas tran vdout0_62ck8 FIND v(dout0_62) AT=45.025n

* CHECK dout0_63 Vdout0_63ck8 = 0 time = 45
.meas tran vdout0_63ck8 FIND v(dout0_63) AT=45.025n

* CHECK dout0_0 Vdout0_0ck10 = 0.9 time = 55
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=55.025n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 55
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=55.025n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 55
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=55.025n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 55
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=55.025n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 55
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=55.025n

* CHECK dout0_5 Vdout0_5ck10 = 0.9 time = 55
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=55.025n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 55
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=55.025n

* CHECK dout0_7 Vdout0_7ck10 = 0.9 time = 55
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=55.025n

* CHECK dout0_8 Vdout0_8ck10 = 0.9 time = 55
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=55.025n

* CHECK dout0_9 Vdout0_9ck10 = 0 time = 55
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=55.025n

* CHECK dout0_10 Vdout0_10ck10 = 0.9 time = 55
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=55.025n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 55
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=55.025n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 55
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=55.025n

* CHECK dout0_13 Vdout0_13ck10 = 0.9 time = 55
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=55.025n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 55
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=55.025n

* CHECK dout0_15 Vdout0_15ck10 = 0.9 time = 55
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=55.025n

* CHECK dout0_16 Vdout0_16ck10 = 0 time = 55
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=55.025n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 55
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=55.025n

* CHECK dout0_18 Vdout0_18ck10 = 0 time = 55
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=55.025n

* CHECK dout0_19 Vdout0_19ck10 = 0 time = 55
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=55.025n

* CHECK dout0_20 Vdout0_20ck10 = 0 time = 55
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=55.025n

* CHECK dout0_21 Vdout0_21ck10 = 0.9 time = 55
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=55.025n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 55
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=55.025n

* CHECK dout0_23 Vdout0_23ck10 = 0 time = 55
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=55.025n

* CHECK dout0_24 Vdout0_24ck10 = 0 time = 55
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=55.025n

* CHECK dout0_25 Vdout0_25ck10 = 0.9 time = 55
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=55.025n

* CHECK dout0_26 Vdout0_26ck10 = 0.9 time = 55
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=55.025n

* CHECK dout0_27 Vdout0_27ck10 = 0.9 time = 55
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=55.025n

* CHECK dout0_28 Vdout0_28ck10 = 0.9 time = 55
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=55.025n

* CHECK dout0_29 Vdout0_29ck10 = 0 time = 55
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=55.025n

* CHECK dout0_30 Vdout0_30ck10 = 0.9 time = 55
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=55.025n

* CHECK dout0_31 Vdout0_31ck10 = 0 time = 55
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=55.025n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 55
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=55.025n

* CHECK dout0_33 Vdout0_33ck10 = 0 time = 55
.meas tran vdout0_33ck10 FIND v(dout0_33) AT=55.025n

* CHECK dout0_34 Vdout0_34ck10 = 0 time = 55
.meas tran vdout0_34ck10 FIND v(dout0_34) AT=55.025n

* CHECK dout0_35 Vdout0_35ck10 = 0.9 time = 55
.meas tran vdout0_35ck10 FIND v(dout0_35) AT=55.025n

* CHECK dout0_36 Vdout0_36ck10 = 0.9 time = 55
.meas tran vdout0_36ck10 FIND v(dout0_36) AT=55.025n

* CHECK dout0_37 Vdout0_37ck10 = 0 time = 55
.meas tran vdout0_37ck10 FIND v(dout0_37) AT=55.025n

* CHECK dout0_38 Vdout0_38ck10 = 0.9 time = 55
.meas tran vdout0_38ck10 FIND v(dout0_38) AT=55.025n

* CHECK dout0_39 Vdout0_39ck10 = 0 time = 55
.meas tran vdout0_39ck10 FIND v(dout0_39) AT=55.025n

* CHECK dout0_40 Vdout0_40ck10 = 0.9 time = 55
.meas tran vdout0_40ck10 FIND v(dout0_40) AT=55.025n

* CHECK dout0_41 Vdout0_41ck10 = 0 time = 55
.meas tran vdout0_41ck10 FIND v(dout0_41) AT=55.025n

* CHECK dout0_42 Vdout0_42ck10 = 0.9 time = 55
.meas tran vdout0_42ck10 FIND v(dout0_42) AT=55.025n

* CHECK dout0_43 Vdout0_43ck10 = 0.9 time = 55
.meas tran vdout0_43ck10 FIND v(dout0_43) AT=55.025n

* CHECK dout0_44 Vdout0_44ck10 = 0.9 time = 55
.meas tran vdout0_44ck10 FIND v(dout0_44) AT=55.025n

* CHECK dout0_45 Vdout0_45ck10 = 0.9 time = 55
.meas tran vdout0_45ck10 FIND v(dout0_45) AT=55.025n

* CHECK dout0_46 Vdout0_46ck10 = 0 time = 55
.meas tran vdout0_46ck10 FIND v(dout0_46) AT=55.025n

* CHECK dout0_47 Vdout0_47ck10 = 0.9 time = 55
.meas tran vdout0_47ck10 FIND v(dout0_47) AT=55.025n

* CHECK dout0_48 Vdout0_48ck10 = 0.9 time = 55
.meas tran vdout0_48ck10 FIND v(dout0_48) AT=55.025n

* CHECK dout0_49 Vdout0_49ck10 = 0 time = 55
.meas tran vdout0_49ck10 FIND v(dout0_49) AT=55.025n

* CHECK dout0_50 Vdout0_50ck10 = 0.9 time = 55
.meas tran vdout0_50ck10 FIND v(dout0_50) AT=55.025n

* CHECK dout0_51 Vdout0_51ck10 = 0 time = 55
.meas tran vdout0_51ck10 FIND v(dout0_51) AT=55.025n

* CHECK dout0_52 Vdout0_52ck10 = 0 time = 55
.meas tran vdout0_52ck10 FIND v(dout0_52) AT=55.025n

* CHECK dout0_53 Vdout0_53ck10 = 0 time = 55
.meas tran vdout0_53ck10 FIND v(dout0_53) AT=55.025n

* CHECK dout0_54 Vdout0_54ck10 = 0.9 time = 55
.meas tran vdout0_54ck10 FIND v(dout0_54) AT=55.025n

* CHECK dout0_55 Vdout0_55ck10 = 0.9 time = 55
.meas tran vdout0_55ck10 FIND v(dout0_55) AT=55.025n

* CHECK dout0_56 Vdout0_56ck10 = 0 time = 55
.meas tran vdout0_56ck10 FIND v(dout0_56) AT=55.025n

* CHECK dout0_57 Vdout0_57ck10 = 0 time = 55
.meas tran vdout0_57ck10 FIND v(dout0_57) AT=55.025n

* CHECK dout0_58 Vdout0_58ck10 = 0 time = 55
.meas tran vdout0_58ck10 FIND v(dout0_58) AT=55.025n

* CHECK dout0_59 Vdout0_59ck10 = 0 time = 55
.meas tran vdout0_59ck10 FIND v(dout0_59) AT=55.025n

* CHECK dout0_60 Vdout0_60ck10 = 0.9 time = 55
.meas tran vdout0_60ck10 FIND v(dout0_60) AT=55.025n

* CHECK dout0_61 Vdout0_61ck10 = 0 time = 55
.meas tran vdout0_61ck10 FIND v(dout0_61) AT=55.025n

* CHECK dout0_62 Vdout0_62ck10 = 0 time = 55
.meas tran vdout0_62ck10 FIND v(dout0_62) AT=55.025n

* CHECK dout0_63 Vdout0_63ck10 = 0 time = 55
.meas tran vdout0_63ck10 FIND v(dout0_63) AT=55.025n

* CHECK dout0_0 Vdout0_0ck12 = 0.9 time = 65
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=65.025n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 65
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=65.025n

* CHECK dout0_2 Vdout0_2ck12 = 0.9 time = 65
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=65.025n

* CHECK dout0_3 Vdout0_3ck12 = 0.9 time = 65
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=65.025n

* CHECK dout0_4 Vdout0_4ck12 = 0.9 time = 65
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=65.025n

* CHECK dout0_5 Vdout0_5ck12 = 0.9 time = 65
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=65.025n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 65
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=65.025n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 65
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=65.025n

* CHECK dout0_8 Vdout0_8ck12 = 0.9 time = 65
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=65.025n

* CHECK dout0_9 Vdout0_9ck12 = 0.9 time = 65
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=65.025n

* CHECK dout0_10 Vdout0_10ck12 = 0.9 time = 65
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=65.025n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 65
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=65.025n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 65
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=65.025n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 65
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=65.025n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 65
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=65.025n

* CHECK dout0_15 Vdout0_15ck12 = 0 time = 65
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=65.025n

* CHECK dout0_16 Vdout0_16ck12 = 0.9 time = 65
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=65.025n

* CHECK dout0_17 Vdout0_17ck12 = 0.9 time = 65
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=65.025n

* CHECK dout0_18 Vdout0_18ck12 = 0.9 time = 65
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=65.025n

* CHECK dout0_19 Vdout0_19ck12 = 0.9 time = 65
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=65.025n

* CHECK dout0_20 Vdout0_20ck12 = 0.9 time = 65
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=65.025n

* CHECK dout0_21 Vdout0_21ck12 = 0.9 time = 65
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=65.025n

* CHECK dout0_22 Vdout0_22ck12 = 0 time = 65
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=65.025n

* CHECK dout0_23 Vdout0_23ck12 = 0.9 time = 65
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=65.025n

* CHECK dout0_24 Vdout0_24ck12 = 0.9 time = 65
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=65.025n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 65
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=65.025n

* CHECK dout0_26 Vdout0_26ck12 = 0 time = 65
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=65.025n

* CHECK dout0_27 Vdout0_27ck12 = 0 time = 65
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=65.025n

* CHECK dout0_28 Vdout0_28ck12 = 0 time = 65
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=65.025n

* CHECK dout0_29 Vdout0_29ck12 = 0.9 time = 65
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=65.025n

* CHECK dout0_30 Vdout0_30ck12 = 0 time = 65
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=65.025n

* CHECK dout0_31 Vdout0_31ck12 = 0.9 time = 65
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=65.025n

* CHECK dout0_32 Vdout0_32ck12 = 0 time = 65
.meas tran vdout0_32ck12 FIND v(dout0_32) AT=65.025n

* CHECK dout0_33 Vdout0_33ck12 = 0 time = 65
.meas tran vdout0_33ck12 FIND v(dout0_33) AT=65.025n

* CHECK dout0_34 Vdout0_34ck12 = 0.9 time = 65
.meas tran vdout0_34ck12 FIND v(dout0_34) AT=65.025n

* CHECK dout0_35 Vdout0_35ck12 = 0 time = 65
.meas tran vdout0_35ck12 FIND v(dout0_35) AT=65.025n

* CHECK dout0_36 Vdout0_36ck12 = 0 time = 65
.meas tran vdout0_36ck12 FIND v(dout0_36) AT=65.025n

* CHECK dout0_37 Vdout0_37ck12 = 0 time = 65
.meas tran vdout0_37ck12 FIND v(dout0_37) AT=65.025n

* CHECK dout0_38 Vdout0_38ck12 = 0 time = 65
.meas tran vdout0_38ck12 FIND v(dout0_38) AT=65.025n

* CHECK dout0_39 Vdout0_39ck12 = 0.9 time = 65
.meas tran vdout0_39ck12 FIND v(dout0_39) AT=65.025n

* CHECK dout0_40 Vdout0_40ck12 = 0 time = 65
.meas tran vdout0_40ck12 FIND v(dout0_40) AT=65.025n

* CHECK dout0_41 Vdout0_41ck12 = 0.9 time = 65
.meas tran vdout0_41ck12 FIND v(dout0_41) AT=65.025n

* CHECK dout0_42 Vdout0_42ck12 = 0.9 time = 65
.meas tran vdout0_42ck12 FIND v(dout0_42) AT=65.025n

* CHECK dout0_43 Vdout0_43ck12 = 0 time = 65
.meas tran vdout0_43ck12 FIND v(dout0_43) AT=65.025n

* CHECK dout0_44 Vdout0_44ck12 = 0.9 time = 65
.meas tran vdout0_44ck12 FIND v(dout0_44) AT=65.025n

* CHECK dout0_45 Vdout0_45ck12 = 0 time = 65
.meas tran vdout0_45ck12 FIND v(dout0_45) AT=65.025n

* CHECK dout0_46 Vdout0_46ck12 = 0.9 time = 65
.meas tran vdout0_46ck12 FIND v(dout0_46) AT=65.025n

* CHECK dout0_47 Vdout0_47ck12 = 0.9 time = 65
.meas tran vdout0_47ck12 FIND v(dout0_47) AT=65.025n

* CHECK dout0_48 Vdout0_48ck12 = 0 time = 65
.meas tran vdout0_48ck12 FIND v(dout0_48) AT=65.025n

* CHECK dout0_49 Vdout0_49ck12 = 0 time = 65
.meas tran vdout0_49ck12 FIND v(dout0_49) AT=65.025n

* CHECK dout0_50 Vdout0_50ck12 = 0.9 time = 65
.meas tran vdout0_50ck12 FIND v(dout0_50) AT=65.025n

* CHECK dout0_51 Vdout0_51ck12 = 0 time = 65
.meas tran vdout0_51ck12 FIND v(dout0_51) AT=65.025n

* CHECK dout0_52 Vdout0_52ck12 = 0.9 time = 65
.meas tran vdout0_52ck12 FIND v(dout0_52) AT=65.025n

* CHECK dout0_53 Vdout0_53ck12 = 0.9 time = 65
.meas tran vdout0_53ck12 FIND v(dout0_53) AT=65.025n

* CHECK dout0_54 Vdout0_54ck12 = 0 time = 65
.meas tran vdout0_54ck12 FIND v(dout0_54) AT=65.025n

* CHECK dout0_55 Vdout0_55ck12 = 0.9 time = 65
.meas tran vdout0_55ck12 FIND v(dout0_55) AT=65.025n

* CHECK dout0_56 Vdout0_56ck12 = 0 time = 65
.meas tran vdout0_56ck12 FIND v(dout0_56) AT=65.025n

* CHECK dout0_57 Vdout0_57ck12 = 0 time = 65
.meas tran vdout0_57ck12 FIND v(dout0_57) AT=65.025n

* CHECK dout0_58 Vdout0_58ck12 = 0 time = 65
.meas tran vdout0_58ck12 FIND v(dout0_58) AT=65.025n

* CHECK dout0_59 Vdout0_59ck12 = 0 time = 65
.meas tran vdout0_59ck12 FIND v(dout0_59) AT=65.025n

* CHECK dout0_60 Vdout0_60ck12 = 0.9 time = 65
.meas tran vdout0_60ck12 FIND v(dout0_60) AT=65.025n

* CHECK dout0_61 Vdout0_61ck12 = 0 time = 65
.meas tran vdout0_61ck12 FIND v(dout0_61) AT=65.025n

* CHECK dout0_62 Vdout0_62ck12 = 0 time = 65
.meas tran vdout0_62ck12 FIND v(dout0_62) AT=65.025n

* CHECK dout0_63 Vdout0_63ck12 = 0.9 time = 65
.meas tran vdout0_63ck12 FIND v(dout0_63) AT=65.025n

* CHECK dout0_0 Vdout0_0ck13 = 0.9 time = 70
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=70.025n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 70
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=70.025n

* CHECK dout0_2 Vdout0_2ck13 = 0.9 time = 70
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=70.025n

* CHECK dout0_3 Vdout0_3ck13 = 0.9 time = 70
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=70.025n

* CHECK dout0_4 Vdout0_4ck13 = 0.9 time = 70
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=70.025n

* CHECK dout0_5 Vdout0_5ck13 = 0.9 time = 70
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=70.025n

* CHECK dout0_6 Vdout0_6ck13 = 0 time = 70
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=70.025n

* CHECK dout0_7 Vdout0_7ck13 = 0 time = 70
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=70.025n

* CHECK dout0_8 Vdout0_8ck13 = 0.9 time = 70
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=70.025n

* CHECK dout0_9 Vdout0_9ck13 = 0.9 time = 70
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=70.025n

* CHECK dout0_10 Vdout0_10ck13 = 0.9 time = 70
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=70.025n

* CHECK dout0_11 Vdout0_11ck13 = 0 time = 70
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=70.025n

* CHECK dout0_12 Vdout0_12ck13 = 0 time = 70
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=70.025n

* CHECK dout0_13 Vdout0_13ck13 = 0 time = 70
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=70.025n

* CHECK dout0_14 Vdout0_14ck13 = 0 time = 70
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=70.025n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 70
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=70.025n

* CHECK dout0_16 Vdout0_16ck13 = 0.9 time = 70
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=70.025n

* CHECK dout0_17 Vdout0_17ck13 = 0.9 time = 70
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=70.025n

* CHECK dout0_18 Vdout0_18ck13 = 0.9 time = 70
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=70.025n

* CHECK dout0_19 Vdout0_19ck13 = 0.9 time = 70
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=70.025n

* CHECK dout0_20 Vdout0_20ck13 = 0.9 time = 70
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=70.025n

* CHECK dout0_21 Vdout0_21ck13 = 0.9 time = 70
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=70.025n

* CHECK dout0_22 Vdout0_22ck13 = 0 time = 70
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=70.025n

* CHECK dout0_23 Vdout0_23ck13 = 0.9 time = 70
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=70.025n

* CHECK dout0_24 Vdout0_24ck13 = 0.9 time = 70
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=70.025n

* CHECK dout0_25 Vdout0_25ck13 = 0 time = 70
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=70.025n

* CHECK dout0_26 Vdout0_26ck13 = 0 time = 70
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=70.025n

* CHECK dout0_27 Vdout0_27ck13 = 0 time = 70
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=70.025n

* CHECK dout0_28 Vdout0_28ck13 = 0 time = 70
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=70.025n

* CHECK dout0_29 Vdout0_29ck13 = 0.9 time = 70
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=70.025n

* CHECK dout0_30 Vdout0_30ck13 = 0 time = 70
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=70.025n

* CHECK dout0_31 Vdout0_31ck13 = 0.9 time = 70
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=70.025n

* CHECK dout0_32 Vdout0_32ck13 = 0 time = 70
.meas tran vdout0_32ck13 FIND v(dout0_32) AT=70.025n

* CHECK dout0_33 Vdout0_33ck13 = 0 time = 70
.meas tran vdout0_33ck13 FIND v(dout0_33) AT=70.025n

* CHECK dout0_34 Vdout0_34ck13 = 0.9 time = 70
.meas tran vdout0_34ck13 FIND v(dout0_34) AT=70.025n

* CHECK dout0_35 Vdout0_35ck13 = 0 time = 70
.meas tran vdout0_35ck13 FIND v(dout0_35) AT=70.025n

* CHECK dout0_36 Vdout0_36ck13 = 0 time = 70
.meas tran vdout0_36ck13 FIND v(dout0_36) AT=70.025n

* CHECK dout0_37 Vdout0_37ck13 = 0 time = 70
.meas tran vdout0_37ck13 FIND v(dout0_37) AT=70.025n

* CHECK dout0_38 Vdout0_38ck13 = 0 time = 70
.meas tran vdout0_38ck13 FIND v(dout0_38) AT=70.025n

* CHECK dout0_39 Vdout0_39ck13 = 0.9 time = 70
.meas tran vdout0_39ck13 FIND v(dout0_39) AT=70.025n

* CHECK dout0_40 Vdout0_40ck13 = 0 time = 70
.meas tran vdout0_40ck13 FIND v(dout0_40) AT=70.025n

* CHECK dout0_41 Vdout0_41ck13 = 0.9 time = 70
.meas tran vdout0_41ck13 FIND v(dout0_41) AT=70.025n

* CHECK dout0_42 Vdout0_42ck13 = 0.9 time = 70
.meas tran vdout0_42ck13 FIND v(dout0_42) AT=70.025n

* CHECK dout0_43 Vdout0_43ck13 = 0 time = 70
.meas tran vdout0_43ck13 FIND v(dout0_43) AT=70.025n

* CHECK dout0_44 Vdout0_44ck13 = 0.9 time = 70
.meas tran vdout0_44ck13 FIND v(dout0_44) AT=70.025n

* CHECK dout0_45 Vdout0_45ck13 = 0 time = 70
.meas tran vdout0_45ck13 FIND v(dout0_45) AT=70.025n

* CHECK dout0_46 Vdout0_46ck13 = 0.9 time = 70
.meas tran vdout0_46ck13 FIND v(dout0_46) AT=70.025n

* CHECK dout0_47 Vdout0_47ck13 = 0.9 time = 70
.meas tran vdout0_47ck13 FIND v(dout0_47) AT=70.025n

* CHECK dout0_48 Vdout0_48ck13 = 0 time = 70
.meas tran vdout0_48ck13 FIND v(dout0_48) AT=70.025n

* CHECK dout0_49 Vdout0_49ck13 = 0 time = 70
.meas tran vdout0_49ck13 FIND v(dout0_49) AT=70.025n

* CHECK dout0_50 Vdout0_50ck13 = 0.9 time = 70
.meas tran vdout0_50ck13 FIND v(dout0_50) AT=70.025n

* CHECK dout0_51 Vdout0_51ck13 = 0 time = 70
.meas tran vdout0_51ck13 FIND v(dout0_51) AT=70.025n

* CHECK dout0_52 Vdout0_52ck13 = 0.9 time = 70
.meas tran vdout0_52ck13 FIND v(dout0_52) AT=70.025n

* CHECK dout0_53 Vdout0_53ck13 = 0.9 time = 70
.meas tran vdout0_53ck13 FIND v(dout0_53) AT=70.025n

* CHECK dout0_54 Vdout0_54ck13 = 0 time = 70
.meas tran vdout0_54ck13 FIND v(dout0_54) AT=70.025n

* CHECK dout0_55 Vdout0_55ck13 = 0.9 time = 70
.meas tran vdout0_55ck13 FIND v(dout0_55) AT=70.025n

* CHECK dout0_56 Vdout0_56ck13 = 0 time = 70
.meas tran vdout0_56ck13 FIND v(dout0_56) AT=70.025n

* CHECK dout0_57 Vdout0_57ck13 = 0 time = 70
.meas tran vdout0_57ck13 FIND v(dout0_57) AT=70.025n

* CHECK dout0_58 Vdout0_58ck13 = 0 time = 70
.meas tran vdout0_58ck13 FIND v(dout0_58) AT=70.025n

* CHECK dout0_59 Vdout0_59ck13 = 0 time = 70
.meas tran vdout0_59ck13 FIND v(dout0_59) AT=70.025n

* CHECK dout0_60 Vdout0_60ck13 = 0.9 time = 70
.meas tran vdout0_60ck13 FIND v(dout0_60) AT=70.025n

* CHECK dout0_61 Vdout0_61ck13 = 0 time = 70
.meas tran vdout0_61ck13 FIND v(dout0_61) AT=70.025n

* CHECK dout0_62 Vdout0_62ck13 = 0 time = 70
.meas tran vdout0_62ck13 FIND v(dout0_62) AT=70.025n

* CHECK dout0_63 Vdout0_63ck13 = 0.9 time = 70
.meas tran vdout0_63ck13 FIND v(dout0_63) AT=70.025n

* CHECK dout0_0 Vdout0_0ck14 = 0.9 time = 75
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=75.025n

* CHECK dout0_1 Vdout0_1ck14 = 0 time = 75
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=75.025n

* CHECK dout0_2 Vdout0_2ck14 = 0.9 time = 75
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=75.025n

* CHECK dout0_3 Vdout0_3ck14 = 0 time = 75
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=75.025n

* CHECK dout0_4 Vdout0_4ck14 = 0.9 time = 75
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=75.025n

* CHECK dout0_5 Vdout0_5ck14 = 0.9 time = 75
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=75.025n

* CHECK dout0_6 Vdout0_6ck14 = 0.9 time = 75
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=75.025n

* CHECK dout0_7 Vdout0_7ck14 = 0 time = 75
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=75.025n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 75
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=75.025n

* CHECK dout0_9 Vdout0_9ck14 = 0.9 time = 75
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=75.025n

* CHECK dout0_10 Vdout0_10ck14 = 0 time = 75
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=75.025n

* CHECK dout0_11 Vdout0_11ck14 = 0.9 time = 75
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=75.025n

* CHECK dout0_12 Vdout0_12ck14 = 0.9 time = 75
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=75.025n

* CHECK dout0_13 Vdout0_13ck14 = 0 time = 75
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=75.025n

* CHECK dout0_14 Vdout0_14ck14 = 0.9 time = 75
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=75.025n

* CHECK dout0_15 Vdout0_15ck14 = 0.9 time = 75
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=75.025n

* CHECK dout0_16 Vdout0_16ck14 = 0 time = 75
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=75.025n

* CHECK dout0_17 Vdout0_17ck14 = 0.9 time = 75
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=75.025n

* CHECK dout0_18 Vdout0_18ck14 = 0.9 time = 75
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=75.025n

* CHECK dout0_19 Vdout0_19ck14 = 0 time = 75
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=75.025n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 75
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=75.025n

* CHECK dout0_21 Vdout0_21ck14 = 0 time = 75
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=75.025n

* CHECK dout0_22 Vdout0_22ck14 = 0.9 time = 75
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=75.025n

* CHECK dout0_23 Vdout0_23ck14 = 0 time = 75
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=75.025n

* CHECK dout0_24 Vdout0_24ck14 = 0.9 time = 75
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=75.025n

* CHECK dout0_25 Vdout0_25ck14 = 0 time = 75
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=75.025n

* CHECK dout0_26 Vdout0_26ck14 = 0.9 time = 75
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=75.025n

* CHECK dout0_27 Vdout0_27ck14 = 0.9 time = 75
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=75.025n

* CHECK dout0_28 Vdout0_28ck14 = 0 time = 75
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=75.025n

* CHECK dout0_29 Vdout0_29ck14 = 0.9 time = 75
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=75.025n

* CHECK dout0_30 Vdout0_30ck14 = 0 time = 75
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=75.025n

* CHECK dout0_31 Vdout0_31ck14 = 0.9 time = 75
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=75.025n

* CHECK dout0_32 Vdout0_32ck14 = 0 time = 75
.meas tran vdout0_32ck14 FIND v(dout0_32) AT=75.025n

* CHECK dout0_33 Vdout0_33ck14 = 0.9 time = 75
.meas tran vdout0_33ck14 FIND v(dout0_33) AT=75.025n

* CHECK dout0_34 Vdout0_34ck14 = 0.9 time = 75
.meas tran vdout0_34ck14 FIND v(dout0_34) AT=75.025n

* CHECK dout0_35 Vdout0_35ck14 = 0.9 time = 75
.meas tran vdout0_35ck14 FIND v(dout0_35) AT=75.025n

* CHECK dout0_36 Vdout0_36ck14 = 0 time = 75
.meas tran vdout0_36ck14 FIND v(dout0_36) AT=75.025n

* CHECK dout0_37 Vdout0_37ck14 = 0.9 time = 75
.meas tran vdout0_37ck14 FIND v(dout0_37) AT=75.025n

* CHECK dout0_38 Vdout0_38ck14 = 0 time = 75
.meas tran vdout0_38ck14 FIND v(dout0_38) AT=75.025n

* CHECK dout0_39 Vdout0_39ck14 = 0 time = 75
.meas tran vdout0_39ck14 FIND v(dout0_39) AT=75.025n

* CHECK dout0_40 Vdout0_40ck14 = 0.9 time = 75
.meas tran vdout0_40ck14 FIND v(dout0_40) AT=75.025n

* CHECK dout0_41 Vdout0_41ck14 = 0.9 time = 75
.meas tran vdout0_41ck14 FIND v(dout0_41) AT=75.025n

* CHECK dout0_42 Vdout0_42ck14 = 0.9 time = 75
.meas tran vdout0_42ck14 FIND v(dout0_42) AT=75.025n

* CHECK dout0_43 Vdout0_43ck14 = 0 time = 75
.meas tran vdout0_43ck14 FIND v(dout0_43) AT=75.025n

* CHECK dout0_44 Vdout0_44ck14 = 0.9 time = 75
.meas tran vdout0_44ck14 FIND v(dout0_44) AT=75.025n

* CHECK dout0_45 Vdout0_45ck14 = 0.9 time = 75
.meas tran vdout0_45ck14 FIND v(dout0_45) AT=75.025n

* CHECK dout0_46 Vdout0_46ck14 = 0 time = 75
.meas tran vdout0_46ck14 FIND v(dout0_46) AT=75.025n

* CHECK dout0_47 Vdout0_47ck14 = 0.9 time = 75
.meas tran vdout0_47ck14 FIND v(dout0_47) AT=75.025n

* CHECK dout0_48 Vdout0_48ck14 = 0 time = 75
.meas tran vdout0_48ck14 FIND v(dout0_48) AT=75.025n

* CHECK dout0_49 Vdout0_49ck14 = 0.9 time = 75
.meas tran vdout0_49ck14 FIND v(dout0_49) AT=75.025n

* CHECK dout0_50 Vdout0_50ck14 = 0 time = 75
.meas tran vdout0_50ck14 FIND v(dout0_50) AT=75.025n

* CHECK dout0_51 Vdout0_51ck14 = 0 time = 75
.meas tran vdout0_51ck14 FIND v(dout0_51) AT=75.025n

* CHECK dout0_52 Vdout0_52ck14 = 0 time = 75
.meas tran vdout0_52ck14 FIND v(dout0_52) AT=75.025n

* CHECK dout0_53 Vdout0_53ck14 = 0.9 time = 75
.meas tran vdout0_53ck14 FIND v(dout0_53) AT=75.025n

* CHECK dout0_54 Vdout0_54ck14 = 0.9 time = 75
.meas tran vdout0_54ck14 FIND v(dout0_54) AT=75.025n

* CHECK dout0_55 Vdout0_55ck14 = 0 time = 75
.meas tran vdout0_55ck14 FIND v(dout0_55) AT=75.025n

* CHECK dout0_56 Vdout0_56ck14 = 0.9 time = 75
.meas tran vdout0_56ck14 FIND v(dout0_56) AT=75.025n

* CHECK dout0_57 Vdout0_57ck14 = 0.9 time = 75
.meas tran vdout0_57ck14 FIND v(dout0_57) AT=75.025n

* CHECK dout0_58 Vdout0_58ck14 = 0 time = 75
.meas tran vdout0_58ck14 FIND v(dout0_58) AT=75.025n

* CHECK dout0_59 Vdout0_59ck14 = 0 time = 75
.meas tran vdout0_59ck14 FIND v(dout0_59) AT=75.025n

* CHECK dout0_60 Vdout0_60ck14 = 0.9 time = 75
.meas tran vdout0_60ck14 FIND v(dout0_60) AT=75.025n

* CHECK dout0_61 Vdout0_61ck14 = 0.9 time = 75
.meas tran vdout0_61ck14 FIND v(dout0_61) AT=75.025n

* CHECK dout0_62 Vdout0_62ck14 = 0.9 time = 75
.meas tran vdout0_62ck14 FIND v(dout0_62) AT=75.025n

* CHECK dout0_63 Vdout0_63ck14 = 0 time = 75
.meas tran vdout0_63ck14 FIND v(dout0_63) AT=75.025n

* CHECK dout0_0 Vdout0_0ck15 = 0.9 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0.9 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 0.9 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 0.9 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0.9 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 0 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0.9 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0.9 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 0.9 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 0 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 0.9 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 0.9 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0.9 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 0.9 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 0 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 0 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 0 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 0.9 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0.9 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 0 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 0.9 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0.9 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 0 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 0.9 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 0.9 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_32 Vdout0_32ck15 = 0 time = 80
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=80.025n

* CHECK dout0_33 Vdout0_33ck15 = 0.9 time = 80
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=80.025n

* CHECK dout0_34 Vdout0_34ck15 = 0.9 time = 80
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=80.025n

* CHECK dout0_35 Vdout0_35ck15 = 0.9 time = 80
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=80.025n

* CHECK dout0_36 Vdout0_36ck15 = 0 time = 80
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=80.025n

* CHECK dout0_37 Vdout0_37ck15 = 0.9 time = 80
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=80.025n

* CHECK dout0_38 Vdout0_38ck15 = 0 time = 80
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=80.025n

* CHECK dout0_39 Vdout0_39ck15 = 0 time = 80
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=80.025n

* CHECK dout0_40 Vdout0_40ck15 = 0.9 time = 80
.meas tran vdout0_40ck15 FIND v(dout0_40) AT=80.025n

* CHECK dout0_41 Vdout0_41ck15 = 0.9 time = 80
.meas tran vdout0_41ck15 FIND v(dout0_41) AT=80.025n

* CHECK dout0_42 Vdout0_42ck15 = 0.9 time = 80
.meas tran vdout0_42ck15 FIND v(dout0_42) AT=80.025n

* CHECK dout0_43 Vdout0_43ck15 = 0 time = 80
.meas tran vdout0_43ck15 FIND v(dout0_43) AT=80.025n

* CHECK dout0_44 Vdout0_44ck15 = 0.9 time = 80
.meas tran vdout0_44ck15 FIND v(dout0_44) AT=80.025n

* CHECK dout0_45 Vdout0_45ck15 = 0.9 time = 80
.meas tran vdout0_45ck15 FIND v(dout0_45) AT=80.025n

* CHECK dout0_46 Vdout0_46ck15 = 0 time = 80
.meas tran vdout0_46ck15 FIND v(dout0_46) AT=80.025n

* CHECK dout0_47 Vdout0_47ck15 = 0.9 time = 80
.meas tran vdout0_47ck15 FIND v(dout0_47) AT=80.025n

* CHECK dout0_48 Vdout0_48ck15 = 0 time = 80
.meas tran vdout0_48ck15 FIND v(dout0_48) AT=80.025n

* CHECK dout0_49 Vdout0_49ck15 = 0.9 time = 80
.meas tran vdout0_49ck15 FIND v(dout0_49) AT=80.025n

* CHECK dout0_50 Vdout0_50ck15 = 0 time = 80
.meas tran vdout0_50ck15 FIND v(dout0_50) AT=80.025n

* CHECK dout0_51 Vdout0_51ck15 = 0 time = 80
.meas tran vdout0_51ck15 FIND v(dout0_51) AT=80.025n

* CHECK dout0_52 Vdout0_52ck15 = 0 time = 80
.meas tran vdout0_52ck15 FIND v(dout0_52) AT=80.025n

* CHECK dout0_53 Vdout0_53ck15 = 0.9 time = 80
.meas tran vdout0_53ck15 FIND v(dout0_53) AT=80.025n

* CHECK dout0_54 Vdout0_54ck15 = 0.9 time = 80
.meas tran vdout0_54ck15 FIND v(dout0_54) AT=80.025n

* CHECK dout0_55 Vdout0_55ck15 = 0 time = 80
.meas tran vdout0_55ck15 FIND v(dout0_55) AT=80.025n

* CHECK dout0_56 Vdout0_56ck15 = 0.9 time = 80
.meas tran vdout0_56ck15 FIND v(dout0_56) AT=80.025n

* CHECK dout0_57 Vdout0_57ck15 = 0.9 time = 80
.meas tran vdout0_57ck15 FIND v(dout0_57) AT=80.025n

* CHECK dout0_58 Vdout0_58ck15 = 0 time = 80
.meas tran vdout0_58ck15 FIND v(dout0_58) AT=80.025n

* CHECK dout0_59 Vdout0_59ck15 = 0 time = 80
.meas tran vdout0_59ck15 FIND v(dout0_59) AT=80.025n

* CHECK dout0_60 Vdout0_60ck15 = 0.9 time = 80
.meas tran vdout0_60ck15 FIND v(dout0_60) AT=80.025n

* CHECK dout0_61 Vdout0_61ck15 = 0.9 time = 80
.meas tran vdout0_61ck15 FIND v(dout0_61) AT=80.025n

* CHECK dout0_62 Vdout0_62ck15 = 0.9 time = 80
.meas tran vdout0_62ck15 FIND v(dout0_62) AT=80.025n

* CHECK dout0_63 Vdout0_63ck15 = 0 time = 80
.meas tran vdout0_63ck15 FIND v(dout0_63) AT=80.025n

* CHECK dout0_0 Vdout0_0ck16 = 0.9 time = 85
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=85.025n

* CHECK dout0_1 Vdout0_1ck16 = 0 time = 85
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=85.025n

* CHECK dout0_2 Vdout0_2ck16 = 0.9 time = 85
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=85.025n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 85
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=85.025n

* CHECK dout0_4 Vdout0_4ck16 = 0.9 time = 85
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=85.025n

* CHECK dout0_5 Vdout0_5ck16 = 0.9 time = 85
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=85.025n

* CHECK dout0_6 Vdout0_6ck16 = 0.9 time = 85
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=85.025n

* CHECK dout0_7 Vdout0_7ck16 = 0 time = 85
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=85.025n

* CHECK dout0_8 Vdout0_8ck16 = 0 time = 85
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=85.025n

* CHECK dout0_9 Vdout0_9ck16 = 0.9 time = 85
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=85.025n

* CHECK dout0_10 Vdout0_10ck16 = 0 time = 85
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=85.025n

* CHECK dout0_11 Vdout0_11ck16 = 0.9 time = 85
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=85.025n

* CHECK dout0_12 Vdout0_12ck16 = 0.9 time = 85
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=85.025n

* CHECK dout0_13 Vdout0_13ck16 = 0 time = 85
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=85.025n

* CHECK dout0_14 Vdout0_14ck16 = 0.9 time = 85
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=85.025n

* CHECK dout0_15 Vdout0_15ck16 = 0.9 time = 85
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=85.025n

* CHECK dout0_16 Vdout0_16ck16 = 0 time = 85
.meas tran vdout0_16ck16 FIND v(dout0_16) AT=85.025n

* CHECK dout0_17 Vdout0_17ck16 = 0.9 time = 85
.meas tran vdout0_17ck16 FIND v(dout0_17) AT=85.025n

* CHECK dout0_18 Vdout0_18ck16 = 0.9 time = 85
.meas tran vdout0_18ck16 FIND v(dout0_18) AT=85.025n

* CHECK dout0_19 Vdout0_19ck16 = 0 time = 85
.meas tran vdout0_19ck16 FIND v(dout0_19) AT=85.025n

* CHECK dout0_20 Vdout0_20ck16 = 0 time = 85
.meas tran vdout0_20ck16 FIND v(dout0_20) AT=85.025n

* CHECK dout0_21 Vdout0_21ck16 = 0 time = 85
.meas tran vdout0_21ck16 FIND v(dout0_21) AT=85.025n

* CHECK dout0_22 Vdout0_22ck16 = 0.9 time = 85
.meas tran vdout0_22ck16 FIND v(dout0_22) AT=85.025n

* CHECK dout0_23 Vdout0_23ck16 = 0 time = 85
.meas tran vdout0_23ck16 FIND v(dout0_23) AT=85.025n

* CHECK dout0_24 Vdout0_24ck16 = 0.9 time = 85
.meas tran vdout0_24ck16 FIND v(dout0_24) AT=85.025n

* CHECK dout0_25 Vdout0_25ck16 = 0 time = 85
.meas tran vdout0_25ck16 FIND v(dout0_25) AT=85.025n

* CHECK dout0_26 Vdout0_26ck16 = 0.9 time = 85
.meas tran vdout0_26ck16 FIND v(dout0_26) AT=85.025n

* CHECK dout0_27 Vdout0_27ck16 = 0.9 time = 85
.meas tran vdout0_27ck16 FIND v(dout0_27) AT=85.025n

* CHECK dout0_28 Vdout0_28ck16 = 0 time = 85
.meas tran vdout0_28ck16 FIND v(dout0_28) AT=85.025n

* CHECK dout0_29 Vdout0_29ck16 = 0.9 time = 85
.meas tran vdout0_29ck16 FIND v(dout0_29) AT=85.025n

* CHECK dout0_30 Vdout0_30ck16 = 0 time = 85
.meas tran vdout0_30ck16 FIND v(dout0_30) AT=85.025n

* CHECK dout0_31 Vdout0_31ck16 = 0.9 time = 85
.meas tran vdout0_31ck16 FIND v(dout0_31) AT=85.025n

* CHECK dout0_32 Vdout0_32ck16 = 0 time = 85
.meas tran vdout0_32ck16 FIND v(dout0_32) AT=85.025n

* CHECK dout0_33 Vdout0_33ck16 = 0.9 time = 85
.meas tran vdout0_33ck16 FIND v(dout0_33) AT=85.025n

* CHECK dout0_34 Vdout0_34ck16 = 0.9 time = 85
.meas tran vdout0_34ck16 FIND v(dout0_34) AT=85.025n

* CHECK dout0_35 Vdout0_35ck16 = 0.9 time = 85
.meas tran vdout0_35ck16 FIND v(dout0_35) AT=85.025n

* CHECK dout0_36 Vdout0_36ck16 = 0 time = 85
.meas tran vdout0_36ck16 FIND v(dout0_36) AT=85.025n

* CHECK dout0_37 Vdout0_37ck16 = 0.9 time = 85
.meas tran vdout0_37ck16 FIND v(dout0_37) AT=85.025n

* CHECK dout0_38 Vdout0_38ck16 = 0 time = 85
.meas tran vdout0_38ck16 FIND v(dout0_38) AT=85.025n

* CHECK dout0_39 Vdout0_39ck16 = 0 time = 85
.meas tran vdout0_39ck16 FIND v(dout0_39) AT=85.025n

* CHECK dout0_40 Vdout0_40ck16 = 0.9 time = 85
.meas tran vdout0_40ck16 FIND v(dout0_40) AT=85.025n

* CHECK dout0_41 Vdout0_41ck16 = 0.9 time = 85
.meas tran vdout0_41ck16 FIND v(dout0_41) AT=85.025n

* CHECK dout0_42 Vdout0_42ck16 = 0.9 time = 85
.meas tran vdout0_42ck16 FIND v(dout0_42) AT=85.025n

* CHECK dout0_43 Vdout0_43ck16 = 0 time = 85
.meas tran vdout0_43ck16 FIND v(dout0_43) AT=85.025n

* CHECK dout0_44 Vdout0_44ck16 = 0.9 time = 85
.meas tran vdout0_44ck16 FIND v(dout0_44) AT=85.025n

* CHECK dout0_45 Vdout0_45ck16 = 0.9 time = 85
.meas tran vdout0_45ck16 FIND v(dout0_45) AT=85.025n

* CHECK dout0_46 Vdout0_46ck16 = 0 time = 85
.meas tran vdout0_46ck16 FIND v(dout0_46) AT=85.025n

* CHECK dout0_47 Vdout0_47ck16 = 0.9 time = 85
.meas tran vdout0_47ck16 FIND v(dout0_47) AT=85.025n

* CHECK dout0_48 Vdout0_48ck16 = 0 time = 85
.meas tran vdout0_48ck16 FIND v(dout0_48) AT=85.025n

* CHECK dout0_49 Vdout0_49ck16 = 0.9 time = 85
.meas tran vdout0_49ck16 FIND v(dout0_49) AT=85.025n

* CHECK dout0_50 Vdout0_50ck16 = 0 time = 85
.meas tran vdout0_50ck16 FIND v(dout0_50) AT=85.025n

* CHECK dout0_51 Vdout0_51ck16 = 0 time = 85
.meas tran vdout0_51ck16 FIND v(dout0_51) AT=85.025n

* CHECK dout0_52 Vdout0_52ck16 = 0 time = 85
.meas tran vdout0_52ck16 FIND v(dout0_52) AT=85.025n

* CHECK dout0_53 Vdout0_53ck16 = 0.9 time = 85
.meas tran vdout0_53ck16 FIND v(dout0_53) AT=85.025n

* CHECK dout0_54 Vdout0_54ck16 = 0.9 time = 85
.meas tran vdout0_54ck16 FIND v(dout0_54) AT=85.025n

* CHECK dout0_55 Vdout0_55ck16 = 0 time = 85
.meas tran vdout0_55ck16 FIND v(dout0_55) AT=85.025n

* CHECK dout0_56 Vdout0_56ck16 = 0.9 time = 85
.meas tran vdout0_56ck16 FIND v(dout0_56) AT=85.025n

* CHECK dout0_57 Vdout0_57ck16 = 0.9 time = 85
.meas tran vdout0_57ck16 FIND v(dout0_57) AT=85.025n

* CHECK dout0_58 Vdout0_58ck16 = 0 time = 85
.meas tran vdout0_58ck16 FIND v(dout0_58) AT=85.025n

* CHECK dout0_59 Vdout0_59ck16 = 0 time = 85
.meas tran vdout0_59ck16 FIND v(dout0_59) AT=85.025n

* CHECK dout0_60 Vdout0_60ck16 = 0.9 time = 85
.meas tran vdout0_60ck16 FIND v(dout0_60) AT=85.025n

* CHECK dout0_61 Vdout0_61ck16 = 0.9 time = 85
.meas tran vdout0_61ck16 FIND v(dout0_61) AT=85.025n

* CHECK dout0_62 Vdout0_62ck16 = 0.9 time = 85
.meas tran vdout0_62ck16 FIND v(dout0_62) AT=85.025n

* CHECK dout0_63 Vdout0_63ck16 = 0 time = 85
.meas tran vdout0_63ck16 FIND v(dout0_63) AT=85.025n

* CHECK dout0_0 Vdout0_0ck17 = 0.9 time = 90
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=90.025n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 90
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=90.025n

* CHECK dout0_2 Vdout0_2ck17 = 0.9 time = 90
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=90.025n

* CHECK dout0_3 Vdout0_3ck17 = 0.9 time = 90
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=90.025n

* CHECK dout0_4 Vdout0_4ck17 = 0.9 time = 90
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=90.025n

* CHECK dout0_5 Vdout0_5ck17 = 0.9 time = 90
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=90.025n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 90
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=90.025n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 90
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=90.025n

* CHECK dout0_8 Vdout0_8ck17 = 0.9 time = 90
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=90.025n

* CHECK dout0_9 Vdout0_9ck17 = 0.9 time = 90
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=90.025n

* CHECK dout0_10 Vdout0_10ck17 = 0.9 time = 90
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=90.025n

* CHECK dout0_11 Vdout0_11ck17 = 0 time = 90
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=90.025n

* CHECK dout0_12 Vdout0_12ck17 = 0 time = 90
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=90.025n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 90
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=90.025n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 90
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=90.025n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 90
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=90.025n

* CHECK dout0_16 Vdout0_16ck17 = 0.9 time = 90
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=90.025n

* CHECK dout0_17 Vdout0_17ck17 = 0.9 time = 90
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=90.025n

* CHECK dout0_18 Vdout0_18ck17 = 0.9 time = 90
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=90.025n

* CHECK dout0_19 Vdout0_19ck17 = 0.9 time = 90
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=90.025n

* CHECK dout0_20 Vdout0_20ck17 = 0.9 time = 90
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=90.025n

* CHECK dout0_21 Vdout0_21ck17 = 0.9 time = 90
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=90.025n

* CHECK dout0_22 Vdout0_22ck17 = 0 time = 90
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=90.025n

* CHECK dout0_23 Vdout0_23ck17 = 0.9 time = 90
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=90.025n

* CHECK dout0_24 Vdout0_24ck17 = 0.9 time = 90
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=90.025n

* CHECK dout0_25 Vdout0_25ck17 = 0 time = 90
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=90.025n

* CHECK dout0_26 Vdout0_26ck17 = 0 time = 90
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=90.025n

* CHECK dout0_27 Vdout0_27ck17 = 0 time = 90
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=90.025n

* CHECK dout0_28 Vdout0_28ck17 = 0 time = 90
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=90.025n

* CHECK dout0_29 Vdout0_29ck17 = 0.9 time = 90
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=90.025n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 90
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=90.025n

* CHECK dout0_31 Vdout0_31ck17 = 0.9 time = 90
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=90.025n

* CHECK dout0_32 Vdout0_32ck17 = 0 time = 90
.meas tran vdout0_32ck17 FIND v(dout0_32) AT=90.025n

* CHECK dout0_33 Vdout0_33ck17 = 0 time = 90
.meas tran vdout0_33ck17 FIND v(dout0_33) AT=90.025n

* CHECK dout0_34 Vdout0_34ck17 = 0.9 time = 90
.meas tran vdout0_34ck17 FIND v(dout0_34) AT=90.025n

* CHECK dout0_35 Vdout0_35ck17 = 0 time = 90
.meas tran vdout0_35ck17 FIND v(dout0_35) AT=90.025n

* CHECK dout0_36 Vdout0_36ck17 = 0 time = 90
.meas tran vdout0_36ck17 FIND v(dout0_36) AT=90.025n

* CHECK dout0_37 Vdout0_37ck17 = 0 time = 90
.meas tran vdout0_37ck17 FIND v(dout0_37) AT=90.025n

* CHECK dout0_38 Vdout0_38ck17 = 0 time = 90
.meas tran vdout0_38ck17 FIND v(dout0_38) AT=90.025n

* CHECK dout0_39 Vdout0_39ck17 = 0.9 time = 90
.meas tran vdout0_39ck17 FIND v(dout0_39) AT=90.025n

* CHECK dout0_40 Vdout0_40ck17 = 0 time = 90
.meas tran vdout0_40ck17 FIND v(dout0_40) AT=90.025n

* CHECK dout0_41 Vdout0_41ck17 = 0.9 time = 90
.meas tran vdout0_41ck17 FIND v(dout0_41) AT=90.025n

* CHECK dout0_42 Vdout0_42ck17 = 0.9 time = 90
.meas tran vdout0_42ck17 FIND v(dout0_42) AT=90.025n

* CHECK dout0_43 Vdout0_43ck17 = 0 time = 90
.meas tran vdout0_43ck17 FIND v(dout0_43) AT=90.025n

* CHECK dout0_44 Vdout0_44ck17 = 0.9 time = 90
.meas tran vdout0_44ck17 FIND v(dout0_44) AT=90.025n

* CHECK dout0_45 Vdout0_45ck17 = 0 time = 90
.meas tran vdout0_45ck17 FIND v(dout0_45) AT=90.025n

* CHECK dout0_46 Vdout0_46ck17 = 0.9 time = 90
.meas tran vdout0_46ck17 FIND v(dout0_46) AT=90.025n

* CHECK dout0_47 Vdout0_47ck17 = 0.9 time = 90
.meas tran vdout0_47ck17 FIND v(dout0_47) AT=90.025n

* CHECK dout0_48 Vdout0_48ck17 = 0 time = 90
.meas tran vdout0_48ck17 FIND v(dout0_48) AT=90.025n

* CHECK dout0_49 Vdout0_49ck17 = 0 time = 90
.meas tran vdout0_49ck17 FIND v(dout0_49) AT=90.025n

* CHECK dout0_50 Vdout0_50ck17 = 0.9 time = 90
.meas tran vdout0_50ck17 FIND v(dout0_50) AT=90.025n

* CHECK dout0_51 Vdout0_51ck17 = 0 time = 90
.meas tran vdout0_51ck17 FIND v(dout0_51) AT=90.025n

* CHECK dout0_52 Vdout0_52ck17 = 0.9 time = 90
.meas tran vdout0_52ck17 FIND v(dout0_52) AT=90.025n

* CHECK dout0_53 Vdout0_53ck17 = 0.9 time = 90
.meas tran vdout0_53ck17 FIND v(dout0_53) AT=90.025n

* CHECK dout0_54 Vdout0_54ck17 = 0 time = 90
.meas tran vdout0_54ck17 FIND v(dout0_54) AT=90.025n

* CHECK dout0_55 Vdout0_55ck17 = 0.9 time = 90
.meas tran vdout0_55ck17 FIND v(dout0_55) AT=90.025n

* CHECK dout0_56 Vdout0_56ck17 = 0 time = 90
.meas tran vdout0_56ck17 FIND v(dout0_56) AT=90.025n

* CHECK dout0_57 Vdout0_57ck17 = 0 time = 90
.meas tran vdout0_57ck17 FIND v(dout0_57) AT=90.025n

* CHECK dout0_58 Vdout0_58ck17 = 0 time = 90
.meas tran vdout0_58ck17 FIND v(dout0_58) AT=90.025n

* CHECK dout0_59 Vdout0_59ck17 = 0 time = 90
.meas tran vdout0_59ck17 FIND v(dout0_59) AT=90.025n

* CHECK dout0_60 Vdout0_60ck17 = 0.9 time = 90
.meas tran vdout0_60ck17 FIND v(dout0_60) AT=90.025n

* CHECK dout0_61 Vdout0_61ck17 = 0 time = 90
.meas tran vdout0_61ck17 FIND v(dout0_61) AT=90.025n

* CHECK dout0_62 Vdout0_62ck17 = 0 time = 90
.meas tran vdout0_62ck17 FIND v(dout0_62) AT=90.025n

* CHECK dout0_63 Vdout0_63ck17 = 0.9 time = 90
.meas tran vdout0_63ck17 FIND v(dout0_63) AT=90.025n

* CHECK dout0_0 Vdout0_0ck19 = 0.9 time = 100
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=100.025n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 100
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=100.025n

* CHECK dout0_2 Vdout0_2ck19 = 0.9 time = 100
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=100.025n

* CHECK dout0_3 Vdout0_3ck19 = 0.9 time = 100
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=100.025n

* CHECK dout0_4 Vdout0_4ck19 = 0.9 time = 100
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=100.025n

* CHECK dout0_5 Vdout0_5ck19 = 0.9 time = 100
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=100.025n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 100
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=100.025n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 100
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=100.025n

* CHECK dout0_8 Vdout0_8ck19 = 0.9 time = 100
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=100.025n

* CHECK dout0_9 Vdout0_9ck19 = 0.9 time = 100
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=100.025n

* CHECK dout0_10 Vdout0_10ck19 = 0.9 time = 100
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=100.025n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 100
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=100.025n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 100
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=100.025n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 100
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=100.025n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 100
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=100.025n

* CHECK dout0_15 Vdout0_15ck19 = 0 time = 100
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=100.025n

* CHECK dout0_16 Vdout0_16ck19 = 0.9 time = 100
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=100.025n

* CHECK dout0_17 Vdout0_17ck19 = 0.9 time = 100
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=100.025n

* CHECK dout0_18 Vdout0_18ck19 = 0.9 time = 100
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=100.025n

* CHECK dout0_19 Vdout0_19ck19 = 0.9 time = 100
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=100.025n

* CHECK dout0_20 Vdout0_20ck19 = 0.9 time = 100
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=100.025n

* CHECK dout0_21 Vdout0_21ck19 = 0.9 time = 100
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=100.025n

* CHECK dout0_22 Vdout0_22ck19 = 0 time = 100
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=100.025n

* CHECK dout0_23 Vdout0_23ck19 = 0.9 time = 100
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=100.025n

* CHECK dout0_24 Vdout0_24ck19 = 0.9 time = 100
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=100.025n

* CHECK dout0_25 Vdout0_25ck19 = 0 time = 100
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=100.025n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 100
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=100.025n

* CHECK dout0_27 Vdout0_27ck19 = 0 time = 100
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=100.025n

* CHECK dout0_28 Vdout0_28ck19 = 0 time = 100
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=100.025n

* CHECK dout0_29 Vdout0_29ck19 = 0.9 time = 100
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=100.025n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 100
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=100.025n

* CHECK dout0_31 Vdout0_31ck19 = 0.9 time = 100
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=100.025n

* CHECK dout0_32 Vdout0_32ck19 = 0 time = 100
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=100.025n

* CHECK dout0_33 Vdout0_33ck19 = 0 time = 100
.meas tran vdout0_33ck19 FIND v(dout0_33) AT=100.025n

* CHECK dout0_34 Vdout0_34ck19 = 0.9 time = 100
.meas tran vdout0_34ck19 FIND v(dout0_34) AT=100.025n

* CHECK dout0_35 Vdout0_35ck19 = 0 time = 100
.meas tran vdout0_35ck19 FIND v(dout0_35) AT=100.025n

* CHECK dout0_36 Vdout0_36ck19 = 0 time = 100
.meas tran vdout0_36ck19 FIND v(dout0_36) AT=100.025n

* CHECK dout0_37 Vdout0_37ck19 = 0 time = 100
.meas tran vdout0_37ck19 FIND v(dout0_37) AT=100.025n

* CHECK dout0_38 Vdout0_38ck19 = 0 time = 100
.meas tran vdout0_38ck19 FIND v(dout0_38) AT=100.025n

* CHECK dout0_39 Vdout0_39ck19 = 0.9 time = 100
.meas tran vdout0_39ck19 FIND v(dout0_39) AT=100.025n

* CHECK dout0_40 Vdout0_40ck19 = 0 time = 100
.meas tran vdout0_40ck19 FIND v(dout0_40) AT=100.025n

* CHECK dout0_41 Vdout0_41ck19 = 0.9 time = 100
.meas tran vdout0_41ck19 FIND v(dout0_41) AT=100.025n

* CHECK dout0_42 Vdout0_42ck19 = 0.9 time = 100
.meas tran vdout0_42ck19 FIND v(dout0_42) AT=100.025n

* CHECK dout0_43 Vdout0_43ck19 = 0 time = 100
.meas tran vdout0_43ck19 FIND v(dout0_43) AT=100.025n

* CHECK dout0_44 Vdout0_44ck19 = 0.9 time = 100
.meas tran vdout0_44ck19 FIND v(dout0_44) AT=100.025n

* CHECK dout0_45 Vdout0_45ck19 = 0 time = 100
.meas tran vdout0_45ck19 FIND v(dout0_45) AT=100.025n

* CHECK dout0_46 Vdout0_46ck19 = 0.9 time = 100
.meas tran vdout0_46ck19 FIND v(dout0_46) AT=100.025n

* CHECK dout0_47 Vdout0_47ck19 = 0.9 time = 100
.meas tran vdout0_47ck19 FIND v(dout0_47) AT=100.025n

* CHECK dout0_48 Vdout0_48ck19 = 0 time = 100
.meas tran vdout0_48ck19 FIND v(dout0_48) AT=100.025n

* CHECK dout0_49 Vdout0_49ck19 = 0 time = 100
.meas tran vdout0_49ck19 FIND v(dout0_49) AT=100.025n

* CHECK dout0_50 Vdout0_50ck19 = 0.9 time = 100
.meas tran vdout0_50ck19 FIND v(dout0_50) AT=100.025n

* CHECK dout0_51 Vdout0_51ck19 = 0 time = 100
.meas tran vdout0_51ck19 FIND v(dout0_51) AT=100.025n

* CHECK dout0_52 Vdout0_52ck19 = 0.9 time = 100
.meas tran vdout0_52ck19 FIND v(dout0_52) AT=100.025n

* CHECK dout0_53 Vdout0_53ck19 = 0.9 time = 100
.meas tran vdout0_53ck19 FIND v(dout0_53) AT=100.025n

* CHECK dout0_54 Vdout0_54ck19 = 0 time = 100
.meas tran vdout0_54ck19 FIND v(dout0_54) AT=100.025n

* CHECK dout0_55 Vdout0_55ck19 = 0.9 time = 100
.meas tran vdout0_55ck19 FIND v(dout0_55) AT=100.025n

* CHECK dout0_56 Vdout0_56ck19 = 0 time = 100
.meas tran vdout0_56ck19 FIND v(dout0_56) AT=100.025n

* CHECK dout0_57 Vdout0_57ck19 = 0 time = 100
.meas tran vdout0_57ck19 FIND v(dout0_57) AT=100.025n

* CHECK dout0_58 Vdout0_58ck19 = 0 time = 100
.meas tran vdout0_58ck19 FIND v(dout0_58) AT=100.025n

* CHECK dout0_59 Vdout0_59ck19 = 0 time = 100
.meas tran vdout0_59ck19 FIND v(dout0_59) AT=100.025n

* CHECK dout0_60 Vdout0_60ck19 = 0.9 time = 100
.meas tran vdout0_60ck19 FIND v(dout0_60) AT=100.025n

* CHECK dout0_61 Vdout0_61ck19 = 0 time = 100
.meas tran vdout0_61ck19 FIND v(dout0_61) AT=100.025n

* CHECK dout0_62 Vdout0_62ck19 = 0 time = 100
.meas tran vdout0_62ck19 FIND v(dout0_62) AT=100.025n

* CHECK dout0_63 Vdout0_63ck19 = 0.9 time = 100
.meas tran vdout0_63ck19 FIND v(dout0_63) AT=100.025n

* CHECK dout0_0 Vdout0_0ck20 = 0.9 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 0.9 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 0.9 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 0.9 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0.9 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0.9 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 0.9 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 0.9 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0.9 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 0.9 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 0 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 0.9 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0.9 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 0 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 0 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0.9 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 0 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0.9 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 0 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0.9 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 0.9 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 0 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 0.9 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 0 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 0.9 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_32 Vdout0_32ck20 = 0 time = 105
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=105.025n

* CHECK dout0_33 Vdout0_33ck20 = 0.9 time = 105
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=105.025n

* CHECK dout0_34 Vdout0_34ck20 = 0.9 time = 105
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=105.025n

* CHECK dout0_35 Vdout0_35ck20 = 0.9 time = 105
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=105.025n

* CHECK dout0_36 Vdout0_36ck20 = 0 time = 105
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=105.025n

* CHECK dout0_37 Vdout0_37ck20 = 0.9 time = 105
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=105.025n

* CHECK dout0_38 Vdout0_38ck20 = 0 time = 105
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=105.025n

* CHECK dout0_39 Vdout0_39ck20 = 0 time = 105
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=105.025n

* CHECK dout0_40 Vdout0_40ck20 = 0.9 time = 105
.meas tran vdout0_40ck20 FIND v(dout0_40) AT=105.025n

* CHECK dout0_41 Vdout0_41ck20 = 0.9 time = 105
.meas tran vdout0_41ck20 FIND v(dout0_41) AT=105.025n

* CHECK dout0_42 Vdout0_42ck20 = 0.9 time = 105
.meas tran vdout0_42ck20 FIND v(dout0_42) AT=105.025n

* CHECK dout0_43 Vdout0_43ck20 = 0 time = 105
.meas tran vdout0_43ck20 FIND v(dout0_43) AT=105.025n

* CHECK dout0_44 Vdout0_44ck20 = 0.9 time = 105
.meas tran vdout0_44ck20 FIND v(dout0_44) AT=105.025n

* CHECK dout0_45 Vdout0_45ck20 = 0.9 time = 105
.meas tran vdout0_45ck20 FIND v(dout0_45) AT=105.025n

* CHECK dout0_46 Vdout0_46ck20 = 0 time = 105
.meas tran vdout0_46ck20 FIND v(dout0_46) AT=105.025n

* CHECK dout0_47 Vdout0_47ck20 = 0.9 time = 105
.meas tran vdout0_47ck20 FIND v(dout0_47) AT=105.025n

* CHECK dout0_48 Vdout0_48ck20 = 0 time = 105
.meas tran vdout0_48ck20 FIND v(dout0_48) AT=105.025n

* CHECK dout0_49 Vdout0_49ck20 = 0.9 time = 105
.meas tran vdout0_49ck20 FIND v(dout0_49) AT=105.025n

* CHECK dout0_50 Vdout0_50ck20 = 0 time = 105
.meas tran vdout0_50ck20 FIND v(dout0_50) AT=105.025n

* CHECK dout0_51 Vdout0_51ck20 = 0 time = 105
.meas tran vdout0_51ck20 FIND v(dout0_51) AT=105.025n

* CHECK dout0_52 Vdout0_52ck20 = 0 time = 105
.meas tran vdout0_52ck20 FIND v(dout0_52) AT=105.025n

* CHECK dout0_53 Vdout0_53ck20 = 0.9 time = 105
.meas tran vdout0_53ck20 FIND v(dout0_53) AT=105.025n

* CHECK dout0_54 Vdout0_54ck20 = 0.9 time = 105
.meas tran vdout0_54ck20 FIND v(dout0_54) AT=105.025n

* CHECK dout0_55 Vdout0_55ck20 = 0 time = 105
.meas tran vdout0_55ck20 FIND v(dout0_55) AT=105.025n

* CHECK dout0_56 Vdout0_56ck20 = 0.9 time = 105
.meas tran vdout0_56ck20 FIND v(dout0_56) AT=105.025n

* CHECK dout0_57 Vdout0_57ck20 = 0.9 time = 105
.meas tran vdout0_57ck20 FIND v(dout0_57) AT=105.025n

* CHECK dout0_58 Vdout0_58ck20 = 0 time = 105
.meas tran vdout0_58ck20 FIND v(dout0_58) AT=105.025n

* CHECK dout0_59 Vdout0_59ck20 = 0 time = 105
.meas tran vdout0_59ck20 FIND v(dout0_59) AT=105.025n

* CHECK dout0_60 Vdout0_60ck20 = 0.9 time = 105
.meas tran vdout0_60ck20 FIND v(dout0_60) AT=105.025n

* CHECK dout0_61 Vdout0_61ck20 = 0.9 time = 105
.meas tran vdout0_61ck20 FIND v(dout0_61) AT=105.025n

* CHECK dout0_62 Vdout0_62ck20 = 0.9 time = 105
.meas tran vdout0_62ck20 FIND v(dout0_62) AT=105.025n

* CHECK dout0_63 Vdout0_63ck20 = 0 time = 105
.meas tran vdout0_63ck20 FIND v(dout0_63) AT=105.025n

* CHECK dout0_0 Vdout0_0ck29 = 0.9 time = 150
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=150.025n

* CHECK dout0_1 Vdout0_1ck29 = 0.9 time = 150
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=150.025n

* CHECK dout0_2 Vdout0_2ck29 = 0.9 time = 150
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=150.025n

* CHECK dout0_3 Vdout0_3ck29 = 0.9 time = 150
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=150.025n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 150
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=150.025n

* CHECK dout0_5 Vdout0_5ck29 = 0.9 time = 150
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=150.025n

* CHECK dout0_6 Vdout0_6ck29 = 0.9 time = 150
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=150.025n

* CHECK dout0_7 Vdout0_7ck29 = 0.9 time = 150
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=150.025n

* CHECK dout0_8 Vdout0_8ck29 = 0.9 time = 150
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=150.025n

* CHECK dout0_9 Vdout0_9ck29 = 0.9 time = 150
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=150.025n

* CHECK dout0_10 Vdout0_10ck29 = 0.9 time = 150
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=150.025n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 150
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=150.025n

* CHECK dout0_12 Vdout0_12ck29 = 0.9 time = 150
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=150.025n

* CHECK dout0_13 Vdout0_13ck29 = 0.9 time = 150
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=150.025n

* CHECK dout0_14 Vdout0_14ck29 = 0.9 time = 150
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=150.025n

* CHECK dout0_15 Vdout0_15ck29 = 0.9 time = 150
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=150.025n

* CHECK dout0_16 Vdout0_16ck29 = 0 time = 150
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=150.025n

* CHECK dout0_17 Vdout0_17ck29 = 0.9 time = 150
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=150.025n

* CHECK dout0_18 Vdout0_18ck29 = 0 time = 150
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=150.025n

* CHECK dout0_19 Vdout0_19ck29 = 0 time = 150
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=150.025n

* CHECK dout0_20 Vdout0_20ck29 = 0.9 time = 150
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=150.025n

* CHECK dout0_21 Vdout0_21ck29 = 0 time = 150
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=150.025n

* CHECK dout0_22 Vdout0_22ck29 = 0 time = 150
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=150.025n

* CHECK dout0_23 Vdout0_23ck29 = 0.9 time = 150
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=150.025n

* CHECK dout0_24 Vdout0_24ck29 = 0 time = 150
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=150.025n

* CHECK dout0_25 Vdout0_25ck29 = 0 time = 150
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=150.025n

* CHECK dout0_26 Vdout0_26ck29 = 0 time = 150
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=150.025n

* CHECK dout0_27 Vdout0_27ck29 = 0 time = 150
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=150.025n

* CHECK dout0_28 Vdout0_28ck29 = 0 time = 150
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=150.025n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 150
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=150.025n

* CHECK dout0_30 Vdout0_30ck29 = 0 time = 150
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=150.025n

* CHECK dout0_31 Vdout0_31ck29 = 0 time = 150
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=150.025n

* CHECK dout0_32 Vdout0_32ck29 = 0 time = 150
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=150.025n

* CHECK dout0_33 Vdout0_33ck29 = 0 time = 150
.meas tran vdout0_33ck29 FIND v(dout0_33) AT=150.025n

* CHECK dout0_34 Vdout0_34ck29 = 0 time = 150
.meas tran vdout0_34ck29 FIND v(dout0_34) AT=150.025n

* CHECK dout0_35 Vdout0_35ck29 = 0 time = 150
.meas tran vdout0_35ck29 FIND v(dout0_35) AT=150.025n

* CHECK dout0_36 Vdout0_36ck29 = 0.9 time = 150
.meas tran vdout0_36ck29 FIND v(dout0_36) AT=150.025n

* CHECK dout0_37 Vdout0_37ck29 = 0.9 time = 150
.meas tran vdout0_37ck29 FIND v(dout0_37) AT=150.025n

* CHECK dout0_38 Vdout0_38ck29 = 0.9 time = 150
.meas tran vdout0_38ck29 FIND v(dout0_38) AT=150.025n

* CHECK dout0_39 Vdout0_39ck29 = 0.9 time = 150
.meas tran vdout0_39ck29 FIND v(dout0_39) AT=150.025n

* CHECK dout0_40 Vdout0_40ck29 = 0.9 time = 150
.meas tran vdout0_40ck29 FIND v(dout0_40) AT=150.025n

* CHECK dout0_41 Vdout0_41ck29 = 0 time = 150
.meas tran vdout0_41ck29 FIND v(dout0_41) AT=150.025n

* CHECK dout0_42 Vdout0_42ck29 = 0.9 time = 150
.meas tran vdout0_42ck29 FIND v(dout0_42) AT=150.025n

* CHECK dout0_43 Vdout0_43ck29 = 0.9 time = 150
.meas tran vdout0_43ck29 FIND v(dout0_43) AT=150.025n

* CHECK dout0_44 Vdout0_44ck29 = 0 time = 150
.meas tran vdout0_44ck29 FIND v(dout0_44) AT=150.025n

* CHECK dout0_45 Vdout0_45ck29 = 0.9 time = 150
.meas tran vdout0_45ck29 FIND v(dout0_45) AT=150.025n

* CHECK dout0_46 Vdout0_46ck29 = 0.9 time = 150
.meas tran vdout0_46ck29 FIND v(dout0_46) AT=150.025n

* CHECK dout0_47 Vdout0_47ck29 = 0 time = 150
.meas tran vdout0_47ck29 FIND v(dout0_47) AT=150.025n

* CHECK dout0_48 Vdout0_48ck29 = 0 time = 150
.meas tran vdout0_48ck29 FIND v(dout0_48) AT=150.025n

* CHECK dout0_49 Vdout0_49ck29 = 0.9 time = 150
.meas tran vdout0_49ck29 FIND v(dout0_49) AT=150.025n

* CHECK dout0_50 Vdout0_50ck29 = 0 time = 150
.meas tran vdout0_50ck29 FIND v(dout0_50) AT=150.025n

* CHECK dout0_51 Vdout0_51ck29 = 0 time = 150
.meas tran vdout0_51ck29 FIND v(dout0_51) AT=150.025n

* CHECK dout0_52 Vdout0_52ck29 = 0 time = 150
.meas tran vdout0_52ck29 FIND v(dout0_52) AT=150.025n

* CHECK dout0_53 Vdout0_53ck29 = 0 time = 150
.meas tran vdout0_53ck29 FIND v(dout0_53) AT=150.025n

* CHECK dout0_54 Vdout0_54ck29 = 0.9 time = 150
.meas tran vdout0_54ck29 FIND v(dout0_54) AT=150.025n

* CHECK dout0_55 Vdout0_55ck29 = 0 time = 150
.meas tran vdout0_55ck29 FIND v(dout0_55) AT=150.025n

* CHECK dout0_56 Vdout0_56ck29 = 0 time = 150
.meas tran vdout0_56ck29 FIND v(dout0_56) AT=150.025n

* CHECK dout0_57 Vdout0_57ck29 = 0.9 time = 150
.meas tran vdout0_57ck29 FIND v(dout0_57) AT=150.025n

* CHECK dout0_58 Vdout0_58ck29 = 0.9 time = 150
.meas tran vdout0_58ck29 FIND v(dout0_58) AT=150.025n

* CHECK dout0_59 Vdout0_59ck29 = 0 time = 150
.meas tran vdout0_59ck29 FIND v(dout0_59) AT=150.025n

* CHECK dout0_60 Vdout0_60ck29 = 0 time = 150
.meas tran vdout0_60ck29 FIND v(dout0_60) AT=150.025n

* CHECK dout0_61 Vdout0_61ck29 = 0.9 time = 150
.meas tran vdout0_61ck29 FIND v(dout0_61) AT=150.025n

* CHECK dout0_62 Vdout0_62ck29 = 0 time = 150
.meas tran vdout0_62ck29 FIND v(dout0_62) AT=150.025n

* CHECK dout0_63 Vdout0_63ck29 = 0.9 time = 150
.meas tran vdout0_63ck29 FIND v(dout0_63) AT=150.025n

* CHECK dout0_0 Vdout0_0ck31 = 0.9 time = 160
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=160.025n

* CHECK dout0_1 Vdout0_1ck31 = 0.9 time = 160
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=160.025n

* CHECK dout0_2 Vdout0_2ck31 = 0.9 time = 160
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=160.025n

* CHECK dout0_3 Vdout0_3ck31 = 0.9 time = 160
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=160.025n

* CHECK dout0_4 Vdout0_4ck31 = 0 time = 160
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=160.025n

* CHECK dout0_5 Vdout0_5ck31 = 0.9 time = 160
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=160.025n

* CHECK dout0_6 Vdout0_6ck31 = 0.9 time = 160
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=160.025n

* CHECK dout0_7 Vdout0_7ck31 = 0.9 time = 160
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=160.025n

* CHECK dout0_8 Vdout0_8ck31 = 0.9 time = 160
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=160.025n

* CHECK dout0_9 Vdout0_9ck31 = 0.9 time = 160
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=160.025n

* CHECK dout0_10 Vdout0_10ck31 = 0.9 time = 160
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=160.025n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 160
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=160.025n

* CHECK dout0_12 Vdout0_12ck31 = 0.9 time = 160
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=160.025n

* CHECK dout0_13 Vdout0_13ck31 = 0.9 time = 160
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=160.025n

* CHECK dout0_14 Vdout0_14ck31 = 0.9 time = 160
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=160.025n

* CHECK dout0_15 Vdout0_15ck31 = 0.9 time = 160
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=160.025n

* CHECK dout0_16 Vdout0_16ck31 = 0 time = 160
.meas tran vdout0_16ck31 FIND v(dout0_16) AT=160.025n

* CHECK dout0_17 Vdout0_17ck31 = 0.9 time = 160
.meas tran vdout0_17ck31 FIND v(dout0_17) AT=160.025n

* CHECK dout0_18 Vdout0_18ck31 = 0 time = 160
.meas tran vdout0_18ck31 FIND v(dout0_18) AT=160.025n

* CHECK dout0_19 Vdout0_19ck31 = 0 time = 160
.meas tran vdout0_19ck31 FIND v(dout0_19) AT=160.025n

* CHECK dout0_20 Vdout0_20ck31 = 0.9 time = 160
.meas tran vdout0_20ck31 FIND v(dout0_20) AT=160.025n

* CHECK dout0_21 Vdout0_21ck31 = 0 time = 160
.meas tran vdout0_21ck31 FIND v(dout0_21) AT=160.025n

* CHECK dout0_22 Vdout0_22ck31 = 0 time = 160
.meas tran vdout0_22ck31 FIND v(dout0_22) AT=160.025n

* CHECK dout0_23 Vdout0_23ck31 = 0.9 time = 160
.meas tran vdout0_23ck31 FIND v(dout0_23) AT=160.025n

* CHECK dout0_24 Vdout0_24ck31 = 0 time = 160
.meas tran vdout0_24ck31 FIND v(dout0_24) AT=160.025n

* CHECK dout0_25 Vdout0_25ck31 = 0 time = 160
.meas tran vdout0_25ck31 FIND v(dout0_25) AT=160.025n

* CHECK dout0_26 Vdout0_26ck31 = 0 time = 160
.meas tran vdout0_26ck31 FIND v(dout0_26) AT=160.025n

* CHECK dout0_27 Vdout0_27ck31 = 0 time = 160
.meas tran vdout0_27ck31 FIND v(dout0_27) AT=160.025n

* CHECK dout0_28 Vdout0_28ck31 = 0 time = 160
.meas tran vdout0_28ck31 FIND v(dout0_28) AT=160.025n

* CHECK dout0_29 Vdout0_29ck31 = 0 time = 160
.meas tran vdout0_29ck31 FIND v(dout0_29) AT=160.025n

* CHECK dout0_30 Vdout0_30ck31 = 0 time = 160
.meas tran vdout0_30ck31 FIND v(dout0_30) AT=160.025n

* CHECK dout0_31 Vdout0_31ck31 = 0 time = 160
.meas tran vdout0_31ck31 FIND v(dout0_31) AT=160.025n

* CHECK dout0_32 Vdout0_32ck31 = 0 time = 160
.meas tran vdout0_32ck31 FIND v(dout0_32) AT=160.025n

* CHECK dout0_33 Vdout0_33ck31 = 0 time = 160
.meas tran vdout0_33ck31 FIND v(dout0_33) AT=160.025n

* CHECK dout0_34 Vdout0_34ck31 = 0 time = 160
.meas tran vdout0_34ck31 FIND v(dout0_34) AT=160.025n

* CHECK dout0_35 Vdout0_35ck31 = 0 time = 160
.meas tran vdout0_35ck31 FIND v(dout0_35) AT=160.025n

* CHECK dout0_36 Vdout0_36ck31 = 0.9 time = 160
.meas tran vdout0_36ck31 FIND v(dout0_36) AT=160.025n

* CHECK dout0_37 Vdout0_37ck31 = 0.9 time = 160
.meas tran vdout0_37ck31 FIND v(dout0_37) AT=160.025n

* CHECK dout0_38 Vdout0_38ck31 = 0.9 time = 160
.meas tran vdout0_38ck31 FIND v(dout0_38) AT=160.025n

* CHECK dout0_39 Vdout0_39ck31 = 0.9 time = 160
.meas tran vdout0_39ck31 FIND v(dout0_39) AT=160.025n

* CHECK dout0_40 Vdout0_40ck31 = 0.9 time = 160
.meas tran vdout0_40ck31 FIND v(dout0_40) AT=160.025n

* CHECK dout0_41 Vdout0_41ck31 = 0 time = 160
.meas tran vdout0_41ck31 FIND v(dout0_41) AT=160.025n

* CHECK dout0_42 Vdout0_42ck31 = 0.9 time = 160
.meas tran vdout0_42ck31 FIND v(dout0_42) AT=160.025n

* CHECK dout0_43 Vdout0_43ck31 = 0.9 time = 160
.meas tran vdout0_43ck31 FIND v(dout0_43) AT=160.025n

* CHECK dout0_44 Vdout0_44ck31 = 0 time = 160
.meas tran vdout0_44ck31 FIND v(dout0_44) AT=160.025n

* CHECK dout0_45 Vdout0_45ck31 = 0.9 time = 160
.meas tran vdout0_45ck31 FIND v(dout0_45) AT=160.025n

* CHECK dout0_46 Vdout0_46ck31 = 0.9 time = 160
.meas tran vdout0_46ck31 FIND v(dout0_46) AT=160.025n

* CHECK dout0_47 Vdout0_47ck31 = 0 time = 160
.meas tran vdout0_47ck31 FIND v(dout0_47) AT=160.025n

* CHECK dout0_48 Vdout0_48ck31 = 0 time = 160
.meas tran vdout0_48ck31 FIND v(dout0_48) AT=160.025n

* CHECK dout0_49 Vdout0_49ck31 = 0.9 time = 160
.meas tran vdout0_49ck31 FIND v(dout0_49) AT=160.025n

* CHECK dout0_50 Vdout0_50ck31 = 0 time = 160
.meas tran vdout0_50ck31 FIND v(dout0_50) AT=160.025n

* CHECK dout0_51 Vdout0_51ck31 = 0 time = 160
.meas tran vdout0_51ck31 FIND v(dout0_51) AT=160.025n

* CHECK dout0_52 Vdout0_52ck31 = 0 time = 160
.meas tran vdout0_52ck31 FIND v(dout0_52) AT=160.025n

* CHECK dout0_53 Vdout0_53ck31 = 0 time = 160
.meas tran vdout0_53ck31 FIND v(dout0_53) AT=160.025n

* CHECK dout0_54 Vdout0_54ck31 = 0.9 time = 160
.meas tran vdout0_54ck31 FIND v(dout0_54) AT=160.025n

* CHECK dout0_55 Vdout0_55ck31 = 0 time = 160
.meas tran vdout0_55ck31 FIND v(dout0_55) AT=160.025n

* CHECK dout0_56 Vdout0_56ck31 = 0 time = 160
.meas tran vdout0_56ck31 FIND v(dout0_56) AT=160.025n

* CHECK dout0_57 Vdout0_57ck31 = 0.9 time = 160
.meas tran vdout0_57ck31 FIND v(dout0_57) AT=160.025n

* CHECK dout0_58 Vdout0_58ck31 = 0.9 time = 160
.meas tran vdout0_58ck31 FIND v(dout0_58) AT=160.025n

* CHECK dout0_59 Vdout0_59ck31 = 0 time = 160
.meas tran vdout0_59ck31 FIND v(dout0_59) AT=160.025n

* CHECK dout0_60 Vdout0_60ck31 = 0 time = 160
.meas tran vdout0_60ck31 FIND v(dout0_60) AT=160.025n

* CHECK dout0_61 Vdout0_61ck31 = 0.9 time = 160
.meas tran vdout0_61ck31 FIND v(dout0_61) AT=160.025n

* CHECK dout0_62 Vdout0_62ck31 = 0 time = 160
.meas tran vdout0_62ck31 FIND v(dout0_62) AT=160.025n

* CHECK dout0_63 Vdout0_63ck31 = 0.9 time = 160
.meas tran vdout0_63ck31 FIND v(dout0_63) AT=160.025n

* CHECK dout0_0 Vdout0_0ck34 = 0.9 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 0.9 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 0.9 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 0.9 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 0.9 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 0.9 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0.9 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 0.9 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0.9 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 0.9 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 0.9 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 0.9 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0.9 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 0.9 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 0 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 0.9 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 0 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 0 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 0.9 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 0 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 0 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 0.9 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 0 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 0 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 0 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 0 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 0 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 0 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_32 Vdout0_32ck34 = 0 time = 175
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=175.025n

* CHECK dout0_33 Vdout0_33ck34 = 0 time = 175
.meas tran vdout0_33ck34 FIND v(dout0_33) AT=175.025n

* CHECK dout0_34 Vdout0_34ck34 = 0 time = 175
.meas tran vdout0_34ck34 FIND v(dout0_34) AT=175.025n

* CHECK dout0_35 Vdout0_35ck34 = 0 time = 175
.meas tran vdout0_35ck34 FIND v(dout0_35) AT=175.025n

* CHECK dout0_36 Vdout0_36ck34 = 0.9 time = 175
.meas tran vdout0_36ck34 FIND v(dout0_36) AT=175.025n

* CHECK dout0_37 Vdout0_37ck34 = 0.9 time = 175
.meas tran vdout0_37ck34 FIND v(dout0_37) AT=175.025n

* CHECK dout0_38 Vdout0_38ck34 = 0.9 time = 175
.meas tran vdout0_38ck34 FIND v(dout0_38) AT=175.025n

* CHECK dout0_39 Vdout0_39ck34 = 0.9 time = 175
.meas tran vdout0_39ck34 FIND v(dout0_39) AT=175.025n

* CHECK dout0_40 Vdout0_40ck34 = 0.9 time = 175
.meas tran vdout0_40ck34 FIND v(dout0_40) AT=175.025n

* CHECK dout0_41 Vdout0_41ck34 = 0 time = 175
.meas tran vdout0_41ck34 FIND v(dout0_41) AT=175.025n

* CHECK dout0_42 Vdout0_42ck34 = 0.9 time = 175
.meas tran vdout0_42ck34 FIND v(dout0_42) AT=175.025n

* CHECK dout0_43 Vdout0_43ck34 = 0.9 time = 175
.meas tran vdout0_43ck34 FIND v(dout0_43) AT=175.025n

* CHECK dout0_44 Vdout0_44ck34 = 0 time = 175
.meas tran vdout0_44ck34 FIND v(dout0_44) AT=175.025n

* CHECK dout0_45 Vdout0_45ck34 = 0.9 time = 175
.meas tran vdout0_45ck34 FIND v(dout0_45) AT=175.025n

* CHECK dout0_46 Vdout0_46ck34 = 0.9 time = 175
.meas tran vdout0_46ck34 FIND v(dout0_46) AT=175.025n

* CHECK dout0_47 Vdout0_47ck34 = 0 time = 175
.meas tran vdout0_47ck34 FIND v(dout0_47) AT=175.025n

* CHECK dout0_48 Vdout0_48ck34 = 0 time = 175
.meas tran vdout0_48ck34 FIND v(dout0_48) AT=175.025n

* CHECK dout0_49 Vdout0_49ck34 = 0.9 time = 175
.meas tran vdout0_49ck34 FIND v(dout0_49) AT=175.025n

* CHECK dout0_50 Vdout0_50ck34 = 0 time = 175
.meas tran vdout0_50ck34 FIND v(dout0_50) AT=175.025n

* CHECK dout0_51 Vdout0_51ck34 = 0 time = 175
.meas tran vdout0_51ck34 FIND v(dout0_51) AT=175.025n

* CHECK dout0_52 Vdout0_52ck34 = 0 time = 175
.meas tran vdout0_52ck34 FIND v(dout0_52) AT=175.025n

* CHECK dout0_53 Vdout0_53ck34 = 0 time = 175
.meas tran vdout0_53ck34 FIND v(dout0_53) AT=175.025n

* CHECK dout0_54 Vdout0_54ck34 = 0.9 time = 175
.meas tran vdout0_54ck34 FIND v(dout0_54) AT=175.025n

* CHECK dout0_55 Vdout0_55ck34 = 0 time = 175
.meas tran vdout0_55ck34 FIND v(dout0_55) AT=175.025n

* CHECK dout0_56 Vdout0_56ck34 = 0 time = 175
.meas tran vdout0_56ck34 FIND v(dout0_56) AT=175.025n

* CHECK dout0_57 Vdout0_57ck34 = 0.9 time = 175
.meas tran vdout0_57ck34 FIND v(dout0_57) AT=175.025n

* CHECK dout0_58 Vdout0_58ck34 = 0.9 time = 175
.meas tran vdout0_58ck34 FIND v(dout0_58) AT=175.025n

* CHECK dout0_59 Vdout0_59ck34 = 0 time = 175
.meas tran vdout0_59ck34 FIND v(dout0_59) AT=175.025n

* CHECK dout0_60 Vdout0_60ck34 = 0 time = 175
.meas tran vdout0_60ck34 FIND v(dout0_60) AT=175.025n

* CHECK dout0_61 Vdout0_61ck34 = 0.9 time = 175
.meas tran vdout0_61ck34 FIND v(dout0_61) AT=175.025n

* CHECK dout0_62 Vdout0_62ck34 = 0 time = 175
.meas tran vdout0_62ck34 FIND v(dout0_62) AT=175.025n

* CHECK dout0_63 Vdout0_63ck34 = 0.9 time = 175
.meas tran vdout0_63ck34 FIND v(dout0_63) AT=175.025n

* CHECK dout0_0 Vdout0_0ck35 = 0.9 time = 180
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=180.025n

* CHECK dout0_1 Vdout0_1ck35 = 0.9 time = 180
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=180.025n

* CHECK dout0_2 Vdout0_2ck35 = 0.9 time = 180
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=180.025n

* CHECK dout0_3 Vdout0_3ck35 = 0.9 time = 180
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=180.025n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 180
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=180.025n

* CHECK dout0_5 Vdout0_5ck35 = 0.9 time = 180
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=180.025n

* CHECK dout0_6 Vdout0_6ck35 = 0.9 time = 180
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=180.025n

* CHECK dout0_7 Vdout0_7ck35 = 0.9 time = 180
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=180.025n

* CHECK dout0_8 Vdout0_8ck35 = 0.9 time = 180
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=180.025n

* CHECK dout0_9 Vdout0_9ck35 = 0.9 time = 180
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=180.025n

* CHECK dout0_10 Vdout0_10ck35 = 0.9 time = 180
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=180.025n

* CHECK dout0_11 Vdout0_11ck35 = 0 time = 180
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=180.025n

* CHECK dout0_12 Vdout0_12ck35 = 0.9 time = 180
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=180.025n

* CHECK dout0_13 Vdout0_13ck35 = 0.9 time = 180
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=180.025n

* CHECK dout0_14 Vdout0_14ck35 = 0.9 time = 180
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=180.025n

* CHECK dout0_15 Vdout0_15ck35 = 0.9 time = 180
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=180.025n

* CHECK dout0_16 Vdout0_16ck35 = 0 time = 180
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=180.025n

* CHECK dout0_17 Vdout0_17ck35 = 0.9 time = 180
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=180.025n

* CHECK dout0_18 Vdout0_18ck35 = 0 time = 180
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=180.025n

* CHECK dout0_19 Vdout0_19ck35 = 0 time = 180
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=180.025n

* CHECK dout0_20 Vdout0_20ck35 = 0.9 time = 180
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=180.025n

* CHECK dout0_21 Vdout0_21ck35 = 0 time = 180
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=180.025n

* CHECK dout0_22 Vdout0_22ck35 = 0 time = 180
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=180.025n

* CHECK dout0_23 Vdout0_23ck35 = 0.9 time = 180
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=180.025n

* CHECK dout0_24 Vdout0_24ck35 = 0 time = 180
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=180.025n

* CHECK dout0_25 Vdout0_25ck35 = 0 time = 180
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=180.025n

* CHECK dout0_26 Vdout0_26ck35 = 0 time = 180
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=180.025n

* CHECK dout0_27 Vdout0_27ck35 = 0 time = 180
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=180.025n

* CHECK dout0_28 Vdout0_28ck35 = 0 time = 180
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=180.025n

* CHECK dout0_29 Vdout0_29ck35 = 0 time = 180
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=180.025n

* CHECK dout0_30 Vdout0_30ck35 = 0 time = 180
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=180.025n

* CHECK dout0_31 Vdout0_31ck35 = 0 time = 180
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=180.025n

* CHECK dout0_32 Vdout0_32ck35 = 0 time = 180
.meas tran vdout0_32ck35 FIND v(dout0_32) AT=180.025n

* CHECK dout0_33 Vdout0_33ck35 = 0 time = 180
.meas tran vdout0_33ck35 FIND v(dout0_33) AT=180.025n

* CHECK dout0_34 Vdout0_34ck35 = 0 time = 180
.meas tran vdout0_34ck35 FIND v(dout0_34) AT=180.025n

* CHECK dout0_35 Vdout0_35ck35 = 0 time = 180
.meas tran vdout0_35ck35 FIND v(dout0_35) AT=180.025n

* CHECK dout0_36 Vdout0_36ck35 = 0.9 time = 180
.meas tran vdout0_36ck35 FIND v(dout0_36) AT=180.025n

* CHECK dout0_37 Vdout0_37ck35 = 0.9 time = 180
.meas tran vdout0_37ck35 FIND v(dout0_37) AT=180.025n

* CHECK dout0_38 Vdout0_38ck35 = 0.9 time = 180
.meas tran vdout0_38ck35 FIND v(dout0_38) AT=180.025n

* CHECK dout0_39 Vdout0_39ck35 = 0.9 time = 180
.meas tran vdout0_39ck35 FIND v(dout0_39) AT=180.025n

* CHECK dout0_40 Vdout0_40ck35 = 0.9 time = 180
.meas tran vdout0_40ck35 FIND v(dout0_40) AT=180.025n

* CHECK dout0_41 Vdout0_41ck35 = 0 time = 180
.meas tran vdout0_41ck35 FIND v(dout0_41) AT=180.025n

* CHECK dout0_42 Vdout0_42ck35 = 0.9 time = 180
.meas tran vdout0_42ck35 FIND v(dout0_42) AT=180.025n

* CHECK dout0_43 Vdout0_43ck35 = 0.9 time = 180
.meas tran vdout0_43ck35 FIND v(dout0_43) AT=180.025n

* CHECK dout0_44 Vdout0_44ck35 = 0 time = 180
.meas tran vdout0_44ck35 FIND v(dout0_44) AT=180.025n

* CHECK dout0_45 Vdout0_45ck35 = 0.9 time = 180
.meas tran vdout0_45ck35 FIND v(dout0_45) AT=180.025n

* CHECK dout0_46 Vdout0_46ck35 = 0.9 time = 180
.meas tran vdout0_46ck35 FIND v(dout0_46) AT=180.025n

* CHECK dout0_47 Vdout0_47ck35 = 0 time = 180
.meas tran vdout0_47ck35 FIND v(dout0_47) AT=180.025n

* CHECK dout0_48 Vdout0_48ck35 = 0 time = 180
.meas tran vdout0_48ck35 FIND v(dout0_48) AT=180.025n

* CHECK dout0_49 Vdout0_49ck35 = 0.9 time = 180
.meas tran vdout0_49ck35 FIND v(dout0_49) AT=180.025n

* CHECK dout0_50 Vdout0_50ck35 = 0 time = 180
.meas tran vdout0_50ck35 FIND v(dout0_50) AT=180.025n

* CHECK dout0_51 Vdout0_51ck35 = 0 time = 180
.meas tran vdout0_51ck35 FIND v(dout0_51) AT=180.025n

* CHECK dout0_52 Vdout0_52ck35 = 0 time = 180
.meas tran vdout0_52ck35 FIND v(dout0_52) AT=180.025n

* CHECK dout0_53 Vdout0_53ck35 = 0 time = 180
.meas tran vdout0_53ck35 FIND v(dout0_53) AT=180.025n

* CHECK dout0_54 Vdout0_54ck35 = 0.9 time = 180
.meas tran vdout0_54ck35 FIND v(dout0_54) AT=180.025n

* CHECK dout0_55 Vdout0_55ck35 = 0 time = 180
.meas tran vdout0_55ck35 FIND v(dout0_55) AT=180.025n

* CHECK dout0_56 Vdout0_56ck35 = 0 time = 180
.meas tran vdout0_56ck35 FIND v(dout0_56) AT=180.025n

* CHECK dout0_57 Vdout0_57ck35 = 0.9 time = 180
.meas tran vdout0_57ck35 FIND v(dout0_57) AT=180.025n

* CHECK dout0_58 Vdout0_58ck35 = 0.9 time = 180
.meas tran vdout0_58ck35 FIND v(dout0_58) AT=180.025n

* CHECK dout0_59 Vdout0_59ck35 = 0 time = 180
.meas tran vdout0_59ck35 FIND v(dout0_59) AT=180.025n

* CHECK dout0_60 Vdout0_60ck35 = 0 time = 180
.meas tran vdout0_60ck35 FIND v(dout0_60) AT=180.025n

* CHECK dout0_61 Vdout0_61ck35 = 0.9 time = 180
.meas tran vdout0_61ck35 FIND v(dout0_61) AT=180.025n

* CHECK dout0_62 Vdout0_62ck35 = 0 time = 180
.meas tran vdout0_62ck35 FIND v(dout0_62) AT=180.025n

* CHECK dout0_63 Vdout0_63ck35 = 0.9 time = 180
.meas tran vdout0_63ck35 FIND v(dout0_63) AT=180.025n

* CHECK dout0_0 Vdout0_0ck37 = 0.9 time = 190
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=190.025n

* CHECK dout0_1 Vdout0_1ck37 = 0.9 time = 190
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=190.025n

* CHECK dout0_2 Vdout0_2ck37 = 0.9 time = 190
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=190.025n

* CHECK dout0_3 Vdout0_3ck37 = 0.9 time = 190
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=190.025n

* CHECK dout0_4 Vdout0_4ck37 = 0 time = 190
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=190.025n

* CHECK dout0_5 Vdout0_5ck37 = 0.9 time = 190
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=190.025n

* CHECK dout0_6 Vdout0_6ck37 = 0.9 time = 190
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=190.025n

* CHECK dout0_7 Vdout0_7ck37 = 0.9 time = 190
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=190.025n

* CHECK dout0_8 Vdout0_8ck37 = 0.9 time = 190
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=190.025n

* CHECK dout0_9 Vdout0_9ck37 = 0.9 time = 190
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=190.025n

* CHECK dout0_10 Vdout0_10ck37 = 0.9 time = 190
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=190.025n

* CHECK dout0_11 Vdout0_11ck37 = 0 time = 190
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=190.025n

* CHECK dout0_12 Vdout0_12ck37 = 0.9 time = 190
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=190.025n

* CHECK dout0_13 Vdout0_13ck37 = 0.9 time = 190
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=190.025n

* CHECK dout0_14 Vdout0_14ck37 = 0.9 time = 190
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=190.025n

* CHECK dout0_15 Vdout0_15ck37 = 0.9 time = 190
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=190.025n

* CHECK dout0_16 Vdout0_16ck37 = 0 time = 190
.meas tran vdout0_16ck37 FIND v(dout0_16) AT=190.025n

* CHECK dout0_17 Vdout0_17ck37 = 0.9 time = 190
.meas tran vdout0_17ck37 FIND v(dout0_17) AT=190.025n

* CHECK dout0_18 Vdout0_18ck37 = 0 time = 190
.meas tran vdout0_18ck37 FIND v(dout0_18) AT=190.025n

* CHECK dout0_19 Vdout0_19ck37 = 0 time = 190
.meas tran vdout0_19ck37 FIND v(dout0_19) AT=190.025n

* CHECK dout0_20 Vdout0_20ck37 = 0.9 time = 190
.meas tran vdout0_20ck37 FIND v(dout0_20) AT=190.025n

* CHECK dout0_21 Vdout0_21ck37 = 0 time = 190
.meas tran vdout0_21ck37 FIND v(dout0_21) AT=190.025n

* CHECK dout0_22 Vdout0_22ck37 = 0 time = 190
.meas tran vdout0_22ck37 FIND v(dout0_22) AT=190.025n

* CHECK dout0_23 Vdout0_23ck37 = 0.9 time = 190
.meas tran vdout0_23ck37 FIND v(dout0_23) AT=190.025n

* CHECK dout0_24 Vdout0_24ck37 = 0 time = 190
.meas tran vdout0_24ck37 FIND v(dout0_24) AT=190.025n

* CHECK dout0_25 Vdout0_25ck37 = 0 time = 190
.meas tran vdout0_25ck37 FIND v(dout0_25) AT=190.025n

* CHECK dout0_26 Vdout0_26ck37 = 0 time = 190
.meas tran vdout0_26ck37 FIND v(dout0_26) AT=190.025n

* CHECK dout0_27 Vdout0_27ck37 = 0 time = 190
.meas tran vdout0_27ck37 FIND v(dout0_27) AT=190.025n

* CHECK dout0_28 Vdout0_28ck37 = 0 time = 190
.meas tran vdout0_28ck37 FIND v(dout0_28) AT=190.025n

* CHECK dout0_29 Vdout0_29ck37 = 0 time = 190
.meas tran vdout0_29ck37 FIND v(dout0_29) AT=190.025n

* CHECK dout0_30 Vdout0_30ck37 = 0 time = 190
.meas tran vdout0_30ck37 FIND v(dout0_30) AT=190.025n

* CHECK dout0_31 Vdout0_31ck37 = 0 time = 190
.meas tran vdout0_31ck37 FIND v(dout0_31) AT=190.025n

* CHECK dout0_32 Vdout0_32ck37 = 0 time = 190
.meas tran vdout0_32ck37 FIND v(dout0_32) AT=190.025n

* CHECK dout0_33 Vdout0_33ck37 = 0 time = 190
.meas tran vdout0_33ck37 FIND v(dout0_33) AT=190.025n

* CHECK dout0_34 Vdout0_34ck37 = 0 time = 190
.meas tran vdout0_34ck37 FIND v(dout0_34) AT=190.025n

* CHECK dout0_35 Vdout0_35ck37 = 0 time = 190
.meas tran vdout0_35ck37 FIND v(dout0_35) AT=190.025n

* CHECK dout0_36 Vdout0_36ck37 = 0.9 time = 190
.meas tran vdout0_36ck37 FIND v(dout0_36) AT=190.025n

* CHECK dout0_37 Vdout0_37ck37 = 0.9 time = 190
.meas tran vdout0_37ck37 FIND v(dout0_37) AT=190.025n

* CHECK dout0_38 Vdout0_38ck37 = 0.9 time = 190
.meas tran vdout0_38ck37 FIND v(dout0_38) AT=190.025n

* CHECK dout0_39 Vdout0_39ck37 = 0.9 time = 190
.meas tran vdout0_39ck37 FIND v(dout0_39) AT=190.025n

* CHECK dout0_40 Vdout0_40ck37 = 0.9 time = 190
.meas tran vdout0_40ck37 FIND v(dout0_40) AT=190.025n

* CHECK dout0_41 Vdout0_41ck37 = 0 time = 190
.meas tran vdout0_41ck37 FIND v(dout0_41) AT=190.025n

* CHECK dout0_42 Vdout0_42ck37 = 0.9 time = 190
.meas tran vdout0_42ck37 FIND v(dout0_42) AT=190.025n

* CHECK dout0_43 Vdout0_43ck37 = 0.9 time = 190
.meas tran vdout0_43ck37 FIND v(dout0_43) AT=190.025n

* CHECK dout0_44 Vdout0_44ck37 = 0 time = 190
.meas tran vdout0_44ck37 FIND v(dout0_44) AT=190.025n

* CHECK dout0_45 Vdout0_45ck37 = 0.9 time = 190
.meas tran vdout0_45ck37 FIND v(dout0_45) AT=190.025n

* CHECK dout0_46 Vdout0_46ck37 = 0.9 time = 190
.meas tran vdout0_46ck37 FIND v(dout0_46) AT=190.025n

* CHECK dout0_47 Vdout0_47ck37 = 0 time = 190
.meas tran vdout0_47ck37 FIND v(dout0_47) AT=190.025n

* CHECK dout0_48 Vdout0_48ck37 = 0 time = 190
.meas tran vdout0_48ck37 FIND v(dout0_48) AT=190.025n

* CHECK dout0_49 Vdout0_49ck37 = 0.9 time = 190
.meas tran vdout0_49ck37 FIND v(dout0_49) AT=190.025n

* CHECK dout0_50 Vdout0_50ck37 = 0 time = 190
.meas tran vdout0_50ck37 FIND v(dout0_50) AT=190.025n

* CHECK dout0_51 Vdout0_51ck37 = 0 time = 190
.meas tran vdout0_51ck37 FIND v(dout0_51) AT=190.025n

* CHECK dout0_52 Vdout0_52ck37 = 0 time = 190
.meas tran vdout0_52ck37 FIND v(dout0_52) AT=190.025n

* CHECK dout0_53 Vdout0_53ck37 = 0 time = 190
.meas tran vdout0_53ck37 FIND v(dout0_53) AT=190.025n

* CHECK dout0_54 Vdout0_54ck37 = 0.9 time = 190
.meas tran vdout0_54ck37 FIND v(dout0_54) AT=190.025n

* CHECK dout0_55 Vdout0_55ck37 = 0 time = 190
.meas tran vdout0_55ck37 FIND v(dout0_55) AT=190.025n

* CHECK dout0_56 Vdout0_56ck37 = 0 time = 190
.meas tran vdout0_56ck37 FIND v(dout0_56) AT=190.025n

* CHECK dout0_57 Vdout0_57ck37 = 0.9 time = 190
.meas tran vdout0_57ck37 FIND v(dout0_57) AT=190.025n

* CHECK dout0_58 Vdout0_58ck37 = 0.9 time = 190
.meas tran vdout0_58ck37 FIND v(dout0_58) AT=190.025n

* CHECK dout0_59 Vdout0_59ck37 = 0 time = 190
.meas tran vdout0_59ck37 FIND v(dout0_59) AT=190.025n

* CHECK dout0_60 Vdout0_60ck37 = 0 time = 190
.meas tran vdout0_60ck37 FIND v(dout0_60) AT=190.025n

* CHECK dout0_61 Vdout0_61ck37 = 0.9 time = 190
.meas tran vdout0_61ck37 FIND v(dout0_61) AT=190.025n

* CHECK dout0_62 Vdout0_62ck37 = 0 time = 190
.meas tran vdout0_62ck37 FIND v(dout0_62) AT=190.025n

* CHECK dout0_63 Vdout0_63ck37 = 0.9 time = 190
.meas tran vdout0_63ck37 FIND v(dout0_63) AT=190.025n

* CHECK dout0_0 Vdout0_0ck39 = 0.9 time = 200
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=200.025n

* CHECK dout0_1 Vdout0_1ck39 = 0.9 time = 200
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=200.025n

* CHECK dout0_2 Vdout0_2ck39 = 0.9 time = 200
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=200.025n

* CHECK dout0_3 Vdout0_3ck39 = 0.9 time = 200
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=200.025n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 200
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=200.025n

* CHECK dout0_5 Vdout0_5ck39 = 0.9 time = 200
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=200.025n

* CHECK dout0_6 Vdout0_6ck39 = 0.9 time = 200
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=200.025n

* CHECK dout0_7 Vdout0_7ck39 = 0.9 time = 200
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=200.025n

* CHECK dout0_8 Vdout0_8ck39 = 0.9 time = 200
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=200.025n

* CHECK dout0_9 Vdout0_9ck39 = 0.9 time = 200
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=200.025n

* CHECK dout0_10 Vdout0_10ck39 = 0.9 time = 200
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=200.025n

* CHECK dout0_11 Vdout0_11ck39 = 0 time = 200
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=200.025n

* CHECK dout0_12 Vdout0_12ck39 = 0.9 time = 200
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=200.025n

* CHECK dout0_13 Vdout0_13ck39 = 0.9 time = 200
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=200.025n

* CHECK dout0_14 Vdout0_14ck39 = 0.9 time = 200
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=200.025n

* CHECK dout0_15 Vdout0_15ck39 = 0.9 time = 200
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=200.025n

* CHECK dout0_16 Vdout0_16ck39 = 0 time = 200
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=200.025n

* CHECK dout0_17 Vdout0_17ck39 = 0.9 time = 200
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=200.025n

* CHECK dout0_18 Vdout0_18ck39 = 0 time = 200
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=200.025n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 200
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=200.025n

* CHECK dout0_20 Vdout0_20ck39 = 0.9 time = 200
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=200.025n

* CHECK dout0_21 Vdout0_21ck39 = 0 time = 200
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=200.025n

* CHECK dout0_22 Vdout0_22ck39 = 0 time = 200
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=200.025n

* CHECK dout0_23 Vdout0_23ck39 = 0.9 time = 200
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=200.025n

* CHECK dout0_24 Vdout0_24ck39 = 0 time = 200
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=200.025n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 200
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=200.025n

* CHECK dout0_26 Vdout0_26ck39 = 0 time = 200
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=200.025n

* CHECK dout0_27 Vdout0_27ck39 = 0 time = 200
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=200.025n

* CHECK dout0_28 Vdout0_28ck39 = 0 time = 200
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=200.025n

* CHECK dout0_29 Vdout0_29ck39 = 0 time = 200
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=200.025n

* CHECK dout0_30 Vdout0_30ck39 = 0 time = 200
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=200.025n

* CHECK dout0_31 Vdout0_31ck39 = 0 time = 200
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=200.025n

* CHECK dout0_32 Vdout0_32ck39 = 0 time = 200
.meas tran vdout0_32ck39 FIND v(dout0_32) AT=200.025n

* CHECK dout0_33 Vdout0_33ck39 = 0 time = 200
.meas tran vdout0_33ck39 FIND v(dout0_33) AT=200.025n

* CHECK dout0_34 Vdout0_34ck39 = 0 time = 200
.meas tran vdout0_34ck39 FIND v(dout0_34) AT=200.025n

* CHECK dout0_35 Vdout0_35ck39 = 0 time = 200
.meas tran vdout0_35ck39 FIND v(dout0_35) AT=200.025n

* CHECK dout0_36 Vdout0_36ck39 = 0.9 time = 200
.meas tran vdout0_36ck39 FIND v(dout0_36) AT=200.025n

* CHECK dout0_37 Vdout0_37ck39 = 0.9 time = 200
.meas tran vdout0_37ck39 FIND v(dout0_37) AT=200.025n

* CHECK dout0_38 Vdout0_38ck39 = 0.9 time = 200
.meas tran vdout0_38ck39 FIND v(dout0_38) AT=200.025n

* CHECK dout0_39 Vdout0_39ck39 = 0.9 time = 200
.meas tran vdout0_39ck39 FIND v(dout0_39) AT=200.025n

* CHECK dout0_40 Vdout0_40ck39 = 0.9 time = 200
.meas tran vdout0_40ck39 FIND v(dout0_40) AT=200.025n

* CHECK dout0_41 Vdout0_41ck39 = 0 time = 200
.meas tran vdout0_41ck39 FIND v(dout0_41) AT=200.025n

* CHECK dout0_42 Vdout0_42ck39 = 0.9 time = 200
.meas tran vdout0_42ck39 FIND v(dout0_42) AT=200.025n

* CHECK dout0_43 Vdout0_43ck39 = 0.9 time = 200
.meas tran vdout0_43ck39 FIND v(dout0_43) AT=200.025n

* CHECK dout0_44 Vdout0_44ck39 = 0 time = 200
.meas tran vdout0_44ck39 FIND v(dout0_44) AT=200.025n

* CHECK dout0_45 Vdout0_45ck39 = 0.9 time = 200
.meas tran vdout0_45ck39 FIND v(dout0_45) AT=200.025n

* CHECK dout0_46 Vdout0_46ck39 = 0.9 time = 200
.meas tran vdout0_46ck39 FIND v(dout0_46) AT=200.025n

* CHECK dout0_47 Vdout0_47ck39 = 0 time = 200
.meas tran vdout0_47ck39 FIND v(dout0_47) AT=200.025n

* CHECK dout0_48 Vdout0_48ck39 = 0 time = 200
.meas tran vdout0_48ck39 FIND v(dout0_48) AT=200.025n

* CHECK dout0_49 Vdout0_49ck39 = 0.9 time = 200
.meas tran vdout0_49ck39 FIND v(dout0_49) AT=200.025n

* CHECK dout0_50 Vdout0_50ck39 = 0 time = 200
.meas tran vdout0_50ck39 FIND v(dout0_50) AT=200.025n

* CHECK dout0_51 Vdout0_51ck39 = 0 time = 200
.meas tran vdout0_51ck39 FIND v(dout0_51) AT=200.025n

* CHECK dout0_52 Vdout0_52ck39 = 0 time = 200
.meas tran vdout0_52ck39 FIND v(dout0_52) AT=200.025n

* CHECK dout0_53 Vdout0_53ck39 = 0 time = 200
.meas tran vdout0_53ck39 FIND v(dout0_53) AT=200.025n

* CHECK dout0_54 Vdout0_54ck39 = 0.9 time = 200
.meas tran vdout0_54ck39 FIND v(dout0_54) AT=200.025n

* CHECK dout0_55 Vdout0_55ck39 = 0 time = 200
.meas tran vdout0_55ck39 FIND v(dout0_55) AT=200.025n

* CHECK dout0_56 Vdout0_56ck39 = 0 time = 200
.meas tran vdout0_56ck39 FIND v(dout0_56) AT=200.025n

* CHECK dout0_57 Vdout0_57ck39 = 0.9 time = 200
.meas tran vdout0_57ck39 FIND v(dout0_57) AT=200.025n

* CHECK dout0_58 Vdout0_58ck39 = 0.9 time = 200
.meas tran vdout0_58ck39 FIND v(dout0_58) AT=200.025n

* CHECK dout0_59 Vdout0_59ck39 = 0 time = 200
.meas tran vdout0_59ck39 FIND v(dout0_59) AT=200.025n

* CHECK dout0_60 Vdout0_60ck39 = 0 time = 200
.meas tran vdout0_60ck39 FIND v(dout0_60) AT=200.025n

* CHECK dout0_61 Vdout0_61ck39 = 0.9 time = 200
.meas tran vdout0_61ck39 FIND v(dout0_61) AT=200.025n

* CHECK dout0_62 Vdout0_62ck39 = 0 time = 200
.meas tran vdout0_62ck39 FIND v(dout0_62) AT=200.025n

* CHECK dout0_63 Vdout0_63ck39 = 0.9 time = 200
.meas tran vdout0_63ck39 FIND v(dout0_63) AT=200.025n

* CHECK dout0_0 Vdout0_0ck42 = 0.9 time = 215
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=215.025n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 215
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=215.025n

* CHECK dout0_2 Vdout0_2ck42 = 0.9 time = 215
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=215.025n

* CHECK dout0_3 Vdout0_3ck42 = 0.9 time = 215
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=215.025n

* CHECK dout0_4 Vdout0_4ck42 = 0 time = 215
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=215.025n

* CHECK dout0_5 Vdout0_5ck42 = 0.9 time = 215
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=215.025n

* CHECK dout0_6 Vdout0_6ck42 = 0.9 time = 215
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=215.025n

* CHECK dout0_7 Vdout0_7ck42 = 0.9 time = 215
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=215.025n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 215
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=215.025n

* CHECK dout0_9 Vdout0_9ck42 = 0.9 time = 215
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=215.025n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 215
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=215.025n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 215
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=215.025n

* CHECK dout0_12 Vdout0_12ck42 = 0.9 time = 215
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=215.025n

* CHECK dout0_13 Vdout0_13ck42 = 0.9 time = 215
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=215.025n

* CHECK dout0_14 Vdout0_14ck42 = 0.9 time = 215
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=215.025n

* CHECK dout0_15 Vdout0_15ck42 = 0.9 time = 215
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=215.025n

* CHECK dout0_16 Vdout0_16ck42 = 0.9 time = 215
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=215.025n

* CHECK dout0_17 Vdout0_17ck42 = 0.9 time = 215
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=215.025n

* CHECK dout0_18 Vdout0_18ck42 = 0 time = 215
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=215.025n

* CHECK dout0_19 Vdout0_19ck42 = 0.9 time = 215
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=215.025n

* CHECK dout0_20 Vdout0_20ck42 = 0.9 time = 215
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=215.025n

* CHECK dout0_21 Vdout0_21ck42 = 0.9 time = 215
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=215.025n

* CHECK dout0_22 Vdout0_22ck42 = 0.9 time = 215
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=215.025n

* CHECK dout0_23 Vdout0_23ck42 = 0 time = 215
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=215.025n

* CHECK dout0_24 Vdout0_24ck42 = 0 time = 215
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=215.025n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 215
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=215.025n

* CHECK dout0_26 Vdout0_26ck42 = 0.9 time = 215
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=215.025n

* CHECK dout0_27 Vdout0_27ck42 = 0.9 time = 215
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=215.025n

* CHECK dout0_28 Vdout0_28ck42 = 0 time = 215
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=215.025n

* CHECK dout0_29 Vdout0_29ck42 = 0.9 time = 215
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=215.025n

* CHECK dout0_30 Vdout0_30ck42 = 0 time = 215
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=215.025n

* CHECK dout0_31 Vdout0_31ck42 = 0.9 time = 215
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=215.025n

* CHECK dout0_32 Vdout0_32ck42 = 0.9 time = 215
.meas tran vdout0_32ck42 FIND v(dout0_32) AT=215.025n

* CHECK dout0_33 Vdout0_33ck42 = 0 time = 215
.meas tran vdout0_33ck42 FIND v(dout0_33) AT=215.025n

* CHECK dout0_34 Vdout0_34ck42 = 0.9 time = 215
.meas tran vdout0_34ck42 FIND v(dout0_34) AT=215.025n

* CHECK dout0_35 Vdout0_35ck42 = 0.9 time = 215
.meas tran vdout0_35ck42 FIND v(dout0_35) AT=215.025n

* CHECK dout0_36 Vdout0_36ck42 = 0.9 time = 215
.meas tran vdout0_36ck42 FIND v(dout0_36) AT=215.025n

* CHECK dout0_37 Vdout0_37ck42 = 0.9 time = 215
.meas tran vdout0_37ck42 FIND v(dout0_37) AT=215.025n

* CHECK dout0_38 Vdout0_38ck42 = 0.9 time = 215
.meas tran vdout0_38ck42 FIND v(dout0_38) AT=215.025n

* CHECK dout0_39 Vdout0_39ck42 = 0 time = 215
.meas tran vdout0_39ck42 FIND v(dout0_39) AT=215.025n

* CHECK dout0_40 Vdout0_40ck42 = 0.9 time = 215
.meas tran vdout0_40ck42 FIND v(dout0_40) AT=215.025n

* CHECK dout0_41 Vdout0_41ck42 = 0 time = 215
.meas tran vdout0_41ck42 FIND v(dout0_41) AT=215.025n

* CHECK dout0_42 Vdout0_42ck42 = 0 time = 215
.meas tran vdout0_42ck42 FIND v(dout0_42) AT=215.025n

* CHECK dout0_43 Vdout0_43ck42 = 0 time = 215
.meas tran vdout0_43ck42 FIND v(dout0_43) AT=215.025n

* CHECK dout0_44 Vdout0_44ck42 = 0.9 time = 215
.meas tran vdout0_44ck42 FIND v(dout0_44) AT=215.025n

* CHECK dout0_45 Vdout0_45ck42 = 0 time = 215
.meas tran vdout0_45ck42 FIND v(dout0_45) AT=215.025n

* CHECK dout0_46 Vdout0_46ck42 = 0.9 time = 215
.meas tran vdout0_46ck42 FIND v(dout0_46) AT=215.025n

* CHECK dout0_47 Vdout0_47ck42 = 0 time = 215
.meas tran vdout0_47ck42 FIND v(dout0_47) AT=215.025n

* CHECK dout0_48 Vdout0_48ck42 = 0 time = 215
.meas tran vdout0_48ck42 FIND v(dout0_48) AT=215.025n

* CHECK dout0_49 Vdout0_49ck42 = 0.9 time = 215
.meas tran vdout0_49ck42 FIND v(dout0_49) AT=215.025n

* CHECK dout0_50 Vdout0_50ck42 = 0.9 time = 215
.meas tran vdout0_50ck42 FIND v(dout0_50) AT=215.025n

* CHECK dout0_51 Vdout0_51ck42 = 0 time = 215
.meas tran vdout0_51ck42 FIND v(dout0_51) AT=215.025n

* CHECK dout0_52 Vdout0_52ck42 = 0 time = 215
.meas tran vdout0_52ck42 FIND v(dout0_52) AT=215.025n

* CHECK dout0_53 Vdout0_53ck42 = 0 time = 215
.meas tran vdout0_53ck42 FIND v(dout0_53) AT=215.025n

* CHECK dout0_54 Vdout0_54ck42 = 0.9 time = 215
.meas tran vdout0_54ck42 FIND v(dout0_54) AT=215.025n

* CHECK dout0_55 Vdout0_55ck42 = 0 time = 215
.meas tran vdout0_55ck42 FIND v(dout0_55) AT=215.025n

* CHECK dout0_56 Vdout0_56ck42 = 0 time = 215
.meas tran vdout0_56ck42 FIND v(dout0_56) AT=215.025n

* CHECK dout0_57 Vdout0_57ck42 = 0 time = 215
.meas tran vdout0_57ck42 FIND v(dout0_57) AT=215.025n

* CHECK dout0_58 Vdout0_58ck42 = 0.9 time = 215
.meas tran vdout0_58ck42 FIND v(dout0_58) AT=215.025n

* CHECK dout0_59 Vdout0_59ck42 = 0.9 time = 215
.meas tran vdout0_59ck42 FIND v(dout0_59) AT=215.025n

* CHECK dout0_60 Vdout0_60ck42 = 0.9 time = 215
.meas tran vdout0_60ck42 FIND v(dout0_60) AT=215.025n

* CHECK dout0_61 Vdout0_61ck42 = 0 time = 215
.meas tran vdout0_61ck42 FIND v(dout0_61) AT=215.025n

* CHECK dout0_62 Vdout0_62ck42 = 0 time = 215
.meas tran vdout0_62ck42 FIND v(dout0_62) AT=215.025n

* CHECK dout0_63 Vdout0_63ck42 = 0 time = 215
.meas tran vdout0_63ck42 FIND v(dout0_63) AT=215.025n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 225
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=225.025n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 225
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=225.025n

* CHECK dout0_2 Vdout0_2ck44 = 0.9 time = 225
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=225.025n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 225
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=225.025n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 225
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=225.025n

* CHECK dout0_5 Vdout0_5ck44 = 0.9 time = 225
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=225.025n

* CHECK dout0_6 Vdout0_6ck44 = 0.9 time = 225
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=225.025n

* CHECK dout0_7 Vdout0_7ck44 = 0 time = 225
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=225.025n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 225
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=225.025n

* CHECK dout0_9 Vdout0_9ck44 = 0.9 time = 225
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=225.025n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 225
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=225.025n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 225
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=225.025n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 225
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=225.025n

* CHECK dout0_13 Vdout0_13ck44 = 0.9 time = 225
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=225.025n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 225
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=225.025n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 225
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=225.025n

* CHECK dout0_16 Vdout0_16ck44 = 0.9 time = 225
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=225.025n

* CHECK dout0_17 Vdout0_17ck44 = 0 time = 225
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=225.025n

* CHECK dout0_18 Vdout0_18ck44 = 0 time = 225
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=225.025n

* CHECK dout0_19 Vdout0_19ck44 = 0.9 time = 225
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=225.025n

* CHECK dout0_20 Vdout0_20ck44 = 0 time = 225
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=225.025n

* CHECK dout0_21 Vdout0_21ck44 = 0 time = 225
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=225.025n

* CHECK dout0_22 Vdout0_22ck44 = 0 time = 225
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=225.025n

* CHECK dout0_23 Vdout0_23ck44 = 0.9 time = 225
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=225.025n

* CHECK dout0_24 Vdout0_24ck44 = 0 time = 225
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=225.025n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 225
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=225.025n

* CHECK dout0_26 Vdout0_26ck44 = 0.9 time = 225
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=225.025n

* CHECK dout0_27 Vdout0_27ck44 = 0 time = 225
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=225.025n

* CHECK dout0_28 Vdout0_28ck44 = 0.9 time = 225
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=225.025n

* CHECK dout0_29 Vdout0_29ck44 = 0 time = 225
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=225.025n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 225
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=225.025n

* CHECK dout0_31 Vdout0_31ck44 = 0.9 time = 225
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=225.025n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 225
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=225.025n

* CHECK dout0_33 Vdout0_33ck44 = 0 time = 225
.meas tran vdout0_33ck44 FIND v(dout0_33) AT=225.025n

* CHECK dout0_34 Vdout0_34ck44 = 0.9 time = 225
.meas tran vdout0_34ck44 FIND v(dout0_34) AT=225.025n

* CHECK dout0_35 Vdout0_35ck44 = 0.9 time = 225
.meas tran vdout0_35ck44 FIND v(dout0_35) AT=225.025n

* CHECK dout0_36 Vdout0_36ck44 = 0.9 time = 225
.meas tran vdout0_36ck44 FIND v(dout0_36) AT=225.025n

* CHECK dout0_37 Vdout0_37ck44 = 0 time = 225
.meas tran vdout0_37ck44 FIND v(dout0_37) AT=225.025n

* CHECK dout0_38 Vdout0_38ck44 = 0 time = 225
.meas tran vdout0_38ck44 FIND v(dout0_38) AT=225.025n

* CHECK dout0_39 Vdout0_39ck44 = 0 time = 225
.meas tran vdout0_39ck44 FIND v(dout0_39) AT=225.025n

* CHECK dout0_40 Vdout0_40ck44 = 0.9 time = 225
.meas tran vdout0_40ck44 FIND v(dout0_40) AT=225.025n

* CHECK dout0_41 Vdout0_41ck44 = 0 time = 225
.meas tran vdout0_41ck44 FIND v(dout0_41) AT=225.025n

* CHECK dout0_42 Vdout0_42ck44 = 0 time = 225
.meas tran vdout0_42ck44 FIND v(dout0_42) AT=225.025n

* CHECK dout0_43 Vdout0_43ck44 = 0.9 time = 225
.meas tran vdout0_43ck44 FIND v(dout0_43) AT=225.025n

* CHECK dout0_44 Vdout0_44ck44 = 0 time = 225
.meas tran vdout0_44ck44 FIND v(dout0_44) AT=225.025n

* CHECK dout0_45 Vdout0_45ck44 = 0 time = 225
.meas tran vdout0_45ck44 FIND v(dout0_45) AT=225.025n

* CHECK dout0_46 Vdout0_46ck44 = 0 time = 225
.meas tran vdout0_46ck44 FIND v(dout0_46) AT=225.025n

* CHECK dout0_47 Vdout0_47ck44 = 0.9 time = 225
.meas tran vdout0_47ck44 FIND v(dout0_47) AT=225.025n

* CHECK dout0_48 Vdout0_48ck44 = 0 time = 225
.meas tran vdout0_48ck44 FIND v(dout0_48) AT=225.025n

* CHECK dout0_49 Vdout0_49ck44 = 0 time = 225
.meas tran vdout0_49ck44 FIND v(dout0_49) AT=225.025n

* CHECK dout0_50 Vdout0_50ck44 = 0 time = 225
.meas tran vdout0_50ck44 FIND v(dout0_50) AT=225.025n

* CHECK dout0_51 Vdout0_51ck44 = 0 time = 225
.meas tran vdout0_51ck44 FIND v(dout0_51) AT=225.025n

* CHECK dout0_52 Vdout0_52ck44 = 0.9 time = 225
.meas tran vdout0_52ck44 FIND v(dout0_52) AT=225.025n

* CHECK dout0_53 Vdout0_53ck44 = 0 time = 225
.meas tran vdout0_53ck44 FIND v(dout0_53) AT=225.025n

* CHECK dout0_54 Vdout0_54ck44 = 0 time = 225
.meas tran vdout0_54ck44 FIND v(dout0_54) AT=225.025n

* CHECK dout0_55 Vdout0_55ck44 = 0.9 time = 225
.meas tran vdout0_55ck44 FIND v(dout0_55) AT=225.025n

* CHECK dout0_56 Vdout0_56ck44 = 0.9 time = 225
.meas tran vdout0_56ck44 FIND v(dout0_56) AT=225.025n

* CHECK dout0_57 Vdout0_57ck44 = 0 time = 225
.meas tran vdout0_57ck44 FIND v(dout0_57) AT=225.025n

* CHECK dout0_58 Vdout0_58ck44 = 0 time = 225
.meas tran vdout0_58ck44 FIND v(dout0_58) AT=225.025n

* CHECK dout0_59 Vdout0_59ck44 = 0 time = 225
.meas tran vdout0_59ck44 FIND v(dout0_59) AT=225.025n

* CHECK dout0_60 Vdout0_60ck44 = 0 time = 225
.meas tran vdout0_60ck44 FIND v(dout0_60) AT=225.025n

* CHECK dout0_61 Vdout0_61ck44 = 0 time = 225
.meas tran vdout0_61ck44 FIND v(dout0_61) AT=225.025n

* CHECK dout0_62 Vdout0_62ck44 = 0.9 time = 225
.meas tran vdout0_62ck44 FIND v(dout0_62) AT=225.025n

* CHECK dout0_63 Vdout0_63ck44 = 0 time = 225
.meas tran vdout0_63ck44 FIND v(dout0_63) AT=225.025n

* CHECK dout0_0 Vdout0_0ck45 = 0.9 time = 230
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=230.025n

* CHECK dout0_1 Vdout0_1ck45 = 0.9 time = 230
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=230.025n

* CHECK dout0_2 Vdout0_2ck45 = 0 time = 230
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=230.025n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 230
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=230.025n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 230
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=230.025n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 230
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=230.025n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 230
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=230.025n

* CHECK dout0_7 Vdout0_7ck45 = 0 time = 230
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=230.025n

* CHECK dout0_8 Vdout0_8ck45 = 0.9 time = 230
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=230.025n

* CHECK dout0_9 Vdout0_9ck45 = 0 time = 230
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=230.025n

* CHECK dout0_10 Vdout0_10ck45 = 0.9 time = 230
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=230.025n

* CHECK dout0_11 Vdout0_11ck45 = 0 time = 230
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=230.025n

* CHECK dout0_12 Vdout0_12ck45 = 0 time = 230
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=230.025n

* CHECK dout0_13 Vdout0_13ck45 = 0.9 time = 230
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=230.025n

* CHECK dout0_14 Vdout0_14ck45 = 0.9 time = 230
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=230.025n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 230
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=230.025n

* CHECK dout0_16 Vdout0_16ck45 = 0 time = 230
.meas tran vdout0_16ck45 FIND v(dout0_16) AT=230.025n

* CHECK dout0_17 Vdout0_17ck45 = 0.9 time = 230
.meas tran vdout0_17ck45 FIND v(dout0_17) AT=230.025n

* CHECK dout0_18 Vdout0_18ck45 = 0 time = 230
.meas tran vdout0_18ck45 FIND v(dout0_18) AT=230.025n

* CHECK dout0_19 Vdout0_19ck45 = 0 time = 230
.meas tran vdout0_19ck45 FIND v(dout0_19) AT=230.025n

* CHECK dout0_20 Vdout0_20ck45 = 0 time = 230
.meas tran vdout0_20ck45 FIND v(dout0_20) AT=230.025n

* CHECK dout0_21 Vdout0_21ck45 = 0 time = 230
.meas tran vdout0_21ck45 FIND v(dout0_21) AT=230.025n

* CHECK dout0_22 Vdout0_22ck45 = 0 time = 230
.meas tran vdout0_22ck45 FIND v(dout0_22) AT=230.025n

* CHECK dout0_23 Vdout0_23ck45 = 0 time = 230
.meas tran vdout0_23ck45 FIND v(dout0_23) AT=230.025n

* CHECK dout0_24 Vdout0_24ck45 = 0 time = 230
.meas tran vdout0_24ck45 FIND v(dout0_24) AT=230.025n

* CHECK dout0_25 Vdout0_25ck45 = 0.9 time = 230
.meas tran vdout0_25ck45 FIND v(dout0_25) AT=230.025n

* CHECK dout0_26 Vdout0_26ck45 = 0 time = 230
.meas tran vdout0_26ck45 FIND v(dout0_26) AT=230.025n

* CHECK dout0_27 Vdout0_27ck45 = 0.9 time = 230
.meas tran vdout0_27ck45 FIND v(dout0_27) AT=230.025n

* CHECK dout0_28 Vdout0_28ck45 = 0 time = 230
.meas tran vdout0_28ck45 FIND v(dout0_28) AT=230.025n

* CHECK dout0_29 Vdout0_29ck45 = 0.9 time = 230
.meas tran vdout0_29ck45 FIND v(dout0_29) AT=230.025n

* CHECK dout0_30 Vdout0_30ck45 = 0 time = 230
.meas tran vdout0_30ck45 FIND v(dout0_30) AT=230.025n

* CHECK dout0_31 Vdout0_31ck45 = 0.9 time = 230
.meas tran vdout0_31ck45 FIND v(dout0_31) AT=230.025n

* CHECK dout0_32 Vdout0_32ck45 = 0 time = 230
.meas tran vdout0_32ck45 FIND v(dout0_32) AT=230.025n

* CHECK dout0_33 Vdout0_33ck45 = 0.9 time = 230
.meas tran vdout0_33ck45 FIND v(dout0_33) AT=230.025n

* CHECK dout0_34 Vdout0_34ck45 = 0.9 time = 230
.meas tran vdout0_34ck45 FIND v(dout0_34) AT=230.025n

* CHECK dout0_35 Vdout0_35ck45 = 0 time = 230
.meas tran vdout0_35ck45 FIND v(dout0_35) AT=230.025n

* CHECK dout0_36 Vdout0_36ck45 = 0 time = 230
.meas tran vdout0_36ck45 FIND v(dout0_36) AT=230.025n

* CHECK dout0_37 Vdout0_37ck45 = 0 time = 230
.meas tran vdout0_37ck45 FIND v(dout0_37) AT=230.025n

* CHECK dout0_38 Vdout0_38ck45 = 0.9 time = 230
.meas tran vdout0_38ck45 FIND v(dout0_38) AT=230.025n

* CHECK dout0_39 Vdout0_39ck45 = 0 time = 230
.meas tran vdout0_39ck45 FIND v(dout0_39) AT=230.025n

* CHECK dout0_40 Vdout0_40ck45 = 0.9 time = 230
.meas tran vdout0_40ck45 FIND v(dout0_40) AT=230.025n

* CHECK dout0_41 Vdout0_41ck45 = 0.9 time = 230
.meas tran vdout0_41ck45 FIND v(dout0_41) AT=230.025n

* CHECK dout0_42 Vdout0_42ck45 = 0.9 time = 230
.meas tran vdout0_42ck45 FIND v(dout0_42) AT=230.025n

* CHECK dout0_43 Vdout0_43ck45 = 0.9 time = 230
.meas tran vdout0_43ck45 FIND v(dout0_43) AT=230.025n

* CHECK dout0_44 Vdout0_44ck45 = 0.9 time = 230
.meas tran vdout0_44ck45 FIND v(dout0_44) AT=230.025n

* CHECK dout0_45 Vdout0_45ck45 = 0 time = 230
.meas tran vdout0_45ck45 FIND v(dout0_45) AT=230.025n

* CHECK dout0_46 Vdout0_46ck45 = 0.9 time = 230
.meas tran vdout0_46ck45 FIND v(dout0_46) AT=230.025n

* CHECK dout0_47 Vdout0_47ck45 = 0 time = 230
.meas tran vdout0_47ck45 FIND v(dout0_47) AT=230.025n

* CHECK dout0_48 Vdout0_48ck45 = 0.9 time = 230
.meas tran vdout0_48ck45 FIND v(dout0_48) AT=230.025n

* CHECK dout0_49 Vdout0_49ck45 = 0.9 time = 230
.meas tran vdout0_49ck45 FIND v(dout0_49) AT=230.025n

* CHECK dout0_50 Vdout0_50ck45 = 0 time = 230
.meas tran vdout0_50ck45 FIND v(dout0_50) AT=230.025n

* CHECK dout0_51 Vdout0_51ck45 = 0.9 time = 230
.meas tran vdout0_51ck45 FIND v(dout0_51) AT=230.025n

* CHECK dout0_52 Vdout0_52ck45 = 0.9 time = 230
.meas tran vdout0_52ck45 FIND v(dout0_52) AT=230.025n

* CHECK dout0_53 Vdout0_53ck45 = 0.9 time = 230
.meas tran vdout0_53ck45 FIND v(dout0_53) AT=230.025n

* CHECK dout0_54 Vdout0_54ck45 = 0 time = 230
.meas tran vdout0_54ck45 FIND v(dout0_54) AT=230.025n

* CHECK dout0_55 Vdout0_55ck45 = 0.9 time = 230
.meas tran vdout0_55ck45 FIND v(dout0_55) AT=230.025n

* CHECK dout0_56 Vdout0_56ck45 = 0 time = 230
.meas tran vdout0_56ck45 FIND v(dout0_56) AT=230.025n

* CHECK dout0_57 Vdout0_57ck45 = 0 time = 230
.meas tran vdout0_57ck45 FIND v(dout0_57) AT=230.025n

* CHECK dout0_58 Vdout0_58ck45 = 0 time = 230
.meas tran vdout0_58ck45 FIND v(dout0_58) AT=230.025n

* CHECK dout0_59 Vdout0_59ck45 = 0.9 time = 230
.meas tran vdout0_59ck45 FIND v(dout0_59) AT=230.025n

* CHECK dout0_60 Vdout0_60ck45 = 0.9 time = 230
.meas tran vdout0_60ck45 FIND v(dout0_60) AT=230.025n

* CHECK dout0_61 Vdout0_61ck45 = 0 time = 230
.meas tran vdout0_61ck45 FIND v(dout0_61) AT=230.025n

* CHECK dout0_62 Vdout0_62ck45 = 0 time = 230
.meas tran vdout0_62ck45 FIND v(dout0_62) AT=230.025n

* CHECK dout0_63 Vdout0_63ck45 = 0.9 time = 230
.meas tran vdout0_63ck45 FIND v(dout0_63) AT=230.025n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 235
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=235.025n

* CHECK dout0_1 Vdout0_1ck46 = 0 time = 235
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=235.025n

* CHECK dout0_2 Vdout0_2ck46 = 0.9 time = 235
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=235.025n

* CHECK dout0_3 Vdout0_3ck46 = 0 time = 235
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=235.025n

* CHECK dout0_4 Vdout0_4ck46 = 0 time = 235
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=235.025n

* CHECK dout0_5 Vdout0_5ck46 = 0.9 time = 235
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=235.025n

* CHECK dout0_6 Vdout0_6ck46 = 0.9 time = 235
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=235.025n

* CHECK dout0_7 Vdout0_7ck46 = 0 time = 235
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=235.025n

* CHECK dout0_8 Vdout0_8ck46 = 0 time = 235
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=235.025n

* CHECK dout0_9 Vdout0_9ck46 = 0.9 time = 235
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=235.025n

* CHECK dout0_10 Vdout0_10ck46 = 0 time = 235
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=235.025n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 235
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=235.025n

* CHECK dout0_12 Vdout0_12ck46 = 0 time = 235
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=235.025n

* CHECK dout0_13 Vdout0_13ck46 = 0.9 time = 235
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=235.025n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 235
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=235.025n

* CHECK dout0_15 Vdout0_15ck46 = 0 time = 235
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=235.025n

* CHECK dout0_16 Vdout0_16ck46 = 0.9 time = 235
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=235.025n

* CHECK dout0_17 Vdout0_17ck46 = 0 time = 235
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=235.025n

* CHECK dout0_18 Vdout0_18ck46 = 0 time = 235
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=235.025n

* CHECK dout0_19 Vdout0_19ck46 = 0.9 time = 235
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=235.025n

* CHECK dout0_20 Vdout0_20ck46 = 0 time = 235
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=235.025n

* CHECK dout0_21 Vdout0_21ck46 = 0 time = 235
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=235.025n

* CHECK dout0_22 Vdout0_22ck46 = 0 time = 235
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=235.025n

* CHECK dout0_23 Vdout0_23ck46 = 0.9 time = 235
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=235.025n

* CHECK dout0_24 Vdout0_24ck46 = 0 time = 235
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=235.025n

* CHECK dout0_25 Vdout0_25ck46 = 0 time = 235
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=235.025n

* CHECK dout0_26 Vdout0_26ck46 = 0.9 time = 235
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=235.025n

* CHECK dout0_27 Vdout0_27ck46 = 0 time = 235
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=235.025n

* CHECK dout0_28 Vdout0_28ck46 = 0.9 time = 235
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=235.025n

* CHECK dout0_29 Vdout0_29ck46 = 0 time = 235
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=235.025n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 235
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=235.025n

* CHECK dout0_31 Vdout0_31ck46 = 0.9 time = 235
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=235.025n

* CHECK dout0_32 Vdout0_32ck46 = 0 time = 235
.meas tran vdout0_32ck46 FIND v(dout0_32) AT=235.025n

* CHECK dout0_33 Vdout0_33ck46 = 0 time = 235
.meas tran vdout0_33ck46 FIND v(dout0_33) AT=235.025n

* CHECK dout0_34 Vdout0_34ck46 = 0.9 time = 235
.meas tran vdout0_34ck46 FIND v(dout0_34) AT=235.025n

* CHECK dout0_35 Vdout0_35ck46 = 0.9 time = 235
.meas tran vdout0_35ck46 FIND v(dout0_35) AT=235.025n

* CHECK dout0_36 Vdout0_36ck46 = 0.9 time = 235
.meas tran vdout0_36ck46 FIND v(dout0_36) AT=235.025n

* CHECK dout0_37 Vdout0_37ck46 = 0 time = 235
.meas tran vdout0_37ck46 FIND v(dout0_37) AT=235.025n

* CHECK dout0_38 Vdout0_38ck46 = 0 time = 235
.meas tran vdout0_38ck46 FIND v(dout0_38) AT=235.025n

* CHECK dout0_39 Vdout0_39ck46 = 0 time = 235
.meas tran vdout0_39ck46 FIND v(dout0_39) AT=235.025n

* CHECK dout0_40 Vdout0_40ck46 = 0.9 time = 235
.meas tran vdout0_40ck46 FIND v(dout0_40) AT=235.025n

* CHECK dout0_41 Vdout0_41ck46 = 0 time = 235
.meas tran vdout0_41ck46 FIND v(dout0_41) AT=235.025n

* CHECK dout0_42 Vdout0_42ck46 = 0 time = 235
.meas tran vdout0_42ck46 FIND v(dout0_42) AT=235.025n

* CHECK dout0_43 Vdout0_43ck46 = 0.9 time = 235
.meas tran vdout0_43ck46 FIND v(dout0_43) AT=235.025n

* CHECK dout0_44 Vdout0_44ck46 = 0 time = 235
.meas tran vdout0_44ck46 FIND v(dout0_44) AT=235.025n

* CHECK dout0_45 Vdout0_45ck46 = 0 time = 235
.meas tran vdout0_45ck46 FIND v(dout0_45) AT=235.025n

* CHECK dout0_46 Vdout0_46ck46 = 0 time = 235
.meas tran vdout0_46ck46 FIND v(dout0_46) AT=235.025n

* CHECK dout0_47 Vdout0_47ck46 = 0.9 time = 235
.meas tran vdout0_47ck46 FIND v(dout0_47) AT=235.025n

* CHECK dout0_48 Vdout0_48ck46 = 0 time = 235
.meas tran vdout0_48ck46 FIND v(dout0_48) AT=235.025n

* CHECK dout0_49 Vdout0_49ck46 = 0 time = 235
.meas tran vdout0_49ck46 FIND v(dout0_49) AT=235.025n

* CHECK dout0_50 Vdout0_50ck46 = 0 time = 235
.meas tran vdout0_50ck46 FIND v(dout0_50) AT=235.025n

* CHECK dout0_51 Vdout0_51ck46 = 0 time = 235
.meas tran vdout0_51ck46 FIND v(dout0_51) AT=235.025n

* CHECK dout0_52 Vdout0_52ck46 = 0.9 time = 235
.meas tran vdout0_52ck46 FIND v(dout0_52) AT=235.025n

* CHECK dout0_53 Vdout0_53ck46 = 0 time = 235
.meas tran vdout0_53ck46 FIND v(dout0_53) AT=235.025n

* CHECK dout0_54 Vdout0_54ck46 = 0 time = 235
.meas tran vdout0_54ck46 FIND v(dout0_54) AT=235.025n

* CHECK dout0_55 Vdout0_55ck46 = 0.9 time = 235
.meas tran vdout0_55ck46 FIND v(dout0_55) AT=235.025n

* CHECK dout0_56 Vdout0_56ck46 = 0.9 time = 235
.meas tran vdout0_56ck46 FIND v(dout0_56) AT=235.025n

* CHECK dout0_57 Vdout0_57ck46 = 0 time = 235
.meas tran vdout0_57ck46 FIND v(dout0_57) AT=235.025n

* CHECK dout0_58 Vdout0_58ck46 = 0 time = 235
.meas tran vdout0_58ck46 FIND v(dout0_58) AT=235.025n

* CHECK dout0_59 Vdout0_59ck46 = 0 time = 235
.meas tran vdout0_59ck46 FIND v(dout0_59) AT=235.025n

* CHECK dout0_60 Vdout0_60ck46 = 0 time = 235
.meas tran vdout0_60ck46 FIND v(dout0_60) AT=235.025n

* CHECK dout0_61 Vdout0_61ck46 = 0 time = 235
.meas tran vdout0_61ck46 FIND v(dout0_61) AT=235.025n

* CHECK dout0_62 Vdout0_62ck46 = 0.9 time = 235
.meas tran vdout0_62ck46 FIND v(dout0_62) AT=235.025n

* CHECK dout0_63 Vdout0_63ck46 = 0 time = 235
.meas tran vdout0_63ck46 FIND v(dout0_63) AT=235.025n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 270
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=270.025n

* CHECK dout0_1 Vdout0_1ck53 = 0.9 time = 270
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=270.025n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 270
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=270.025n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 270
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=270.025n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 270
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=270.025n

* CHECK dout0_5 Vdout0_5ck53 = 0.9 time = 270
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=270.025n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 270
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=270.025n

* CHECK dout0_7 Vdout0_7ck53 = 0.9 time = 270
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=270.025n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 270
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=270.025n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 270
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=270.025n

* CHECK dout0_10 Vdout0_10ck53 = 0.9 time = 270
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=270.025n

* CHECK dout0_11 Vdout0_11ck53 = 0.9 time = 270
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=270.025n

* CHECK dout0_12 Vdout0_12ck53 = 0 time = 270
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=270.025n

* CHECK dout0_13 Vdout0_13ck53 = 0.9 time = 270
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=270.025n

* CHECK dout0_14 Vdout0_14ck53 = 0.9 time = 270
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=270.025n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 270
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=270.025n

* CHECK dout0_16 Vdout0_16ck53 = 0.9 time = 270
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=270.025n

* CHECK dout0_17 Vdout0_17ck53 = 0 time = 270
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=270.025n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 270
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=270.025n

* CHECK dout0_19 Vdout0_19ck53 = 0.9 time = 270
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=270.025n

* CHECK dout0_20 Vdout0_20ck53 = 0 time = 270
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=270.025n

* CHECK dout0_21 Vdout0_21ck53 = 0.9 time = 270
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=270.025n

* CHECK dout0_22 Vdout0_22ck53 = 0.9 time = 270
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=270.025n

* CHECK dout0_23 Vdout0_23ck53 = 0.9 time = 270
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=270.025n

* CHECK dout0_24 Vdout0_24ck53 = 0.9 time = 270
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=270.025n

* CHECK dout0_25 Vdout0_25ck53 = 0.9 time = 270
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=270.025n

* CHECK dout0_26 Vdout0_26ck53 = 0.9 time = 270
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=270.025n

* CHECK dout0_27 Vdout0_27ck53 = 0.9 time = 270
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=270.025n

* CHECK dout0_28 Vdout0_28ck53 = 0.9 time = 270
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=270.025n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 270
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=270.025n

* CHECK dout0_30 Vdout0_30ck53 = 0.9 time = 270
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=270.025n

* CHECK dout0_31 Vdout0_31ck53 = 0.9 time = 270
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=270.025n

* CHECK dout0_32 Vdout0_32ck53 = 0.9 time = 270
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=270.025n

* CHECK dout0_33 Vdout0_33ck53 = 0 time = 270
.meas tran vdout0_33ck53 FIND v(dout0_33) AT=270.025n

* CHECK dout0_34 Vdout0_34ck53 = 0 time = 270
.meas tran vdout0_34ck53 FIND v(dout0_34) AT=270.025n

* CHECK dout0_35 Vdout0_35ck53 = 0.9 time = 270
.meas tran vdout0_35ck53 FIND v(dout0_35) AT=270.025n

* CHECK dout0_36 Vdout0_36ck53 = 0.9 time = 270
.meas tran vdout0_36ck53 FIND v(dout0_36) AT=270.025n

* CHECK dout0_37 Vdout0_37ck53 = 0.9 time = 270
.meas tran vdout0_37ck53 FIND v(dout0_37) AT=270.025n

* CHECK dout0_38 Vdout0_38ck53 = 0.9 time = 270
.meas tran vdout0_38ck53 FIND v(dout0_38) AT=270.025n

* CHECK dout0_39 Vdout0_39ck53 = 0 time = 270
.meas tran vdout0_39ck53 FIND v(dout0_39) AT=270.025n

* CHECK dout0_40 Vdout0_40ck53 = 0.9 time = 270
.meas tran vdout0_40ck53 FIND v(dout0_40) AT=270.025n

* CHECK dout0_41 Vdout0_41ck53 = 0.9 time = 270
.meas tran vdout0_41ck53 FIND v(dout0_41) AT=270.025n

* CHECK dout0_42 Vdout0_42ck53 = 0.9 time = 270
.meas tran vdout0_42ck53 FIND v(dout0_42) AT=270.025n

* CHECK dout0_43 Vdout0_43ck53 = 0.9 time = 270
.meas tran vdout0_43ck53 FIND v(dout0_43) AT=270.025n

* CHECK dout0_44 Vdout0_44ck53 = 0 time = 270
.meas tran vdout0_44ck53 FIND v(dout0_44) AT=270.025n

* CHECK dout0_45 Vdout0_45ck53 = 0.9 time = 270
.meas tran vdout0_45ck53 FIND v(dout0_45) AT=270.025n

* CHECK dout0_46 Vdout0_46ck53 = 0 time = 270
.meas tran vdout0_46ck53 FIND v(dout0_46) AT=270.025n

* CHECK dout0_47 Vdout0_47ck53 = 0.9 time = 270
.meas tran vdout0_47ck53 FIND v(dout0_47) AT=270.025n

* CHECK dout0_48 Vdout0_48ck53 = 0 time = 270
.meas tran vdout0_48ck53 FIND v(dout0_48) AT=270.025n

* CHECK dout0_49 Vdout0_49ck53 = 0.9 time = 270
.meas tran vdout0_49ck53 FIND v(dout0_49) AT=270.025n

* CHECK dout0_50 Vdout0_50ck53 = 0.9 time = 270
.meas tran vdout0_50ck53 FIND v(dout0_50) AT=270.025n

* CHECK dout0_51 Vdout0_51ck53 = 0.9 time = 270
.meas tran vdout0_51ck53 FIND v(dout0_51) AT=270.025n

* CHECK dout0_52 Vdout0_52ck53 = 0 time = 270
.meas tran vdout0_52ck53 FIND v(dout0_52) AT=270.025n

* CHECK dout0_53 Vdout0_53ck53 = 0 time = 270
.meas tran vdout0_53ck53 FIND v(dout0_53) AT=270.025n

* CHECK dout0_54 Vdout0_54ck53 = 0 time = 270
.meas tran vdout0_54ck53 FIND v(dout0_54) AT=270.025n

* CHECK dout0_55 Vdout0_55ck53 = 0 time = 270
.meas tran vdout0_55ck53 FIND v(dout0_55) AT=270.025n

* CHECK dout0_56 Vdout0_56ck53 = 0 time = 270
.meas tran vdout0_56ck53 FIND v(dout0_56) AT=270.025n

* CHECK dout0_57 Vdout0_57ck53 = 0 time = 270
.meas tran vdout0_57ck53 FIND v(dout0_57) AT=270.025n

* CHECK dout0_58 Vdout0_58ck53 = 0.9 time = 270
.meas tran vdout0_58ck53 FIND v(dout0_58) AT=270.025n

* CHECK dout0_59 Vdout0_59ck53 = 0 time = 270
.meas tran vdout0_59ck53 FIND v(dout0_59) AT=270.025n

* CHECK dout0_60 Vdout0_60ck53 = 0 time = 270
.meas tran vdout0_60ck53 FIND v(dout0_60) AT=270.025n

* CHECK dout0_61 Vdout0_61ck53 = 0 time = 270
.meas tran vdout0_61ck53 FIND v(dout0_61) AT=270.025n

* CHECK dout0_62 Vdout0_62ck53 = 0.9 time = 270
.meas tran vdout0_62ck53 FIND v(dout0_62) AT=270.025n

* CHECK dout0_63 Vdout0_63ck53 = 0.9 time = 270
.meas tran vdout0_63ck53 FIND v(dout0_63) AT=270.025n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 275
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=275.025n

* CHECK dout0_1 Vdout0_1ck54 = 0.9 time = 275
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=275.025n

* CHECK dout0_2 Vdout0_2ck54 = 0 time = 275
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=275.025n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 275
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=275.025n

* CHECK dout0_4 Vdout0_4ck54 = 0 time = 275
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=275.025n

* CHECK dout0_5 Vdout0_5ck54 = 0.9 time = 275
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=275.025n

* CHECK dout0_6 Vdout0_6ck54 = 0 time = 275
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=275.025n

* CHECK dout0_7 Vdout0_7ck54 = 0.9 time = 275
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=275.025n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 275
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=275.025n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 275
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=275.025n

* CHECK dout0_10 Vdout0_10ck54 = 0.9 time = 275
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=275.025n

* CHECK dout0_11 Vdout0_11ck54 = 0.9 time = 275
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=275.025n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 275
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=275.025n

* CHECK dout0_13 Vdout0_13ck54 = 0.9 time = 275
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=275.025n

* CHECK dout0_14 Vdout0_14ck54 = 0.9 time = 275
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=275.025n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 275
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=275.025n

* CHECK dout0_16 Vdout0_16ck54 = 0.9 time = 275
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=275.025n

* CHECK dout0_17 Vdout0_17ck54 = 0 time = 275
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=275.025n

* CHECK dout0_18 Vdout0_18ck54 = 0 time = 275
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=275.025n

* CHECK dout0_19 Vdout0_19ck54 = 0.9 time = 275
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=275.025n

* CHECK dout0_20 Vdout0_20ck54 = 0 time = 275
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=275.025n

* CHECK dout0_21 Vdout0_21ck54 = 0.9 time = 275
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=275.025n

* CHECK dout0_22 Vdout0_22ck54 = 0.9 time = 275
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=275.025n

* CHECK dout0_23 Vdout0_23ck54 = 0.9 time = 275
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=275.025n

* CHECK dout0_24 Vdout0_24ck54 = 0.9 time = 275
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=275.025n

* CHECK dout0_25 Vdout0_25ck54 = 0.9 time = 275
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=275.025n

* CHECK dout0_26 Vdout0_26ck54 = 0.9 time = 275
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=275.025n

* CHECK dout0_27 Vdout0_27ck54 = 0.9 time = 275
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=275.025n

* CHECK dout0_28 Vdout0_28ck54 = 0.9 time = 275
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=275.025n

* CHECK dout0_29 Vdout0_29ck54 = 0 time = 275
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=275.025n

* CHECK dout0_30 Vdout0_30ck54 = 0.9 time = 275
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=275.025n

* CHECK dout0_31 Vdout0_31ck54 = 0.9 time = 275
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=275.025n

* CHECK dout0_32 Vdout0_32ck54 = 0.9 time = 275
.meas tran vdout0_32ck54 FIND v(dout0_32) AT=275.025n

* CHECK dout0_33 Vdout0_33ck54 = 0 time = 275
.meas tran vdout0_33ck54 FIND v(dout0_33) AT=275.025n

* CHECK dout0_34 Vdout0_34ck54 = 0 time = 275
.meas tran vdout0_34ck54 FIND v(dout0_34) AT=275.025n

* CHECK dout0_35 Vdout0_35ck54 = 0.9 time = 275
.meas tran vdout0_35ck54 FIND v(dout0_35) AT=275.025n

* CHECK dout0_36 Vdout0_36ck54 = 0.9 time = 275
.meas tran vdout0_36ck54 FIND v(dout0_36) AT=275.025n

* CHECK dout0_37 Vdout0_37ck54 = 0.9 time = 275
.meas tran vdout0_37ck54 FIND v(dout0_37) AT=275.025n

* CHECK dout0_38 Vdout0_38ck54 = 0.9 time = 275
.meas tran vdout0_38ck54 FIND v(dout0_38) AT=275.025n

* CHECK dout0_39 Vdout0_39ck54 = 0 time = 275
.meas tran vdout0_39ck54 FIND v(dout0_39) AT=275.025n

* CHECK dout0_40 Vdout0_40ck54 = 0.9 time = 275
.meas tran vdout0_40ck54 FIND v(dout0_40) AT=275.025n

* CHECK dout0_41 Vdout0_41ck54 = 0.9 time = 275
.meas tran vdout0_41ck54 FIND v(dout0_41) AT=275.025n

* CHECK dout0_42 Vdout0_42ck54 = 0.9 time = 275
.meas tran vdout0_42ck54 FIND v(dout0_42) AT=275.025n

* CHECK dout0_43 Vdout0_43ck54 = 0.9 time = 275
.meas tran vdout0_43ck54 FIND v(dout0_43) AT=275.025n

* CHECK dout0_44 Vdout0_44ck54 = 0 time = 275
.meas tran vdout0_44ck54 FIND v(dout0_44) AT=275.025n

* CHECK dout0_45 Vdout0_45ck54 = 0.9 time = 275
.meas tran vdout0_45ck54 FIND v(dout0_45) AT=275.025n

* CHECK dout0_46 Vdout0_46ck54 = 0 time = 275
.meas tran vdout0_46ck54 FIND v(dout0_46) AT=275.025n

* CHECK dout0_47 Vdout0_47ck54 = 0.9 time = 275
.meas tran vdout0_47ck54 FIND v(dout0_47) AT=275.025n

* CHECK dout0_48 Vdout0_48ck54 = 0 time = 275
.meas tran vdout0_48ck54 FIND v(dout0_48) AT=275.025n

* CHECK dout0_49 Vdout0_49ck54 = 0.9 time = 275
.meas tran vdout0_49ck54 FIND v(dout0_49) AT=275.025n

* CHECK dout0_50 Vdout0_50ck54 = 0.9 time = 275
.meas tran vdout0_50ck54 FIND v(dout0_50) AT=275.025n

* CHECK dout0_51 Vdout0_51ck54 = 0.9 time = 275
.meas tran vdout0_51ck54 FIND v(dout0_51) AT=275.025n

* CHECK dout0_52 Vdout0_52ck54 = 0 time = 275
.meas tran vdout0_52ck54 FIND v(dout0_52) AT=275.025n

* CHECK dout0_53 Vdout0_53ck54 = 0 time = 275
.meas tran vdout0_53ck54 FIND v(dout0_53) AT=275.025n

* CHECK dout0_54 Vdout0_54ck54 = 0 time = 275
.meas tran vdout0_54ck54 FIND v(dout0_54) AT=275.025n

* CHECK dout0_55 Vdout0_55ck54 = 0 time = 275
.meas tran vdout0_55ck54 FIND v(dout0_55) AT=275.025n

* CHECK dout0_56 Vdout0_56ck54 = 0 time = 275
.meas tran vdout0_56ck54 FIND v(dout0_56) AT=275.025n

* CHECK dout0_57 Vdout0_57ck54 = 0 time = 275
.meas tran vdout0_57ck54 FIND v(dout0_57) AT=275.025n

* CHECK dout0_58 Vdout0_58ck54 = 0.9 time = 275
.meas tran vdout0_58ck54 FIND v(dout0_58) AT=275.025n

* CHECK dout0_59 Vdout0_59ck54 = 0 time = 275
.meas tran vdout0_59ck54 FIND v(dout0_59) AT=275.025n

* CHECK dout0_60 Vdout0_60ck54 = 0 time = 275
.meas tran vdout0_60ck54 FIND v(dout0_60) AT=275.025n

* CHECK dout0_61 Vdout0_61ck54 = 0 time = 275
.meas tran vdout0_61ck54 FIND v(dout0_61) AT=275.025n

* CHECK dout0_62 Vdout0_62ck54 = 0.9 time = 275
.meas tran vdout0_62ck54 FIND v(dout0_62) AT=275.025n

* CHECK dout0_63 Vdout0_63ck54 = 0.9 time = 275
.meas tran vdout0_63ck54 FIND v(dout0_63) AT=275.025n

* CHECK dout0_0 Vdout0_0ck57 = 0 time = 290
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=290.025n

* CHECK dout0_1 Vdout0_1ck57 = 0 time = 290
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=290.025n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 290
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=290.025n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 290
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=290.025n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 290
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=290.025n

* CHECK dout0_5 Vdout0_5ck57 = 0.9 time = 290
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=290.025n

* CHECK dout0_6 Vdout0_6ck57 = 0 time = 290
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=290.025n

* CHECK dout0_7 Vdout0_7ck57 = 0.9 time = 290
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=290.025n

* CHECK dout0_8 Vdout0_8ck57 = 0.9 time = 290
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=290.025n

* CHECK dout0_9 Vdout0_9ck57 = 0.9 time = 290
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=290.025n

* CHECK dout0_10 Vdout0_10ck57 = 0.9 time = 290
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=290.025n

* CHECK dout0_11 Vdout0_11ck57 = 0 time = 290
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=290.025n

* CHECK dout0_12 Vdout0_12ck57 = 0 time = 290
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=290.025n

* CHECK dout0_13 Vdout0_13ck57 = 0 time = 290
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=290.025n

* CHECK dout0_14 Vdout0_14ck57 = 0.9 time = 290
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=290.025n

* CHECK dout0_15 Vdout0_15ck57 = 0 time = 290
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=290.025n

* CHECK dout0_16 Vdout0_16ck57 = 0.9 time = 290
.meas tran vdout0_16ck57 FIND v(dout0_16) AT=290.025n

* CHECK dout0_17 Vdout0_17ck57 = 0 time = 290
.meas tran vdout0_17ck57 FIND v(dout0_17) AT=290.025n

* CHECK dout0_18 Vdout0_18ck57 = 0 time = 290
.meas tran vdout0_18ck57 FIND v(dout0_18) AT=290.025n

* CHECK dout0_19 Vdout0_19ck57 = 0.9 time = 290
.meas tran vdout0_19ck57 FIND v(dout0_19) AT=290.025n

* CHECK dout0_20 Vdout0_20ck57 = 0.9 time = 290
.meas tran vdout0_20ck57 FIND v(dout0_20) AT=290.025n

* CHECK dout0_21 Vdout0_21ck57 = 0 time = 290
.meas tran vdout0_21ck57 FIND v(dout0_21) AT=290.025n

* CHECK dout0_22 Vdout0_22ck57 = 0 time = 290
.meas tran vdout0_22ck57 FIND v(dout0_22) AT=290.025n

* CHECK dout0_23 Vdout0_23ck57 = 0.9 time = 290
.meas tran vdout0_23ck57 FIND v(dout0_23) AT=290.025n

* CHECK dout0_24 Vdout0_24ck57 = 0.9 time = 290
.meas tran vdout0_24ck57 FIND v(dout0_24) AT=290.025n

* CHECK dout0_25 Vdout0_25ck57 = 0 time = 290
.meas tran vdout0_25ck57 FIND v(dout0_25) AT=290.025n

* CHECK dout0_26 Vdout0_26ck57 = 0.9 time = 290
.meas tran vdout0_26ck57 FIND v(dout0_26) AT=290.025n

* CHECK dout0_27 Vdout0_27ck57 = 0.9 time = 290
.meas tran vdout0_27ck57 FIND v(dout0_27) AT=290.025n

* CHECK dout0_28 Vdout0_28ck57 = 0 time = 290
.meas tran vdout0_28ck57 FIND v(dout0_28) AT=290.025n

* CHECK dout0_29 Vdout0_29ck57 = 0 time = 290
.meas tran vdout0_29ck57 FIND v(dout0_29) AT=290.025n

* CHECK dout0_30 Vdout0_30ck57 = 0.9 time = 290
.meas tran vdout0_30ck57 FIND v(dout0_30) AT=290.025n

* CHECK dout0_31 Vdout0_31ck57 = 0.9 time = 290
.meas tran vdout0_31ck57 FIND v(dout0_31) AT=290.025n

* CHECK dout0_32 Vdout0_32ck57 = 0 time = 290
.meas tran vdout0_32ck57 FIND v(dout0_32) AT=290.025n

* CHECK dout0_33 Vdout0_33ck57 = 0 time = 290
.meas tran vdout0_33ck57 FIND v(dout0_33) AT=290.025n

* CHECK dout0_34 Vdout0_34ck57 = 0.9 time = 290
.meas tran vdout0_34ck57 FIND v(dout0_34) AT=290.025n

* CHECK dout0_35 Vdout0_35ck57 = 0 time = 290
.meas tran vdout0_35ck57 FIND v(dout0_35) AT=290.025n

* CHECK dout0_36 Vdout0_36ck57 = 0 time = 290
.meas tran vdout0_36ck57 FIND v(dout0_36) AT=290.025n

* CHECK dout0_37 Vdout0_37ck57 = 0 time = 290
.meas tran vdout0_37ck57 FIND v(dout0_37) AT=290.025n

* CHECK dout0_38 Vdout0_38ck57 = 0.9 time = 290
.meas tran vdout0_38ck57 FIND v(dout0_38) AT=290.025n

* CHECK dout0_39 Vdout0_39ck57 = 0 time = 290
.meas tran vdout0_39ck57 FIND v(dout0_39) AT=290.025n

* CHECK dout0_40 Vdout0_40ck57 = 0.9 time = 290
.meas tran vdout0_40ck57 FIND v(dout0_40) AT=290.025n

* CHECK dout0_41 Vdout0_41ck57 = 0 time = 290
.meas tran vdout0_41ck57 FIND v(dout0_41) AT=290.025n

* CHECK dout0_42 Vdout0_42ck57 = 0 time = 290
.meas tran vdout0_42ck57 FIND v(dout0_42) AT=290.025n

* CHECK dout0_43 Vdout0_43ck57 = 0 time = 290
.meas tran vdout0_43ck57 FIND v(dout0_43) AT=290.025n

* CHECK dout0_44 Vdout0_44ck57 = 0.9 time = 290
.meas tran vdout0_44ck57 FIND v(dout0_44) AT=290.025n

* CHECK dout0_45 Vdout0_45ck57 = 0 time = 290
.meas tran vdout0_45ck57 FIND v(dout0_45) AT=290.025n

* CHECK dout0_46 Vdout0_46ck57 = 0.9 time = 290
.meas tran vdout0_46ck57 FIND v(dout0_46) AT=290.025n

* CHECK dout0_47 Vdout0_47ck57 = 0 time = 290
.meas tran vdout0_47ck57 FIND v(dout0_47) AT=290.025n

* CHECK dout0_48 Vdout0_48ck57 = 0.9 time = 290
.meas tran vdout0_48ck57 FIND v(dout0_48) AT=290.025n

* CHECK dout0_49 Vdout0_49ck57 = 0.9 time = 290
.meas tran vdout0_49ck57 FIND v(dout0_49) AT=290.025n

* CHECK dout0_50 Vdout0_50ck57 = 0.9 time = 290
.meas tran vdout0_50ck57 FIND v(dout0_50) AT=290.025n

* CHECK dout0_51 Vdout0_51ck57 = 0 time = 290
.meas tran vdout0_51ck57 FIND v(dout0_51) AT=290.025n

* CHECK dout0_52 Vdout0_52ck57 = 0 time = 290
.meas tran vdout0_52ck57 FIND v(dout0_52) AT=290.025n

* CHECK dout0_53 Vdout0_53ck57 = 0.9 time = 290
.meas tran vdout0_53ck57 FIND v(dout0_53) AT=290.025n

* CHECK dout0_54 Vdout0_54ck57 = 0 time = 290
.meas tran vdout0_54ck57 FIND v(dout0_54) AT=290.025n

* CHECK dout0_55 Vdout0_55ck57 = 0 time = 290
.meas tran vdout0_55ck57 FIND v(dout0_55) AT=290.025n

* CHECK dout0_56 Vdout0_56ck57 = 0.9 time = 290
.meas tran vdout0_56ck57 FIND v(dout0_56) AT=290.025n

* CHECK dout0_57 Vdout0_57ck57 = 0 time = 290
.meas tran vdout0_57ck57 FIND v(dout0_57) AT=290.025n

* CHECK dout0_58 Vdout0_58ck57 = 0 time = 290
.meas tran vdout0_58ck57 FIND v(dout0_58) AT=290.025n

* CHECK dout0_59 Vdout0_59ck57 = 0.9 time = 290
.meas tran vdout0_59ck57 FIND v(dout0_59) AT=290.025n

* CHECK dout0_60 Vdout0_60ck57 = 0 time = 290
.meas tran vdout0_60ck57 FIND v(dout0_60) AT=290.025n

* CHECK dout0_61 Vdout0_61ck57 = 0.9 time = 290
.meas tran vdout0_61ck57 FIND v(dout0_61) AT=290.025n

* CHECK dout0_62 Vdout0_62ck57 = 0 time = 290
.meas tran vdout0_62ck57 FIND v(dout0_62) AT=290.025n

* CHECK dout0_63 Vdout0_63ck57 = 0 time = 290
.meas tran vdout0_63ck57 FIND v(dout0_63) AT=290.025n

* CHECK dout0_0 Vdout0_0ck59 = 0 time = 300
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=300.025n

* CHECK dout0_1 Vdout0_1ck59 = 0 time = 300
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=300.025n

* CHECK dout0_2 Vdout0_2ck59 = 0 time = 300
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=300.025n

* CHECK dout0_3 Vdout0_3ck59 = 0 time = 300
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=300.025n

* CHECK dout0_4 Vdout0_4ck59 = 0 time = 300
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=300.025n

* CHECK dout0_5 Vdout0_5ck59 = 0.9 time = 300
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=300.025n

* CHECK dout0_6 Vdout0_6ck59 = 0 time = 300
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=300.025n

* CHECK dout0_7 Vdout0_7ck59 = 0.9 time = 300
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=300.025n

* CHECK dout0_8 Vdout0_8ck59 = 0.9 time = 300
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=300.025n

* CHECK dout0_9 Vdout0_9ck59 = 0.9 time = 300
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=300.025n

* CHECK dout0_10 Vdout0_10ck59 = 0.9 time = 300
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=300.025n

* CHECK dout0_11 Vdout0_11ck59 = 0 time = 300
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=300.025n

* CHECK dout0_12 Vdout0_12ck59 = 0 time = 300
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=300.025n

* CHECK dout0_13 Vdout0_13ck59 = 0 time = 300
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=300.025n

* CHECK dout0_14 Vdout0_14ck59 = 0.9 time = 300
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=300.025n

* CHECK dout0_15 Vdout0_15ck59 = 0 time = 300
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=300.025n

* CHECK dout0_16 Vdout0_16ck59 = 0.9 time = 300
.meas tran vdout0_16ck59 FIND v(dout0_16) AT=300.025n

* CHECK dout0_17 Vdout0_17ck59 = 0 time = 300
.meas tran vdout0_17ck59 FIND v(dout0_17) AT=300.025n

* CHECK dout0_18 Vdout0_18ck59 = 0 time = 300
.meas tran vdout0_18ck59 FIND v(dout0_18) AT=300.025n

* CHECK dout0_19 Vdout0_19ck59 = 0.9 time = 300
.meas tran vdout0_19ck59 FIND v(dout0_19) AT=300.025n

* CHECK dout0_20 Vdout0_20ck59 = 0.9 time = 300
.meas tran vdout0_20ck59 FIND v(dout0_20) AT=300.025n

* CHECK dout0_21 Vdout0_21ck59 = 0 time = 300
.meas tran vdout0_21ck59 FIND v(dout0_21) AT=300.025n

* CHECK dout0_22 Vdout0_22ck59 = 0 time = 300
.meas tran vdout0_22ck59 FIND v(dout0_22) AT=300.025n

* CHECK dout0_23 Vdout0_23ck59 = 0.9 time = 300
.meas tran vdout0_23ck59 FIND v(dout0_23) AT=300.025n

* CHECK dout0_24 Vdout0_24ck59 = 0.9 time = 300
.meas tran vdout0_24ck59 FIND v(dout0_24) AT=300.025n

* CHECK dout0_25 Vdout0_25ck59 = 0 time = 300
.meas tran vdout0_25ck59 FIND v(dout0_25) AT=300.025n

* CHECK dout0_26 Vdout0_26ck59 = 0.9 time = 300
.meas tran vdout0_26ck59 FIND v(dout0_26) AT=300.025n

* CHECK dout0_27 Vdout0_27ck59 = 0.9 time = 300
.meas tran vdout0_27ck59 FIND v(dout0_27) AT=300.025n

* CHECK dout0_28 Vdout0_28ck59 = 0 time = 300
.meas tran vdout0_28ck59 FIND v(dout0_28) AT=300.025n

* CHECK dout0_29 Vdout0_29ck59 = 0 time = 300
.meas tran vdout0_29ck59 FIND v(dout0_29) AT=300.025n

* CHECK dout0_30 Vdout0_30ck59 = 0.9 time = 300
.meas tran vdout0_30ck59 FIND v(dout0_30) AT=300.025n

* CHECK dout0_31 Vdout0_31ck59 = 0.9 time = 300
.meas tran vdout0_31ck59 FIND v(dout0_31) AT=300.025n

* CHECK dout0_32 Vdout0_32ck59 = 0 time = 300
.meas tran vdout0_32ck59 FIND v(dout0_32) AT=300.025n

* CHECK dout0_33 Vdout0_33ck59 = 0 time = 300
.meas tran vdout0_33ck59 FIND v(dout0_33) AT=300.025n

* CHECK dout0_34 Vdout0_34ck59 = 0.9 time = 300
.meas tran vdout0_34ck59 FIND v(dout0_34) AT=300.025n

* CHECK dout0_35 Vdout0_35ck59 = 0 time = 300
.meas tran vdout0_35ck59 FIND v(dout0_35) AT=300.025n

* CHECK dout0_36 Vdout0_36ck59 = 0 time = 300
.meas tran vdout0_36ck59 FIND v(dout0_36) AT=300.025n

* CHECK dout0_37 Vdout0_37ck59 = 0 time = 300
.meas tran vdout0_37ck59 FIND v(dout0_37) AT=300.025n

* CHECK dout0_38 Vdout0_38ck59 = 0.9 time = 300
.meas tran vdout0_38ck59 FIND v(dout0_38) AT=300.025n

* CHECK dout0_39 Vdout0_39ck59 = 0 time = 300
.meas tran vdout0_39ck59 FIND v(dout0_39) AT=300.025n

* CHECK dout0_40 Vdout0_40ck59 = 0.9 time = 300
.meas tran vdout0_40ck59 FIND v(dout0_40) AT=300.025n

* CHECK dout0_41 Vdout0_41ck59 = 0 time = 300
.meas tran vdout0_41ck59 FIND v(dout0_41) AT=300.025n

* CHECK dout0_42 Vdout0_42ck59 = 0 time = 300
.meas tran vdout0_42ck59 FIND v(dout0_42) AT=300.025n

* CHECK dout0_43 Vdout0_43ck59 = 0 time = 300
.meas tran vdout0_43ck59 FIND v(dout0_43) AT=300.025n

* CHECK dout0_44 Vdout0_44ck59 = 0.9 time = 300
.meas tran vdout0_44ck59 FIND v(dout0_44) AT=300.025n

* CHECK dout0_45 Vdout0_45ck59 = 0 time = 300
.meas tran vdout0_45ck59 FIND v(dout0_45) AT=300.025n

* CHECK dout0_46 Vdout0_46ck59 = 0.9 time = 300
.meas tran vdout0_46ck59 FIND v(dout0_46) AT=300.025n

* CHECK dout0_47 Vdout0_47ck59 = 0 time = 300
.meas tran vdout0_47ck59 FIND v(dout0_47) AT=300.025n

* CHECK dout0_48 Vdout0_48ck59 = 0.9 time = 300
.meas tran vdout0_48ck59 FIND v(dout0_48) AT=300.025n

* CHECK dout0_49 Vdout0_49ck59 = 0.9 time = 300
.meas tran vdout0_49ck59 FIND v(dout0_49) AT=300.025n

* CHECK dout0_50 Vdout0_50ck59 = 0.9 time = 300
.meas tran vdout0_50ck59 FIND v(dout0_50) AT=300.025n

* CHECK dout0_51 Vdout0_51ck59 = 0 time = 300
.meas tran vdout0_51ck59 FIND v(dout0_51) AT=300.025n

* CHECK dout0_52 Vdout0_52ck59 = 0 time = 300
.meas tran vdout0_52ck59 FIND v(dout0_52) AT=300.025n

* CHECK dout0_53 Vdout0_53ck59 = 0.9 time = 300
.meas tran vdout0_53ck59 FIND v(dout0_53) AT=300.025n

* CHECK dout0_54 Vdout0_54ck59 = 0 time = 300
.meas tran vdout0_54ck59 FIND v(dout0_54) AT=300.025n

* CHECK dout0_55 Vdout0_55ck59 = 0 time = 300
.meas tran vdout0_55ck59 FIND v(dout0_55) AT=300.025n

* CHECK dout0_56 Vdout0_56ck59 = 0.9 time = 300
.meas tran vdout0_56ck59 FIND v(dout0_56) AT=300.025n

* CHECK dout0_57 Vdout0_57ck59 = 0 time = 300
.meas tran vdout0_57ck59 FIND v(dout0_57) AT=300.025n

* CHECK dout0_58 Vdout0_58ck59 = 0 time = 300
.meas tran vdout0_58ck59 FIND v(dout0_58) AT=300.025n

* CHECK dout0_59 Vdout0_59ck59 = 0.9 time = 300
.meas tran vdout0_59ck59 FIND v(dout0_59) AT=300.025n

* CHECK dout0_60 Vdout0_60ck59 = 0 time = 300
.meas tran vdout0_60ck59 FIND v(dout0_60) AT=300.025n

* CHECK dout0_61 Vdout0_61ck59 = 0.9 time = 300
.meas tran vdout0_61ck59 FIND v(dout0_61) AT=300.025n

* CHECK dout0_62 Vdout0_62ck59 = 0 time = 300
.meas tran vdout0_62ck59 FIND v(dout0_62) AT=300.025n

* CHECK dout0_63 Vdout0_63ck59 = 0 time = 300
.meas tran vdout0_63ck59 FIND v(dout0_63) AT=300.025n

* CHECK dout0_0 Vdout0_0ck61 = 0 time = 310
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=310.025n

* CHECK dout0_1 Vdout0_1ck61 = 0 time = 310
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=310.025n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 310
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=310.025n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 310
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=310.025n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 310
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=310.025n

* CHECK dout0_5 Vdout0_5ck61 = 0.9 time = 310
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=310.025n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 310
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=310.025n

* CHECK dout0_7 Vdout0_7ck61 = 0.9 time = 310
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=310.025n

* CHECK dout0_8 Vdout0_8ck61 = 0.9 time = 310
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=310.025n

* CHECK dout0_9 Vdout0_9ck61 = 0.9 time = 310
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=310.025n

* CHECK dout0_10 Vdout0_10ck61 = 0.9 time = 310
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=310.025n

* CHECK dout0_11 Vdout0_11ck61 = 0 time = 310
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=310.025n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 310
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=310.025n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 310
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=310.025n

* CHECK dout0_14 Vdout0_14ck61 = 0.9 time = 310
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=310.025n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 310
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=310.025n

* CHECK dout0_16 Vdout0_16ck61 = 0.9 time = 310
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=310.025n

* CHECK dout0_17 Vdout0_17ck61 = 0 time = 310
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=310.025n

* CHECK dout0_18 Vdout0_18ck61 = 0 time = 310
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=310.025n

* CHECK dout0_19 Vdout0_19ck61 = 0.9 time = 310
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=310.025n

* CHECK dout0_20 Vdout0_20ck61 = 0.9 time = 310
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=310.025n

* CHECK dout0_21 Vdout0_21ck61 = 0 time = 310
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=310.025n

* CHECK dout0_22 Vdout0_22ck61 = 0 time = 310
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=310.025n

* CHECK dout0_23 Vdout0_23ck61 = 0.9 time = 310
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=310.025n

* CHECK dout0_24 Vdout0_24ck61 = 0.9 time = 310
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=310.025n

* CHECK dout0_25 Vdout0_25ck61 = 0 time = 310
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=310.025n

* CHECK dout0_26 Vdout0_26ck61 = 0.9 time = 310
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=310.025n

* CHECK dout0_27 Vdout0_27ck61 = 0.9 time = 310
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=310.025n

* CHECK dout0_28 Vdout0_28ck61 = 0 time = 310
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=310.025n

* CHECK dout0_29 Vdout0_29ck61 = 0 time = 310
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=310.025n

* CHECK dout0_30 Vdout0_30ck61 = 0.9 time = 310
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=310.025n

* CHECK dout0_31 Vdout0_31ck61 = 0.9 time = 310
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=310.025n

* CHECK dout0_32 Vdout0_32ck61 = 0 time = 310
.meas tran vdout0_32ck61 FIND v(dout0_32) AT=310.025n

* CHECK dout0_33 Vdout0_33ck61 = 0 time = 310
.meas tran vdout0_33ck61 FIND v(dout0_33) AT=310.025n

* CHECK dout0_34 Vdout0_34ck61 = 0.9 time = 310
.meas tran vdout0_34ck61 FIND v(dout0_34) AT=310.025n

* CHECK dout0_35 Vdout0_35ck61 = 0 time = 310
.meas tran vdout0_35ck61 FIND v(dout0_35) AT=310.025n

* CHECK dout0_36 Vdout0_36ck61 = 0 time = 310
.meas tran vdout0_36ck61 FIND v(dout0_36) AT=310.025n

* CHECK dout0_37 Vdout0_37ck61 = 0 time = 310
.meas tran vdout0_37ck61 FIND v(dout0_37) AT=310.025n

* CHECK dout0_38 Vdout0_38ck61 = 0.9 time = 310
.meas tran vdout0_38ck61 FIND v(dout0_38) AT=310.025n

* CHECK dout0_39 Vdout0_39ck61 = 0 time = 310
.meas tran vdout0_39ck61 FIND v(dout0_39) AT=310.025n

* CHECK dout0_40 Vdout0_40ck61 = 0.9 time = 310
.meas tran vdout0_40ck61 FIND v(dout0_40) AT=310.025n

* CHECK dout0_41 Vdout0_41ck61 = 0 time = 310
.meas tran vdout0_41ck61 FIND v(dout0_41) AT=310.025n

* CHECK dout0_42 Vdout0_42ck61 = 0 time = 310
.meas tran vdout0_42ck61 FIND v(dout0_42) AT=310.025n

* CHECK dout0_43 Vdout0_43ck61 = 0 time = 310
.meas tran vdout0_43ck61 FIND v(dout0_43) AT=310.025n

* CHECK dout0_44 Vdout0_44ck61 = 0.9 time = 310
.meas tran vdout0_44ck61 FIND v(dout0_44) AT=310.025n

* CHECK dout0_45 Vdout0_45ck61 = 0 time = 310
.meas tran vdout0_45ck61 FIND v(dout0_45) AT=310.025n

* CHECK dout0_46 Vdout0_46ck61 = 0.9 time = 310
.meas tran vdout0_46ck61 FIND v(dout0_46) AT=310.025n

* CHECK dout0_47 Vdout0_47ck61 = 0 time = 310
.meas tran vdout0_47ck61 FIND v(dout0_47) AT=310.025n

* CHECK dout0_48 Vdout0_48ck61 = 0.9 time = 310
.meas tran vdout0_48ck61 FIND v(dout0_48) AT=310.025n

* CHECK dout0_49 Vdout0_49ck61 = 0.9 time = 310
.meas tran vdout0_49ck61 FIND v(dout0_49) AT=310.025n

* CHECK dout0_50 Vdout0_50ck61 = 0.9 time = 310
.meas tran vdout0_50ck61 FIND v(dout0_50) AT=310.025n

* CHECK dout0_51 Vdout0_51ck61 = 0 time = 310
.meas tran vdout0_51ck61 FIND v(dout0_51) AT=310.025n

* CHECK dout0_52 Vdout0_52ck61 = 0 time = 310
.meas tran vdout0_52ck61 FIND v(dout0_52) AT=310.025n

* CHECK dout0_53 Vdout0_53ck61 = 0.9 time = 310
.meas tran vdout0_53ck61 FIND v(dout0_53) AT=310.025n

* CHECK dout0_54 Vdout0_54ck61 = 0 time = 310
.meas tran vdout0_54ck61 FIND v(dout0_54) AT=310.025n

* CHECK dout0_55 Vdout0_55ck61 = 0 time = 310
.meas tran vdout0_55ck61 FIND v(dout0_55) AT=310.025n

* CHECK dout0_56 Vdout0_56ck61 = 0.9 time = 310
.meas tran vdout0_56ck61 FIND v(dout0_56) AT=310.025n

* CHECK dout0_57 Vdout0_57ck61 = 0 time = 310
.meas tran vdout0_57ck61 FIND v(dout0_57) AT=310.025n

* CHECK dout0_58 Vdout0_58ck61 = 0 time = 310
.meas tran vdout0_58ck61 FIND v(dout0_58) AT=310.025n

* CHECK dout0_59 Vdout0_59ck61 = 0.9 time = 310
.meas tran vdout0_59ck61 FIND v(dout0_59) AT=310.025n

* CHECK dout0_60 Vdout0_60ck61 = 0 time = 310
.meas tran vdout0_60ck61 FIND v(dout0_60) AT=310.025n

* CHECK dout0_61 Vdout0_61ck61 = 0.9 time = 310
.meas tran vdout0_61ck61 FIND v(dout0_61) AT=310.025n

* CHECK dout0_62 Vdout0_62ck61 = 0 time = 310
.meas tran vdout0_62ck61 FIND v(dout0_62) AT=310.025n

* CHECK dout0_63 Vdout0_63ck61 = 0 time = 310
.meas tran vdout0_63ck61 FIND v(dout0_63) AT=310.025n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 315
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=315.025n

* CHECK dout0_1 Vdout0_1ck62 = 0 time = 315
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=315.025n

* CHECK dout0_2 Vdout0_2ck62 = 0 time = 315
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=315.025n

* CHECK dout0_3 Vdout0_3ck62 = 0 time = 315
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=315.025n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 315
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=315.025n

* CHECK dout0_5 Vdout0_5ck62 = 0.9 time = 315
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=315.025n

* CHECK dout0_6 Vdout0_6ck62 = 0 time = 315
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=315.025n

* CHECK dout0_7 Vdout0_7ck62 = 0.9 time = 315
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=315.025n

* CHECK dout0_8 Vdout0_8ck62 = 0.9 time = 315
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=315.025n

* CHECK dout0_9 Vdout0_9ck62 = 0.9 time = 315
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=315.025n

* CHECK dout0_10 Vdout0_10ck62 = 0.9 time = 315
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=315.025n

* CHECK dout0_11 Vdout0_11ck62 = 0 time = 315
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=315.025n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 315
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=315.025n

* CHECK dout0_13 Vdout0_13ck62 = 0 time = 315
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=315.025n

* CHECK dout0_14 Vdout0_14ck62 = 0.9 time = 315
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=315.025n

* CHECK dout0_15 Vdout0_15ck62 = 0 time = 315
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=315.025n

* CHECK dout0_16 Vdout0_16ck62 = 0.9 time = 315
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=315.025n

* CHECK dout0_17 Vdout0_17ck62 = 0 time = 315
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=315.025n

* CHECK dout0_18 Vdout0_18ck62 = 0 time = 315
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=315.025n

* CHECK dout0_19 Vdout0_19ck62 = 0.9 time = 315
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=315.025n

* CHECK dout0_20 Vdout0_20ck62 = 0.9 time = 315
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=315.025n

* CHECK dout0_21 Vdout0_21ck62 = 0 time = 315
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=315.025n

* CHECK dout0_22 Vdout0_22ck62 = 0 time = 315
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=315.025n

* CHECK dout0_23 Vdout0_23ck62 = 0.9 time = 315
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=315.025n

* CHECK dout0_24 Vdout0_24ck62 = 0.9 time = 315
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=315.025n

* CHECK dout0_25 Vdout0_25ck62 = 0 time = 315
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=315.025n

* CHECK dout0_26 Vdout0_26ck62 = 0.9 time = 315
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=315.025n

* CHECK dout0_27 Vdout0_27ck62 = 0.9 time = 315
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=315.025n

* CHECK dout0_28 Vdout0_28ck62 = 0 time = 315
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=315.025n

* CHECK dout0_29 Vdout0_29ck62 = 0 time = 315
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=315.025n

* CHECK dout0_30 Vdout0_30ck62 = 0.9 time = 315
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=315.025n

* CHECK dout0_31 Vdout0_31ck62 = 0.9 time = 315
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=315.025n

* CHECK dout0_32 Vdout0_32ck62 = 0 time = 315
.meas tran vdout0_32ck62 FIND v(dout0_32) AT=315.025n

* CHECK dout0_33 Vdout0_33ck62 = 0 time = 315
.meas tran vdout0_33ck62 FIND v(dout0_33) AT=315.025n

* CHECK dout0_34 Vdout0_34ck62 = 0.9 time = 315
.meas tran vdout0_34ck62 FIND v(dout0_34) AT=315.025n

* CHECK dout0_35 Vdout0_35ck62 = 0 time = 315
.meas tran vdout0_35ck62 FIND v(dout0_35) AT=315.025n

* CHECK dout0_36 Vdout0_36ck62 = 0 time = 315
.meas tran vdout0_36ck62 FIND v(dout0_36) AT=315.025n

* CHECK dout0_37 Vdout0_37ck62 = 0 time = 315
.meas tran vdout0_37ck62 FIND v(dout0_37) AT=315.025n

* CHECK dout0_38 Vdout0_38ck62 = 0.9 time = 315
.meas tran vdout0_38ck62 FIND v(dout0_38) AT=315.025n

* CHECK dout0_39 Vdout0_39ck62 = 0 time = 315
.meas tran vdout0_39ck62 FIND v(dout0_39) AT=315.025n

* CHECK dout0_40 Vdout0_40ck62 = 0.9 time = 315
.meas tran vdout0_40ck62 FIND v(dout0_40) AT=315.025n

* CHECK dout0_41 Vdout0_41ck62 = 0 time = 315
.meas tran vdout0_41ck62 FIND v(dout0_41) AT=315.025n

* CHECK dout0_42 Vdout0_42ck62 = 0 time = 315
.meas tran vdout0_42ck62 FIND v(dout0_42) AT=315.025n

* CHECK dout0_43 Vdout0_43ck62 = 0 time = 315
.meas tran vdout0_43ck62 FIND v(dout0_43) AT=315.025n

* CHECK dout0_44 Vdout0_44ck62 = 0.9 time = 315
.meas tran vdout0_44ck62 FIND v(dout0_44) AT=315.025n

* CHECK dout0_45 Vdout0_45ck62 = 0 time = 315
.meas tran vdout0_45ck62 FIND v(dout0_45) AT=315.025n

* CHECK dout0_46 Vdout0_46ck62 = 0.9 time = 315
.meas tran vdout0_46ck62 FIND v(dout0_46) AT=315.025n

* CHECK dout0_47 Vdout0_47ck62 = 0 time = 315
.meas tran vdout0_47ck62 FIND v(dout0_47) AT=315.025n

* CHECK dout0_48 Vdout0_48ck62 = 0.9 time = 315
.meas tran vdout0_48ck62 FIND v(dout0_48) AT=315.025n

* CHECK dout0_49 Vdout0_49ck62 = 0.9 time = 315
.meas tran vdout0_49ck62 FIND v(dout0_49) AT=315.025n

* CHECK dout0_50 Vdout0_50ck62 = 0.9 time = 315
.meas tran vdout0_50ck62 FIND v(dout0_50) AT=315.025n

* CHECK dout0_51 Vdout0_51ck62 = 0 time = 315
.meas tran vdout0_51ck62 FIND v(dout0_51) AT=315.025n

* CHECK dout0_52 Vdout0_52ck62 = 0 time = 315
.meas tran vdout0_52ck62 FIND v(dout0_52) AT=315.025n

* CHECK dout0_53 Vdout0_53ck62 = 0.9 time = 315
.meas tran vdout0_53ck62 FIND v(dout0_53) AT=315.025n

* CHECK dout0_54 Vdout0_54ck62 = 0 time = 315
.meas tran vdout0_54ck62 FIND v(dout0_54) AT=315.025n

* CHECK dout0_55 Vdout0_55ck62 = 0 time = 315
.meas tran vdout0_55ck62 FIND v(dout0_55) AT=315.025n

* CHECK dout0_56 Vdout0_56ck62 = 0.9 time = 315
.meas tran vdout0_56ck62 FIND v(dout0_56) AT=315.025n

* CHECK dout0_57 Vdout0_57ck62 = 0 time = 315
.meas tran vdout0_57ck62 FIND v(dout0_57) AT=315.025n

* CHECK dout0_58 Vdout0_58ck62 = 0 time = 315
.meas tran vdout0_58ck62 FIND v(dout0_58) AT=315.025n

* CHECK dout0_59 Vdout0_59ck62 = 0.9 time = 315
.meas tran vdout0_59ck62 FIND v(dout0_59) AT=315.025n

* CHECK dout0_60 Vdout0_60ck62 = 0 time = 315
.meas tran vdout0_60ck62 FIND v(dout0_60) AT=315.025n

* CHECK dout0_61 Vdout0_61ck62 = 0.9 time = 315
.meas tran vdout0_61ck62 FIND v(dout0_61) AT=315.025n

* CHECK dout0_62 Vdout0_62ck62 = 0 time = 315
.meas tran vdout0_62ck62 FIND v(dout0_62) AT=315.025n

* CHECK dout0_63 Vdout0_63ck62 = 0 time = 315
.meas tran vdout0_63ck62 FIND v(dout0_63) AT=315.025n

* CHECK dout0_0 Vdout0_0ck65 = 0.9 time = 330
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=330.025n

* CHECK dout0_1 Vdout0_1ck65 = 0 time = 330
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=330.025n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 330
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=330.025n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 330
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=330.025n

* CHECK dout0_4 Vdout0_4ck65 = 0.9 time = 330
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=330.025n

* CHECK dout0_5 Vdout0_5ck65 = 0.9 time = 330
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=330.025n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 330
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=330.025n

* CHECK dout0_7 Vdout0_7ck65 = 0 time = 330
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=330.025n

* CHECK dout0_8 Vdout0_8ck65 = 0 time = 330
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=330.025n

* CHECK dout0_9 Vdout0_9ck65 = 0.9 time = 330
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=330.025n

* CHECK dout0_10 Vdout0_10ck65 = 0.9 time = 330
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=330.025n

* CHECK dout0_11 Vdout0_11ck65 = 0.9 time = 330
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=330.025n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 330
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=330.025n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 330
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=330.025n

* CHECK dout0_14 Vdout0_14ck65 = 0 time = 330
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=330.025n

* CHECK dout0_15 Vdout0_15ck65 = 0 time = 330
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=330.025n

* CHECK dout0_16 Vdout0_16ck65 = 0 time = 330
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=330.025n

* CHECK dout0_17 Vdout0_17ck65 = 0 time = 330
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=330.025n

* CHECK dout0_18 Vdout0_18ck65 = 0 time = 330
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=330.025n

* CHECK dout0_19 Vdout0_19ck65 = 0.9 time = 330
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=330.025n

* CHECK dout0_20 Vdout0_20ck65 = 0.9 time = 330
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=330.025n

* CHECK dout0_21 Vdout0_21ck65 = 0 time = 330
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=330.025n

* CHECK dout0_22 Vdout0_22ck65 = 0 time = 330
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=330.025n

* CHECK dout0_23 Vdout0_23ck65 = 0 time = 330
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=330.025n

* CHECK dout0_24 Vdout0_24ck65 = 0.9 time = 330
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=330.025n

* CHECK dout0_25 Vdout0_25ck65 = 0 time = 330
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=330.025n

* CHECK dout0_26 Vdout0_26ck65 = 0 time = 330
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=330.025n

* CHECK dout0_27 Vdout0_27ck65 = 0.9 time = 330
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=330.025n

* CHECK dout0_28 Vdout0_28ck65 = 0 time = 330
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=330.025n

* CHECK dout0_29 Vdout0_29ck65 = 0 time = 330
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=330.025n

* CHECK dout0_30 Vdout0_30ck65 = 0 time = 330
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=330.025n

* CHECK dout0_31 Vdout0_31ck65 = 0.9 time = 330
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=330.025n

* CHECK dout0_32 Vdout0_32ck65 = 0.9 time = 330
.meas tran vdout0_32ck65 FIND v(dout0_32) AT=330.025n

* CHECK dout0_33 Vdout0_33ck65 = 0 time = 330
.meas tran vdout0_33ck65 FIND v(dout0_33) AT=330.025n

* CHECK dout0_34 Vdout0_34ck65 = 0 time = 330
.meas tran vdout0_34ck65 FIND v(dout0_34) AT=330.025n

* CHECK dout0_35 Vdout0_35ck65 = 0 time = 330
.meas tran vdout0_35ck65 FIND v(dout0_35) AT=330.025n

* CHECK dout0_36 Vdout0_36ck65 = 0.9 time = 330
.meas tran vdout0_36ck65 FIND v(dout0_36) AT=330.025n

* CHECK dout0_37 Vdout0_37ck65 = 0 time = 330
.meas tran vdout0_37ck65 FIND v(dout0_37) AT=330.025n

* CHECK dout0_38 Vdout0_38ck65 = 0 time = 330
.meas tran vdout0_38ck65 FIND v(dout0_38) AT=330.025n

* CHECK dout0_39 Vdout0_39ck65 = 0.9 time = 330
.meas tran vdout0_39ck65 FIND v(dout0_39) AT=330.025n

* CHECK dout0_40 Vdout0_40ck65 = 0.9 time = 330
.meas tran vdout0_40ck65 FIND v(dout0_40) AT=330.025n

* CHECK dout0_41 Vdout0_41ck65 = 0.9 time = 330
.meas tran vdout0_41ck65 FIND v(dout0_41) AT=330.025n

* CHECK dout0_42 Vdout0_42ck65 = 0 time = 330
.meas tran vdout0_42ck65 FIND v(dout0_42) AT=330.025n

* CHECK dout0_43 Vdout0_43ck65 = 0 time = 330
.meas tran vdout0_43ck65 FIND v(dout0_43) AT=330.025n

* CHECK dout0_44 Vdout0_44ck65 = 0.9 time = 330
.meas tran vdout0_44ck65 FIND v(dout0_44) AT=330.025n

* CHECK dout0_45 Vdout0_45ck65 = 0 time = 330
.meas tran vdout0_45ck65 FIND v(dout0_45) AT=330.025n

* CHECK dout0_46 Vdout0_46ck65 = 0 time = 330
.meas tran vdout0_46ck65 FIND v(dout0_46) AT=330.025n

* CHECK dout0_47 Vdout0_47ck65 = 0.9 time = 330
.meas tran vdout0_47ck65 FIND v(dout0_47) AT=330.025n

* CHECK dout0_48 Vdout0_48ck65 = 0 time = 330
.meas tran vdout0_48ck65 FIND v(dout0_48) AT=330.025n

* CHECK dout0_49 Vdout0_49ck65 = 0.9 time = 330
.meas tran vdout0_49ck65 FIND v(dout0_49) AT=330.025n

* CHECK dout0_50 Vdout0_50ck65 = 0.9 time = 330
.meas tran vdout0_50ck65 FIND v(dout0_50) AT=330.025n

* CHECK dout0_51 Vdout0_51ck65 = 0 time = 330
.meas tran vdout0_51ck65 FIND v(dout0_51) AT=330.025n

* CHECK dout0_52 Vdout0_52ck65 = 0 time = 330
.meas tran vdout0_52ck65 FIND v(dout0_52) AT=330.025n

* CHECK dout0_53 Vdout0_53ck65 = 0.9 time = 330
.meas tran vdout0_53ck65 FIND v(dout0_53) AT=330.025n

* CHECK dout0_54 Vdout0_54ck65 = 0 time = 330
.meas tran vdout0_54ck65 FIND v(dout0_54) AT=330.025n

* CHECK dout0_55 Vdout0_55ck65 = 0 time = 330
.meas tran vdout0_55ck65 FIND v(dout0_55) AT=330.025n

* CHECK dout0_56 Vdout0_56ck65 = 0 time = 330
.meas tran vdout0_56ck65 FIND v(dout0_56) AT=330.025n

* CHECK dout0_57 Vdout0_57ck65 = 0.9 time = 330
.meas tran vdout0_57ck65 FIND v(dout0_57) AT=330.025n

* CHECK dout0_58 Vdout0_58ck65 = 0 time = 330
.meas tran vdout0_58ck65 FIND v(dout0_58) AT=330.025n

* CHECK dout0_59 Vdout0_59ck65 = 0 time = 330
.meas tran vdout0_59ck65 FIND v(dout0_59) AT=330.025n

* CHECK dout0_60 Vdout0_60ck65 = 0.9 time = 330
.meas tran vdout0_60ck65 FIND v(dout0_60) AT=330.025n

* CHECK dout0_61 Vdout0_61ck65 = 0.9 time = 330
.meas tran vdout0_61ck65 FIND v(dout0_61) AT=330.025n

* CHECK dout0_62 Vdout0_62ck65 = 0 time = 330
.meas tran vdout0_62ck65 FIND v(dout0_62) AT=330.025n

* CHECK dout0_63 Vdout0_63ck65 = 0 time = 330
.meas tran vdout0_63ck65 FIND v(dout0_63) AT=330.025n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 340
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=340.025n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 340
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=340.025n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 340
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=340.025n

* CHECK dout0_3 Vdout0_3ck67 = 0 time = 340
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=340.025n

* CHECK dout0_4 Vdout0_4ck67 = 0 time = 340
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=340.025n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 340
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=340.025n

* CHECK dout0_6 Vdout0_6ck67 = 0.9 time = 340
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=340.025n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 340
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=340.025n

* CHECK dout0_8 Vdout0_8ck67 = 0 time = 340
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=340.025n

* CHECK dout0_9 Vdout0_9ck67 = 0 time = 340
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=340.025n

* CHECK dout0_10 Vdout0_10ck67 = 0 time = 340
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=340.025n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 340
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=340.025n

* CHECK dout0_12 Vdout0_12ck67 = 0 time = 340
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=340.025n

* CHECK dout0_13 Vdout0_13ck67 = 0.9 time = 340
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=340.025n

* CHECK dout0_14 Vdout0_14ck67 = 0.9 time = 340
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=340.025n

* CHECK dout0_15 Vdout0_15ck67 = 0.9 time = 340
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=340.025n

* CHECK dout0_16 Vdout0_16ck67 = 0.9 time = 340
.meas tran vdout0_16ck67 FIND v(dout0_16) AT=340.025n

* CHECK dout0_17 Vdout0_17ck67 = 0.9 time = 340
.meas tran vdout0_17ck67 FIND v(dout0_17) AT=340.025n

* CHECK dout0_18 Vdout0_18ck67 = 0 time = 340
.meas tran vdout0_18ck67 FIND v(dout0_18) AT=340.025n

* CHECK dout0_19 Vdout0_19ck67 = 0 time = 340
.meas tran vdout0_19ck67 FIND v(dout0_19) AT=340.025n

* CHECK dout0_20 Vdout0_20ck67 = 0.9 time = 340
.meas tran vdout0_20ck67 FIND v(dout0_20) AT=340.025n

* CHECK dout0_21 Vdout0_21ck67 = 0.9 time = 340
.meas tran vdout0_21ck67 FIND v(dout0_21) AT=340.025n

* CHECK dout0_22 Vdout0_22ck67 = 0.9 time = 340
.meas tran vdout0_22ck67 FIND v(dout0_22) AT=340.025n

* CHECK dout0_23 Vdout0_23ck67 = 0.9 time = 340
.meas tran vdout0_23ck67 FIND v(dout0_23) AT=340.025n

* CHECK dout0_24 Vdout0_24ck67 = 0 time = 340
.meas tran vdout0_24ck67 FIND v(dout0_24) AT=340.025n

* CHECK dout0_25 Vdout0_25ck67 = 0 time = 340
.meas tran vdout0_25ck67 FIND v(dout0_25) AT=340.025n

* CHECK dout0_26 Vdout0_26ck67 = 0 time = 340
.meas tran vdout0_26ck67 FIND v(dout0_26) AT=340.025n

* CHECK dout0_27 Vdout0_27ck67 = 0.9 time = 340
.meas tran vdout0_27ck67 FIND v(dout0_27) AT=340.025n

* CHECK dout0_28 Vdout0_28ck67 = 0 time = 340
.meas tran vdout0_28ck67 FIND v(dout0_28) AT=340.025n

* CHECK dout0_29 Vdout0_29ck67 = 0 time = 340
.meas tran vdout0_29ck67 FIND v(dout0_29) AT=340.025n

* CHECK dout0_30 Vdout0_30ck67 = 0.9 time = 340
.meas tran vdout0_30ck67 FIND v(dout0_30) AT=340.025n

* CHECK dout0_31 Vdout0_31ck67 = 0.9 time = 340
.meas tran vdout0_31ck67 FIND v(dout0_31) AT=340.025n

* CHECK dout0_32 Vdout0_32ck67 = 0 time = 340
.meas tran vdout0_32ck67 FIND v(dout0_32) AT=340.025n

* CHECK dout0_33 Vdout0_33ck67 = 0.9 time = 340
.meas tran vdout0_33ck67 FIND v(dout0_33) AT=340.025n

* CHECK dout0_34 Vdout0_34ck67 = 0.9 time = 340
.meas tran vdout0_34ck67 FIND v(dout0_34) AT=340.025n

* CHECK dout0_35 Vdout0_35ck67 = 0.9 time = 340
.meas tran vdout0_35ck67 FIND v(dout0_35) AT=340.025n

* CHECK dout0_36 Vdout0_36ck67 = 0.9 time = 340
.meas tran vdout0_36ck67 FIND v(dout0_36) AT=340.025n

* CHECK dout0_37 Vdout0_37ck67 = 0 time = 340
.meas tran vdout0_37ck67 FIND v(dout0_37) AT=340.025n

* CHECK dout0_38 Vdout0_38ck67 = 0 time = 340
.meas tran vdout0_38ck67 FIND v(dout0_38) AT=340.025n

* CHECK dout0_39 Vdout0_39ck67 = 0 time = 340
.meas tran vdout0_39ck67 FIND v(dout0_39) AT=340.025n

* CHECK dout0_40 Vdout0_40ck67 = 0.9 time = 340
.meas tran vdout0_40ck67 FIND v(dout0_40) AT=340.025n

* CHECK dout0_41 Vdout0_41ck67 = 0.9 time = 340
.meas tran vdout0_41ck67 FIND v(dout0_41) AT=340.025n

* CHECK dout0_42 Vdout0_42ck67 = 0.9 time = 340
.meas tran vdout0_42ck67 FIND v(dout0_42) AT=340.025n

* CHECK dout0_43 Vdout0_43ck67 = 0.9 time = 340
.meas tran vdout0_43ck67 FIND v(dout0_43) AT=340.025n

* CHECK dout0_44 Vdout0_44ck67 = 0 time = 340
.meas tran vdout0_44ck67 FIND v(dout0_44) AT=340.025n

* CHECK dout0_45 Vdout0_45ck67 = 0.9 time = 340
.meas tran vdout0_45ck67 FIND v(dout0_45) AT=340.025n

* CHECK dout0_46 Vdout0_46ck67 = 0 time = 340
.meas tran vdout0_46ck67 FIND v(dout0_46) AT=340.025n

* CHECK dout0_47 Vdout0_47ck67 = 0 time = 340
.meas tran vdout0_47ck67 FIND v(dout0_47) AT=340.025n

* CHECK dout0_48 Vdout0_48ck67 = 0 time = 340
.meas tran vdout0_48ck67 FIND v(dout0_48) AT=340.025n

* CHECK dout0_49 Vdout0_49ck67 = 0.9 time = 340
.meas tran vdout0_49ck67 FIND v(dout0_49) AT=340.025n

* CHECK dout0_50 Vdout0_50ck67 = 0.9 time = 340
.meas tran vdout0_50ck67 FIND v(dout0_50) AT=340.025n

* CHECK dout0_51 Vdout0_51ck67 = 0.9 time = 340
.meas tran vdout0_51ck67 FIND v(dout0_51) AT=340.025n

* CHECK dout0_52 Vdout0_52ck67 = 0 time = 340
.meas tran vdout0_52ck67 FIND v(dout0_52) AT=340.025n

* CHECK dout0_53 Vdout0_53ck67 = 0 time = 340
.meas tran vdout0_53ck67 FIND v(dout0_53) AT=340.025n

* CHECK dout0_54 Vdout0_54ck67 = 0 time = 340
.meas tran vdout0_54ck67 FIND v(dout0_54) AT=340.025n

* CHECK dout0_55 Vdout0_55ck67 = 0.9 time = 340
.meas tran vdout0_55ck67 FIND v(dout0_55) AT=340.025n

* CHECK dout0_56 Vdout0_56ck67 = 0.9 time = 340
.meas tran vdout0_56ck67 FIND v(dout0_56) AT=340.025n

* CHECK dout0_57 Vdout0_57ck67 = 0.9 time = 340
.meas tran vdout0_57ck67 FIND v(dout0_57) AT=340.025n

* CHECK dout0_58 Vdout0_58ck67 = 0 time = 340
.meas tran vdout0_58ck67 FIND v(dout0_58) AT=340.025n

* CHECK dout0_59 Vdout0_59ck67 = 0 time = 340
.meas tran vdout0_59ck67 FIND v(dout0_59) AT=340.025n

* CHECK dout0_60 Vdout0_60ck67 = 0.9 time = 340
.meas tran vdout0_60ck67 FIND v(dout0_60) AT=340.025n

* CHECK dout0_61 Vdout0_61ck67 = 0 time = 340
.meas tran vdout0_61ck67 FIND v(dout0_61) AT=340.025n

* CHECK dout0_62 Vdout0_62ck67 = 0 time = 340
.meas tran vdout0_62ck67 FIND v(dout0_62) AT=340.025n

* CHECK dout0_63 Vdout0_63ck67 = 0.9 time = 340
.meas tran vdout0_63ck67 FIND v(dout0_63) AT=340.025n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 345
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=345.025n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 345
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=345.025n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 345
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=345.025n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 345
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=345.025n

* CHECK dout0_4 Vdout0_4ck68 = 0 time = 345
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=345.025n

* CHECK dout0_5 Vdout0_5ck68 = 0 time = 345
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=345.025n

* CHECK dout0_6 Vdout0_6ck68 = 0.9 time = 345
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=345.025n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 345
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=345.025n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 345
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=345.025n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 345
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=345.025n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 345
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=345.025n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 345
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=345.025n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 345
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=345.025n

* CHECK dout0_13 Vdout0_13ck68 = 0.9 time = 345
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=345.025n

* CHECK dout0_14 Vdout0_14ck68 = 0.9 time = 345
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=345.025n

* CHECK dout0_15 Vdout0_15ck68 = 0.9 time = 345
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=345.025n

* CHECK dout0_16 Vdout0_16ck68 = 0.9 time = 345
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=345.025n

* CHECK dout0_17 Vdout0_17ck68 = 0.9 time = 345
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=345.025n

* CHECK dout0_18 Vdout0_18ck68 = 0 time = 345
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=345.025n

* CHECK dout0_19 Vdout0_19ck68 = 0 time = 345
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=345.025n

* CHECK dout0_20 Vdout0_20ck68 = 0.9 time = 345
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=345.025n

* CHECK dout0_21 Vdout0_21ck68 = 0.9 time = 345
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=345.025n

* CHECK dout0_22 Vdout0_22ck68 = 0.9 time = 345
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=345.025n

* CHECK dout0_23 Vdout0_23ck68 = 0.9 time = 345
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=345.025n

* CHECK dout0_24 Vdout0_24ck68 = 0 time = 345
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=345.025n

* CHECK dout0_25 Vdout0_25ck68 = 0 time = 345
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=345.025n

* CHECK dout0_26 Vdout0_26ck68 = 0 time = 345
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=345.025n

* CHECK dout0_27 Vdout0_27ck68 = 0.9 time = 345
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=345.025n

* CHECK dout0_28 Vdout0_28ck68 = 0 time = 345
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=345.025n

* CHECK dout0_29 Vdout0_29ck68 = 0 time = 345
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=345.025n

* CHECK dout0_30 Vdout0_30ck68 = 0.9 time = 345
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=345.025n

* CHECK dout0_31 Vdout0_31ck68 = 0.9 time = 345
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=345.025n

* CHECK dout0_32 Vdout0_32ck68 = 0 time = 345
.meas tran vdout0_32ck68 FIND v(dout0_32) AT=345.025n

* CHECK dout0_33 Vdout0_33ck68 = 0.9 time = 345
.meas tran vdout0_33ck68 FIND v(dout0_33) AT=345.025n

* CHECK dout0_34 Vdout0_34ck68 = 0.9 time = 345
.meas tran vdout0_34ck68 FIND v(dout0_34) AT=345.025n

* CHECK dout0_35 Vdout0_35ck68 = 0.9 time = 345
.meas tran vdout0_35ck68 FIND v(dout0_35) AT=345.025n

* CHECK dout0_36 Vdout0_36ck68 = 0.9 time = 345
.meas tran vdout0_36ck68 FIND v(dout0_36) AT=345.025n

* CHECK dout0_37 Vdout0_37ck68 = 0 time = 345
.meas tran vdout0_37ck68 FIND v(dout0_37) AT=345.025n

* CHECK dout0_38 Vdout0_38ck68 = 0 time = 345
.meas tran vdout0_38ck68 FIND v(dout0_38) AT=345.025n

* CHECK dout0_39 Vdout0_39ck68 = 0 time = 345
.meas tran vdout0_39ck68 FIND v(dout0_39) AT=345.025n

* CHECK dout0_40 Vdout0_40ck68 = 0.9 time = 345
.meas tran vdout0_40ck68 FIND v(dout0_40) AT=345.025n

* CHECK dout0_41 Vdout0_41ck68 = 0.9 time = 345
.meas tran vdout0_41ck68 FIND v(dout0_41) AT=345.025n

* CHECK dout0_42 Vdout0_42ck68 = 0.9 time = 345
.meas tran vdout0_42ck68 FIND v(dout0_42) AT=345.025n

* CHECK dout0_43 Vdout0_43ck68 = 0.9 time = 345
.meas tran vdout0_43ck68 FIND v(dout0_43) AT=345.025n

* CHECK dout0_44 Vdout0_44ck68 = 0 time = 345
.meas tran vdout0_44ck68 FIND v(dout0_44) AT=345.025n

* CHECK dout0_45 Vdout0_45ck68 = 0.9 time = 345
.meas tran vdout0_45ck68 FIND v(dout0_45) AT=345.025n

* CHECK dout0_46 Vdout0_46ck68 = 0 time = 345
.meas tran vdout0_46ck68 FIND v(dout0_46) AT=345.025n

* CHECK dout0_47 Vdout0_47ck68 = 0 time = 345
.meas tran vdout0_47ck68 FIND v(dout0_47) AT=345.025n

* CHECK dout0_48 Vdout0_48ck68 = 0 time = 345
.meas tran vdout0_48ck68 FIND v(dout0_48) AT=345.025n

* CHECK dout0_49 Vdout0_49ck68 = 0.9 time = 345
.meas tran vdout0_49ck68 FIND v(dout0_49) AT=345.025n

* CHECK dout0_50 Vdout0_50ck68 = 0.9 time = 345
.meas tran vdout0_50ck68 FIND v(dout0_50) AT=345.025n

* CHECK dout0_51 Vdout0_51ck68 = 0.9 time = 345
.meas tran vdout0_51ck68 FIND v(dout0_51) AT=345.025n

* CHECK dout0_52 Vdout0_52ck68 = 0 time = 345
.meas tran vdout0_52ck68 FIND v(dout0_52) AT=345.025n

* CHECK dout0_53 Vdout0_53ck68 = 0 time = 345
.meas tran vdout0_53ck68 FIND v(dout0_53) AT=345.025n

* CHECK dout0_54 Vdout0_54ck68 = 0 time = 345
.meas tran vdout0_54ck68 FIND v(dout0_54) AT=345.025n

* CHECK dout0_55 Vdout0_55ck68 = 0.9 time = 345
.meas tran vdout0_55ck68 FIND v(dout0_55) AT=345.025n

* CHECK dout0_56 Vdout0_56ck68 = 0.9 time = 345
.meas tran vdout0_56ck68 FIND v(dout0_56) AT=345.025n

* CHECK dout0_57 Vdout0_57ck68 = 0.9 time = 345
.meas tran vdout0_57ck68 FIND v(dout0_57) AT=345.025n

* CHECK dout0_58 Vdout0_58ck68 = 0 time = 345
.meas tran vdout0_58ck68 FIND v(dout0_58) AT=345.025n

* CHECK dout0_59 Vdout0_59ck68 = 0 time = 345
.meas tran vdout0_59ck68 FIND v(dout0_59) AT=345.025n

* CHECK dout0_60 Vdout0_60ck68 = 0.9 time = 345
.meas tran vdout0_60ck68 FIND v(dout0_60) AT=345.025n

* CHECK dout0_61 Vdout0_61ck68 = 0 time = 345
.meas tran vdout0_61ck68 FIND v(dout0_61) AT=345.025n

* CHECK dout0_62 Vdout0_62ck68 = 0 time = 345
.meas tran vdout0_62ck68 FIND v(dout0_62) AT=345.025n

* CHECK dout0_63 Vdout0_63ck68 = 0.9 time = 345
.meas tran vdout0_63ck68 FIND v(dout0_63) AT=345.025n

* CHECK dout0_0 Vdout0_0ck69 = 0.9 time = 350
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=350.025n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 350
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=350.025n

* CHECK dout0_2 Vdout0_2ck69 = 0 time = 350
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=350.025n

* CHECK dout0_3 Vdout0_3ck69 = 0 time = 350
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=350.025n

* CHECK dout0_4 Vdout0_4ck69 = 0.9 time = 350
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=350.025n

* CHECK dout0_5 Vdout0_5ck69 = 0.9 time = 350
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=350.025n

* CHECK dout0_6 Vdout0_6ck69 = 0 time = 350
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=350.025n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 350
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=350.025n

* CHECK dout0_8 Vdout0_8ck69 = 0 time = 350
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=350.025n

* CHECK dout0_9 Vdout0_9ck69 = 0.9 time = 350
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=350.025n

* CHECK dout0_10 Vdout0_10ck69 = 0.9 time = 350
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=350.025n

* CHECK dout0_11 Vdout0_11ck69 = 0.9 time = 350
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=350.025n

* CHECK dout0_12 Vdout0_12ck69 = 0 time = 350
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=350.025n

* CHECK dout0_13 Vdout0_13ck69 = 0 time = 350
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=350.025n

* CHECK dout0_14 Vdout0_14ck69 = 0 time = 350
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=350.025n

* CHECK dout0_15 Vdout0_15ck69 = 0 time = 350
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=350.025n

* CHECK dout0_16 Vdout0_16ck69 = 0 time = 350
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=350.025n

* CHECK dout0_17 Vdout0_17ck69 = 0 time = 350
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=350.025n

* CHECK dout0_18 Vdout0_18ck69 = 0 time = 350
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=350.025n

* CHECK dout0_19 Vdout0_19ck69 = 0.9 time = 350
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=350.025n

* CHECK dout0_20 Vdout0_20ck69 = 0.9 time = 350
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=350.025n

* CHECK dout0_21 Vdout0_21ck69 = 0 time = 350
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=350.025n

* CHECK dout0_22 Vdout0_22ck69 = 0 time = 350
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=350.025n

* CHECK dout0_23 Vdout0_23ck69 = 0 time = 350
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=350.025n

* CHECK dout0_24 Vdout0_24ck69 = 0.9 time = 350
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=350.025n

* CHECK dout0_25 Vdout0_25ck69 = 0 time = 350
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=350.025n

* CHECK dout0_26 Vdout0_26ck69 = 0 time = 350
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=350.025n

* CHECK dout0_27 Vdout0_27ck69 = 0.9 time = 350
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=350.025n

* CHECK dout0_28 Vdout0_28ck69 = 0 time = 350
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=350.025n

* CHECK dout0_29 Vdout0_29ck69 = 0 time = 350
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=350.025n

* CHECK dout0_30 Vdout0_30ck69 = 0 time = 350
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=350.025n

* CHECK dout0_31 Vdout0_31ck69 = 0.9 time = 350
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=350.025n

* CHECK dout0_32 Vdout0_32ck69 = 0.9 time = 350
.meas tran vdout0_32ck69 FIND v(dout0_32) AT=350.025n

* CHECK dout0_33 Vdout0_33ck69 = 0 time = 350
.meas tran vdout0_33ck69 FIND v(dout0_33) AT=350.025n

* CHECK dout0_34 Vdout0_34ck69 = 0 time = 350
.meas tran vdout0_34ck69 FIND v(dout0_34) AT=350.025n

* CHECK dout0_35 Vdout0_35ck69 = 0 time = 350
.meas tran vdout0_35ck69 FIND v(dout0_35) AT=350.025n

* CHECK dout0_36 Vdout0_36ck69 = 0.9 time = 350
.meas tran vdout0_36ck69 FIND v(dout0_36) AT=350.025n

* CHECK dout0_37 Vdout0_37ck69 = 0 time = 350
.meas tran vdout0_37ck69 FIND v(dout0_37) AT=350.025n

* CHECK dout0_38 Vdout0_38ck69 = 0 time = 350
.meas tran vdout0_38ck69 FIND v(dout0_38) AT=350.025n

* CHECK dout0_39 Vdout0_39ck69 = 0.9 time = 350
.meas tran vdout0_39ck69 FIND v(dout0_39) AT=350.025n

* CHECK dout0_40 Vdout0_40ck69 = 0.9 time = 350
.meas tran vdout0_40ck69 FIND v(dout0_40) AT=350.025n

* CHECK dout0_41 Vdout0_41ck69 = 0.9 time = 350
.meas tran vdout0_41ck69 FIND v(dout0_41) AT=350.025n

* CHECK dout0_42 Vdout0_42ck69 = 0 time = 350
.meas tran vdout0_42ck69 FIND v(dout0_42) AT=350.025n

* CHECK dout0_43 Vdout0_43ck69 = 0 time = 350
.meas tran vdout0_43ck69 FIND v(dout0_43) AT=350.025n

* CHECK dout0_44 Vdout0_44ck69 = 0.9 time = 350
.meas tran vdout0_44ck69 FIND v(dout0_44) AT=350.025n

* CHECK dout0_45 Vdout0_45ck69 = 0 time = 350
.meas tran vdout0_45ck69 FIND v(dout0_45) AT=350.025n

* CHECK dout0_46 Vdout0_46ck69 = 0 time = 350
.meas tran vdout0_46ck69 FIND v(dout0_46) AT=350.025n

* CHECK dout0_47 Vdout0_47ck69 = 0.9 time = 350
.meas tran vdout0_47ck69 FIND v(dout0_47) AT=350.025n

* CHECK dout0_48 Vdout0_48ck69 = 0 time = 350
.meas tran vdout0_48ck69 FIND v(dout0_48) AT=350.025n

* CHECK dout0_49 Vdout0_49ck69 = 0.9 time = 350
.meas tran vdout0_49ck69 FIND v(dout0_49) AT=350.025n

* CHECK dout0_50 Vdout0_50ck69 = 0.9 time = 350
.meas tran vdout0_50ck69 FIND v(dout0_50) AT=350.025n

* CHECK dout0_51 Vdout0_51ck69 = 0 time = 350
.meas tran vdout0_51ck69 FIND v(dout0_51) AT=350.025n

* CHECK dout0_52 Vdout0_52ck69 = 0 time = 350
.meas tran vdout0_52ck69 FIND v(dout0_52) AT=350.025n

* CHECK dout0_53 Vdout0_53ck69 = 0.9 time = 350
.meas tran vdout0_53ck69 FIND v(dout0_53) AT=350.025n

* CHECK dout0_54 Vdout0_54ck69 = 0 time = 350
.meas tran vdout0_54ck69 FIND v(dout0_54) AT=350.025n

* CHECK dout0_55 Vdout0_55ck69 = 0 time = 350
.meas tran vdout0_55ck69 FIND v(dout0_55) AT=350.025n

* CHECK dout0_56 Vdout0_56ck69 = 0 time = 350
.meas tran vdout0_56ck69 FIND v(dout0_56) AT=350.025n

* CHECK dout0_57 Vdout0_57ck69 = 0.9 time = 350
.meas tran vdout0_57ck69 FIND v(dout0_57) AT=350.025n

* CHECK dout0_58 Vdout0_58ck69 = 0 time = 350
.meas tran vdout0_58ck69 FIND v(dout0_58) AT=350.025n

* CHECK dout0_59 Vdout0_59ck69 = 0 time = 350
.meas tran vdout0_59ck69 FIND v(dout0_59) AT=350.025n

* CHECK dout0_60 Vdout0_60ck69 = 0.9 time = 350
.meas tran vdout0_60ck69 FIND v(dout0_60) AT=350.025n

* CHECK dout0_61 Vdout0_61ck69 = 0.9 time = 350
.meas tran vdout0_61ck69 FIND v(dout0_61) AT=350.025n

* CHECK dout0_62 Vdout0_62ck69 = 0 time = 350
.meas tran vdout0_62ck69 FIND v(dout0_62) AT=350.025n

* CHECK dout0_63 Vdout0_63ck69 = 0 time = 350
.meas tran vdout0_63ck69 FIND v(dout0_63) AT=350.025n

* CHECK dout0_0 Vdout0_0ck70 = 0.9 time = 355
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=355.025n

* CHECK dout0_1 Vdout0_1ck70 = 0 time = 355
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=355.025n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 355
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=355.025n

* CHECK dout0_3 Vdout0_3ck70 = 0 time = 355
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=355.025n

* CHECK dout0_4 Vdout0_4ck70 = 0.9 time = 355
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=355.025n

* CHECK dout0_5 Vdout0_5ck70 = 0.9 time = 355
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=355.025n

* CHECK dout0_6 Vdout0_6ck70 = 0 time = 355
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=355.025n

* CHECK dout0_7 Vdout0_7ck70 = 0 time = 355
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=355.025n

* CHECK dout0_8 Vdout0_8ck70 = 0 time = 355
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=355.025n

* CHECK dout0_9 Vdout0_9ck70 = 0.9 time = 355
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=355.025n

* CHECK dout0_10 Vdout0_10ck70 = 0.9 time = 355
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=355.025n

* CHECK dout0_11 Vdout0_11ck70 = 0.9 time = 355
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=355.025n

* CHECK dout0_12 Vdout0_12ck70 = 0 time = 355
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=355.025n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 355
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=355.025n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 355
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=355.025n

* CHECK dout0_15 Vdout0_15ck70 = 0 time = 355
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=355.025n

* CHECK dout0_16 Vdout0_16ck70 = 0 time = 355
.meas tran vdout0_16ck70 FIND v(dout0_16) AT=355.025n

* CHECK dout0_17 Vdout0_17ck70 = 0 time = 355
.meas tran vdout0_17ck70 FIND v(dout0_17) AT=355.025n

* CHECK dout0_18 Vdout0_18ck70 = 0 time = 355
.meas tran vdout0_18ck70 FIND v(dout0_18) AT=355.025n

* CHECK dout0_19 Vdout0_19ck70 = 0.9 time = 355
.meas tran vdout0_19ck70 FIND v(dout0_19) AT=355.025n

* CHECK dout0_20 Vdout0_20ck70 = 0.9 time = 355
.meas tran vdout0_20ck70 FIND v(dout0_20) AT=355.025n

* CHECK dout0_21 Vdout0_21ck70 = 0 time = 355
.meas tran vdout0_21ck70 FIND v(dout0_21) AT=355.025n

* CHECK dout0_22 Vdout0_22ck70 = 0 time = 355
.meas tran vdout0_22ck70 FIND v(dout0_22) AT=355.025n

* CHECK dout0_23 Vdout0_23ck70 = 0 time = 355
.meas tran vdout0_23ck70 FIND v(dout0_23) AT=355.025n

* CHECK dout0_24 Vdout0_24ck70 = 0.9 time = 355
.meas tran vdout0_24ck70 FIND v(dout0_24) AT=355.025n

* CHECK dout0_25 Vdout0_25ck70 = 0 time = 355
.meas tran vdout0_25ck70 FIND v(dout0_25) AT=355.025n

* CHECK dout0_26 Vdout0_26ck70 = 0 time = 355
.meas tran vdout0_26ck70 FIND v(dout0_26) AT=355.025n

* CHECK dout0_27 Vdout0_27ck70 = 0.9 time = 355
.meas tran vdout0_27ck70 FIND v(dout0_27) AT=355.025n

* CHECK dout0_28 Vdout0_28ck70 = 0 time = 355
.meas tran vdout0_28ck70 FIND v(dout0_28) AT=355.025n

* CHECK dout0_29 Vdout0_29ck70 = 0 time = 355
.meas tran vdout0_29ck70 FIND v(dout0_29) AT=355.025n

* CHECK dout0_30 Vdout0_30ck70 = 0 time = 355
.meas tran vdout0_30ck70 FIND v(dout0_30) AT=355.025n

* CHECK dout0_31 Vdout0_31ck70 = 0.9 time = 355
.meas tran vdout0_31ck70 FIND v(dout0_31) AT=355.025n

* CHECK dout0_32 Vdout0_32ck70 = 0.9 time = 355
.meas tran vdout0_32ck70 FIND v(dout0_32) AT=355.025n

* CHECK dout0_33 Vdout0_33ck70 = 0 time = 355
.meas tran vdout0_33ck70 FIND v(dout0_33) AT=355.025n

* CHECK dout0_34 Vdout0_34ck70 = 0 time = 355
.meas tran vdout0_34ck70 FIND v(dout0_34) AT=355.025n

* CHECK dout0_35 Vdout0_35ck70 = 0 time = 355
.meas tran vdout0_35ck70 FIND v(dout0_35) AT=355.025n

* CHECK dout0_36 Vdout0_36ck70 = 0.9 time = 355
.meas tran vdout0_36ck70 FIND v(dout0_36) AT=355.025n

* CHECK dout0_37 Vdout0_37ck70 = 0 time = 355
.meas tran vdout0_37ck70 FIND v(dout0_37) AT=355.025n

* CHECK dout0_38 Vdout0_38ck70 = 0 time = 355
.meas tran vdout0_38ck70 FIND v(dout0_38) AT=355.025n

* CHECK dout0_39 Vdout0_39ck70 = 0.9 time = 355
.meas tran vdout0_39ck70 FIND v(dout0_39) AT=355.025n

* CHECK dout0_40 Vdout0_40ck70 = 0.9 time = 355
.meas tran vdout0_40ck70 FIND v(dout0_40) AT=355.025n

* CHECK dout0_41 Vdout0_41ck70 = 0.9 time = 355
.meas tran vdout0_41ck70 FIND v(dout0_41) AT=355.025n

* CHECK dout0_42 Vdout0_42ck70 = 0 time = 355
.meas tran vdout0_42ck70 FIND v(dout0_42) AT=355.025n

* CHECK dout0_43 Vdout0_43ck70 = 0 time = 355
.meas tran vdout0_43ck70 FIND v(dout0_43) AT=355.025n

* CHECK dout0_44 Vdout0_44ck70 = 0.9 time = 355
.meas tran vdout0_44ck70 FIND v(dout0_44) AT=355.025n

* CHECK dout0_45 Vdout0_45ck70 = 0 time = 355
.meas tran vdout0_45ck70 FIND v(dout0_45) AT=355.025n

* CHECK dout0_46 Vdout0_46ck70 = 0 time = 355
.meas tran vdout0_46ck70 FIND v(dout0_46) AT=355.025n

* CHECK dout0_47 Vdout0_47ck70 = 0.9 time = 355
.meas tran vdout0_47ck70 FIND v(dout0_47) AT=355.025n

* CHECK dout0_48 Vdout0_48ck70 = 0 time = 355
.meas tran vdout0_48ck70 FIND v(dout0_48) AT=355.025n

* CHECK dout0_49 Vdout0_49ck70 = 0.9 time = 355
.meas tran vdout0_49ck70 FIND v(dout0_49) AT=355.025n

* CHECK dout0_50 Vdout0_50ck70 = 0.9 time = 355
.meas tran vdout0_50ck70 FIND v(dout0_50) AT=355.025n

* CHECK dout0_51 Vdout0_51ck70 = 0 time = 355
.meas tran vdout0_51ck70 FIND v(dout0_51) AT=355.025n

* CHECK dout0_52 Vdout0_52ck70 = 0 time = 355
.meas tran vdout0_52ck70 FIND v(dout0_52) AT=355.025n

* CHECK dout0_53 Vdout0_53ck70 = 0.9 time = 355
.meas tran vdout0_53ck70 FIND v(dout0_53) AT=355.025n

* CHECK dout0_54 Vdout0_54ck70 = 0 time = 355
.meas tran vdout0_54ck70 FIND v(dout0_54) AT=355.025n

* CHECK dout0_55 Vdout0_55ck70 = 0 time = 355
.meas tran vdout0_55ck70 FIND v(dout0_55) AT=355.025n

* CHECK dout0_56 Vdout0_56ck70 = 0 time = 355
.meas tran vdout0_56ck70 FIND v(dout0_56) AT=355.025n

* CHECK dout0_57 Vdout0_57ck70 = 0.9 time = 355
.meas tran vdout0_57ck70 FIND v(dout0_57) AT=355.025n

* CHECK dout0_58 Vdout0_58ck70 = 0 time = 355
.meas tran vdout0_58ck70 FIND v(dout0_58) AT=355.025n

* CHECK dout0_59 Vdout0_59ck70 = 0 time = 355
.meas tran vdout0_59ck70 FIND v(dout0_59) AT=355.025n

* CHECK dout0_60 Vdout0_60ck70 = 0.9 time = 355
.meas tran vdout0_60ck70 FIND v(dout0_60) AT=355.025n

* CHECK dout0_61 Vdout0_61ck70 = 0.9 time = 355
.meas tran vdout0_61ck70 FIND v(dout0_61) AT=355.025n

* CHECK dout0_62 Vdout0_62ck70 = 0 time = 355
.meas tran vdout0_62ck70 FIND v(dout0_62) AT=355.025n

* CHECK dout0_63 Vdout0_63ck70 = 0 time = 355
.meas tran vdout0_63ck70 FIND v(dout0_63) AT=355.025n

* CHECK dout0_0 Vdout0_0ck71 = 0.9 time = 360
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=360.025n

* CHECK dout0_1 Vdout0_1ck71 = 0 time = 360
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=360.025n

* CHECK dout0_2 Vdout0_2ck71 = 0 time = 360
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=360.025n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 360
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=360.025n

* CHECK dout0_4 Vdout0_4ck71 = 0.9 time = 360
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=360.025n

* CHECK dout0_5 Vdout0_5ck71 = 0.9 time = 360
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=360.025n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 360
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=360.025n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 360
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=360.025n

* CHECK dout0_8 Vdout0_8ck71 = 0 time = 360
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=360.025n

* CHECK dout0_9 Vdout0_9ck71 = 0.9 time = 360
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=360.025n

* CHECK dout0_10 Vdout0_10ck71 = 0.9 time = 360
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=360.025n

* CHECK dout0_11 Vdout0_11ck71 = 0.9 time = 360
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=360.025n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 360
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=360.025n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 360
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=360.025n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 360
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=360.025n

* CHECK dout0_15 Vdout0_15ck71 = 0 time = 360
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=360.025n

* CHECK dout0_16 Vdout0_16ck71 = 0 time = 360
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=360.025n

* CHECK dout0_17 Vdout0_17ck71 = 0 time = 360
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=360.025n

* CHECK dout0_18 Vdout0_18ck71 = 0 time = 360
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=360.025n

* CHECK dout0_19 Vdout0_19ck71 = 0.9 time = 360
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=360.025n

* CHECK dout0_20 Vdout0_20ck71 = 0.9 time = 360
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=360.025n

* CHECK dout0_21 Vdout0_21ck71 = 0 time = 360
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=360.025n

* CHECK dout0_22 Vdout0_22ck71 = 0 time = 360
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=360.025n

* CHECK dout0_23 Vdout0_23ck71 = 0 time = 360
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=360.025n

* CHECK dout0_24 Vdout0_24ck71 = 0.9 time = 360
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=360.025n

* CHECK dout0_25 Vdout0_25ck71 = 0 time = 360
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=360.025n

* CHECK dout0_26 Vdout0_26ck71 = 0 time = 360
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=360.025n

* CHECK dout0_27 Vdout0_27ck71 = 0.9 time = 360
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=360.025n

* CHECK dout0_28 Vdout0_28ck71 = 0 time = 360
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=360.025n

* CHECK dout0_29 Vdout0_29ck71 = 0 time = 360
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=360.025n

* CHECK dout0_30 Vdout0_30ck71 = 0 time = 360
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=360.025n

* CHECK dout0_31 Vdout0_31ck71 = 0.9 time = 360
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=360.025n

* CHECK dout0_32 Vdout0_32ck71 = 0.9 time = 360
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=360.025n

* CHECK dout0_33 Vdout0_33ck71 = 0 time = 360
.meas tran vdout0_33ck71 FIND v(dout0_33) AT=360.025n

* CHECK dout0_34 Vdout0_34ck71 = 0 time = 360
.meas tran vdout0_34ck71 FIND v(dout0_34) AT=360.025n

* CHECK dout0_35 Vdout0_35ck71 = 0 time = 360
.meas tran vdout0_35ck71 FIND v(dout0_35) AT=360.025n

* CHECK dout0_36 Vdout0_36ck71 = 0.9 time = 360
.meas tran vdout0_36ck71 FIND v(dout0_36) AT=360.025n

* CHECK dout0_37 Vdout0_37ck71 = 0 time = 360
.meas tran vdout0_37ck71 FIND v(dout0_37) AT=360.025n

* CHECK dout0_38 Vdout0_38ck71 = 0 time = 360
.meas tran vdout0_38ck71 FIND v(dout0_38) AT=360.025n

* CHECK dout0_39 Vdout0_39ck71 = 0.9 time = 360
.meas tran vdout0_39ck71 FIND v(dout0_39) AT=360.025n

* CHECK dout0_40 Vdout0_40ck71 = 0.9 time = 360
.meas tran vdout0_40ck71 FIND v(dout0_40) AT=360.025n

* CHECK dout0_41 Vdout0_41ck71 = 0.9 time = 360
.meas tran vdout0_41ck71 FIND v(dout0_41) AT=360.025n

* CHECK dout0_42 Vdout0_42ck71 = 0 time = 360
.meas tran vdout0_42ck71 FIND v(dout0_42) AT=360.025n

* CHECK dout0_43 Vdout0_43ck71 = 0 time = 360
.meas tran vdout0_43ck71 FIND v(dout0_43) AT=360.025n

* CHECK dout0_44 Vdout0_44ck71 = 0.9 time = 360
.meas tran vdout0_44ck71 FIND v(dout0_44) AT=360.025n

* CHECK dout0_45 Vdout0_45ck71 = 0 time = 360
.meas tran vdout0_45ck71 FIND v(dout0_45) AT=360.025n

* CHECK dout0_46 Vdout0_46ck71 = 0 time = 360
.meas tran vdout0_46ck71 FIND v(dout0_46) AT=360.025n

* CHECK dout0_47 Vdout0_47ck71 = 0.9 time = 360
.meas tran vdout0_47ck71 FIND v(dout0_47) AT=360.025n

* CHECK dout0_48 Vdout0_48ck71 = 0 time = 360
.meas tran vdout0_48ck71 FIND v(dout0_48) AT=360.025n

* CHECK dout0_49 Vdout0_49ck71 = 0.9 time = 360
.meas tran vdout0_49ck71 FIND v(dout0_49) AT=360.025n

* CHECK dout0_50 Vdout0_50ck71 = 0.9 time = 360
.meas tran vdout0_50ck71 FIND v(dout0_50) AT=360.025n

* CHECK dout0_51 Vdout0_51ck71 = 0 time = 360
.meas tran vdout0_51ck71 FIND v(dout0_51) AT=360.025n

* CHECK dout0_52 Vdout0_52ck71 = 0 time = 360
.meas tran vdout0_52ck71 FIND v(dout0_52) AT=360.025n

* CHECK dout0_53 Vdout0_53ck71 = 0.9 time = 360
.meas tran vdout0_53ck71 FIND v(dout0_53) AT=360.025n

* CHECK dout0_54 Vdout0_54ck71 = 0 time = 360
.meas tran vdout0_54ck71 FIND v(dout0_54) AT=360.025n

* CHECK dout0_55 Vdout0_55ck71 = 0 time = 360
.meas tran vdout0_55ck71 FIND v(dout0_55) AT=360.025n

* CHECK dout0_56 Vdout0_56ck71 = 0 time = 360
.meas tran vdout0_56ck71 FIND v(dout0_56) AT=360.025n

* CHECK dout0_57 Vdout0_57ck71 = 0.9 time = 360
.meas tran vdout0_57ck71 FIND v(dout0_57) AT=360.025n

* CHECK dout0_58 Vdout0_58ck71 = 0 time = 360
.meas tran vdout0_58ck71 FIND v(dout0_58) AT=360.025n

* CHECK dout0_59 Vdout0_59ck71 = 0 time = 360
.meas tran vdout0_59ck71 FIND v(dout0_59) AT=360.025n

* CHECK dout0_60 Vdout0_60ck71 = 0.9 time = 360
.meas tran vdout0_60ck71 FIND v(dout0_60) AT=360.025n

* CHECK dout0_61 Vdout0_61ck71 = 0.9 time = 360
.meas tran vdout0_61ck71 FIND v(dout0_61) AT=360.025n

* CHECK dout0_62 Vdout0_62ck71 = 0 time = 360
.meas tran vdout0_62ck71 FIND v(dout0_62) AT=360.025n

* CHECK dout0_63 Vdout0_63ck71 = 0 time = 360
.meas tran vdout0_63ck71 FIND v(dout0_63) AT=360.025n

* CHECK dout0_0 Vdout0_0ck72 = 0.9 time = 365
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=365.025n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 365
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=365.025n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 365
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=365.025n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 365
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=365.025n

* CHECK dout0_4 Vdout0_4ck72 = 0.9 time = 365
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=365.025n

* CHECK dout0_5 Vdout0_5ck72 = 0.9 time = 365
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=365.025n

* CHECK dout0_6 Vdout0_6ck72 = 0 time = 365
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=365.025n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 365
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=365.025n

* CHECK dout0_8 Vdout0_8ck72 = 0 time = 365
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=365.025n

* CHECK dout0_9 Vdout0_9ck72 = 0.9 time = 365
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=365.025n

* CHECK dout0_10 Vdout0_10ck72 = 0.9 time = 365
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=365.025n

* CHECK dout0_11 Vdout0_11ck72 = 0.9 time = 365
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=365.025n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 365
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=365.025n

* CHECK dout0_13 Vdout0_13ck72 = 0 time = 365
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=365.025n

* CHECK dout0_14 Vdout0_14ck72 = 0 time = 365
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=365.025n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 365
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=365.025n

* CHECK dout0_16 Vdout0_16ck72 = 0 time = 365
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=365.025n

* CHECK dout0_17 Vdout0_17ck72 = 0 time = 365
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=365.025n

* CHECK dout0_18 Vdout0_18ck72 = 0 time = 365
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=365.025n

* CHECK dout0_19 Vdout0_19ck72 = 0.9 time = 365
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=365.025n

* CHECK dout0_20 Vdout0_20ck72 = 0.9 time = 365
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=365.025n

* CHECK dout0_21 Vdout0_21ck72 = 0 time = 365
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=365.025n

* CHECK dout0_22 Vdout0_22ck72 = 0 time = 365
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=365.025n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 365
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=365.025n

* CHECK dout0_24 Vdout0_24ck72 = 0.9 time = 365
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=365.025n

* CHECK dout0_25 Vdout0_25ck72 = 0 time = 365
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=365.025n

* CHECK dout0_26 Vdout0_26ck72 = 0 time = 365
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=365.025n

* CHECK dout0_27 Vdout0_27ck72 = 0.9 time = 365
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=365.025n

* CHECK dout0_28 Vdout0_28ck72 = 0 time = 365
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=365.025n

* CHECK dout0_29 Vdout0_29ck72 = 0 time = 365
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=365.025n

* CHECK dout0_30 Vdout0_30ck72 = 0 time = 365
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=365.025n

* CHECK dout0_31 Vdout0_31ck72 = 0.9 time = 365
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=365.025n

* CHECK dout0_32 Vdout0_32ck72 = 0.9 time = 365
.meas tran vdout0_32ck72 FIND v(dout0_32) AT=365.025n

* CHECK dout0_33 Vdout0_33ck72 = 0 time = 365
.meas tran vdout0_33ck72 FIND v(dout0_33) AT=365.025n

* CHECK dout0_34 Vdout0_34ck72 = 0 time = 365
.meas tran vdout0_34ck72 FIND v(dout0_34) AT=365.025n

* CHECK dout0_35 Vdout0_35ck72 = 0 time = 365
.meas tran vdout0_35ck72 FIND v(dout0_35) AT=365.025n

* CHECK dout0_36 Vdout0_36ck72 = 0.9 time = 365
.meas tran vdout0_36ck72 FIND v(dout0_36) AT=365.025n

* CHECK dout0_37 Vdout0_37ck72 = 0 time = 365
.meas tran vdout0_37ck72 FIND v(dout0_37) AT=365.025n

* CHECK dout0_38 Vdout0_38ck72 = 0 time = 365
.meas tran vdout0_38ck72 FIND v(dout0_38) AT=365.025n

* CHECK dout0_39 Vdout0_39ck72 = 0.9 time = 365
.meas tran vdout0_39ck72 FIND v(dout0_39) AT=365.025n

* CHECK dout0_40 Vdout0_40ck72 = 0.9 time = 365
.meas tran vdout0_40ck72 FIND v(dout0_40) AT=365.025n

* CHECK dout0_41 Vdout0_41ck72 = 0.9 time = 365
.meas tran vdout0_41ck72 FIND v(dout0_41) AT=365.025n

* CHECK dout0_42 Vdout0_42ck72 = 0 time = 365
.meas tran vdout0_42ck72 FIND v(dout0_42) AT=365.025n

* CHECK dout0_43 Vdout0_43ck72 = 0 time = 365
.meas tran vdout0_43ck72 FIND v(dout0_43) AT=365.025n

* CHECK dout0_44 Vdout0_44ck72 = 0.9 time = 365
.meas tran vdout0_44ck72 FIND v(dout0_44) AT=365.025n

* CHECK dout0_45 Vdout0_45ck72 = 0 time = 365
.meas tran vdout0_45ck72 FIND v(dout0_45) AT=365.025n

* CHECK dout0_46 Vdout0_46ck72 = 0 time = 365
.meas tran vdout0_46ck72 FIND v(dout0_46) AT=365.025n

* CHECK dout0_47 Vdout0_47ck72 = 0.9 time = 365
.meas tran vdout0_47ck72 FIND v(dout0_47) AT=365.025n

* CHECK dout0_48 Vdout0_48ck72 = 0 time = 365
.meas tran vdout0_48ck72 FIND v(dout0_48) AT=365.025n

* CHECK dout0_49 Vdout0_49ck72 = 0.9 time = 365
.meas tran vdout0_49ck72 FIND v(dout0_49) AT=365.025n

* CHECK dout0_50 Vdout0_50ck72 = 0.9 time = 365
.meas tran vdout0_50ck72 FIND v(dout0_50) AT=365.025n

* CHECK dout0_51 Vdout0_51ck72 = 0 time = 365
.meas tran vdout0_51ck72 FIND v(dout0_51) AT=365.025n

* CHECK dout0_52 Vdout0_52ck72 = 0 time = 365
.meas tran vdout0_52ck72 FIND v(dout0_52) AT=365.025n

* CHECK dout0_53 Vdout0_53ck72 = 0.9 time = 365
.meas tran vdout0_53ck72 FIND v(dout0_53) AT=365.025n

* CHECK dout0_54 Vdout0_54ck72 = 0 time = 365
.meas tran vdout0_54ck72 FIND v(dout0_54) AT=365.025n

* CHECK dout0_55 Vdout0_55ck72 = 0 time = 365
.meas tran vdout0_55ck72 FIND v(dout0_55) AT=365.025n

* CHECK dout0_56 Vdout0_56ck72 = 0 time = 365
.meas tran vdout0_56ck72 FIND v(dout0_56) AT=365.025n

* CHECK dout0_57 Vdout0_57ck72 = 0.9 time = 365
.meas tran vdout0_57ck72 FIND v(dout0_57) AT=365.025n

* CHECK dout0_58 Vdout0_58ck72 = 0 time = 365
.meas tran vdout0_58ck72 FIND v(dout0_58) AT=365.025n

* CHECK dout0_59 Vdout0_59ck72 = 0 time = 365
.meas tran vdout0_59ck72 FIND v(dout0_59) AT=365.025n

* CHECK dout0_60 Vdout0_60ck72 = 0.9 time = 365
.meas tran vdout0_60ck72 FIND v(dout0_60) AT=365.025n

* CHECK dout0_61 Vdout0_61ck72 = 0.9 time = 365
.meas tran vdout0_61ck72 FIND v(dout0_61) AT=365.025n

* CHECK dout0_62 Vdout0_62ck72 = 0 time = 365
.meas tran vdout0_62ck72 FIND v(dout0_62) AT=365.025n

* CHECK dout0_63 Vdout0_63ck72 = 0 time = 365
.meas tran vdout0_63ck72 FIND v(dout0_63) AT=365.025n

* CHECK dout0_0 Vdout0_0ck73 = 0.9 time = 370
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=370.025n

* CHECK dout0_1 Vdout0_1ck73 = 0 time = 370
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=370.025n

* CHECK dout0_2 Vdout0_2ck73 = 0 time = 370
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=370.025n

* CHECK dout0_3 Vdout0_3ck73 = 0 time = 370
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=370.025n

* CHECK dout0_4 Vdout0_4ck73 = 0.9 time = 370
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=370.025n

* CHECK dout0_5 Vdout0_5ck73 = 0.9 time = 370
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=370.025n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 370
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=370.025n

* CHECK dout0_7 Vdout0_7ck73 = 0 time = 370
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=370.025n

* CHECK dout0_8 Vdout0_8ck73 = 0 time = 370
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=370.025n

* CHECK dout0_9 Vdout0_9ck73 = 0.9 time = 370
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=370.025n

* CHECK dout0_10 Vdout0_10ck73 = 0.9 time = 370
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=370.025n

* CHECK dout0_11 Vdout0_11ck73 = 0.9 time = 370
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=370.025n

* CHECK dout0_12 Vdout0_12ck73 = 0 time = 370
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=370.025n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 370
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=370.025n

* CHECK dout0_14 Vdout0_14ck73 = 0 time = 370
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=370.025n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 370
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=370.025n

* CHECK dout0_16 Vdout0_16ck73 = 0 time = 370
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=370.025n

* CHECK dout0_17 Vdout0_17ck73 = 0 time = 370
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=370.025n

* CHECK dout0_18 Vdout0_18ck73 = 0 time = 370
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=370.025n

* CHECK dout0_19 Vdout0_19ck73 = 0.9 time = 370
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=370.025n

* CHECK dout0_20 Vdout0_20ck73 = 0.9 time = 370
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=370.025n

* CHECK dout0_21 Vdout0_21ck73 = 0 time = 370
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=370.025n

* CHECK dout0_22 Vdout0_22ck73 = 0 time = 370
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=370.025n

* CHECK dout0_23 Vdout0_23ck73 = 0 time = 370
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=370.025n

* CHECK dout0_24 Vdout0_24ck73 = 0.9 time = 370
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=370.025n

* CHECK dout0_25 Vdout0_25ck73 = 0 time = 370
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=370.025n

* CHECK dout0_26 Vdout0_26ck73 = 0 time = 370
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=370.025n

* CHECK dout0_27 Vdout0_27ck73 = 0.9 time = 370
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=370.025n

* CHECK dout0_28 Vdout0_28ck73 = 0 time = 370
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=370.025n

* CHECK dout0_29 Vdout0_29ck73 = 0 time = 370
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=370.025n

* CHECK dout0_30 Vdout0_30ck73 = 0 time = 370
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=370.025n

* CHECK dout0_31 Vdout0_31ck73 = 0.9 time = 370
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=370.025n

* CHECK dout0_32 Vdout0_32ck73 = 0.9 time = 370
.meas tran vdout0_32ck73 FIND v(dout0_32) AT=370.025n

* CHECK dout0_33 Vdout0_33ck73 = 0 time = 370
.meas tran vdout0_33ck73 FIND v(dout0_33) AT=370.025n

* CHECK dout0_34 Vdout0_34ck73 = 0 time = 370
.meas tran vdout0_34ck73 FIND v(dout0_34) AT=370.025n

* CHECK dout0_35 Vdout0_35ck73 = 0 time = 370
.meas tran vdout0_35ck73 FIND v(dout0_35) AT=370.025n

* CHECK dout0_36 Vdout0_36ck73 = 0.9 time = 370
.meas tran vdout0_36ck73 FIND v(dout0_36) AT=370.025n

* CHECK dout0_37 Vdout0_37ck73 = 0 time = 370
.meas tran vdout0_37ck73 FIND v(dout0_37) AT=370.025n

* CHECK dout0_38 Vdout0_38ck73 = 0 time = 370
.meas tran vdout0_38ck73 FIND v(dout0_38) AT=370.025n

* CHECK dout0_39 Vdout0_39ck73 = 0.9 time = 370
.meas tran vdout0_39ck73 FIND v(dout0_39) AT=370.025n

* CHECK dout0_40 Vdout0_40ck73 = 0.9 time = 370
.meas tran vdout0_40ck73 FIND v(dout0_40) AT=370.025n

* CHECK dout0_41 Vdout0_41ck73 = 0.9 time = 370
.meas tran vdout0_41ck73 FIND v(dout0_41) AT=370.025n

* CHECK dout0_42 Vdout0_42ck73 = 0 time = 370
.meas tran vdout0_42ck73 FIND v(dout0_42) AT=370.025n

* CHECK dout0_43 Vdout0_43ck73 = 0 time = 370
.meas tran vdout0_43ck73 FIND v(dout0_43) AT=370.025n

* CHECK dout0_44 Vdout0_44ck73 = 0.9 time = 370
.meas tran vdout0_44ck73 FIND v(dout0_44) AT=370.025n

* CHECK dout0_45 Vdout0_45ck73 = 0 time = 370
.meas tran vdout0_45ck73 FIND v(dout0_45) AT=370.025n

* CHECK dout0_46 Vdout0_46ck73 = 0 time = 370
.meas tran vdout0_46ck73 FIND v(dout0_46) AT=370.025n

* CHECK dout0_47 Vdout0_47ck73 = 0.9 time = 370
.meas tran vdout0_47ck73 FIND v(dout0_47) AT=370.025n

* CHECK dout0_48 Vdout0_48ck73 = 0 time = 370
.meas tran vdout0_48ck73 FIND v(dout0_48) AT=370.025n

* CHECK dout0_49 Vdout0_49ck73 = 0.9 time = 370
.meas tran vdout0_49ck73 FIND v(dout0_49) AT=370.025n

* CHECK dout0_50 Vdout0_50ck73 = 0.9 time = 370
.meas tran vdout0_50ck73 FIND v(dout0_50) AT=370.025n

* CHECK dout0_51 Vdout0_51ck73 = 0 time = 370
.meas tran vdout0_51ck73 FIND v(dout0_51) AT=370.025n

* CHECK dout0_52 Vdout0_52ck73 = 0 time = 370
.meas tran vdout0_52ck73 FIND v(dout0_52) AT=370.025n

* CHECK dout0_53 Vdout0_53ck73 = 0.9 time = 370
.meas tran vdout0_53ck73 FIND v(dout0_53) AT=370.025n

* CHECK dout0_54 Vdout0_54ck73 = 0 time = 370
.meas tran vdout0_54ck73 FIND v(dout0_54) AT=370.025n

* CHECK dout0_55 Vdout0_55ck73 = 0 time = 370
.meas tran vdout0_55ck73 FIND v(dout0_55) AT=370.025n

* CHECK dout0_56 Vdout0_56ck73 = 0 time = 370
.meas tran vdout0_56ck73 FIND v(dout0_56) AT=370.025n

* CHECK dout0_57 Vdout0_57ck73 = 0.9 time = 370
.meas tran vdout0_57ck73 FIND v(dout0_57) AT=370.025n

* CHECK dout0_58 Vdout0_58ck73 = 0 time = 370
.meas tran vdout0_58ck73 FIND v(dout0_58) AT=370.025n

* CHECK dout0_59 Vdout0_59ck73 = 0 time = 370
.meas tran vdout0_59ck73 FIND v(dout0_59) AT=370.025n

* CHECK dout0_60 Vdout0_60ck73 = 0.9 time = 370
.meas tran vdout0_60ck73 FIND v(dout0_60) AT=370.025n

* CHECK dout0_61 Vdout0_61ck73 = 0.9 time = 370
.meas tran vdout0_61ck73 FIND v(dout0_61) AT=370.025n

* CHECK dout0_62 Vdout0_62ck73 = 0 time = 370
.meas tran vdout0_62ck73 FIND v(dout0_62) AT=370.025n

* CHECK dout0_63 Vdout0_63ck73 = 0 time = 370
.meas tran vdout0_63ck73 FIND v(dout0_63) AT=370.025n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 375
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=375.025n

* CHECK dout0_1 Vdout0_1ck74 = 0 time = 375
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=375.025n

* CHECK dout0_2 Vdout0_2ck74 = 0 time = 375
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=375.025n

* CHECK dout0_3 Vdout0_3ck74 = 0 time = 375
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=375.025n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 375
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=375.025n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 375
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=375.025n

* CHECK dout0_6 Vdout0_6ck74 = 0.9 time = 375
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=375.025n

* CHECK dout0_7 Vdout0_7ck74 = 0 time = 375
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=375.025n

* CHECK dout0_8 Vdout0_8ck74 = 0 time = 375
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=375.025n

* CHECK dout0_9 Vdout0_9ck74 = 0 time = 375
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=375.025n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 375
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=375.025n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 375
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=375.025n

* CHECK dout0_12 Vdout0_12ck74 = 0 time = 375
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=375.025n

* CHECK dout0_13 Vdout0_13ck74 = 0.9 time = 375
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=375.025n

* CHECK dout0_14 Vdout0_14ck74 = 0.9 time = 375
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=375.025n

* CHECK dout0_15 Vdout0_15ck74 = 0.9 time = 375
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=375.025n

* CHECK dout0_16 Vdout0_16ck74 = 0.9 time = 375
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=375.025n

* CHECK dout0_17 Vdout0_17ck74 = 0.9 time = 375
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=375.025n

* CHECK dout0_18 Vdout0_18ck74 = 0 time = 375
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=375.025n

* CHECK dout0_19 Vdout0_19ck74 = 0 time = 375
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=375.025n

* CHECK dout0_20 Vdout0_20ck74 = 0.9 time = 375
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=375.025n

* CHECK dout0_21 Vdout0_21ck74 = 0.9 time = 375
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=375.025n

* CHECK dout0_22 Vdout0_22ck74 = 0.9 time = 375
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=375.025n

* CHECK dout0_23 Vdout0_23ck74 = 0.9 time = 375
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=375.025n

* CHECK dout0_24 Vdout0_24ck74 = 0 time = 375
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=375.025n

* CHECK dout0_25 Vdout0_25ck74 = 0 time = 375
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=375.025n

* CHECK dout0_26 Vdout0_26ck74 = 0 time = 375
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=375.025n

* CHECK dout0_27 Vdout0_27ck74 = 0.9 time = 375
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=375.025n

* CHECK dout0_28 Vdout0_28ck74 = 0 time = 375
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=375.025n

* CHECK dout0_29 Vdout0_29ck74 = 0 time = 375
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=375.025n

* CHECK dout0_30 Vdout0_30ck74 = 0.9 time = 375
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=375.025n

* CHECK dout0_31 Vdout0_31ck74 = 0.9 time = 375
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=375.025n

* CHECK dout0_32 Vdout0_32ck74 = 0 time = 375
.meas tran vdout0_32ck74 FIND v(dout0_32) AT=375.025n

* CHECK dout0_33 Vdout0_33ck74 = 0.9 time = 375
.meas tran vdout0_33ck74 FIND v(dout0_33) AT=375.025n

* CHECK dout0_34 Vdout0_34ck74 = 0.9 time = 375
.meas tran vdout0_34ck74 FIND v(dout0_34) AT=375.025n

* CHECK dout0_35 Vdout0_35ck74 = 0.9 time = 375
.meas tran vdout0_35ck74 FIND v(dout0_35) AT=375.025n

* CHECK dout0_36 Vdout0_36ck74 = 0.9 time = 375
.meas tran vdout0_36ck74 FIND v(dout0_36) AT=375.025n

* CHECK dout0_37 Vdout0_37ck74 = 0 time = 375
.meas tran vdout0_37ck74 FIND v(dout0_37) AT=375.025n

* CHECK dout0_38 Vdout0_38ck74 = 0 time = 375
.meas tran vdout0_38ck74 FIND v(dout0_38) AT=375.025n

* CHECK dout0_39 Vdout0_39ck74 = 0 time = 375
.meas tran vdout0_39ck74 FIND v(dout0_39) AT=375.025n

* CHECK dout0_40 Vdout0_40ck74 = 0.9 time = 375
.meas tran vdout0_40ck74 FIND v(dout0_40) AT=375.025n

* CHECK dout0_41 Vdout0_41ck74 = 0.9 time = 375
.meas tran vdout0_41ck74 FIND v(dout0_41) AT=375.025n

* CHECK dout0_42 Vdout0_42ck74 = 0.9 time = 375
.meas tran vdout0_42ck74 FIND v(dout0_42) AT=375.025n

* CHECK dout0_43 Vdout0_43ck74 = 0.9 time = 375
.meas tran vdout0_43ck74 FIND v(dout0_43) AT=375.025n

* CHECK dout0_44 Vdout0_44ck74 = 0 time = 375
.meas tran vdout0_44ck74 FIND v(dout0_44) AT=375.025n

* CHECK dout0_45 Vdout0_45ck74 = 0.9 time = 375
.meas tran vdout0_45ck74 FIND v(dout0_45) AT=375.025n

* CHECK dout0_46 Vdout0_46ck74 = 0 time = 375
.meas tran vdout0_46ck74 FIND v(dout0_46) AT=375.025n

* CHECK dout0_47 Vdout0_47ck74 = 0 time = 375
.meas tran vdout0_47ck74 FIND v(dout0_47) AT=375.025n

* CHECK dout0_48 Vdout0_48ck74 = 0 time = 375
.meas tran vdout0_48ck74 FIND v(dout0_48) AT=375.025n

* CHECK dout0_49 Vdout0_49ck74 = 0.9 time = 375
.meas tran vdout0_49ck74 FIND v(dout0_49) AT=375.025n

* CHECK dout0_50 Vdout0_50ck74 = 0.9 time = 375
.meas tran vdout0_50ck74 FIND v(dout0_50) AT=375.025n

* CHECK dout0_51 Vdout0_51ck74 = 0.9 time = 375
.meas tran vdout0_51ck74 FIND v(dout0_51) AT=375.025n

* CHECK dout0_52 Vdout0_52ck74 = 0 time = 375
.meas tran vdout0_52ck74 FIND v(dout0_52) AT=375.025n

* CHECK dout0_53 Vdout0_53ck74 = 0 time = 375
.meas tran vdout0_53ck74 FIND v(dout0_53) AT=375.025n

* CHECK dout0_54 Vdout0_54ck74 = 0 time = 375
.meas tran vdout0_54ck74 FIND v(dout0_54) AT=375.025n

* CHECK dout0_55 Vdout0_55ck74 = 0.9 time = 375
.meas tran vdout0_55ck74 FIND v(dout0_55) AT=375.025n

* CHECK dout0_56 Vdout0_56ck74 = 0.9 time = 375
.meas tran vdout0_56ck74 FIND v(dout0_56) AT=375.025n

* CHECK dout0_57 Vdout0_57ck74 = 0.9 time = 375
.meas tran vdout0_57ck74 FIND v(dout0_57) AT=375.025n

* CHECK dout0_58 Vdout0_58ck74 = 0 time = 375
.meas tran vdout0_58ck74 FIND v(dout0_58) AT=375.025n

* CHECK dout0_59 Vdout0_59ck74 = 0 time = 375
.meas tran vdout0_59ck74 FIND v(dout0_59) AT=375.025n

* CHECK dout0_60 Vdout0_60ck74 = 0.9 time = 375
.meas tran vdout0_60ck74 FIND v(dout0_60) AT=375.025n

* CHECK dout0_61 Vdout0_61ck74 = 0 time = 375
.meas tran vdout0_61ck74 FIND v(dout0_61) AT=375.025n

* CHECK dout0_62 Vdout0_62ck74 = 0 time = 375
.meas tran vdout0_62ck74 FIND v(dout0_62) AT=375.025n

* CHECK dout0_63 Vdout0_63ck74 = 0.9 time = 375
.meas tran vdout0_63ck74 FIND v(dout0_63) AT=375.025n

* CHECK dout0_0 Vdout0_0ck75 = 0 time = 380
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=380.025n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 380
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=380.025n

* CHECK dout0_2 Vdout0_2ck75 = 0 time = 380
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=380.025n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 380
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=380.025n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 380
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=380.025n

* CHECK dout0_5 Vdout0_5ck75 = 0 time = 380
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=380.025n

* CHECK dout0_6 Vdout0_6ck75 = 0.9 time = 380
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=380.025n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 380
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=380.025n

* CHECK dout0_8 Vdout0_8ck75 = 0 time = 380
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=380.025n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 380
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=380.025n

* CHECK dout0_10 Vdout0_10ck75 = 0 time = 380
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=380.025n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 380
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=380.025n

* CHECK dout0_12 Vdout0_12ck75 = 0 time = 380
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=380.025n

* CHECK dout0_13 Vdout0_13ck75 = 0.9 time = 380
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=380.025n

* CHECK dout0_14 Vdout0_14ck75 = 0.9 time = 380
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=380.025n

* CHECK dout0_15 Vdout0_15ck75 = 0.9 time = 380
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=380.025n

* CHECK dout0_16 Vdout0_16ck75 = 0.9 time = 380
.meas tran vdout0_16ck75 FIND v(dout0_16) AT=380.025n

* CHECK dout0_17 Vdout0_17ck75 = 0.9 time = 380
.meas tran vdout0_17ck75 FIND v(dout0_17) AT=380.025n

* CHECK dout0_18 Vdout0_18ck75 = 0 time = 380
.meas tran vdout0_18ck75 FIND v(dout0_18) AT=380.025n

* CHECK dout0_19 Vdout0_19ck75 = 0 time = 380
.meas tran vdout0_19ck75 FIND v(dout0_19) AT=380.025n

* CHECK dout0_20 Vdout0_20ck75 = 0.9 time = 380
.meas tran vdout0_20ck75 FIND v(dout0_20) AT=380.025n

* CHECK dout0_21 Vdout0_21ck75 = 0.9 time = 380
.meas tran vdout0_21ck75 FIND v(dout0_21) AT=380.025n

* CHECK dout0_22 Vdout0_22ck75 = 0.9 time = 380
.meas tran vdout0_22ck75 FIND v(dout0_22) AT=380.025n

* CHECK dout0_23 Vdout0_23ck75 = 0.9 time = 380
.meas tran vdout0_23ck75 FIND v(dout0_23) AT=380.025n

* CHECK dout0_24 Vdout0_24ck75 = 0 time = 380
.meas tran vdout0_24ck75 FIND v(dout0_24) AT=380.025n

* CHECK dout0_25 Vdout0_25ck75 = 0 time = 380
.meas tran vdout0_25ck75 FIND v(dout0_25) AT=380.025n

* CHECK dout0_26 Vdout0_26ck75 = 0 time = 380
.meas tran vdout0_26ck75 FIND v(dout0_26) AT=380.025n

* CHECK dout0_27 Vdout0_27ck75 = 0.9 time = 380
.meas tran vdout0_27ck75 FIND v(dout0_27) AT=380.025n

* CHECK dout0_28 Vdout0_28ck75 = 0 time = 380
.meas tran vdout0_28ck75 FIND v(dout0_28) AT=380.025n

* CHECK dout0_29 Vdout0_29ck75 = 0 time = 380
.meas tran vdout0_29ck75 FIND v(dout0_29) AT=380.025n

* CHECK dout0_30 Vdout0_30ck75 = 0.9 time = 380
.meas tran vdout0_30ck75 FIND v(dout0_30) AT=380.025n

* CHECK dout0_31 Vdout0_31ck75 = 0.9 time = 380
.meas tran vdout0_31ck75 FIND v(dout0_31) AT=380.025n

* CHECK dout0_32 Vdout0_32ck75 = 0 time = 380
.meas tran vdout0_32ck75 FIND v(dout0_32) AT=380.025n

* CHECK dout0_33 Vdout0_33ck75 = 0.9 time = 380
.meas tran vdout0_33ck75 FIND v(dout0_33) AT=380.025n

* CHECK dout0_34 Vdout0_34ck75 = 0.9 time = 380
.meas tran vdout0_34ck75 FIND v(dout0_34) AT=380.025n

* CHECK dout0_35 Vdout0_35ck75 = 0.9 time = 380
.meas tran vdout0_35ck75 FIND v(dout0_35) AT=380.025n

* CHECK dout0_36 Vdout0_36ck75 = 0.9 time = 380
.meas tran vdout0_36ck75 FIND v(dout0_36) AT=380.025n

* CHECK dout0_37 Vdout0_37ck75 = 0 time = 380
.meas tran vdout0_37ck75 FIND v(dout0_37) AT=380.025n

* CHECK dout0_38 Vdout0_38ck75 = 0 time = 380
.meas tran vdout0_38ck75 FIND v(dout0_38) AT=380.025n

* CHECK dout0_39 Vdout0_39ck75 = 0 time = 380
.meas tran vdout0_39ck75 FIND v(dout0_39) AT=380.025n

* CHECK dout0_40 Vdout0_40ck75 = 0.9 time = 380
.meas tran vdout0_40ck75 FIND v(dout0_40) AT=380.025n

* CHECK dout0_41 Vdout0_41ck75 = 0.9 time = 380
.meas tran vdout0_41ck75 FIND v(dout0_41) AT=380.025n

* CHECK dout0_42 Vdout0_42ck75 = 0.9 time = 380
.meas tran vdout0_42ck75 FIND v(dout0_42) AT=380.025n

* CHECK dout0_43 Vdout0_43ck75 = 0.9 time = 380
.meas tran vdout0_43ck75 FIND v(dout0_43) AT=380.025n

* CHECK dout0_44 Vdout0_44ck75 = 0 time = 380
.meas tran vdout0_44ck75 FIND v(dout0_44) AT=380.025n

* CHECK dout0_45 Vdout0_45ck75 = 0.9 time = 380
.meas tran vdout0_45ck75 FIND v(dout0_45) AT=380.025n

* CHECK dout0_46 Vdout0_46ck75 = 0 time = 380
.meas tran vdout0_46ck75 FIND v(dout0_46) AT=380.025n

* CHECK dout0_47 Vdout0_47ck75 = 0 time = 380
.meas tran vdout0_47ck75 FIND v(dout0_47) AT=380.025n

* CHECK dout0_48 Vdout0_48ck75 = 0 time = 380
.meas tran vdout0_48ck75 FIND v(dout0_48) AT=380.025n

* CHECK dout0_49 Vdout0_49ck75 = 0.9 time = 380
.meas tran vdout0_49ck75 FIND v(dout0_49) AT=380.025n

* CHECK dout0_50 Vdout0_50ck75 = 0.9 time = 380
.meas tran vdout0_50ck75 FIND v(dout0_50) AT=380.025n

* CHECK dout0_51 Vdout0_51ck75 = 0.9 time = 380
.meas tran vdout0_51ck75 FIND v(dout0_51) AT=380.025n

* CHECK dout0_52 Vdout0_52ck75 = 0 time = 380
.meas tran vdout0_52ck75 FIND v(dout0_52) AT=380.025n

* CHECK dout0_53 Vdout0_53ck75 = 0 time = 380
.meas tran vdout0_53ck75 FIND v(dout0_53) AT=380.025n

* CHECK dout0_54 Vdout0_54ck75 = 0 time = 380
.meas tran vdout0_54ck75 FIND v(dout0_54) AT=380.025n

* CHECK dout0_55 Vdout0_55ck75 = 0.9 time = 380
.meas tran vdout0_55ck75 FIND v(dout0_55) AT=380.025n

* CHECK dout0_56 Vdout0_56ck75 = 0.9 time = 380
.meas tran vdout0_56ck75 FIND v(dout0_56) AT=380.025n

* CHECK dout0_57 Vdout0_57ck75 = 0.9 time = 380
.meas tran vdout0_57ck75 FIND v(dout0_57) AT=380.025n

* CHECK dout0_58 Vdout0_58ck75 = 0 time = 380
.meas tran vdout0_58ck75 FIND v(dout0_58) AT=380.025n

* CHECK dout0_59 Vdout0_59ck75 = 0 time = 380
.meas tran vdout0_59ck75 FIND v(dout0_59) AT=380.025n

* CHECK dout0_60 Vdout0_60ck75 = 0.9 time = 380
.meas tran vdout0_60ck75 FIND v(dout0_60) AT=380.025n

* CHECK dout0_61 Vdout0_61ck75 = 0 time = 380
.meas tran vdout0_61ck75 FIND v(dout0_61) AT=380.025n

* CHECK dout0_62 Vdout0_62ck75 = 0 time = 380
.meas tran vdout0_62ck75 FIND v(dout0_62) AT=380.025n

* CHECK dout0_63 Vdout0_63ck75 = 0.9 time = 380
.meas tran vdout0_63ck75 FIND v(dout0_63) AT=380.025n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 390
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=390.025n

* CHECK dout0_1 Vdout0_1ck77 = 0 time = 390
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=390.025n

* CHECK dout0_2 Vdout0_2ck77 = 0 time = 390
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=390.025n

* CHECK dout0_3 Vdout0_3ck77 = 0 time = 390
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=390.025n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 390
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=390.025n

* CHECK dout0_5 Vdout0_5ck77 = 0 time = 390
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=390.025n

* CHECK dout0_6 Vdout0_6ck77 = 0.9 time = 390
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=390.025n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 390
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=390.025n

* CHECK dout0_8 Vdout0_8ck77 = 0 time = 390
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=390.025n

* CHECK dout0_9 Vdout0_9ck77 = 0 time = 390
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=390.025n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 390
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=390.025n

* CHECK dout0_11 Vdout0_11ck77 = 0 time = 390
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=390.025n

* CHECK dout0_12 Vdout0_12ck77 = 0 time = 390
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=390.025n

* CHECK dout0_13 Vdout0_13ck77 = 0.9 time = 390
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=390.025n

* CHECK dout0_14 Vdout0_14ck77 = 0.9 time = 390
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=390.025n

* CHECK dout0_15 Vdout0_15ck77 = 0.9 time = 390
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=390.025n

* CHECK dout0_16 Vdout0_16ck77 = 0.9 time = 390
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=390.025n

* CHECK dout0_17 Vdout0_17ck77 = 0.9 time = 390
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=390.025n

* CHECK dout0_18 Vdout0_18ck77 = 0 time = 390
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=390.025n

* CHECK dout0_19 Vdout0_19ck77 = 0 time = 390
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=390.025n

* CHECK dout0_20 Vdout0_20ck77 = 0.9 time = 390
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=390.025n

* CHECK dout0_21 Vdout0_21ck77 = 0.9 time = 390
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=390.025n

* CHECK dout0_22 Vdout0_22ck77 = 0.9 time = 390
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=390.025n

* CHECK dout0_23 Vdout0_23ck77 = 0.9 time = 390
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=390.025n

* CHECK dout0_24 Vdout0_24ck77 = 0 time = 390
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=390.025n

* CHECK dout0_25 Vdout0_25ck77 = 0 time = 390
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=390.025n

* CHECK dout0_26 Vdout0_26ck77 = 0 time = 390
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=390.025n

* CHECK dout0_27 Vdout0_27ck77 = 0.9 time = 390
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=390.025n

* CHECK dout0_28 Vdout0_28ck77 = 0 time = 390
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=390.025n

* CHECK dout0_29 Vdout0_29ck77 = 0 time = 390
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=390.025n

* CHECK dout0_30 Vdout0_30ck77 = 0.9 time = 390
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=390.025n

* CHECK dout0_31 Vdout0_31ck77 = 0.9 time = 390
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=390.025n

* CHECK dout0_32 Vdout0_32ck77 = 0 time = 390
.meas tran vdout0_32ck77 FIND v(dout0_32) AT=390.025n

* CHECK dout0_33 Vdout0_33ck77 = 0.9 time = 390
.meas tran vdout0_33ck77 FIND v(dout0_33) AT=390.025n

* CHECK dout0_34 Vdout0_34ck77 = 0.9 time = 390
.meas tran vdout0_34ck77 FIND v(dout0_34) AT=390.025n

* CHECK dout0_35 Vdout0_35ck77 = 0.9 time = 390
.meas tran vdout0_35ck77 FIND v(dout0_35) AT=390.025n

* CHECK dout0_36 Vdout0_36ck77 = 0.9 time = 390
.meas tran vdout0_36ck77 FIND v(dout0_36) AT=390.025n

* CHECK dout0_37 Vdout0_37ck77 = 0 time = 390
.meas tran vdout0_37ck77 FIND v(dout0_37) AT=390.025n

* CHECK dout0_38 Vdout0_38ck77 = 0 time = 390
.meas tran vdout0_38ck77 FIND v(dout0_38) AT=390.025n

* CHECK dout0_39 Vdout0_39ck77 = 0 time = 390
.meas tran vdout0_39ck77 FIND v(dout0_39) AT=390.025n

* CHECK dout0_40 Vdout0_40ck77 = 0.9 time = 390
.meas tran vdout0_40ck77 FIND v(dout0_40) AT=390.025n

* CHECK dout0_41 Vdout0_41ck77 = 0.9 time = 390
.meas tran vdout0_41ck77 FIND v(dout0_41) AT=390.025n

* CHECK dout0_42 Vdout0_42ck77 = 0.9 time = 390
.meas tran vdout0_42ck77 FIND v(dout0_42) AT=390.025n

* CHECK dout0_43 Vdout0_43ck77 = 0.9 time = 390
.meas tran vdout0_43ck77 FIND v(dout0_43) AT=390.025n

* CHECK dout0_44 Vdout0_44ck77 = 0 time = 390
.meas tran vdout0_44ck77 FIND v(dout0_44) AT=390.025n

* CHECK dout0_45 Vdout0_45ck77 = 0.9 time = 390
.meas tran vdout0_45ck77 FIND v(dout0_45) AT=390.025n

* CHECK dout0_46 Vdout0_46ck77 = 0 time = 390
.meas tran vdout0_46ck77 FIND v(dout0_46) AT=390.025n

* CHECK dout0_47 Vdout0_47ck77 = 0 time = 390
.meas tran vdout0_47ck77 FIND v(dout0_47) AT=390.025n

* CHECK dout0_48 Vdout0_48ck77 = 0 time = 390
.meas tran vdout0_48ck77 FIND v(dout0_48) AT=390.025n

* CHECK dout0_49 Vdout0_49ck77 = 0.9 time = 390
.meas tran vdout0_49ck77 FIND v(dout0_49) AT=390.025n

* CHECK dout0_50 Vdout0_50ck77 = 0.9 time = 390
.meas tran vdout0_50ck77 FIND v(dout0_50) AT=390.025n

* CHECK dout0_51 Vdout0_51ck77 = 0.9 time = 390
.meas tran vdout0_51ck77 FIND v(dout0_51) AT=390.025n

* CHECK dout0_52 Vdout0_52ck77 = 0 time = 390
.meas tran vdout0_52ck77 FIND v(dout0_52) AT=390.025n

* CHECK dout0_53 Vdout0_53ck77 = 0 time = 390
.meas tran vdout0_53ck77 FIND v(dout0_53) AT=390.025n

* CHECK dout0_54 Vdout0_54ck77 = 0 time = 390
.meas tran vdout0_54ck77 FIND v(dout0_54) AT=390.025n

* CHECK dout0_55 Vdout0_55ck77 = 0.9 time = 390
.meas tran vdout0_55ck77 FIND v(dout0_55) AT=390.025n

* CHECK dout0_56 Vdout0_56ck77 = 0.9 time = 390
.meas tran vdout0_56ck77 FIND v(dout0_56) AT=390.025n

* CHECK dout0_57 Vdout0_57ck77 = 0.9 time = 390
.meas tran vdout0_57ck77 FIND v(dout0_57) AT=390.025n

* CHECK dout0_58 Vdout0_58ck77 = 0 time = 390
.meas tran vdout0_58ck77 FIND v(dout0_58) AT=390.025n

* CHECK dout0_59 Vdout0_59ck77 = 0 time = 390
.meas tran vdout0_59ck77 FIND v(dout0_59) AT=390.025n

* CHECK dout0_60 Vdout0_60ck77 = 0.9 time = 390
.meas tran vdout0_60ck77 FIND v(dout0_60) AT=390.025n

* CHECK dout0_61 Vdout0_61ck77 = 0 time = 390
.meas tran vdout0_61ck77 FIND v(dout0_61) AT=390.025n

* CHECK dout0_62 Vdout0_62ck77 = 0 time = 390
.meas tran vdout0_62ck77 FIND v(dout0_62) AT=390.025n

* CHECK dout0_63 Vdout0_63ck77 = 0.9 time = 390
.meas tran vdout0_63ck77 FIND v(dout0_63) AT=390.025n

* CHECK dout0_0 Vdout0_0ck78 = 0 time = 395
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=395.025n

* CHECK dout0_1 Vdout0_1ck78 = 0.9 time = 395
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=395.025n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 395
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=395.025n

* CHECK dout0_3 Vdout0_3ck78 = 0.9 time = 395
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=395.025n

* CHECK dout0_4 Vdout0_4ck78 = 0.9 time = 395
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=395.025n

* CHECK dout0_5 Vdout0_5ck78 = 0 time = 395
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=395.025n

* CHECK dout0_6 Vdout0_6ck78 = 0.9 time = 395
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=395.025n

* CHECK dout0_7 Vdout0_7ck78 = 0.9 time = 395
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=395.025n

* CHECK dout0_8 Vdout0_8ck78 = 0 time = 395
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=395.025n

* CHECK dout0_9 Vdout0_9ck78 = 0.9 time = 395
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=395.025n

* CHECK dout0_10 Vdout0_10ck78 = 0.9 time = 395
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=395.025n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 395
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=395.025n

* CHECK dout0_12 Vdout0_12ck78 = 0 time = 395
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=395.025n

* CHECK dout0_13 Vdout0_13ck78 = 0.9 time = 395
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=395.025n

* CHECK dout0_14 Vdout0_14ck78 = 0 time = 395
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=395.025n

* CHECK dout0_15 Vdout0_15ck78 = 0.9 time = 395
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=395.025n

* CHECK dout0_16 Vdout0_16ck78 = 0.9 time = 395
.meas tran vdout0_16ck78 FIND v(dout0_16) AT=395.025n

* CHECK dout0_17 Vdout0_17ck78 = 0 time = 395
.meas tran vdout0_17ck78 FIND v(dout0_17) AT=395.025n

* CHECK dout0_18 Vdout0_18ck78 = 0 time = 395
.meas tran vdout0_18ck78 FIND v(dout0_18) AT=395.025n

* CHECK dout0_19 Vdout0_19ck78 = 0 time = 395
.meas tran vdout0_19ck78 FIND v(dout0_19) AT=395.025n

* CHECK dout0_20 Vdout0_20ck78 = 0 time = 395
.meas tran vdout0_20ck78 FIND v(dout0_20) AT=395.025n

* CHECK dout0_21 Vdout0_21ck78 = 0.9 time = 395
.meas tran vdout0_21ck78 FIND v(dout0_21) AT=395.025n

* CHECK dout0_22 Vdout0_22ck78 = 0 time = 395
.meas tran vdout0_22ck78 FIND v(dout0_22) AT=395.025n

* CHECK dout0_23 Vdout0_23ck78 = 0.9 time = 395
.meas tran vdout0_23ck78 FIND v(dout0_23) AT=395.025n

* CHECK dout0_24 Vdout0_24ck78 = 0 time = 395
.meas tran vdout0_24ck78 FIND v(dout0_24) AT=395.025n

* CHECK dout0_25 Vdout0_25ck78 = 0 time = 395
.meas tran vdout0_25ck78 FIND v(dout0_25) AT=395.025n

* CHECK dout0_26 Vdout0_26ck78 = 0 time = 395
.meas tran vdout0_26ck78 FIND v(dout0_26) AT=395.025n

* CHECK dout0_27 Vdout0_27ck78 = 0 time = 395
.meas tran vdout0_27ck78 FIND v(dout0_27) AT=395.025n

* CHECK dout0_28 Vdout0_28ck78 = 0.9 time = 395
.meas tran vdout0_28ck78 FIND v(dout0_28) AT=395.025n

* CHECK dout0_29 Vdout0_29ck78 = 0 time = 395
.meas tran vdout0_29ck78 FIND v(dout0_29) AT=395.025n

* CHECK dout0_30 Vdout0_30ck78 = 0.9 time = 395
.meas tran vdout0_30ck78 FIND v(dout0_30) AT=395.025n

* CHECK dout0_31 Vdout0_31ck78 = 0 time = 395
.meas tran vdout0_31ck78 FIND v(dout0_31) AT=395.025n

* CHECK dout0_32 Vdout0_32ck78 = 0 time = 395
.meas tran vdout0_32ck78 FIND v(dout0_32) AT=395.025n

* CHECK dout0_33 Vdout0_33ck78 = 0.9 time = 395
.meas tran vdout0_33ck78 FIND v(dout0_33) AT=395.025n

* CHECK dout0_34 Vdout0_34ck78 = 0 time = 395
.meas tran vdout0_34ck78 FIND v(dout0_34) AT=395.025n

* CHECK dout0_35 Vdout0_35ck78 = 0.9 time = 395
.meas tran vdout0_35ck78 FIND v(dout0_35) AT=395.025n

* CHECK dout0_36 Vdout0_36ck78 = 0 time = 395
.meas tran vdout0_36ck78 FIND v(dout0_36) AT=395.025n

* CHECK dout0_37 Vdout0_37ck78 = 0.9 time = 395
.meas tran vdout0_37ck78 FIND v(dout0_37) AT=395.025n

* CHECK dout0_38 Vdout0_38ck78 = 0.9 time = 395
.meas tran vdout0_38ck78 FIND v(dout0_38) AT=395.025n

* CHECK dout0_39 Vdout0_39ck78 = 0 time = 395
.meas tran vdout0_39ck78 FIND v(dout0_39) AT=395.025n

* CHECK dout0_40 Vdout0_40ck78 = 0 time = 395
.meas tran vdout0_40ck78 FIND v(dout0_40) AT=395.025n

* CHECK dout0_41 Vdout0_41ck78 = 0 time = 395
.meas tran vdout0_41ck78 FIND v(dout0_41) AT=395.025n

* CHECK dout0_42 Vdout0_42ck78 = 0.9 time = 395
.meas tran vdout0_42ck78 FIND v(dout0_42) AT=395.025n

* CHECK dout0_43 Vdout0_43ck78 = 0.9 time = 395
.meas tran vdout0_43ck78 FIND v(dout0_43) AT=395.025n

* CHECK dout0_44 Vdout0_44ck78 = 0 time = 395
.meas tran vdout0_44ck78 FIND v(dout0_44) AT=395.025n

* CHECK dout0_45 Vdout0_45ck78 = 0.9 time = 395
.meas tran vdout0_45ck78 FIND v(dout0_45) AT=395.025n

* CHECK dout0_46 Vdout0_46ck78 = 0 time = 395
.meas tran vdout0_46ck78 FIND v(dout0_46) AT=395.025n

* CHECK dout0_47 Vdout0_47ck78 = 0 time = 395
.meas tran vdout0_47ck78 FIND v(dout0_47) AT=395.025n

* CHECK dout0_48 Vdout0_48ck78 = 0 time = 395
.meas tran vdout0_48ck78 FIND v(dout0_48) AT=395.025n

* CHECK dout0_49 Vdout0_49ck78 = 0 time = 395
.meas tran vdout0_49ck78 FIND v(dout0_49) AT=395.025n

* CHECK dout0_50 Vdout0_50ck78 = 0 time = 395
.meas tran vdout0_50ck78 FIND v(dout0_50) AT=395.025n

* CHECK dout0_51 Vdout0_51ck78 = 0.9 time = 395
.meas tran vdout0_51ck78 FIND v(dout0_51) AT=395.025n

* CHECK dout0_52 Vdout0_52ck78 = 0 time = 395
.meas tran vdout0_52ck78 FIND v(dout0_52) AT=395.025n

* CHECK dout0_53 Vdout0_53ck78 = 0 time = 395
.meas tran vdout0_53ck78 FIND v(dout0_53) AT=395.025n

* CHECK dout0_54 Vdout0_54ck78 = 0.9 time = 395
.meas tran vdout0_54ck78 FIND v(dout0_54) AT=395.025n

* CHECK dout0_55 Vdout0_55ck78 = 0 time = 395
.meas tran vdout0_55ck78 FIND v(dout0_55) AT=395.025n

* CHECK dout0_56 Vdout0_56ck78 = 0 time = 395
.meas tran vdout0_56ck78 FIND v(dout0_56) AT=395.025n

* CHECK dout0_57 Vdout0_57ck78 = 0 time = 395
.meas tran vdout0_57ck78 FIND v(dout0_57) AT=395.025n

* CHECK dout0_58 Vdout0_58ck78 = 0.9 time = 395
.meas tran vdout0_58ck78 FIND v(dout0_58) AT=395.025n

* CHECK dout0_59 Vdout0_59ck78 = 0 time = 395
.meas tran vdout0_59ck78 FIND v(dout0_59) AT=395.025n

* CHECK dout0_60 Vdout0_60ck78 = 0 time = 395
.meas tran vdout0_60ck78 FIND v(dout0_60) AT=395.025n

* CHECK dout0_61 Vdout0_61ck78 = 0.9 time = 395
.meas tran vdout0_61ck78 FIND v(dout0_61) AT=395.025n

* CHECK dout0_62 Vdout0_62ck78 = 0 time = 395
.meas tran vdout0_62ck78 FIND v(dout0_62) AT=395.025n

* CHECK dout0_63 Vdout0_63ck78 = 0 time = 395
.meas tran vdout0_63ck78 FIND v(dout0_63) AT=395.025n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 0.9 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 0 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 0.9 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 0.9 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 0.9 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 0.9 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 0.9 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 0.9 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 0.9 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 0.9 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 0.9 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 0 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 0.9 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 0 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 0.9 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0.9 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 400
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=400.025n

* CHECK dout0_33 Vdout0_33ck79 = 0.9 time = 400
.meas tran vdout0_33ck79 FIND v(dout0_33) AT=400.025n

* CHECK dout0_34 Vdout0_34ck79 = 0.9 time = 400
.meas tran vdout0_34ck79 FIND v(dout0_34) AT=400.025n

* CHECK dout0_35 Vdout0_35ck79 = 0.9 time = 400
.meas tran vdout0_35ck79 FIND v(dout0_35) AT=400.025n

* CHECK dout0_36 Vdout0_36ck79 = 0.9 time = 400
.meas tran vdout0_36ck79 FIND v(dout0_36) AT=400.025n

* CHECK dout0_37 Vdout0_37ck79 = 0 time = 400
.meas tran vdout0_37ck79 FIND v(dout0_37) AT=400.025n

* CHECK dout0_38 Vdout0_38ck79 = 0 time = 400
.meas tran vdout0_38ck79 FIND v(dout0_38) AT=400.025n

* CHECK dout0_39 Vdout0_39ck79 = 0 time = 400
.meas tran vdout0_39ck79 FIND v(dout0_39) AT=400.025n

* CHECK dout0_40 Vdout0_40ck79 = 0.9 time = 400
.meas tran vdout0_40ck79 FIND v(dout0_40) AT=400.025n

* CHECK dout0_41 Vdout0_41ck79 = 0.9 time = 400
.meas tran vdout0_41ck79 FIND v(dout0_41) AT=400.025n

* CHECK dout0_42 Vdout0_42ck79 = 0.9 time = 400
.meas tran vdout0_42ck79 FIND v(dout0_42) AT=400.025n

* CHECK dout0_43 Vdout0_43ck79 = 0.9 time = 400
.meas tran vdout0_43ck79 FIND v(dout0_43) AT=400.025n

* CHECK dout0_44 Vdout0_44ck79 = 0 time = 400
.meas tran vdout0_44ck79 FIND v(dout0_44) AT=400.025n

* CHECK dout0_45 Vdout0_45ck79 = 0.9 time = 400
.meas tran vdout0_45ck79 FIND v(dout0_45) AT=400.025n

* CHECK dout0_46 Vdout0_46ck79 = 0 time = 400
.meas tran vdout0_46ck79 FIND v(dout0_46) AT=400.025n

* CHECK dout0_47 Vdout0_47ck79 = 0 time = 400
.meas tran vdout0_47ck79 FIND v(dout0_47) AT=400.025n

* CHECK dout0_48 Vdout0_48ck79 = 0 time = 400
.meas tran vdout0_48ck79 FIND v(dout0_48) AT=400.025n

* CHECK dout0_49 Vdout0_49ck79 = 0.9 time = 400
.meas tran vdout0_49ck79 FIND v(dout0_49) AT=400.025n

* CHECK dout0_50 Vdout0_50ck79 = 0.9 time = 400
.meas tran vdout0_50ck79 FIND v(dout0_50) AT=400.025n

* CHECK dout0_51 Vdout0_51ck79 = 0.9 time = 400
.meas tran vdout0_51ck79 FIND v(dout0_51) AT=400.025n

* CHECK dout0_52 Vdout0_52ck79 = 0 time = 400
.meas tran vdout0_52ck79 FIND v(dout0_52) AT=400.025n

* CHECK dout0_53 Vdout0_53ck79 = 0 time = 400
.meas tran vdout0_53ck79 FIND v(dout0_53) AT=400.025n

* CHECK dout0_54 Vdout0_54ck79 = 0 time = 400
.meas tran vdout0_54ck79 FIND v(dout0_54) AT=400.025n

* CHECK dout0_55 Vdout0_55ck79 = 0.9 time = 400
.meas tran vdout0_55ck79 FIND v(dout0_55) AT=400.025n

* CHECK dout0_56 Vdout0_56ck79 = 0.9 time = 400
.meas tran vdout0_56ck79 FIND v(dout0_56) AT=400.025n

* CHECK dout0_57 Vdout0_57ck79 = 0.9 time = 400
.meas tran vdout0_57ck79 FIND v(dout0_57) AT=400.025n

* CHECK dout0_58 Vdout0_58ck79 = 0 time = 400
.meas tran vdout0_58ck79 FIND v(dout0_58) AT=400.025n

* CHECK dout0_59 Vdout0_59ck79 = 0 time = 400
.meas tran vdout0_59ck79 FIND v(dout0_59) AT=400.025n

* CHECK dout0_60 Vdout0_60ck79 = 0.9 time = 400
.meas tran vdout0_60ck79 FIND v(dout0_60) AT=400.025n

* CHECK dout0_61 Vdout0_61ck79 = 0 time = 400
.meas tran vdout0_61ck79 FIND v(dout0_61) AT=400.025n

* CHECK dout0_62 Vdout0_62ck79 = 0 time = 400
.meas tran vdout0_62ck79 FIND v(dout0_62) AT=400.025n

* CHECK dout0_63 Vdout0_63ck79 = 0.9 time = 400
.meas tran vdout0_63ck79 FIND v(dout0_63) AT=400.025n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 405
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=405.025n

* CHECK dout0_1 Vdout0_1ck80 = 0 time = 405
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=405.025n

* CHECK dout0_2 Vdout0_2ck80 = 0 time = 405
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=405.025n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 405
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=405.025n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 405
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=405.025n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 405
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=405.025n

* CHECK dout0_6 Vdout0_6ck80 = 0.9 time = 405
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=405.025n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 405
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=405.025n

* CHECK dout0_8 Vdout0_8ck80 = 0 time = 405
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=405.025n

* CHECK dout0_9 Vdout0_9ck80 = 0 time = 405
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=405.025n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 405
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=405.025n

* CHECK dout0_11 Vdout0_11ck80 = 0 time = 405
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=405.025n

* CHECK dout0_12 Vdout0_12ck80 = 0 time = 405
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=405.025n

* CHECK dout0_13 Vdout0_13ck80 = 0.9 time = 405
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=405.025n

* CHECK dout0_14 Vdout0_14ck80 = 0.9 time = 405
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=405.025n

* CHECK dout0_15 Vdout0_15ck80 = 0.9 time = 405
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=405.025n

* CHECK dout0_16 Vdout0_16ck80 = 0.9 time = 405
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=405.025n

* CHECK dout0_17 Vdout0_17ck80 = 0.9 time = 405
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=405.025n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 405
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=405.025n

* CHECK dout0_19 Vdout0_19ck80 = 0 time = 405
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=405.025n

* CHECK dout0_20 Vdout0_20ck80 = 0.9 time = 405
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=405.025n

* CHECK dout0_21 Vdout0_21ck80 = 0.9 time = 405
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=405.025n

* CHECK dout0_22 Vdout0_22ck80 = 0.9 time = 405
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=405.025n

* CHECK dout0_23 Vdout0_23ck80 = 0.9 time = 405
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=405.025n

* CHECK dout0_24 Vdout0_24ck80 = 0 time = 405
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=405.025n

* CHECK dout0_25 Vdout0_25ck80 = 0 time = 405
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=405.025n

* CHECK dout0_26 Vdout0_26ck80 = 0 time = 405
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=405.025n

* CHECK dout0_27 Vdout0_27ck80 = 0.9 time = 405
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=405.025n

* CHECK dout0_28 Vdout0_28ck80 = 0 time = 405
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=405.025n

* CHECK dout0_29 Vdout0_29ck80 = 0 time = 405
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=405.025n

* CHECK dout0_30 Vdout0_30ck80 = 0.9 time = 405
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=405.025n

* CHECK dout0_31 Vdout0_31ck80 = 0.9 time = 405
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=405.025n

* CHECK dout0_32 Vdout0_32ck80 = 0 time = 405
.meas tran vdout0_32ck80 FIND v(dout0_32) AT=405.025n

* CHECK dout0_33 Vdout0_33ck80 = 0.9 time = 405
.meas tran vdout0_33ck80 FIND v(dout0_33) AT=405.025n

* CHECK dout0_34 Vdout0_34ck80 = 0.9 time = 405
.meas tran vdout0_34ck80 FIND v(dout0_34) AT=405.025n

* CHECK dout0_35 Vdout0_35ck80 = 0.9 time = 405
.meas tran vdout0_35ck80 FIND v(dout0_35) AT=405.025n

* CHECK dout0_36 Vdout0_36ck80 = 0.9 time = 405
.meas tran vdout0_36ck80 FIND v(dout0_36) AT=405.025n

* CHECK dout0_37 Vdout0_37ck80 = 0 time = 405
.meas tran vdout0_37ck80 FIND v(dout0_37) AT=405.025n

* CHECK dout0_38 Vdout0_38ck80 = 0 time = 405
.meas tran vdout0_38ck80 FIND v(dout0_38) AT=405.025n

* CHECK dout0_39 Vdout0_39ck80 = 0 time = 405
.meas tran vdout0_39ck80 FIND v(dout0_39) AT=405.025n

* CHECK dout0_40 Vdout0_40ck80 = 0.9 time = 405
.meas tran vdout0_40ck80 FIND v(dout0_40) AT=405.025n

* CHECK dout0_41 Vdout0_41ck80 = 0.9 time = 405
.meas tran vdout0_41ck80 FIND v(dout0_41) AT=405.025n

* CHECK dout0_42 Vdout0_42ck80 = 0.9 time = 405
.meas tran vdout0_42ck80 FIND v(dout0_42) AT=405.025n

* CHECK dout0_43 Vdout0_43ck80 = 0.9 time = 405
.meas tran vdout0_43ck80 FIND v(dout0_43) AT=405.025n

* CHECK dout0_44 Vdout0_44ck80 = 0 time = 405
.meas tran vdout0_44ck80 FIND v(dout0_44) AT=405.025n

* CHECK dout0_45 Vdout0_45ck80 = 0.9 time = 405
.meas tran vdout0_45ck80 FIND v(dout0_45) AT=405.025n

* CHECK dout0_46 Vdout0_46ck80 = 0 time = 405
.meas tran vdout0_46ck80 FIND v(dout0_46) AT=405.025n

* CHECK dout0_47 Vdout0_47ck80 = 0 time = 405
.meas tran vdout0_47ck80 FIND v(dout0_47) AT=405.025n

* CHECK dout0_48 Vdout0_48ck80 = 0 time = 405
.meas tran vdout0_48ck80 FIND v(dout0_48) AT=405.025n

* CHECK dout0_49 Vdout0_49ck80 = 0.9 time = 405
.meas tran vdout0_49ck80 FIND v(dout0_49) AT=405.025n

* CHECK dout0_50 Vdout0_50ck80 = 0.9 time = 405
.meas tran vdout0_50ck80 FIND v(dout0_50) AT=405.025n

* CHECK dout0_51 Vdout0_51ck80 = 0.9 time = 405
.meas tran vdout0_51ck80 FIND v(dout0_51) AT=405.025n

* CHECK dout0_52 Vdout0_52ck80 = 0 time = 405
.meas tran vdout0_52ck80 FIND v(dout0_52) AT=405.025n

* CHECK dout0_53 Vdout0_53ck80 = 0 time = 405
.meas tran vdout0_53ck80 FIND v(dout0_53) AT=405.025n

* CHECK dout0_54 Vdout0_54ck80 = 0 time = 405
.meas tran vdout0_54ck80 FIND v(dout0_54) AT=405.025n

* CHECK dout0_55 Vdout0_55ck80 = 0.9 time = 405
.meas tran vdout0_55ck80 FIND v(dout0_55) AT=405.025n

* CHECK dout0_56 Vdout0_56ck80 = 0.9 time = 405
.meas tran vdout0_56ck80 FIND v(dout0_56) AT=405.025n

* CHECK dout0_57 Vdout0_57ck80 = 0.9 time = 405
.meas tran vdout0_57ck80 FIND v(dout0_57) AT=405.025n

* CHECK dout0_58 Vdout0_58ck80 = 0 time = 405
.meas tran vdout0_58ck80 FIND v(dout0_58) AT=405.025n

* CHECK dout0_59 Vdout0_59ck80 = 0 time = 405
.meas tran vdout0_59ck80 FIND v(dout0_59) AT=405.025n

* CHECK dout0_60 Vdout0_60ck80 = 0.9 time = 405
.meas tran vdout0_60ck80 FIND v(dout0_60) AT=405.025n

* CHECK dout0_61 Vdout0_61ck80 = 0 time = 405
.meas tran vdout0_61ck80 FIND v(dout0_61) AT=405.025n

* CHECK dout0_62 Vdout0_62ck80 = 0 time = 405
.meas tran vdout0_62ck80 FIND v(dout0_62) AT=405.025n

* CHECK dout0_63 Vdout0_63ck80 = 0.9 time = 405
.meas tran vdout0_63ck80 FIND v(dout0_63) AT=405.025n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 0.9 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0.9 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 0.9 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 0.9 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0.9 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 0.9 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 0 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 0.9 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 0.9 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 0.9 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 0.9 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 0 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 0.9 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 0.9 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0.9 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 410
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=410.025n

* CHECK dout0_33 Vdout0_33ck81 = 0.9 time = 410
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=410.025n

* CHECK dout0_34 Vdout0_34ck81 = 0.9 time = 410
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=410.025n

* CHECK dout0_35 Vdout0_35ck81 = 0.9 time = 410
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=410.025n

* CHECK dout0_36 Vdout0_36ck81 = 0.9 time = 410
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=410.025n

* CHECK dout0_37 Vdout0_37ck81 = 0 time = 410
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=410.025n

* CHECK dout0_38 Vdout0_38ck81 = 0 time = 410
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=410.025n

* CHECK dout0_39 Vdout0_39ck81 = 0 time = 410
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=410.025n

* CHECK dout0_40 Vdout0_40ck81 = 0.9 time = 410
.meas tran vdout0_40ck81 FIND v(dout0_40) AT=410.025n

* CHECK dout0_41 Vdout0_41ck81 = 0.9 time = 410
.meas tran vdout0_41ck81 FIND v(dout0_41) AT=410.025n

* CHECK dout0_42 Vdout0_42ck81 = 0.9 time = 410
.meas tran vdout0_42ck81 FIND v(dout0_42) AT=410.025n

* CHECK dout0_43 Vdout0_43ck81 = 0.9 time = 410
.meas tran vdout0_43ck81 FIND v(dout0_43) AT=410.025n

* CHECK dout0_44 Vdout0_44ck81 = 0 time = 410
.meas tran vdout0_44ck81 FIND v(dout0_44) AT=410.025n

* CHECK dout0_45 Vdout0_45ck81 = 0.9 time = 410
.meas tran vdout0_45ck81 FIND v(dout0_45) AT=410.025n

* CHECK dout0_46 Vdout0_46ck81 = 0 time = 410
.meas tran vdout0_46ck81 FIND v(dout0_46) AT=410.025n

* CHECK dout0_47 Vdout0_47ck81 = 0 time = 410
.meas tran vdout0_47ck81 FIND v(dout0_47) AT=410.025n

* CHECK dout0_48 Vdout0_48ck81 = 0 time = 410
.meas tran vdout0_48ck81 FIND v(dout0_48) AT=410.025n

* CHECK dout0_49 Vdout0_49ck81 = 0.9 time = 410
.meas tran vdout0_49ck81 FIND v(dout0_49) AT=410.025n

* CHECK dout0_50 Vdout0_50ck81 = 0.9 time = 410
.meas tran vdout0_50ck81 FIND v(dout0_50) AT=410.025n

* CHECK dout0_51 Vdout0_51ck81 = 0.9 time = 410
.meas tran vdout0_51ck81 FIND v(dout0_51) AT=410.025n

* CHECK dout0_52 Vdout0_52ck81 = 0 time = 410
.meas tran vdout0_52ck81 FIND v(dout0_52) AT=410.025n

* CHECK dout0_53 Vdout0_53ck81 = 0 time = 410
.meas tran vdout0_53ck81 FIND v(dout0_53) AT=410.025n

* CHECK dout0_54 Vdout0_54ck81 = 0 time = 410
.meas tran vdout0_54ck81 FIND v(dout0_54) AT=410.025n

* CHECK dout0_55 Vdout0_55ck81 = 0.9 time = 410
.meas tran vdout0_55ck81 FIND v(dout0_55) AT=410.025n

* CHECK dout0_56 Vdout0_56ck81 = 0.9 time = 410
.meas tran vdout0_56ck81 FIND v(dout0_56) AT=410.025n

* CHECK dout0_57 Vdout0_57ck81 = 0.9 time = 410
.meas tran vdout0_57ck81 FIND v(dout0_57) AT=410.025n

* CHECK dout0_58 Vdout0_58ck81 = 0 time = 410
.meas tran vdout0_58ck81 FIND v(dout0_58) AT=410.025n

* CHECK dout0_59 Vdout0_59ck81 = 0 time = 410
.meas tran vdout0_59ck81 FIND v(dout0_59) AT=410.025n

* CHECK dout0_60 Vdout0_60ck81 = 0.9 time = 410
.meas tran vdout0_60ck81 FIND v(dout0_60) AT=410.025n

* CHECK dout0_61 Vdout0_61ck81 = 0 time = 410
.meas tran vdout0_61ck81 FIND v(dout0_61) AT=410.025n

* CHECK dout0_62 Vdout0_62ck81 = 0 time = 410
.meas tran vdout0_62ck81 FIND v(dout0_62) AT=410.025n

* CHECK dout0_63 Vdout0_63ck81 = 0.9 time = 410
.meas tran vdout0_63ck81 FIND v(dout0_63) AT=410.025n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 415
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=415.025n

* CHECK dout0_1 Vdout0_1ck82 = 0 time = 415
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=415.025n

* CHECK dout0_2 Vdout0_2ck82 = 0 time = 415
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=415.025n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 415
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=415.025n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 415
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=415.025n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 415
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=415.025n

* CHECK dout0_6 Vdout0_6ck82 = 0.9 time = 415
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=415.025n

* CHECK dout0_7 Vdout0_7ck82 = 0 time = 415
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=415.025n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 415
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=415.025n

* CHECK dout0_9 Vdout0_9ck82 = 0 time = 415
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=415.025n

* CHECK dout0_10 Vdout0_10ck82 = 0 time = 415
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=415.025n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 415
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=415.025n

* CHECK dout0_12 Vdout0_12ck82 = 0 time = 415
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=415.025n

* CHECK dout0_13 Vdout0_13ck82 = 0.9 time = 415
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=415.025n

* CHECK dout0_14 Vdout0_14ck82 = 0.9 time = 415
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=415.025n

* CHECK dout0_15 Vdout0_15ck82 = 0.9 time = 415
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=415.025n

* CHECK dout0_16 Vdout0_16ck82 = 0.9 time = 415
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=415.025n

* CHECK dout0_17 Vdout0_17ck82 = 0.9 time = 415
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=415.025n

* CHECK dout0_18 Vdout0_18ck82 = 0 time = 415
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=415.025n

* CHECK dout0_19 Vdout0_19ck82 = 0 time = 415
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=415.025n

* CHECK dout0_20 Vdout0_20ck82 = 0.9 time = 415
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=415.025n

* CHECK dout0_21 Vdout0_21ck82 = 0.9 time = 415
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=415.025n

* CHECK dout0_22 Vdout0_22ck82 = 0.9 time = 415
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=415.025n

* CHECK dout0_23 Vdout0_23ck82 = 0.9 time = 415
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=415.025n

* CHECK dout0_24 Vdout0_24ck82 = 0 time = 415
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=415.025n

* CHECK dout0_25 Vdout0_25ck82 = 0 time = 415
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=415.025n

* CHECK dout0_26 Vdout0_26ck82 = 0 time = 415
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=415.025n

* CHECK dout0_27 Vdout0_27ck82 = 0.9 time = 415
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=415.025n

* CHECK dout0_28 Vdout0_28ck82 = 0 time = 415
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=415.025n

* CHECK dout0_29 Vdout0_29ck82 = 0 time = 415
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=415.025n

* CHECK dout0_30 Vdout0_30ck82 = 0.9 time = 415
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=415.025n

* CHECK dout0_31 Vdout0_31ck82 = 0.9 time = 415
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=415.025n

* CHECK dout0_32 Vdout0_32ck82 = 0 time = 415
.meas tran vdout0_32ck82 FIND v(dout0_32) AT=415.025n

* CHECK dout0_33 Vdout0_33ck82 = 0.9 time = 415
.meas tran vdout0_33ck82 FIND v(dout0_33) AT=415.025n

* CHECK dout0_34 Vdout0_34ck82 = 0.9 time = 415
.meas tran vdout0_34ck82 FIND v(dout0_34) AT=415.025n

* CHECK dout0_35 Vdout0_35ck82 = 0.9 time = 415
.meas tran vdout0_35ck82 FIND v(dout0_35) AT=415.025n

* CHECK dout0_36 Vdout0_36ck82 = 0.9 time = 415
.meas tran vdout0_36ck82 FIND v(dout0_36) AT=415.025n

* CHECK dout0_37 Vdout0_37ck82 = 0 time = 415
.meas tran vdout0_37ck82 FIND v(dout0_37) AT=415.025n

* CHECK dout0_38 Vdout0_38ck82 = 0 time = 415
.meas tran vdout0_38ck82 FIND v(dout0_38) AT=415.025n

* CHECK dout0_39 Vdout0_39ck82 = 0 time = 415
.meas tran vdout0_39ck82 FIND v(dout0_39) AT=415.025n

* CHECK dout0_40 Vdout0_40ck82 = 0.9 time = 415
.meas tran vdout0_40ck82 FIND v(dout0_40) AT=415.025n

* CHECK dout0_41 Vdout0_41ck82 = 0.9 time = 415
.meas tran vdout0_41ck82 FIND v(dout0_41) AT=415.025n

* CHECK dout0_42 Vdout0_42ck82 = 0.9 time = 415
.meas tran vdout0_42ck82 FIND v(dout0_42) AT=415.025n

* CHECK dout0_43 Vdout0_43ck82 = 0.9 time = 415
.meas tran vdout0_43ck82 FIND v(dout0_43) AT=415.025n

* CHECK dout0_44 Vdout0_44ck82 = 0 time = 415
.meas tran vdout0_44ck82 FIND v(dout0_44) AT=415.025n

* CHECK dout0_45 Vdout0_45ck82 = 0.9 time = 415
.meas tran vdout0_45ck82 FIND v(dout0_45) AT=415.025n

* CHECK dout0_46 Vdout0_46ck82 = 0 time = 415
.meas tran vdout0_46ck82 FIND v(dout0_46) AT=415.025n

* CHECK dout0_47 Vdout0_47ck82 = 0 time = 415
.meas tran vdout0_47ck82 FIND v(dout0_47) AT=415.025n

* CHECK dout0_48 Vdout0_48ck82 = 0 time = 415
.meas tran vdout0_48ck82 FIND v(dout0_48) AT=415.025n

* CHECK dout0_49 Vdout0_49ck82 = 0.9 time = 415
.meas tran vdout0_49ck82 FIND v(dout0_49) AT=415.025n

* CHECK dout0_50 Vdout0_50ck82 = 0.9 time = 415
.meas tran vdout0_50ck82 FIND v(dout0_50) AT=415.025n

* CHECK dout0_51 Vdout0_51ck82 = 0.9 time = 415
.meas tran vdout0_51ck82 FIND v(dout0_51) AT=415.025n

* CHECK dout0_52 Vdout0_52ck82 = 0 time = 415
.meas tran vdout0_52ck82 FIND v(dout0_52) AT=415.025n

* CHECK dout0_53 Vdout0_53ck82 = 0 time = 415
.meas tran vdout0_53ck82 FIND v(dout0_53) AT=415.025n

* CHECK dout0_54 Vdout0_54ck82 = 0 time = 415
.meas tran vdout0_54ck82 FIND v(dout0_54) AT=415.025n

* CHECK dout0_55 Vdout0_55ck82 = 0.9 time = 415
.meas tran vdout0_55ck82 FIND v(dout0_55) AT=415.025n

* CHECK dout0_56 Vdout0_56ck82 = 0.9 time = 415
.meas tran vdout0_56ck82 FIND v(dout0_56) AT=415.025n

* CHECK dout0_57 Vdout0_57ck82 = 0.9 time = 415
.meas tran vdout0_57ck82 FIND v(dout0_57) AT=415.025n

* CHECK dout0_58 Vdout0_58ck82 = 0 time = 415
.meas tran vdout0_58ck82 FIND v(dout0_58) AT=415.025n

* CHECK dout0_59 Vdout0_59ck82 = 0 time = 415
.meas tran vdout0_59ck82 FIND v(dout0_59) AT=415.025n

* CHECK dout0_60 Vdout0_60ck82 = 0.9 time = 415
.meas tran vdout0_60ck82 FIND v(dout0_60) AT=415.025n

* CHECK dout0_61 Vdout0_61ck82 = 0 time = 415
.meas tran vdout0_61ck82 FIND v(dout0_61) AT=415.025n

* CHECK dout0_62 Vdout0_62ck82 = 0 time = 415
.meas tran vdout0_62ck82 FIND v(dout0_62) AT=415.025n

* CHECK dout0_63 Vdout0_63ck82 = 0.9 time = 415
.meas tran vdout0_63ck82 FIND v(dout0_63) AT=415.025n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 435
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=435.025n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 435
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=435.025n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 435
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=435.025n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 435
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=435.025n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 435
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=435.025n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 435
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=435.025n

* CHECK dout0_6 Vdout0_6ck86 = 0.9 time = 435
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=435.025n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 435
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=435.025n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 435
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=435.025n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 435
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=435.025n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 435
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=435.025n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 435
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=435.025n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 435
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=435.025n

* CHECK dout0_13 Vdout0_13ck86 = 0.9 time = 435
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=435.025n

* CHECK dout0_14 Vdout0_14ck86 = 0.9 time = 435
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=435.025n

* CHECK dout0_15 Vdout0_15ck86 = 0.9 time = 435
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=435.025n

* CHECK dout0_16 Vdout0_16ck86 = 0.9 time = 435
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=435.025n

* CHECK dout0_17 Vdout0_17ck86 = 0.9 time = 435
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=435.025n

* CHECK dout0_18 Vdout0_18ck86 = 0 time = 435
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=435.025n

* CHECK dout0_19 Vdout0_19ck86 = 0 time = 435
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=435.025n

* CHECK dout0_20 Vdout0_20ck86 = 0.9 time = 435
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=435.025n

* CHECK dout0_21 Vdout0_21ck86 = 0.9 time = 435
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=435.025n

* CHECK dout0_22 Vdout0_22ck86 = 0.9 time = 435
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=435.025n

* CHECK dout0_23 Vdout0_23ck86 = 0.9 time = 435
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=435.025n

* CHECK dout0_24 Vdout0_24ck86 = 0 time = 435
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=435.025n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 435
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=435.025n

* CHECK dout0_26 Vdout0_26ck86 = 0 time = 435
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=435.025n

* CHECK dout0_27 Vdout0_27ck86 = 0.9 time = 435
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=435.025n

* CHECK dout0_28 Vdout0_28ck86 = 0 time = 435
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=435.025n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 435
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=435.025n

* CHECK dout0_30 Vdout0_30ck86 = 0.9 time = 435
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=435.025n

* CHECK dout0_31 Vdout0_31ck86 = 0.9 time = 435
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=435.025n

* CHECK dout0_32 Vdout0_32ck86 = 0 time = 435
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=435.025n

* CHECK dout0_33 Vdout0_33ck86 = 0.9 time = 435
.meas tran vdout0_33ck86 FIND v(dout0_33) AT=435.025n

* CHECK dout0_34 Vdout0_34ck86 = 0.9 time = 435
.meas tran vdout0_34ck86 FIND v(dout0_34) AT=435.025n

* CHECK dout0_35 Vdout0_35ck86 = 0.9 time = 435
.meas tran vdout0_35ck86 FIND v(dout0_35) AT=435.025n

* CHECK dout0_36 Vdout0_36ck86 = 0.9 time = 435
.meas tran vdout0_36ck86 FIND v(dout0_36) AT=435.025n

* CHECK dout0_37 Vdout0_37ck86 = 0 time = 435
.meas tran vdout0_37ck86 FIND v(dout0_37) AT=435.025n

* CHECK dout0_38 Vdout0_38ck86 = 0 time = 435
.meas tran vdout0_38ck86 FIND v(dout0_38) AT=435.025n

* CHECK dout0_39 Vdout0_39ck86 = 0 time = 435
.meas tran vdout0_39ck86 FIND v(dout0_39) AT=435.025n

* CHECK dout0_40 Vdout0_40ck86 = 0.9 time = 435
.meas tran vdout0_40ck86 FIND v(dout0_40) AT=435.025n

* CHECK dout0_41 Vdout0_41ck86 = 0.9 time = 435
.meas tran vdout0_41ck86 FIND v(dout0_41) AT=435.025n

* CHECK dout0_42 Vdout0_42ck86 = 0.9 time = 435
.meas tran vdout0_42ck86 FIND v(dout0_42) AT=435.025n

* CHECK dout0_43 Vdout0_43ck86 = 0.9 time = 435
.meas tran vdout0_43ck86 FIND v(dout0_43) AT=435.025n

* CHECK dout0_44 Vdout0_44ck86 = 0 time = 435
.meas tran vdout0_44ck86 FIND v(dout0_44) AT=435.025n

* CHECK dout0_45 Vdout0_45ck86 = 0.9 time = 435
.meas tran vdout0_45ck86 FIND v(dout0_45) AT=435.025n

* CHECK dout0_46 Vdout0_46ck86 = 0 time = 435
.meas tran vdout0_46ck86 FIND v(dout0_46) AT=435.025n

* CHECK dout0_47 Vdout0_47ck86 = 0 time = 435
.meas tran vdout0_47ck86 FIND v(dout0_47) AT=435.025n

* CHECK dout0_48 Vdout0_48ck86 = 0 time = 435
.meas tran vdout0_48ck86 FIND v(dout0_48) AT=435.025n

* CHECK dout0_49 Vdout0_49ck86 = 0.9 time = 435
.meas tran vdout0_49ck86 FIND v(dout0_49) AT=435.025n

* CHECK dout0_50 Vdout0_50ck86 = 0.9 time = 435
.meas tran vdout0_50ck86 FIND v(dout0_50) AT=435.025n

* CHECK dout0_51 Vdout0_51ck86 = 0.9 time = 435
.meas tran vdout0_51ck86 FIND v(dout0_51) AT=435.025n

* CHECK dout0_52 Vdout0_52ck86 = 0 time = 435
.meas tran vdout0_52ck86 FIND v(dout0_52) AT=435.025n

* CHECK dout0_53 Vdout0_53ck86 = 0 time = 435
.meas tran vdout0_53ck86 FIND v(dout0_53) AT=435.025n

* CHECK dout0_54 Vdout0_54ck86 = 0 time = 435
.meas tran vdout0_54ck86 FIND v(dout0_54) AT=435.025n

* CHECK dout0_55 Vdout0_55ck86 = 0.9 time = 435
.meas tran vdout0_55ck86 FIND v(dout0_55) AT=435.025n

* CHECK dout0_56 Vdout0_56ck86 = 0.9 time = 435
.meas tran vdout0_56ck86 FIND v(dout0_56) AT=435.025n

* CHECK dout0_57 Vdout0_57ck86 = 0.9 time = 435
.meas tran vdout0_57ck86 FIND v(dout0_57) AT=435.025n

* CHECK dout0_58 Vdout0_58ck86 = 0 time = 435
.meas tran vdout0_58ck86 FIND v(dout0_58) AT=435.025n

* CHECK dout0_59 Vdout0_59ck86 = 0 time = 435
.meas tran vdout0_59ck86 FIND v(dout0_59) AT=435.025n

* CHECK dout0_60 Vdout0_60ck86 = 0.9 time = 435
.meas tran vdout0_60ck86 FIND v(dout0_60) AT=435.025n

* CHECK dout0_61 Vdout0_61ck86 = 0 time = 435
.meas tran vdout0_61ck86 FIND v(dout0_61) AT=435.025n

* CHECK dout0_62 Vdout0_62ck86 = 0 time = 435
.meas tran vdout0_62ck86 FIND v(dout0_62) AT=435.025n

* CHECK dout0_63 Vdout0_63ck86 = 0.9 time = 435
.meas tran vdout0_63ck86 FIND v(dout0_63) AT=435.025n

* CHECK dout0_0 Vdout0_0ck90 = 0.9 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 0.9 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 0.9 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 0 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 0.9 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 0.9 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 0.9 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 0 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 0.9 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 0.9 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 0.9 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 0.9 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 0 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 0 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 0.9 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 0.9 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 0 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 0.9 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 0.9 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 0 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 0.9 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0.9 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 0.9 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_32 Vdout0_32ck90 = 0.9 time = 455
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=455.025n

* CHECK dout0_33 Vdout0_33ck90 = 0 time = 455
.meas tran vdout0_33ck90 FIND v(dout0_33) AT=455.025n

* CHECK dout0_34 Vdout0_34ck90 = 0 time = 455
.meas tran vdout0_34ck90 FIND v(dout0_34) AT=455.025n

* CHECK dout0_35 Vdout0_35ck90 = 0 time = 455
.meas tran vdout0_35ck90 FIND v(dout0_35) AT=455.025n

* CHECK dout0_36 Vdout0_36ck90 = 0.9 time = 455
.meas tran vdout0_36ck90 FIND v(dout0_36) AT=455.025n

* CHECK dout0_37 Vdout0_37ck90 = 0 time = 455
.meas tran vdout0_37ck90 FIND v(dout0_37) AT=455.025n

* CHECK dout0_38 Vdout0_38ck90 = 0.9 time = 455
.meas tran vdout0_38ck90 FIND v(dout0_38) AT=455.025n

* CHECK dout0_39 Vdout0_39ck90 = 0.9 time = 455
.meas tran vdout0_39ck90 FIND v(dout0_39) AT=455.025n

* CHECK dout0_40 Vdout0_40ck90 = 0.9 time = 455
.meas tran vdout0_40ck90 FIND v(dout0_40) AT=455.025n

* CHECK dout0_41 Vdout0_41ck90 = 0 time = 455
.meas tran vdout0_41ck90 FIND v(dout0_41) AT=455.025n

* CHECK dout0_42 Vdout0_42ck90 = 0.9 time = 455
.meas tran vdout0_42ck90 FIND v(dout0_42) AT=455.025n

* CHECK dout0_43 Vdout0_43ck90 = 0 time = 455
.meas tran vdout0_43ck90 FIND v(dout0_43) AT=455.025n

* CHECK dout0_44 Vdout0_44ck90 = 0.9 time = 455
.meas tran vdout0_44ck90 FIND v(dout0_44) AT=455.025n

* CHECK dout0_45 Vdout0_45ck90 = 0.9 time = 455
.meas tran vdout0_45ck90 FIND v(dout0_45) AT=455.025n

* CHECK dout0_46 Vdout0_46ck90 = 0 time = 455
.meas tran vdout0_46ck90 FIND v(dout0_46) AT=455.025n

* CHECK dout0_47 Vdout0_47ck90 = 0 time = 455
.meas tran vdout0_47ck90 FIND v(dout0_47) AT=455.025n

* CHECK dout0_48 Vdout0_48ck90 = 0.9 time = 455
.meas tran vdout0_48ck90 FIND v(dout0_48) AT=455.025n

* CHECK dout0_49 Vdout0_49ck90 = 0 time = 455
.meas tran vdout0_49ck90 FIND v(dout0_49) AT=455.025n

* CHECK dout0_50 Vdout0_50ck90 = 0 time = 455
.meas tran vdout0_50ck90 FIND v(dout0_50) AT=455.025n

* CHECK dout0_51 Vdout0_51ck90 = 0.9 time = 455
.meas tran vdout0_51ck90 FIND v(dout0_51) AT=455.025n

* CHECK dout0_52 Vdout0_52ck90 = 0 time = 455
.meas tran vdout0_52ck90 FIND v(dout0_52) AT=455.025n

* CHECK dout0_53 Vdout0_53ck90 = 0 time = 455
.meas tran vdout0_53ck90 FIND v(dout0_53) AT=455.025n

* CHECK dout0_54 Vdout0_54ck90 = 0.9 time = 455
.meas tran vdout0_54ck90 FIND v(dout0_54) AT=455.025n

* CHECK dout0_55 Vdout0_55ck90 = 0 time = 455
.meas tran vdout0_55ck90 FIND v(dout0_55) AT=455.025n

* CHECK dout0_56 Vdout0_56ck90 = 0 time = 455
.meas tran vdout0_56ck90 FIND v(dout0_56) AT=455.025n

* CHECK dout0_57 Vdout0_57ck90 = 0.9 time = 455
.meas tran vdout0_57ck90 FIND v(dout0_57) AT=455.025n

* CHECK dout0_58 Vdout0_58ck90 = 0 time = 455
.meas tran vdout0_58ck90 FIND v(dout0_58) AT=455.025n

* CHECK dout0_59 Vdout0_59ck90 = 0.9 time = 455
.meas tran vdout0_59ck90 FIND v(dout0_59) AT=455.025n

* CHECK dout0_60 Vdout0_60ck90 = 0 time = 455
.meas tran vdout0_60ck90 FIND v(dout0_60) AT=455.025n

* CHECK dout0_61 Vdout0_61ck90 = 0 time = 455
.meas tran vdout0_61ck90 FIND v(dout0_61) AT=455.025n

* CHECK dout0_62 Vdout0_62ck90 = 0 time = 455
.meas tran vdout0_62ck90 FIND v(dout0_62) AT=455.025n

* CHECK dout0_63 Vdout0_63ck90 = 0 time = 455
.meas tran vdout0_63ck90 FIND v(dout0_63) AT=455.025n

* CHECK dout0_0 Vdout0_0ck92 = 0.9 time = 465
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=465.025n

* CHECK dout0_1 Vdout0_1ck92 = 0.9 time = 465
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=465.025n

* CHECK dout0_2 Vdout0_2ck92 = 0.9 time = 465
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=465.025n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 465
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=465.025n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 465
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=465.025n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 465
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=465.025n

* CHECK dout0_6 Vdout0_6ck92 = 0.9 time = 465
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=465.025n

* CHECK dout0_7 Vdout0_7ck92 = 0.9 time = 465
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=465.025n

* CHECK dout0_8 Vdout0_8ck92 = 0.9 time = 465
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=465.025n

* CHECK dout0_9 Vdout0_9ck92 = 0.9 time = 465
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=465.025n

* CHECK dout0_10 Vdout0_10ck92 = 0 time = 465
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=465.025n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 465
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=465.025n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 465
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=465.025n

* CHECK dout0_13 Vdout0_13ck92 = 0.9 time = 465
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=465.025n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 465
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=465.025n

* CHECK dout0_15 Vdout0_15ck92 = 0.9 time = 465
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=465.025n

* CHECK dout0_16 Vdout0_16ck92 = 0 time = 465
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=465.025n

* CHECK dout0_17 Vdout0_17ck92 = 0.9 time = 465
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=465.025n

* CHECK dout0_18 Vdout0_18ck92 = 0.9 time = 465
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=465.025n

* CHECK dout0_19 Vdout0_19ck92 = 0 time = 465
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=465.025n

* CHECK dout0_20 Vdout0_20ck92 = 0.9 time = 465
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=465.025n

* CHECK dout0_21 Vdout0_21ck92 = 0 time = 465
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=465.025n

* CHECK dout0_22 Vdout0_22ck92 = 0.9 time = 465
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=465.025n

* CHECK dout0_23 Vdout0_23ck92 = 0.9 time = 465
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=465.025n

* CHECK dout0_24 Vdout0_24ck92 = 0 time = 465
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=465.025n

* CHECK dout0_25 Vdout0_25ck92 = 0.9 time = 465
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=465.025n

* CHECK dout0_26 Vdout0_26ck92 = 0 time = 465
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=465.025n

* CHECK dout0_27 Vdout0_27ck92 = 0 time = 465
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=465.025n

* CHECK dout0_28 Vdout0_28ck92 = 0 time = 465
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=465.025n

* CHECK dout0_29 Vdout0_29ck92 = 0.9 time = 465
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=465.025n

* CHECK dout0_30 Vdout0_30ck92 = 0 time = 465
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=465.025n

* CHECK dout0_31 Vdout0_31ck92 = 0.9 time = 465
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=465.025n

* CHECK dout0_32 Vdout0_32ck92 = 0.9 time = 465
.meas tran vdout0_32ck92 FIND v(dout0_32) AT=465.025n

* CHECK dout0_33 Vdout0_33ck92 = 0 time = 465
.meas tran vdout0_33ck92 FIND v(dout0_33) AT=465.025n

* CHECK dout0_34 Vdout0_34ck92 = 0 time = 465
.meas tran vdout0_34ck92 FIND v(dout0_34) AT=465.025n

* CHECK dout0_35 Vdout0_35ck92 = 0.9 time = 465
.meas tran vdout0_35ck92 FIND v(dout0_35) AT=465.025n

* CHECK dout0_36 Vdout0_36ck92 = 0 time = 465
.meas tran vdout0_36ck92 FIND v(dout0_36) AT=465.025n

* CHECK dout0_37 Vdout0_37ck92 = 0.9 time = 465
.meas tran vdout0_37ck92 FIND v(dout0_37) AT=465.025n

* CHECK dout0_38 Vdout0_38ck92 = 0.9 time = 465
.meas tran vdout0_38ck92 FIND v(dout0_38) AT=465.025n

* CHECK dout0_39 Vdout0_39ck92 = 0 time = 465
.meas tran vdout0_39ck92 FIND v(dout0_39) AT=465.025n

* CHECK dout0_40 Vdout0_40ck92 = 0 time = 465
.meas tran vdout0_40ck92 FIND v(dout0_40) AT=465.025n

* CHECK dout0_41 Vdout0_41ck92 = 0.9 time = 465
.meas tran vdout0_41ck92 FIND v(dout0_41) AT=465.025n

* CHECK dout0_42 Vdout0_42ck92 = 0 time = 465
.meas tran vdout0_42ck92 FIND v(dout0_42) AT=465.025n

* CHECK dout0_43 Vdout0_43ck92 = 0 time = 465
.meas tran vdout0_43ck92 FIND v(dout0_43) AT=465.025n

* CHECK dout0_44 Vdout0_44ck92 = 0 time = 465
.meas tran vdout0_44ck92 FIND v(dout0_44) AT=465.025n

* CHECK dout0_45 Vdout0_45ck92 = 0 time = 465
.meas tran vdout0_45ck92 FIND v(dout0_45) AT=465.025n

* CHECK dout0_46 Vdout0_46ck92 = 0.9 time = 465
.meas tran vdout0_46ck92 FIND v(dout0_46) AT=465.025n

* CHECK dout0_47 Vdout0_47ck92 = 0 time = 465
.meas tran vdout0_47ck92 FIND v(dout0_47) AT=465.025n

* CHECK dout0_48 Vdout0_48ck92 = 0.9 time = 465
.meas tran vdout0_48ck92 FIND v(dout0_48) AT=465.025n

* CHECK dout0_49 Vdout0_49ck92 = 0 time = 465
.meas tran vdout0_49ck92 FIND v(dout0_49) AT=465.025n

* CHECK dout0_50 Vdout0_50ck92 = 0.9 time = 465
.meas tran vdout0_50ck92 FIND v(dout0_50) AT=465.025n

* CHECK dout0_51 Vdout0_51ck92 = 0.9 time = 465
.meas tran vdout0_51ck92 FIND v(dout0_51) AT=465.025n

* CHECK dout0_52 Vdout0_52ck92 = 0.9 time = 465
.meas tran vdout0_52ck92 FIND v(dout0_52) AT=465.025n

* CHECK dout0_53 Vdout0_53ck92 = 0 time = 465
.meas tran vdout0_53ck92 FIND v(dout0_53) AT=465.025n

* CHECK dout0_54 Vdout0_54ck92 = 0.9 time = 465
.meas tran vdout0_54ck92 FIND v(dout0_54) AT=465.025n

* CHECK dout0_55 Vdout0_55ck92 = 0.9 time = 465
.meas tran vdout0_55ck92 FIND v(dout0_55) AT=465.025n

* CHECK dout0_56 Vdout0_56ck92 = 0.9 time = 465
.meas tran vdout0_56ck92 FIND v(dout0_56) AT=465.025n

* CHECK dout0_57 Vdout0_57ck92 = 0 time = 465
.meas tran vdout0_57ck92 FIND v(dout0_57) AT=465.025n

* CHECK dout0_58 Vdout0_58ck92 = 0.9 time = 465
.meas tran vdout0_58ck92 FIND v(dout0_58) AT=465.025n

* CHECK dout0_59 Vdout0_59ck92 = 0.9 time = 465
.meas tran vdout0_59ck92 FIND v(dout0_59) AT=465.025n

* CHECK dout0_60 Vdout0_60ck92 = 0 time = 465
.meas tran vdout0_60ck92 FIND v(dout0_60) AT=465.025n

* CHECK dout0_61 Vdout0_61ck92 = 0 time = 465
.meas tran vdout0_61ck92 FIND v(dout0_61) AT=465.025n

* CHECK dout0_62 Vdout0_62ck92 = 0 time = 465
.meas tran vdout0_62ck92 FIND v(dout0_62) AT=465.025n

* CHECK dout0_63 Vdout0_63ck92 = 0.9 time = 465
.meas tran vdout0_63ck92 FIND v(dout0_63) AT=465.025n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 0.9 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 0 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 0.9 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 0.9 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 0 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 0.9 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 0.9 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 0.9 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 0.9 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 0.9 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 0.9 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 0 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 0 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 0.9 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 0.9 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 0 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 0 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 0 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 0.9 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 0.9 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 0.9 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 0 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 0.9 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 470
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=470.025n

* CHECK dout0_33 Vdout0_33ck93 = 0 time = 470
.meas tran vdout0_33ck93 FIND v(dout0_33) AT=470.025n

* CHECK dout0_34 Vdout0_34ck93 = 0.9 time = 470
.meas tran vdout0_34ck93 FIND v(dout0_34) AT=470.025n

* CHECK dout0_35 Vdout0_35ck93 = 0.9 time = 470
.meas tran vdout0_35ck93 FIND v(dout0_35) AT=470.025n

* CHECK dout0_36 Vdout0_36ck93 = 0 time = 470
.meas tran vdout0_36ck93 FIND v(dout0_36) AT=470.025n

* CHECK dout0_37 Vdout0_37ck93 = 0.9 time = 470
.meas tran vdout0_37ck93 FIND v(dout0_37) AT=470.025n

* CHECK dout0_38 Vdout0_38ck93 = 0 time = 470
.meas tran vdout0_38ck93 FIND v(dout0_38) AT=470.025n

* CHECK dout0_39 Vdout0_39ck93 = 0.9 time = 470
.meas tran vdout0_39ck93 FIND v(dout0_39) AT=470.025n

* CHECK dout0_40 Vdout0_40ck93 = 0.9 time = 470
.meas tran vdout0_40ck93 FIND v(dout0_40) AT=470.025n

* CHECK dout0_41 Vdout0_41ck93 = 0.9 time = 470
.meas tran vdout0_41ck93 FIND v(dout0_41) AT=470.025n

* CHECK dout0_42 Vdout0_42ck93 = 0.9 time = 470
.meas tran vdout0_42ck93 FIND v(dout0_42) AT=470.025n

* CHECK dout0_43 Vdout0_43ck93 = 0 time = 470
.meas tran vdout0_43ck93 FIND v(dout0_43) AT=470.025n

* CHECK dout0_44 Vdout0_44ck93 = 0 time = 470
.meas tran vdout0_44ck93 FIND v(dout0_44) AT=470.025n

* CHECK dout0_45 Vdout0_45ck93 = 0.9 time = 470
.meas tran vdout0_45ck93 FIND v(dout0_45) AT=470.025n

* CHECK dout0_46 Vdout0_46ck93 = 0.9 time = 470
.meas tran vdout0_46ck93 FIND v(dout0_46) AT=470.025n

* CHECK dout0_47 Vdout0_47ck93 = 0.9 time = 470
.meas tran vdout0_47ck93 FIND v(dout0_47) AT=470.025n

* CHECK dout0_48 Vdout0_48ck93 = 0.9 time = 470
.meas tran vdout0_48ck93 FIND v(dout0_48) AT=470.025n

* CHECK dout0_49 Vdout0_49ck93 = 0 time = 470
.meas tran vdout0_49ck93 FIND v(dout0_49) AT=470.025n

* CHECK dout0_50 Vdout0_50ck93 = 0 time = 470
.meas tran vdout0_50ck93 FIND v(dout0_50) AT=470.025n

* CHECK dout0_51 Vdout0_51ck93 = 0 time = 470
.meas tran vdout0_51ck93 FIND v(dout0_51) AT=470.025n

* CHECK dout0_52 Vdout0_52ck93 = 0.9 time = 470
.meas tran vdout0_52ck93 FIND v(dout0_52) AT=470.025n

* CHECK dout0_53 Vdout0_53ck93 = 0 time = 470
.meas tran vdout0_53ck93 FIND v(dout0_53) AT=470.025n

* CHECK dout0_54 Vdout0_54ck93 = 0 time = 470
.meas tran vdout0_54ck93 FIND v(dout0_54) AT=470.025n

* CHECK dout0_55 Vdout0_55ck93 = 0 time = 470
.meas tran vdout0_55ck93 FIND v(dout0_55) AT=470.025n

* CHECK dout0_56 Vdout0_56ck93 = 0.9 time = 470
.meas tran vdout0_56ck93 FIND v(dout0_56) AT=470.025n

* CHECK dout0_57 Vdout0_57ck93 = 0 time = 470
.meas tran vdout0_57ck93 FIND v(dout0_57) AT=470.025n

* CHECK dout0_58 Vdout0_58ck93 = 0 time = 470
.meas tran vdout0_58ck93 FIND v(dout0_58) AT=470.025n

* CHECK dout0_59 Vdout0_59ck93 = 0.9 time = 470
.meas tran vdout0_59ck93 FIND v(dout0_59) AT=470.025n

* CHECK dout0_60 Vdout0_60ck93 = 0 time = 470
.meas tran vdout0_60ck93 FIND v(dout0_60) AT=470.025n

* CHECK dout0_61 Vdout0_61ck93 = 0 time = 470
.meas tran vdout0_61ck93 FIND v(dout0_61) AT=470.025n

* CHECK dout0_62 Vdout0_62ck93 = 0.9 time = 470
.meas tran vdout0_62ck93 FIND v(dout0_62) AT=470.025n

* CHECK dout0_63 Vdout0_63ck93 = 0.9 time = 470
.meas tran vdout0_63ck93 FIND v(dout0_63) AT=470.025n

* CHECK dout0_0 Vdout0_0ck95 = 0.9 time = 480
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=480.025n

* CHECK dout0_1 Vdout0_1ck95 = 0.9 time = 480
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=480.025n

* CHECK dout0_2 Vdout0_2ck95 = 0.9 time = 480
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=480.025n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 480
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=480.025n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 480
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=480.025n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 480
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=480.025n

* CHECK dout0_6 Vdout0_6ck95 = 0.9 time = 480
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=480.025n

* CHECK dout0_7 Vdout0_7ck95 = 0.9 time = 480
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=480.025n

* CHECK dout0_8 Vdout0_8ck95 = 0.9 time = 480
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=480.025n

* CHECK dout0_9 Vdout0_9ck95 = 0.9 time = 480
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=480.025n

* CHECK dout0_10 Vdout0_10ck95 = 0 time = 480
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=480.025n

* CHECK dout0_11 Vdout0_11ck95 = 0 time = 480
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=480.025n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 480
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=480.025n

* CHECK dout0_13 Vdout0_13ck95 = 0.9 time = 480
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=480.025n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 480
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=480.025n

* CHECK dout0_15 Vdout0_15ck95 = 0.9 time = 480
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=480.025n

* CHECK dout0_16 Vdout0_16ck95 = 0 time = 480
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=480.025n

* CHECK dout0_17 Vdout0_17ck95 = 0.9 time = 480
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=480.025n

* CHECK dout0_18 Vdout0_18ck95 = 0.9 time = 480
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=480.025n

* CHECK dout0_19 Vdout0_19ck95 = 0 time = 480
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=480.025n

* CHECK dout0_20 Vdout0_20ck95 = 0.9 time = 480
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=480.025n

* CHECK dout0_21 Vdout0_21ck95 = 0 time = 480
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=480.025n

* CHECK dout0_22 Vdout0_22ck95 = 0.9 time = 480
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=480.025n

* CHECK dout0_23 Vdout0_23ck95 = 0.9 time = 480
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=480.025n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 480
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=480.025n

* CHECK dout0_25 Vdout0_25ck95 = 0.9 time = 480
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=480.025n

* CHECK dout0_26 Vdout0_26ck95 = 0 time = 480
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=480.025n

* CHECK dout0_27 Vdout0_27ck95 = 0 time = 480
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=480.025n

* CHECK dout0_28 Vdout0_28ck95 = 0 time = 480
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=480.025n

* CHECK dout0_29 Vdout0_29ck95 = 0.9 time = 480
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=480.025n

* CHECK dout0_30 Vdout0_30ck95 = 0 time = 480
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=480.025n

* CHECK dout0_31 Vdout0_31ck95 = 0.9 time = 480
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=480.025n

* CHECK dout0_32 Vdout0_32ck95 = 0.9 time = 480
.meas tran vdout0_32ck95 FIND v(dout0_32) AT=480.025n

* CHECK dout0_33 Vdout0_33ck95 = 0 time = 480
.meas tran vdout0_33ck95 FIND v(dout0_33) AT=480.025n

* CHECK dout0_34 Vdout0_34ck95 = 0 time = 480
.meas tran vdout0_34ck95 FIND v(dout0_34) AT=480.025n

* CHECK dout0_35 Vdout0_35ck95 = 0.9 time = 480
.meas tran vdout0_35ck95 FIND v(dout0_35) AT=480.025n

* CHECK dout0_36 Vdout0_36ck95 = 0 time = 480
.meas tran vdout0_36ck95 FIND v(dout0_36) AT=480.025n

* CHECK dout0_37 Vdout0_37ck95 = 0.9 time = 480
.meas tran vdout0_37ck95 FIND v(dout0_37) AT=480.025n

* CHECK dout0_38 Vdout0_38ck95 = 0.9 time = 480
.meas tran vdout0_38ck95 FIND v(dout0_38) AT=480.025n

* CHECK dout0_39 Vdout0_39ck95 = 0 time = 480
.meas tran vdout0_39ck95 FIND v(dout0_39) AT=480.025n

* CHECK dout0_40 Vdout0_40ck95 = 0 time = 480
.meas tran vdout0_40ck95 FIND v(dout0_40) AT=480.025n

* CHECK dout0_41 Vdout0_41ck95 = 0.9 time = 480
.meas tran vdout0_41ck95 FIND v(dout0_41) AT=480.025n

* CHECK dout0_42 Vdout0_42ck95 = 0 time = 480
.meas tran vdout0_42ck95 FIND v(dout0_42) AT=480.025n

* CHECK dout0_43 Vdout0_43ck95 = 0 time = 480
.meas tran vdout0_43ck95 FIND v(dout0_43) AT=480.025n

* CHECK dout0_44 Vdout0_44ck95 = 0 time = 480
.meas tran vdout0_44ck95 FIND v(dout0_44) AT=480.025n

* CHECK dout0_45 Vdout0_45ck95 = 0 time = 480
.meas tran vdout0_45ck95 FIND v(dout0_45) AT=480.025n

* CHECK dout0_46 Vdout0_46ck95 = 0.9 time = 480
.meas tran vdout0_46ck95 FIND v(dout0_46) AT=480.025n

* CHECK dout0_47 Vdout0_47ck95 = 0 time = 480
.meas tran vdout0_47ck95 FIND v(dout0_47) AT=480.025n

* CHECK dout0_48 Vdout0_48ck95 = 0.9 time = 480
.meas tran vdout0_48ck95 FIND v(dout0_48) AT=480.025n

* CHECK dout0_49 Vdout0_49ck95 = 0 time = 480
.meas tran vdout0_49ck95 FIND v(dout0_49) AT=480.025n

* CHECK dout0_50 Vdout0_50ck95 = 0.9 time = 480
.meas tran vdout0_50ck95 FIND v(dout0_50) AT=480.025n

* CHECK dout0_51 Vdout0_51ck95 = 0.9 time = 480
.meas tran vdout0_51ck95 FIND v(dout0_51) AT=480.025n

* CHECK dout0_52 Vdout0_52ck95 = 0.9 time = 480
.meas tran vdout0_52ck95 FIND v(dout0_52) AT=480.025n

* CHECK dout0_53 Vdout0_53ck95 = 0 time = 480
.meas tran vdout0_53ck95 FIND v(dout0_53) AT=480.025n

* CHECK dout0_54 Vdout0_54ck95 = 0.9 time = 480
.meas tran vdout0_54ck95 FIND v(dout0_54) AT=480.025n

* CHECK dout0_55 Vdout0_55ck95 = 0.9 time = 480
.meas tran vdout0_55ck95 FIND v(dout0_55) AT=480.025n

* CHECK dout0_56 Vdout0_56ck95 = 0.9 time = 480
.meas tran vdout0_56ck95 FIND v(dout0_56) AT=480.025n

* CHECK dout0_57 Vdout0_57ck95 = 0 time = 480
.meas tran vdout0_57ck95 FIND v(dout0_57) AT=480.025n

* CHECK dout0_58 Vdout0_58ck95 = 0.9 time = 480
.meas tran vdout0_58ck95 FIND v(dout0_58) AT=480.025n

* CHECK dout0_59 Vdout0_59ck95 = 0.9 time = 480
.meas tran vdout0_59ck95 FIND v(dout0_59) AT=480.025n

* CHECK dout0_60 Vdout0_60ck95 = 0 time = 480
.meas tran vdout0_60ck95 FIND v(dout0_60) AT=480.025n

* CHECK dout0_61 Vdout0_61ck95 = 0 time = 480
.meas tran vdout0_61ck95 FIND v(dout0_61) AT=480.025n

* CHECK dout0_62 Vdout0_62ck95 = 0 time = 480
.meas tran vdout0_62ck95 FIND v(dout0_62) AT=480.025n

* CHECK dout0_63 Vdout0_63ck95 = 0.9 time = 480
.meas tran vdout0_63ck95 FIND v(dout0_63) AT=480.025n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 0.9 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 0.9 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 0.9 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 0.9 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 0.9 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 0.9 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0.9 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 0.9 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 0.9 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 0.9 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 0.9 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 0 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0.9 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 0.9 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 0.9 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 0.9 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_32 Vdout0_32ck96 = 0 time = 485
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=485.025n

* CHECK dout0_33 Vdout0_33ck96 = 0 time = 485
.meas tran vdout0_33ck96 FIND v(dout0_33) AT=485.025n

* CHECK dout0_34 Vdout0_34ck96 = 0.9 time = 485
.meas tran vdout0_34ck96 FIND v(dout0_34) AT=485.025n

* CHECK dout0_35 Vdout0_35ck96 = 0.9 time = 485
.meas tran vdout0_35ck96 FIND v(dout0_35) AT=485.025n

* CHECK dout0_36 Vdout0_36ck96 = 0 time = 485
.meas tran vdout0_36ck96 FIND v(dout0_36) AT=485.025n

* CHECK dout0_37 Vdout0_37ck96 = 0.9 time = 485
.meas tran vdout0_37ck96 FIND v(dout0_37) AT=485.025n

* CHECK dout0_38 Vdout0_38ck96 = 0 time = 485
.meas tran vdout0_38ck96 FIND v(dout0_38) AT=485.025n

* CHECK dout0_39 Vdout0_39ck96 = 0.9 time = 485
.meas tran vdout0_39ck96 FIND v(dout0_39) AT=485.025n

* CHECK dout0_40 Vdout0_40ck96 = 0.9 time = 485
.meas tran vdout0_40ck96 FIND v(dout0_40) AT=485.025n

* CHECK dout0_41 Vdout0_41ck96 = 0.9 time = 485
.meas tran vdout0_41ck96 FIND v(dout0_41) AT=485.025n

* CHECK dout0_42 Vdout0_42ck96 = 0.9 time = 485
.meas tran vdout0_42ck96 FIND v(dout0_42) AT=485.025n

* CHECK dout0_43 Vdout0_43ck96 = 0 time = 485
.meas tran vdout0_43ck96 FIND v(dout0_43) AT=485.025n

* CHECK dout0_44 Vdout0_44ck96 = 0 time = 485
.meas tran vdout0_44ck96 FIND v(dout0_44) AT=485.025n

* CHECK dout0_45 Vdout0_45ck96 = 0.9 time = 485
.meas tran vdout0_45ck96 FIND v(dout0_45) AT=485.025n

* CHECK dout0_46 Vdout0_46ck96 = 0.9 time = 485
.meas tran vdout0_46ck96 FIND v(dout0_46) AT=485.025n

* CHECK dout0_47 Vdout0_47ck96 = 0.9 time = 485
.meas tran vdout0_47ck96 FIND v(dout0_47) AT=485.025n

* CHECK dout0_48 Vdout0_48ck96 = 0.9 time = 485
.meas tran vdout0_48ck96 FIND v(dout0_48) AT=485.025n

* CHECK dout0_49 Vdout0_49ck96 = 0 time = 485
.meas tran vdout0_49ck96 FIND v(dout0_49) AT=485.025n

* CHECK dout0_50 Vdout0_50ck96 = 0 time = 485
.meas tran vdout0_50ck96 FIND v(dout0_50) AT=485.025n

* CHECK dout0_51 Vdout0_51ck96 = 0 time = 485
.meas tran vdout0_51ck96 FIND v(dout0_51) AT=485.025n

* CHECK dout0_52 Vdout0_52ck96 = 0.9 time = 485
.meas tran vdout0_52ck96 FIND v(dout0_52) AT=485.025n

* CHECK dout0_53 Vdout0_53ck96 = 0 time = 485
.meas tran vdout0_53ck96 FIND v(dout0_53) AT=485.025n

* CHECK dout0_54 Vdout0_54ck96 = 0 time = 485
.meas tran vdout0_54ck96 FIND v(dout0_54) AT=485.025n

* CHECK dout0_55 Vdout0_55ck96 = 0 time = 485
.meas tran vdout0_55ck96 FIND v(dout0_55) AT=485.025n

* CHECK dout0_56 Vdout0_56ck96 = 0.9 time = 485
.meas tran vdout0_56ck96 FIND v(dout0_56) AT=485.025n

* CHECK dout0_57 Vdout0_57ck96 = 0 time = 485
.meas tran vdout0_57ck96 FIND v(dout0_57) AT=485.025n

* CHECK dout0_58 Vdout0_58ck96 = 0 time = 485
.meas tran vdout0_58ck96 FIND v(dout0_58) AT=485.025n

* CHECK dout0_59 Vdout0_59ck96 = 0.9 time = 485
.meas tran vdout0_59ck96 FIND v(dout0_59) AT=485.025n

* CHECK dout0_60 Vdout0_60ck96 = 0 time = 485
.meas tran vdout0_60ck96 FIND v(dout0_60) AT=485.025n

* CHECK dout0_61 Vdout0_61ck96 = 0 time = 485
.meas tran vdout0_61ck96 FIND v(dout0_61) AT=485.025n

* CHECK dout0_62 Vdout0_62ck96 = 0.9 time = 485
.meas tran vdout0_62ck96 FIND v(dout0_62) AT=485.025n

* CHECK dout0_63 Vdout0_63ck96 = 0.9 time = 485
.meas tran vdout0_63ck96 FIND v(dout0_63) AT=485.025n

* CHECK dout0_0 Vdout0_0ck99 = 0.9 time = 500
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=500.025n

* CHECK dout0_1 Vdout0_1ck99 = 0.9 time = 500
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=500.025n

* CHECK dout0_2 Vdout0_2ck99 = 0.9 time = 500
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=500.025n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 500
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=500.025n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 500
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=500.025n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 500
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=500.025n

* CHECK dout0_6 Vdout0_6ck99 = 0.9 time = 500
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=500.025n

* CHECK dout0_7 Vdout0_7ck99 = 0.9 time = 500
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=500.025n

* CHECK dout0_8 Vdout0_8ck99 = 0.9 time = 500
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=500.025n

* CHECK dout0_9 Vdout0_9ck99 = 0.9 time = 500
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=500.025n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 500
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=500.025n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 500
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=500.025n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 500
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=500.025n

* CHECK dout0_13 Vdout0_13ck99 = 0.9 time = 500
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=500.025n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 500
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=500.025n

* CHECK dout0_15 Vdout0_15ck99 = 0.9 time = 500
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=500.025n

* CHECK dout0_16 Vdout0_16ck99 = 0 time = 500
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=500.025n

* CHECK dout0_17 Vdout0_17ck99 = 0.9 time = 500
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=500.025n

* CHECK dout0_18 Vdout0_18ck99 = 0.9 time = 500
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=500.025n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 500
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=500.025n

* CHECK dout0_20 Vdout0_20ck99 = 0.9 time = 500
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=500.025n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 500
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=500.025n

* CHECK dout0_22 Vdout0_22ck99 = 0.9 time = 500
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=500.025n

* CHECK dout0_23 Vdout0_23ck99 = 0.9 time = 500
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=500.025n

* CHECK dout0_24 Vdout0_24ck99 = 0 time = 500
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=500.025n

* CHECK dout0_25 Vdout0_25ck99 = 0.9 time = 500
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=500.025n

* CHECK dout0_26 Vdout0_26ck99 = 0 time = 500
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=500.025n

* CHECK dout0_27 Vdout0_27ck99 = 0 time = 500
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=500.025n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 500
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=500.025n

* CHECK dout0_29 Vdout0_29ck99 = 0.9 time = 500
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=500.025n

* CHECK dout0_30 Vdout0_30ck99 = 0 time = 500
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=500.025n

* CHECK dout0_31 Vdout0_31ck99 = 0.9 time = 500
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=500.025n

* CHECK dout0_32 Vdout0_32ck99 = 0.9 time = 500
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=500.025n

* CHECK dout0_33 Vdout0_33ck99 = 0 time = 500
.meas tran vdout0_33ck99 FIND v(dout0_33) AT=500.025n

* CHECK dout0_34 Vdout0_34ck99 = 0 time = 500
.meas tran vdout0_34ck99 FIND v(dout0_34) AT=500.025n

* CHECK dout0_35 Vdout0_35ck99 = 0.9 time = 500
.meas tran vdout0_35ck99 FIND v(dout0_35) AT=500.025n

* CHECK dout0_36 Vdout0_36ck99 = 0 time = 500
.meas tran vdout0_36ck99 FIND v(dout0_36) AT=500.025n

* CHECK dout0_37 Vdout0_37ck99 = 0.9 time = 500
.meas tran vdout0_37ck99 FIND v(dout0_37) AT=500.025n

* CHECK dout0_38 Vdout0_38ck99 = 0.9 time = 500
.meas tran vdout0_38ck99 FIND v(dout0_38) AT=500.025n

* CHECK dout0_39 Vdout0_39ck99 = 0 time = 500
.meas tran vdout0_39ck99 FIND v(dout0_39) AT=500.025n

* CHECK dout0_40 Vdout0_40ck99 = 0 time = 500
.meas tran vdout0_40ck99 FIND v(dout0_40) AT=500.025n

* CHECK dout0_41 Vdout0_41ck99 = 0.9 time = 500
.meas tran vdout0_41ck99 FIND v(dout0_41) AT=500.025n

* CHECK dout0_42 Vdout0_42ck99 = 0 time = 500
.meas tran vdout0_42ck99 FIND v(dout0_42) AT=500.025n

* CHECK dout0_43 Vdout0_43ck99 = 0 time = 500
.meas tran vdout0_43ck99 FIND v(dout0_43) AT=500.025n

* CHECK dout0_44 Vdout0_44ck99 = 0 time = 500
.meas tran vdout0_44ck99 FIND v(dout0_44) AT=500.025n

* CHECK dout0_45 Vdout0_45ck99 = 0 time = 500
.meas tran vdout0_45ck99 FIND v(dout0_45) AT=500.025n

* CHECK dout0_46 Vdout0_46ck99 = 0.9 time = 500
.meas tran vdout0_46ck99 FIND v(dout0_46) AT=500.025n

* CHECK dout0_47 Vdout0_47ck99 = 0 time = 500
.meas tran vdout0_47ck99 FIND v(dout0_47) AT=500.025n

* CHECK dout0_48 Vdout0_48ck99 = 0.9 time = 500
.meas tran vdout0_48ck99 FIND v(dout0_48) AT=500.025n

* CHECK dout0_49 Vdout0_49ck99 = 0 time = 500
.meas tran vdout0_49ck99 FIND v(dout0_49) AT=500.025n

* CHECK dout0_50 Vdout0_50ck99 = 0.9 time = 500
.meas tran vdout0_50ck99 FIND v(dout0_50) AT=500.025n

* CHECK dout0_51 Vdout0_51ck99 = 0.9 time = 500
.meas tran vdout0_51ck99 FIND v(dout0_51) AT=500.025n

* CHECK dout0_52 Vdout0_52ck99 = 0.9 time = 500
.meas tran vdout0_52ck99 FIND v(dout0_52) AT=500.025n

* CHECK dout0_53 Vdout0_53ck99 = 0 time = 500
.meas tran vdout0_53ck99 FIND v(dout0_53) AT=500.025n

* CHECK dout0_54 Vdout0_54ck99 = 0.9 time = 500
.meas tran vdout0_54ck99 FIND v(dout0_54) AT=500.025n

* CHECK dout0_55 Vdout0_55ck99 = 0.9 time = 500
.meas tran vdout0_55ck99 FIND v(dout0_55) AT=500.025n

* CHECK dout0_56 Vdout0_56ck99 = 0.9 time = 500
.meas tran vdout0_56ck99 FIND v(dout0_56) AT=500.025n

* CHECK dout0_57 Vdout0_57ck99 = 0 time = 500
.meas tran vdout0_57ck99 FIND v(dout0_57) AT=500.025n

* CHECK dout0_58 Vdout0_58ck99 = 0.9 time = 500
.meas tran vdout0_58ck99 FIND v(dout0_58) AT=500.025n

* CHECK dout0_59 Vdout0_59ck99 = 0.9 time = 500
.meas tran vdout0_59ck99 FIND v(dout0_59) AT=500.025n

* CHECK dout0_60 Vdout0_60ck99 = 0 time = 500
.meas tran vdout0_60ck99 FIND v(dout0_60) AT=500.025n

* CHECK dout0_61 Vdout0_61ck99 = 0 time = 500
.meas tran vdout0_61ck99 FIND v(dout0_61) AT=500.025n

* CHECK dout0_62 Vdout0_62ck99 = 0 time = 500
.meas tran vdout0_62ck99 FIND v(dout0_62) AT=500.025n

* CHECK dout0_63 Vdout0_63ck99 = 0.9 time = 500
.meas tran vdout0_63ck99 FIND v(dout0_63) AT=500.025n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 505
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=505.025n

* CHECK dout0_1 Vdout0_1ck100 = 0.9 time = 505
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=505.025n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 505
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=505.025n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 505
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=505.025n

* CHECK dout0_4 Vdout0_4ck100 = 0.9 time = 505
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=505.025n

* CHECK dout0_5 Vdout0_5ck100 = 0 time = 505
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=505.025n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 505
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=505.025n

* CHECK dout0_7 Vdout0_7ck100 = 0.9 time = 505
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=505.025n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 505
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=505.025n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 505
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=505.025n

* CHECK dout0_10 Vdout0_10ck100 = 0 time = 505
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=505.025n

* CHECK dout0_11 Vdout0_11ck100 = 0.9 time = 505
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=505.025n

* CHECK dout0_12 Vdout0_12ck100 = 0.9 time = 505
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=505.025n

* CHECK dout0_13 Vdout0_13ck100 = 0 time = 505
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=505.025n

* CHECK dout0_14 Vdout0_14ck100 = 0.9 time = 505
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=505.025n

* CHECK dout0_15 Vdout0_15ck100 = 0.9 time = 505
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=505.025n

* CHECK dout0_16 Vdout0_16ck100 = 0.9 time = 505
.meas tran vdout0_16ck100 FIND v(dout0_16) AT=505.025n

* CHECK dout0_17 Vdout0_17ck100 = 0.9 time = 505
.meas tran vdout0_17ck100 FIND v(dout0_17) AT=505.025n

* CHECK dout0_18 Vdout0_18ck100 = 0 time = 505
.meas tran vdout0_18ck100 FIND v(dout0_18) AT=505.025n

* CHECK dout0_19 Vdout0_19ck100 = 0 time = 505
.meas tran vdout0_19ck100 FIND v(dout0_19) AT=505.025n

* CHECK dout0_20 Vdout0_20ck100 = 0.9 time = 505
.meas tran vdout0_20ck100 FIND v(dout0_20) AT=505.025n

* CHECK dout0_21 Vdout0_21ck100 = 0.9 time = 505
.meas tran vdout0_21ck100 FIND v(dout0_21) AT=505.025n

* CHECK dout0_22 Vdout0_22ck100 = 0 time = 505
.meas tran vdout0_22ck100 FIND v(dout0_22) AT=505.025n

* CHECK dout0_23 Vdout0_23ck100 = 0 time = 505
.meas tran vdout0_23ck100 FIND v(dout0_23) AT=505.025n

* CHECK dout0_24 Vdout0_24ck100 = 0 time = 505
.meas tran vdout0_24ck100 FIND v(dout0_24) AT=505.025n

* CHECK dout0_25 Vdout0_25ck100 = 0 time = 505
.meas tran vdout0_25ck100 FIND v(dout0_25) AT=505.025n

* CHECK dout0_26 Vdout0_26ck100 = 0 time = 505
.meas tran vdout0_26ck100 FIND v(dout0_26) AT=505.025n

* CHECK dout0_27 Vdout0_27ck100 = 0.9 time = 505
.meas tran vdout0_27ck100 FIND v(dout0_27) AT=505.025n

* CHECK dout0_28 Vdout0_28ck100 = 0.9 time = 505
.meas tran vdout0_28ck100 FIND v(dout0_28) AT=505.025n

* CHECK dout0_29 Vdout0_29ck100 = 0.9 time = 505
.meas tran vdout0_29ck100 FIND v(dout0_29) AT=505.025n

* CHECK dout0_30 Vdout0_30ck100 = 0 time = 505
.meas tran vdout0_30ck100 FIND v(dout0_30) AT=505.025n

* CHECK dout0_31 Vdout0_31ck100 = 0.9 time = 505
.meas tran vdout0_31ck100 FIND v(dout0_31) AT=505.025n

* CHECK dout0_32 Vdout0_32ck100 = 0 time = 505
.meas tran vdout0_32ck100 FIND v(dout0_32) AT=505.025n

* CHECK dout0_33 Vdout0_33ck100 = 0 time = 505
.meas tran vdout0_33ck100 FIND v(dout0_33) AT=505.025n

* CHECK dout0_34 Vdout0_34ck100 = 0.9 time = 505
.meas tran vdout0_34ck100 FIND v(dout0_34) AT=505.025n

* CHECK dout0_35 Vdout0_35ck100 = 0.9 time = 505
.meas tran vdout0_35ck100 FIND v(dout0_35) AT=505.025n

* CHECK dout0_36 Vdout0_36ck100 = 0 time = 505
.meas tran vdout0_36ck100 FIND v(dout0_36) AT=505.025n

* CHECK dout0_37 Vdout0_37ck100 = 0.9 time = 505
.meas tran vdout0_37ck100 FIND v(dout0_37) AT=505.025n

* CHECK dout0_38 Vdout0_38ck100 = 0 time = 505
.meas tran vdout0_38ck100 FIND v(dout0_38) AT=505.025n

* CHECK dout0_39 Vdout0_39ck100 = 0.9 time = 505
.meas tran vdout0_39ck100 FIND v(dout0_39) AT=505.025n

* CHECK dout0_40 Vdout0_40ck100 = 0.9 time = 505
.meas tran vdout0_40ck100 FIND v(dout0_40) AT=505.025n

* CHECK dout0_41 Vdout0_41ck100 = 0.9 time = 505
.meas tran vdout0_41ck100 FIND v(dout0_41) AT=505.025n

* CHECK dout0_42 Vdout0_42ck100 = 0.9 time = 505
.meas tran vdout0_42ck100 FIND v(dout0_42) AT=505.025n

* CHECK dout0_43 Vdout0_43ck100 = 0 time = 505
.meas tran vdout0_43ck100 FIND v(dout0_43) AT=505.025n

* CHECK dout0_44 Vdout0_44ck100 = 0 time = 505
.meas tran vdout0_44ck100 FIND v(dout0_44) AT=505.025n

* CHECK dout0_45 Vdout0_45ck100 = 0.9 time = 505
.meas tran vdout0_45ck100 FIND v(dout0_45) AT=505.025n

* CHECK dout0_46 Vdout0_46ck100 = 0.9 time = 505
.meas tran vdout0_46ck100 FIND v(dout0_46) AT=505.025n

* CHECK dout0_47 Vdout0_47ck100 = 0.9 time = 505
.meas tran vdout0_47ck100 FIND v(dout0_47) AT=505.025n

* CHECK dout0_48 Vdout0_48ck100 = 0.9 time = 505
.meas tran vdout0_48ck100 FIND v(dout0_48) AT=505.025n

* CHECK dout0_49 Vdout0_49ck100 = 0 time = 505
.meas tran vdout0_49ck100 FIND v(dout0_49) AT=505.025n

* CHECK dout0_50 Vdout0_50ck100 = 0 time = 505
.meas tran vdout0_50ck100 FIND v(dout0_50) AT=505.025n

* CHECK dout0_51 Vdout0_51ck100 = 0 time = 505
.meas tran vdout0_51ck100 FIND v(dout0_51) AT=505.025n

* CHECK dout0_52 Vdout0_52ck100 = 0.9 time = 505
.meas tran vdout0_52ck100 FIND v(dout0_52) AT=505.025n

* CHECK dout0_53 Vdout0_53ck100 = 0 time = 505
.meas tran vdout0_53ck100 FIND v(dout0_53) AT=505.025n

* CHECK dout0_54 Vdout0_54ck100 = 0 time = 505
.meas tran vdout0_54ck100 FIND v(dout0_54) AT=505.025n

* CHECK dout0_55 Vdout0_55ck100 = 0 time = 505
.meas tran vdout0_55ck100 FIND v(dout0_55) AT=505.025n

* CHECK dout0_56 Vdout0_56ck100 = 0.9 time = 505
.meas tran vdout0_56ck100 FIND v(dout0_56) AT=505.025n

* CHECK dout0_57 Vdout0_57ck100 = 0 time = 505
.meas tran vdout0_57ck100 FIND v(dout0_57) AT=505.025n

* CHECK dout0_58 Vdout0_58ck100 = 0 time = 505
.meas tran vdout0_58ck100 FIND v(dout0_58) AT=505.025n

* CHECK dout0_59 Vdout0_59ck100 = 0.9 time = 505
.meas tran vdout0_59ck100 FIND v(dout0_59) AT=505.025n

* CHECK dout0_60 Vdout0_60ck100 = 0 time = 505
.meas tran vdout0_60ck100 FIND v(dout0_60) AT=505.025n

* CHECK dout0_61 Vdout0_61ck100 = 0 time = 505
.meas tran vdout0_61ck100 FIND v(dout0_61) AT=505.025n

* CHECK dout0_62 Vdout0_62ck100 = 0.9 time = 505
.meas tran vdout0_62ck100 FIND v(dout0_62) AT=505.025n

* CHECK dout0_63 Vdout0_63ck100 = 0.9 time = 505
.meas tran vdout0_63ck100 FIND v(dout0_63) AT=505.025n

* CHECK dout0_0 Vdout0_0ck101 = 0.9 time = 510
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=510.025n

* CHECK dout0_1 Vdout0_1ck101 = 0.9 time = 510
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=510.025n

* CHECK dout0_2 Vdout0_2ck101 = 0.9 time = 510
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=510.025n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 510
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=510.025n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 510
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=510.025n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 510
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=510.025n

* CHECK dout0_6 Vdout0_6ck101 = 0.9 time = 510
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=510.025n

* CHECK dout0_7 Vdout0_7ck101 = 0.9 time = 510
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=510.025n

* CHECK dout0_8 Vdout0_8ck101 = 0.9 time = 510
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=510.025n

* CHECK dout0_9 Vdout0_9ck101 = 0.9 time = 510
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=510.025n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 510
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=510.025n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 510
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=510.025n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 510
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=510.025n

* CHECK dout0_13 Vdout0_13ck101 = 0.9 time = 510
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=510.025n

* CHECK dout0_14 Vdout0_14ck101 = 0 time = 510
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=510.025n

* CHECK dout0_15 Vdout0_15ck101 = 0.9 time = 510
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=510.025n

* CHECK dout0_16 Vdout0_16ck101 = 0 time = 510
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=510.025n

* CHECK dout0_17 Vdout0_17ck101 = 0.9 time = 510
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=510.025n

* CHECK dout0_18 Vdout0_18ck101 = 0.9 time = 510
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=510.025n

* CHECK dout0_19 Vdout0_19ck101 = 0 time = 510
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=510.025n

* CHECK dout0_20 Vdout0_20ck101 = 0.9 time = 510
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=510.025n

* CHECK dout0_21 Vdout0_21ck101 = 0 time = 510
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=510.025n

* CHECK dout0_22 Vdout0_22ck101 = 0.9 time = 510
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=510.025n

* CHECK dout0_23 Vdout0_23ck101 = 0.9 time = 510
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=510.025n

* CHECK dout0_24 Vdout0_24ck101 = 0 time = 510
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=510.025n

* CHECK dout0_25 Vdout0_25ck101 = 0.9 time = 510
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=510.025n

* CHECK dout0_26 Vdout0_26ck101 = 0 time = 510
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=510.025n

* CHECK dout0_27 Vdout0_27ck101 = 0 time = 510
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=510.025n

* CHECK dout0_28 Vdout0_28ck101 = 0 time = 510
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=510.025n

* CHECK dout0_29 Vdout0_29ck101 = 0.9 time = 510
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=510.025n

* CHECK dout0_30 Vdout0_30ck101 = 0 time = 510
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=510.025n

* CHECK dout0_31 Vdout0_31ck101 = 0.9 time = 510
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=510.025n

* CHECK dout0_32 Vdout0_32ck101 = 0.9 time = 510
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=510.025n

* CHECK dout0_33 Vdout0_33ck101 = 0 time = 510
.meas tran vdout0_33ck101 FIND v(dout0_33) AT=510.025n

* CHECK dout0_34 Vdout0_34ck101 = 0 time = 510
.meas tran vdout0_34ck101 FIND v(dout0_34) AT=510.025n

* CHECK dout0_35 Vdout0_35ck101 = 0.9 time = 510
.meas tran vdout0_35ck101 FIND v(dout0_35) AT=510.025n

* CHECK dout0_36 Vdout0_36ck101 = 0 time = 510
.meas tran vdout0_36ck101 FIND v(dout0_36) AT=510.025n

* CHECK dout0_37 Vdout0_37ck101 = 0.9 time = 510
.meas tran vdout0_37ck101 FIND v(dout0_37) AT=510.025n

* CHECK dout0_38 Vdout0_38ck101 = 0.9 time = 510
.meas tran vdout0_38ck101 FIND v(dout0_38) AT=510.025n

* CHECK dout0_39 Vdout0_39ck101 = 0 time = 510
.meas tran vdout0_39ck101 FIND v(dout0_39) AT=510.025n

* CHECK dout0_40 Vdout0_40ck101 = 0 time = 510
.meas tran vdout0_40ck101 FIND v(dout0_40) AT=510.025n

* CHECK dout0_41 Vdout0_41ck101 = 0.9 time = 510
.meas tran vdout0_41ck101 FIND v(dout0_41) AT=510.025n

* CHECK dout0_42 Vdout0_42ck101 = 0 time = 510
.meas tran vdout0_42ck101 FIND v(dout0_42) AT=510.025n

* CHECK dout0_43 Vdout0_43ck101 = 0 time = 510
.meas tran vdout0_43ck101 FIND v(dout0_43) AT=510.025n

* CHECK dout0_44 Vdout0_44ck101 = 0 time = 510
.meas tran vdout0_44ck101 FIND v(dout0_44) AT=510.025n

* CHECK dout0_45 Vdout0_45ck101 = 0 time = 510
.meas tran vdout0_45ck101 FIND v(dout0_45) AT=510.025n

* CHECK dout0_46 Vdout0_46ck101 = 0.9 time = 510
.meas tran vdout0_46ck101 FIND v(dout0_46) AT=510.025n

* CHECK dout0_47 Vdout0_47ck101 = 0 time = 510
.meas tran vdout0_47ck101 FIND v(dout0_47) AT=510.025n

* CHECK dout0_48 Vdout0_48ck101 = 0.9 time = 510
.meas tran vdout0_48ck101 FIND v(dout0_48) AT=510.025n

* CHECK dout0_49 Vdout0_49ck101 = 0 time = 510
.meas tran vdout0_49ck101 FIND v(dout0_49) AT=510.025n

* CHECK dout0_50 Vdout0_50ck101 = 0.9 time = 510
.meas tran vdout0_50ck101 FIND v(dout0_50) AT=510.025n

* CHECK dout0_51 Vdout0_51ck101 = 0.9 time = 510
.meas tran vdout0_51ck101 FIND v(dout0_51) AT=510.025n

* CHECK dout0_52 Vdout0_52ck101 = 0.9 time = 510
.meas tran vdout0_52ck101 FIND v(dout0_52) AT=510.025n

* CHECK dout0_53 Vdout0_53ck101 = 0 time = 510
.meas tran vdout0_53ck101 FIND v(dout0_53) AT=510.025n

* CHECK dout0_54 Vdout0_54ck101 = 0.9 time = 510
.meas tran vdout0_54ck101 FIND v(dout0_54) AT=510.025n

* CHECK dout0_55 Vdout0_55ck101 = 0.9 time = 510
.meas tran vdout0_55ck101 FIND v(dout0_55) AT=510.025n

* CHECK dout0_56 Vdout0_56ck101 = 0.9 time = 510
.meas tran vdout0_56ck101 FIND v(dout0_56) AT=510.025n

* CHECK dout0_57 Vdout0_57ck101 = 0 time = 510
.meas tran vdout0_57ck101 FIND v(dout0_57) AT=510.025n

* CHECK dout0_58 Vdout0_58ck101 = 0.9 time = 510
.meas tran vdout0_58ck101 FIND v(dout0_58) AT=510.025n

* CHECK dout0_59 Vdout0_59ck101 = 0.9 time = 510
.meas tran vdout0_59ck101 FIND v(dout0_59) AT=510.025n

* CHECK dout0_60 Vdout0_60ck101 = 0 time = 510
.meas tran vdout0_60ck101 FIND v(dout0_60) AT=510.025n

* CHECK dout0_61 Vdout0_61ck101 = 0 time = 510
.meas tran vdout0_61ck101 FIND v(dout0_61) AT=510.025n

* CHECK dout0_62 Vdout0_62ck101 = 0 time = 510
.meas tran vdout0_62ck101 FIND v(dout0_62) AT=510.025n

* CHECK dout0_63 Vdout0_63ck101 = 0.9 time = 510
.meas tran vdout0_63ck101 FIND v(dout0_63) AT=510.025n

* CHECK dout0_0 Vdout0_0ck102 = 0.9 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0.9 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0.9 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0.9 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0.9 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0.9 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0.9 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 0.9 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0.9 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 0 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0.9 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0.9 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0.9 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 0.9 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0.9 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0.9 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 0 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 0.9 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0.9 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_32 Vdout0_32ck102 = 0.9 time = 515
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=515.025n

* CHECK dout0_33 Vdout0_33ck102 = 0 time = 515
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=515.025n

* CHECK dout0_34 Vdout0_34ck102 = 0 time = 515
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=515.025n

* CHECK dout0_35 Vdout0_35ck102 = 0.9 time = 515
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=515.025n

* CHECK dout0_36 Vdout0_36ck102 = 0 time = 515
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=515.025n

* CHECK dout0_37 Vdout0_37ck102 = 0.9 time = 515
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=515.025n

* CHECK dout0_38 Vdout0_38ck102 = 0.9 time = 515
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=515.025n

* CHECK dout0_39 Vdout0_39ck102 = 0 time = 515
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=515.025n

* CHECK dout0_40 Vdout0_40ck102 = 0 time = 515
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=515.025n

* CHECK dout0_41 Vdout0_41ck102 = 0.9 time = 515
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=515.025n

* CHECK dout0_42 Vdout0_42ck102 = 0 time = 515
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=515.025n

* CHECK dout0_43 Vdout0_43ck102 = 0 time = 515
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=515.025n

* CHECK dout0_44 Vdout0_44ck102 = 0 time = 515
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=515.025n

* CHECK dout0_45 Vdout0_45ck102 = 0 time = 515
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=515.025n

* CHECK dout0_46 Vdout0_46ck102 = 0.9 time = 515
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=515.025n

* CHECK dout0_47 Vdout0_47ck102 = 0 time = 515
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=515.025n

* CHECK dout0_48 Vdout0_48ck102 = 0.9 time = 515
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=515.025n

* CHECK dout0_49 Vdout0_49ck102 = 0 time = 515
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=515.025n

* CHECK dout0_50 Vdout0_50ck102 = 0.9 time = 515
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=515.025n

* CHECK dout0_51 Vdout0_51ck102 = 0.9 time = 515
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=515.025n

* CHECK dout0_52 Vdout0_52ck102 = 0.9 time = 515
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=515.025n

* CHECK dout0_53 Vdout0_53ck102 = 0 time = 515
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=515.025n

* CHECK dout0_54 Vdout0_54ck102 = 0.9 time = 515
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=515.025n

* CHECK dout0_55 Vdout0_55ck102 = 0.9 time = 515
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=515.025n

* CHECK dout0_56 Vdout0_56ck102 = 0.9 time = 515
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=515.025n

* CHECK dout0_57 Vdout0_57ck102 = 0 time = 515
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=515.025n

* CHECK dout0_58 Vdout0_58ck102 = 0.9 time = 515
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=515.025n

* CHECK dout0_59 Vdout0_59ck102 = 0.9 time = 515
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=515.025n

* CHECK dout0_60 Vdout0_60ck102 = 0 time = 515
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=515.025n

* CHECK dout0_61 Vdout0_61ck102 = 0 time = 515
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=515.025n

* CHECK dout0_62 Vdout0_62ck102 = 0 time = 515
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=515.025n

* CHECK dout0_63 Vdout0_63ck102 = 0.9 time = 515
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=515.025n

* CHECK dout0_0 Vdout0_0ck106 = 0.9 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 0.9 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0.9 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0.9 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0.9 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0.9 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 0 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0.9 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 0.9 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0.9 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0.9 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 0.9 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0.9 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0.9 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 0.9 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_32 Vdout0_32ck106 = 0.9 time = 535
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=535.025n

* CHECK dout0_33 Vdout0_33ck106 = 0 time = 535
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=535.025n

* CHECK dout0_34 Vdout0_34ck106 = 0.9 time = 535
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=535.025n

* CHECK dout0_35 Vdout0_35ck106 = 0.9 time = 535
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=535.025n

* CHECK dout0_36 Vdout0_36ck106 = 0.9 time = 535
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=535.025n

* CHECK dout0_37 Vdout0_37ck106 = 0 time = 535
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=535.025n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 535
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=535.025n

* CHECK dout0_39 Vdout0_39ck106 = 0 time = 535
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=535.025n

* CHECK dout0_40 Vdout0_40ck106 = 0 time = 535
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=535.025n

* CHECK dout0_41 Vdout0_41ck106 = 0 time = 535
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=535.025n

* CHECK dout0_42 Vdout0_42ck106 = 0.9 time = 535
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=535.025n

* CHECK dout0_43 Vdout0_43ck106 = 0 time = 535
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=535.025n

* CHECK dout0_44 Vdout0_44ck106 = 0 time = 535
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=535.025n

* CHECK dout0_45 Vdout0_45ck106 = 0 time = 535
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=535.025n

* CHECK dout0_46 Vdout0_46ck106 = 0.9 time = 535
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=535.025n

* CHECK dout0_47 Vdout0_47ck106 = 0.9 time = 535
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=535.025n

* CHECK dout0_48 Vdout0_48ck106 = 0 time = 535
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=535.025n

* CHECK dout0_49 Vdout0_49ck106 = 0 time = 535
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=535.025n

* CHECK dout0_50 Vdout0_50ck106 = 0.9 time = 535
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=535.025n

* CHECK dout0_51 Vdout0_51ck106 = 0.9 time = 535
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=535.025n

* CHECK dout0_52 Vdout0_52ck106 = 0.9 time = 535
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=535.025n

* CHECK dout0_53 Vdout0_53ck106 = 0.9 time = 535
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=535.025n

* CHECK dout0_54 Vdout0_54ck106 = 0 time = 535
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=535.025n

* CHECK dout0_55 Vdout0_55ck106 = 0 time = 535
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=535.025n

* CHECK dout0_56 Vdout0_56ck106 = 0 time = 535
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=535.025n

* CHECK dout0_57 Vdout0_57ck106 = 0.9 time = 535
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=535.025n

* CHECK dout0_58 Vdout0_58ck106 = 0 time = 535
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=535.025n

* CHECK dout0_59 Vdout0_59ck106 = 0.9 time = 535
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=535.025n

* CHECK dout0_60 Vdout0_60ck106 = 0 time = 535
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=535.025n

* CHECK dout0_61 Vdout0_61ck106 = 0.9 time = 535
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=535.025n

* CHECK dout0_62 Vdout0_62ck106 = 0.9 time = 535
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=535.025n

* CHECK dout0_63 Vdout0_63ck106 = 0.9 time = 535
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=535.025n

* CHECK dout0_0 Vdout0_0ck107 = 0.9 time = 540
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=540.025n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 540
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=540.025n

* CHECK dout0_2 Vdout0_2ck107 = 0.9 time = 540
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=540.025n

* CHECK dout0_3 Vdout0_3ck107 = 0.9 time = 540
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=540.025n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 540
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=540.025n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 540
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=540.025n

* CHECK dout0_6 Vdout0_6ck107 = 0 time = 540
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=540.025n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 540
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=540.025n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 540
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=540.025n

* CHECK dout0_9 Vdout0_9ck107 = 0.9 time = 540
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=540.025n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 540
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=540.025n

* CHECK dout0_11 Vdout0_11ck107 = 0.9 time = 540
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=540.025n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 540
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=540.025n

* CHECK dout0_13 Vdout0_13ck107 = 0 time = 540
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=540.025n

* CHECK dout0_14 Vdout0_14ck107 = 0 time = 540
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=540.025n

* CHECK dout0_15 Vdout0_15ck107 = 0.9 time = 540
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=540.025n

* CHECK dout0_16 Vdout0_16ck107 = 0 time = 540
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=540.025n

* CHECK dout0_17 Vdout0_17ck107 = 0.9 time = 540
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=540.025n

* CHECK dout0_18 Vdout0_18ck107 = 0.9 time = 540
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=540.025n

* CHECK dout0_19 Vdout0_19ck107 = 0.9 time = 540
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=540.025n

* CHECK dout0_20 Vdout0_20ck107 = 0 time = 540
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=540.025n

* CHECK dout0_21 Vdout0_21ck107 = 0 time = 540
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=540.025n

* CHECK dout0_22 Vdout0_22ck107 = 0.9 time = 540
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=540.025n

* CHECK dout0_23 Vdout0_23ck107 = 0 time = 540
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=540.025n

* CHECK dout0_24 Vdout0_24ck107 = 0 time = 540
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=540.025n

* CHECK dout0_25 Vdout0_25ck107 = 0.9 time = 540
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=540.025n

* CHECK dout0_26 Vdout0_26ck107 = 0.9 time = 540
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=540.025n

* CHECK dout0_27 Vdout0_27ck107 = 0.9 time = 540
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=540.025n

* CHECK dout0_28 Vdout0_28ck107 = 0.9 time = 540
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=540.025n

* CHECK dout0_29 Vdout0_29ck107 = 0 time = 540
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=540.025n

* CHECK dout0_30 Vdout0_30ck107 = 0 time = 540
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=540.025n

* CHECK dout0_31 Vdout0_31ck107 = 0 time = 540
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=540.025n

* CHECK dout0_32 Vdout0_32ck107 = 0.9 time = 540
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=540.025n

* CHECK dout0_33 Vdout0_33ck107 = 0 time = 540
.meas tran vdout0_33ck107 FIND v(dout0_33) AT=540.025n

* CHECK dout0_34 Vdout0_34ck107 = 0.9 time = 540
.meas tran vdout0_34ck107 FIND v(dout0_34) AT=540.025n

* CHECK dout0_35 Vdout0_35ck107 = 0.9 time = 540
.meas tran vdout0_35ck107 FIND v(dout0_35) AT=540.025n

* CHECK dout0_36 Vdout0_36ck107 = 0.9 time = 540
.meas tran vdout0_36ck107 FIND v(dout0_36) AT=540.025n

* CHECK dout0_37 Vdout0_37ck107 = 0 time = 540
.meas tran vdout0_37ck107 FIND v(dout0_37) AT=540.025n

* CHECK dout0_38 Vdout0_38ck107 = 0 time = 540
.meas tran vdout0_38ck107 FIND v(dout0_38) AT=540.025n

* CHECK dout0_39 Vdout0_39ck107 = 0 time = 540
.meas tran vdout0_39ck107 FIND v(dout0_39) AT=540.025n

* CHECK dout0_40 Vdout0_40ck107 = 0 time = 540
.meas tran vdout0_40ck107 FIND v(dout0_40) AT=540.025n

* CHECK dout0_41 Vdout0_41ck107 = 0 time = 540
.meas tran vdout0_41ck107 FIND v(dout0_41) AT=540.025n

* CHECK dout0_42 Vdout0_42ck107 = 0.9 time = 540
.meas tran vdout0_42ck107 FIND v(dout0_42) AT=540.025n

* CHECK dout0_43 Vdout0_43ck107 = 0 time = 540
.meas tran vdout0_43ck107 FIND v(dout0_43) AT=540.025n

* CHECK dout0_44 Vdout0_44ck107 = 0 time = 540
.meas tran vdout0_44ck107 FIND v(dout0_44) AT=540.025n

* CHECK dout0_45 Vdout0_45ck107 = 0 time = 540
.meas tran vdout0_45ck107 FIND v(dout0_45) AT=540.025n

* CHECK dout0_46 Vdout0_46ck107 = 0.9 time = 540
.meas tran vdout0_46ck107 FIND v(dout0_46) AT=540.025n

* CHECK dout0_47 Vdout0_47ck107 = 0.9 time = 540
.meas tran vdout0_47ck107 FIND v(dout0_47) AT=540.025n

* CHECK dout0_48 Vdout0_48ck107 = 0 time = 540
.meas tran vdout0_48ck107 FIND v(dout0_48) AT=540.025n

* CHECK dout0_49 Vdout0_49ck107 = 0 time = 540
.meas tran vdout0_49ck107 FIND v(dout0_49) AT=540.025n

* CHECK dout0_50 Vdout0_50ck107 = 0.9 time = 540
.meas tran vdout0_50ck107 FIND v(dout0_50) AT=540.025n

* CHECK dout0_51 Vdout0_51ck107 = 0.9 time = 540
.meas tran vdout0_51ck107 FIND v(dout0_51) AT=540.025n

* CHECK dout0_52 Vdout0_52ck107 = 0.9 time = 540
.meas tran vdout0_52ck107 FIND v(dout0_52) AT=540.025n

* CHECK dout0_53 Vdout0_53ck107 = 0.9 time = 540
.meas tran vdout0_53ck107 FIND v(dout0_53) AT=540.025n

* CHECK dout0_54 Vdout0_54ck107 = 0 time = 540
.meas tran vdout0_54ck107 FIND v(dout0_54) AT=540.025n

* CHECK dout0_55 Vdout0_55ck107 = 0 time = 540
.meas tran vdout0_55ck107 FIND v(dout0_55) AT=540.025n

* CHECK dout0_56 Vdout0_56ck107 = 0 time = 540
.meas tran vdout0_56ck107 FIND v(dout0_56) AT=540.025n

* CHECK dout0_57 Vdout0_57ck107 = 0.9 time = 540
.meas tran vdout0_57ck107 FIND v(dout0_57) AT=540.025n

* CHECK dout0_58 Vdout0_58ck107 = 0 time = 540
.meas tran vdout0_58ck107 FIND v(dout0_58) AT=540.025n

* CHECK dout0_59 Vdout0_59ck107 = 0.9 time = 540
.meas tran vdout0_59ck107 FIND v(dout0_59) AT=540.025n

* CHECK dout0_60 Vdout0_60ck107 = 0 time = 540
.meas tran vdout0_60ck107 FIND v(dout0_60) AT=540.025n

* CHECK dout0_61 Vdout0_61ck107 = 0.9 time = 540
.meas tran vdout0_61ck107 FIND v(dout0_61) AT=540.025n

* CHECK dout0_62 Vdout0_62ck107 = 0.9 time = 540
.meas tran vdout0_62ck107 FIND v(dout0_62) AT=540.025n

* CHECK dout0_63 Vdout0_63ck107 = 0.9 time = 540
.meas tran vdout0_63ck107 FIND v(dout0_63) AT=540.025n

* CHECK dout0_0 Vdout0_0ck108 = 0.9 time = 545
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=545.025n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 545
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=545.025n

* CHECK dout0_2 Vdout0_2ck108 = 0.9 time = 545
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=545.025n

* CHECK dout0_3 Vdout0_3ck108 = 0.9 time = 545
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=545.025n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 545
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=545.025n

* CHECK dout0_5 Vdout0_5ck108 = 0 time = 545
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=545.025n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 545
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=545.025n

* CHECK dout0_7 Vdout0_7ck108 = 0 time = 545
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=545.025n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 545
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=545.025n

* CHECK dout0_9 Vdout0_9ck108 = 0.9 time = 545
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=545.025n

* CHECK dout0_10 Vdout0_10ck108 = 0 time = 545
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=545.025n

* CHECK dout0_11 Vdout0_11ck108 = 0.9 time = 545
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=545.025n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 545
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=545.025n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 545
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=545.025n

* CHECK dout0_14 Vdout0_14ck108 = 0 time = 545
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=545.025n

* CHECK dout0_15 Vdout0_15ck108 = 0.9 time = 545
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=545.025n

* CHECK dout0_16 Vdout0_16ck108 = 0 time = 545
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=545.025n

* CHECK dout0_17 Vdout0_17ck108 = 0.9 time = 545
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=545.025n

* CHECK dout0_18 Vdout0_18ck108 = 0.9 time = 545
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=545.025n

* CHECK dout0_19 Vdout0_19ck108 = 0.9 time = 545
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=545.025n

* CHECK dout0_20 Vdout0_20ck108 = 0 time = 545
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=545.025n

* CHECK dout0_21 Vdout0_21ck108 = 0 time = 545
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=545.025n

* CHECK dout0_22 Vdout0_22ck108 = 0.9 time = 545
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=545.025n

* CHECK dout0_23 Vdout0_23ck108 = 0 time = 545
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=545.025n

* CHECK dout0_24 Vdout0_24ck108 = 0 time = 545
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=545.025n

* CHECK dout0_25 Vdout0_25ck108 = 0.9 time = 545
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=545.025n

* CHECK dout0_26 Vdout0_26ck108 = 0.9 time = 545
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=545.025n

* CHECK dout0_27 Vdout0_27ck108 = 0.9 time = 545
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=545.025n

* CHECK dout0_28 Vdout0_28ck108 = 0.9 time = 545
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=545.025n

* CHECK dout0_29 Vdout0_29ck108 = 0 time = 545
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=545.025n

* CHECK dout0_30 Vdout0_30ck108 = 0 time = 545
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=545.025n

* CHECK dout0_31 Vdout0_31ck108 = 0 time = 545
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=545.025n

* CHECK dout0_32 Vdout0_32ck108 = 0.9 time = 545
.meas tran vdout0_32ck108 FIND v(dout0_32) AT=545.025n

* CHECK dout0_33 Vdout0_33ck108 = 0 time = 545
.meas tran vdout0_33ck108 FIND v(dout0_33) AT=545.025n

* CHECK dout0_34 Vdout0_34ck108 = 0.9 time = 545
.meas tran vdout0_34ck108 FIND v(dout0_34) AT=545.025n

* CHECK dout0_35 Vdout0_35ck108 = 0.9 time = 545
.meas tran vdout0_35ck108 FIND v(dout0_35) AT=545.025n

* CHECK dout0_36 Vdout0_36ck108 = 0.9 time = 545
.meas tran vdout0_36ck108 FIND v(dout0_36) AT=545.025n

* CHECK dout0_37 Vdout0_37ck108 = 0 time = 545
.meas tran vdout0_37ck108 FIND v(dout0_37) AT=545.025n

* CHECK dout0_38 Vdout0_38ck108 = 0 time = 545
.meas tran vdout0_38ck108 FIND v(dout0_38) AT=545.025n

* CHECK dout0_39 Vdout0_39ck108 = 0 time = 545
.meas tran vdout0_39ck108 FIND v(dout0_39) AT=545.025n

* CHECK dout0_40 Vdout0_40ck108 = 0 time = 545
.meas tran vdout0_40ck108 FIND v(dout0_40) AT=545.025n

* CHECK dout0_41 Vdout0_41ck108 = 0 time = 545
.meas tran vdout0_41ck108 FIND v(dout0_41) AT=545.025n

* CHECK dout0_42 Vdout0_42ck108 = 0.9 time = 545
.meas tran vdout0_42ck108 FIND v(dout0_42) AT=545.025n

* CHECK dout0_43 Vdout0_43ck108 = 0 time = 545
.meas tran vdout0_43ck108 FIND v(dout0_43) AT=545.025n

* CHECK dout0_44 Vdout0_44ck108 = 0 time = 545
.meas tran vdout0_44ck108 FIND v(dout0_44) AT=545.025n

* CHECK dout0_45 Vdout0_45ck108 = 0 time = 545
.meas tran vdout0_45ck108 FIND v(dout0_45) AT=545.025n

* CHECK dout0_46 Vdout0_46ck108 = 0.9 time = 545
.meas tran vdout0_46ck108 FIND v(dout0_46) AT=545.025n

* CHECK dout0_47 Vdout0_47ck108 = 0.9 time = 545
.meas tran vdout0_47ck108 FIND v(dout0_47) AT=545.025n

* CHECK dout0_48 Vdout0_48ck108 = 0 time = 545
.meas tran vdout0_48ck108 FIND v(dout0_48) AT=545.025n

* CHECK dout0_49 Vdout0_49ck108 = 0 time = 545
.meas tran vdout0_49ck108 FIND v(dout0_49) AT=545.025n

* CHECK dout0_50 Vdout0_50ck108 = 0.9 time = 545
.meas tran vdout0_50ck108 FIND v(dout0_50) AT=545.025n

* CHECK dout0_51 Vdout0_51ck108 = 0.9 time = 545
.meas tran vdout0_51ck108 FIND v(dout0_51) AT=545.025n

* CHECK dout0_52 Vdout0_52ck108 = 0.9 time = 545
.meas tran vdout0_52ck108 FIND v(dout0_52) AT=545.025n

* CHECK dout0_53 Vdout0_53ck108 = 0.9 time = 545
.meas tran vdout0_53ck108 FIND v(dout0_53) AT=545.025n

* CHECK dout0_54 Vdout0_54ck108 = 0 time = 545
.meas tran vdout0_54ck108 FIND v(dout0_54) AT=545.025n

* CHECK dout0_55 Vdout0_55ck108 = 0 time = 545
.meas tran vdout0_55ck108 FIND v(dout0_55) AT=545.025n

* CHECK dout0_56 Vdout0_56ck108 = 0 time = 545
.meas tran vdout0_56ck108 FIND v(dout0_56) AT=545.025n

* CHECK dout0_57 Vdout0_57ck108 = 0.9 time = 545
.meas tran vdout0_57ck108 FIND v(dout0_57) AT=545.025n

* CHECK dout0_58 Vdout0_58ck108 = 0 time = 545
.meas tran vdout0_58ck108 FIND v(dout0_58) AT=545.025n

* CHECK dout0_59 Vdout0_59ck108 = 0.9 time = 545
.meas tran vdout0_59ck108 FIND v(dout0_59) AT=545.025n

* CHECK dout0_60 Vdout0_60ck108 = 0 time = 545
.meas tran vdout0_60ck108 FIND v(dout0_60) AT=545.025n

* CHECK dout0_61 Vdout0_61ck108 = 0.9 time = 545
.meas tran vdout0_61ck108 FIND v(dout0_61) AT=545.025n

* CHECK dout0_62 Vdout0_62ck108 = 0.9 time = 545
.meas tran vdout0_62ck108 FIND v(dout0_62) AT=545.025n

* CHECK dout0_63 Vdout0_63ck108 = 0.9 time = 545
.meas tran vdout0_63ck108 FIND v(dout0_63) AT=545.025n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 590
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=590.025n

* CHECK dout0_1 Vdout0_1ck117 = 0.9 time = 590
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=590.025n

* CHECK dout0_2 Vdout0_2ck117 = 0 time = 590
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=590.025n

* CHECK dout0_3 Vdout0_3ck117 = 0 time = 590
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=590.025n

* CHECK dout0_4 Vdout0_4ck117 = 0.9 time = 590
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=590.025n

* CHECK dout0_5 Vdout0_5ck117 = 0.9 time = 590
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=590.025n

* CHECK dout0_6 Vdout0_6ck117 = 0.9 time = 590
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=590.025n

* CHECK dout0_7 Vdout0_7ck117 = 0.9 time = 590
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=590.025n

* CHECK dout0_8 Vdout0_8ck117 = 0 time = 590
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=590.025n

* CHECK dout0_9 Vdout0_9ck117 = 0.9 time = 590
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=590.025n

* CHECK dout0_10 Vdout0_10ck117 = 0 time = 590
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=590.025n

* CHECK dout0_11 Vdout0_11ck117 = 0 time = 590
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=590.025n

* CHECK dout0_12 Vdout0_12ck117 = 0 time = 590
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=590.025n

* CHECK dout0_13 Vdout0_13ck117 = 0 time = 590
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=590.025n

* CHECK dout0_14 Vdout0_14ck117 = 0.9 time = 590
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=590.025n

* CHECK dout0_15 Vdout0_15ck117 = 0 time = 590
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=590.025n

* CHECK dout0_16 Vdout0_16ck117 = 0.9 time = 590
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=590.025n

* CHECK dout0_17 Vdout0_17ck117 = 0 time = 590
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=590.025n

* CHECK dout0_18 Vdout0_18ck117 = 0 time = 590
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=590.025n

* CHECK dout0_19 Vdout0_19ck117 = 0 time = 590
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=590.025n

* CHECK dout0_20 Vdout0_20ck117 = 0 time = 590
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=590.025n

* CHECK dout0_21 Vdout0_21ck117 = 0 time = 590
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=590.025n

* CHECK dout0_22 Vdout0_22ck117 = 0 time = 590
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=590.025n

* CHECK dout0_23 Vdout0_23ck117 = 0.9 time = 590
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=590.025n

* CHECK dout0_24 Vdout0_24ck117 = 0 time = 590
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=590.025n

* CHECK dout0_25 Vdout0_25ck117 = 0.9 time = 590
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=590.025n

* CHECK dout0_26 Vdout0_26ck117 = 0 time = 590
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=590.025n

* CHECK dout0_27 Vdout0_27ck117 = 0.9 time = 590
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=590.025n

* CHECK dout0_28 Vdout0_28ck117 = 0.9 time = 590
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=590.025n

* CHECK dout0_29 Vdout0_29ck117 = 0 time = 590
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=590.025n

* CHECK dout0_30 Vdout0_30ck117 = 0 time = 590
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=590.025n

* CHECK dout0_31 Vdout0_31ck117 = 0.9 time = 590
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=590.025n

* CHECK dout0_32 Vdout0_32ck117 = 0.9 time = 590
.meas tran vdout0_32ck117 FIND v(dout0_32) AT=590.025n

* CHECK dout0_33 Vdout0_33ck117 = 0.9 time = 590
.meas tran vdout0_33ck117 FIND v(dout0_33) AT=590.025n

* CHECK dout0_34 Vdout0_34ck117 = 0.9 time = 590
.meas tran vdout0_34ck117 FIND v(dout0_34) AT=590.025n

* CHECK dout0_35 Vdout0_35ck117 = 0 time = 590
.meas tran vdout0_35ck117 FIND v(dout0_35) AT=590.025n

* CHECK dout0_36 Vdout0_36ck117 = 0 time = 590
.meas tran vdout0_36ck117 FIND v(dout0_36) AT=590.025n

* CHECK dout0_37 Vdout0_37ck117 = 0.9 time = 590
.meas tran vdout0_37ck117 FIND v(dout0_37) AT=590.025n

* CHECK dout0_38 Vdout0_38ck117 = 0 time = 590
.meas tran vdout0_38ck117 FIND v(dout0_38) AT=590.025n

* CHECK dout0_39 Vdout0_39ck117 = 0.9 time = 590
.meas tran vdout0_39ck117 FIND v(dout0_39) AT=590.025n

* CHECK dout0_40 Vdout0_40ck117 = 0 time = 590
.meas tran vdout0_40ck117 FIND v(dout0_40) AT=590.025n

* CHECK dout0_41 Vdout0_41ck117 = 0 time = 590
.meas tran vdout0_41ck117 FIND v(dout0_41) AT=590.025n

* CHECK dout0_42 Vdout0_42ck117 = 0 time = 590
.meas tran vdout0_42ck117 FIND v(dout0_42) AT=590.025n

* CHECK dout0_43 Vdout0_43ck117 = 0.9 time = 590
.meas tran vdout0_43ck117 FIND v(dout0_43) AT=590.025n

* CHECK dout0_44 Vdout0_44ck117 = 0.9 time = 590
.meas tran vdout0_44ck117 FIND v(dout0_44) AT=590.025n

* CHECK dout0_45 Vdout0_45ck117 = 0.9 time = 590
.meas tran vdout0_45ck117 FIND v(dout0_45) AT=590.025n

* CHECK dout0_46 Vdout0_46ck117 = 0.9 time = 590
.meas tran vdout0_46ck117 FIND v(dout0_46) AT=590.025n

* CHECK dout0_47 Vdout0_47ck117 = 0 time = 590
.meas tran vdout0_47ck117 FIND v(dout0_47) AT=590.025n

* CHECK dout0_48 Vdout0_48ck117 = 0 time = 590
.meas tran vdout0_48ck117 FIND v(dout0_48) AT=590.025n

* CHECK dout0_49 Vdout0_49ck117 = 0 time = 590
.meas tran vdout0_49ck117 FIND v(dout0_49) AT=590.025n

* CHECK dout0_50 Vdout0_50ck117 = 0 time = 590
.meas tran vdout0_50ck117 FIND v(dout0_50) AT=590.025n

* CHECK dout0_51 Vdout0_51ck117 = 0.9 time = 590
.meas tran vdout0_51ck117 FIND v(dout0_51) AT=590.025n

* CHECK dout0_52 Vdout0_52ck117 = 0.9 time = 590
.meas tran vdout0_52ck117 FIND v(dout0_52) AT=590.025n

* CHECK dout0_53 Vdout0_53ck117 = 0.9 time = 590
.meas tran vdout0_53ck117 FIND v(dout0_53) AT=590.025n

* CHECK dout0_54 Vdout0_54ck117 = 0.9 time = 590
.meas tran vdout0_54ck117 FIND v(dout0_54) AT=590.025n

* CHECK dout0_55 Vdout0_55ck117 = 0.9 time = 590
.meas tran vdout0_55ck117 FIND v(dout0_55) AT=590.025n

* CHECK dout0_56 Vdout0_56ck117 = 0.9 time = 590
.meas tran vdout0_56ck117 FIND v(dout0_56) AT=590.025n

* CHECK dout0_57 Vdout0_57ck117 = 0 time = 590
.meas tran vdout0_57ck117 FIND v(dout0_57) AT=590.025n

* CHECK dout0_58 Vdout0_58ck117 = 0.9 time = 590
.meas tran vdout0_58ck117 FIND v(dout0_58) AT=590.025n

* CHECK dout0_59 Vdout0_59ck117 = 0.9 time = 590
.meas tran vdout0_59ck117 FIND v(dout0_59) AT=590.025n

* CHECK dout0_60 Vdout0_60ck117 = 0.9 time = 590
.meas tran vdout0_60ck117 FIND v(dout0_60) AT=590.025n

* CHECK dout0_61 Vdout0_61ck117 = 0 time = 590
.meas tran vdout0_61ck117 FIND v(dout0_61) AT=590.025n

* CHECK dout0_62 Vdout0_62ck117 = 0 time = 590
.meas tran vdout0_62ck117 FIND v(dout0_62) AT=590.025n

* CHECK dout0_63 Vdout0_63ck117 = 0 time = 590
.meas tran vdout0_63ck117 FIND v(dout0_63) AT=590.025n

* CHECK dout0_0 Vdout0_0ck119 = 0.9 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0.9 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0.9 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 0.9 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0.9 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0.9 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0.9 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0.9 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0.9 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 0.9 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 0 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0.9 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0.9 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 0.9 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0.9 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0.9 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0.9 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 0.9 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0.9 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0.9 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 600
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=600.025n

* CHECK dout0_33 Vdout0_33ck119 = 0 time = 600
.meas tran vdout0_33ck119 FIND v(dout0_33) AT=600.025n

* CHECK dout0_34 Vdout0_34ck119 = 0 time = 600
.meas tran vdout0_34ck119 FIND v(dout0_34) AT=600.025n

* CHECK dout0_35 Vdout0_35ck119 = 0 time = 600
.meas tran vdout0_35ck119 FIND v(dout0_35) AT=600.025n

* CHECK dout0_36 Vdout0_36ck119 = 0.9 time = 600
.meas tran vdout0_36ck119 FIND v(dout0_36) AT=600.025n

* CHECK dout0_37 Vdout0_37ck119 = 0.9 time = 600
.meas tran vdout0_37ck119 FIND v(dout0_37) AT=600.025n

* CHECK dout0_38 Vdout0_38ck119 = 0 time = 600
.meas tran vdout0_38ck119 FIND v(dout0_38) AT=600.025n

* CHECK dout0_39 Vdout0_39ck119 = 0 time = 600
.meas tran vdout0_39ck119 FIND v(dout0_39) AT=600.025n

* CHECK dout0_40 Vdout0_40ck119 = 0 time = 600
.meas tran vdout0_40ck119 FIND v(dout0_40) AT=600.025n

* CHECK dout0_41 Vdout0_41ck119 = 0 time = 600
.meas tran vdout0_41ck119 FIND v(dout0_41) AT=600.025n

* CHECK dout0_42 Vdout0_42ck119 = 0 time = 600
.meas tran vdout0_42ck119 FIND v(dout0_42) AT=600.025n

* CHECK dout0_43 Vdout0_43ck119 = 0.9 time = 600
.meas tran vdout0_43ck119 FIND v(dout0_43) AT=600.025n

* CHECK dout0_44 Vdout0_44ck119 = 0 time = 600
.meas tran vdout0_44ck119 FIND v(dout0_44) AT=600.025n

* CHECK dout0_45 Vdout0_45ck119 = 0 time = 600
.meas tran vdout0_45ck119 FIND v(dout0_45) AT=600.025n

* CHECK dout0_46 Vdout0_46ck119 = 0 time = 600
.meas tran vdout0_46ck119 FIND v(dout0_46) AT=600.025n

* CHECK dout0_47 Vdout0_47ck119 = 0.9 time = 600
.meas tran vdout0_47ck119 FIND v(dout0_47) AT=600.025n

* CHECK dout0_48 Vdout0_48ck119 = 0 time = 600
.meas tran vdout0_48ck119 FIND v(dout0_48) AT=600.025n

* CHECK dout0_49 Vdout0_49ck119 = 0.9 time = 600
.meas tran vdout0_49ck119 FIND v(dout0_49) AT=600.025n

* CHECK dout0_50 Vdout0_50ck119 = 0 time = 600
.meas tran vdout0_50ck119 FIND v(dout0_50) AT=600.025n

* CHECK dout0_51 Vdout0_51ck119 = 0.9 time = 600
.meas tran vdout0_51ck119 FIND v(dout0_51) AT=600.025n

* CHECK dout0_52 Vdout0_52ck119 = 0 time = 600
.meas tran vdout0_52ck119 FIND v(dout0_52) AT=600.025n

* CHECK dout0_53 Vdout0_53ck119 = 0.9 time = 600
.meas tran vdout0_53ck119 FIND v(dout0_53) AT=600.025n

* CHECK dout0_54 Vdout0_54ck119 = 0 time = 600
.meas tran vdout0_54ck119 FIND v(dout0_54) AT=600.025n

* CHECK dout0_55 Vdout0_55ck119 = 0 time = 600
.meas tran vdout0_55ck119 FIND v(dout0_55) AT=600.025n

* CHECK dout0_56 Vdout0_56ck119 = 0 time = 600
.meas tran vdout0_56ck119 FIND v(dout0_56) AT=600.025n

* CHECK dout0_57 Vdout0_57ck119 = 0 time = 600
.meas tran vdout0_57ck119 FIND v(dout0_57) AT=600.025n

* CHECK dout0_58 Vdout0_58ck119 = 0.9 time = 600
.meas tran vdout0_58ck119 FIND v(dout0_58) AT=600.025n

* CHECK dout0_59 Vdout0_59ck119 = 0.9 time = 600
.meas tran vdout0_59ck119 FIND v(dout0_59) AT=600.025n

* CHECK dout0_60 Vdout0_60ck119 = 0.9 time = 600
.meas tran vdout0_60ck119 FIND v(dout0_60) AT=600.025n

* CHECK dout0_61 Vdout0_61ck119 = 0 time = 600
.meas tran vdout0_61ck119 FIND v(dout0_61) AT=600.025n

* CHECK dout0_62 Vdout0_62ck119 = 0 time = 600
.meas tran vdout0_62ck119 FIND v(dout0_62) AT=600.025n

* CHECK dout0_63 Vdout0_63ck119 = 0.9 time = 600
.meas tran vdout0_63ck119 FIND v(dout0_63) AT=600.025n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 605
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=605.025n

* CHECK dout0_1 Vdout0_1ck120 = 0.9 time = 605
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=605.025n

* CHECK dout0_2 Vdout0_2ck120 = 0 time = 605
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=605.025n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 605
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=605.025n

* CHECK dout0_4 Vdout0_4ck120 = 0.9 time = 605
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=605.025n

* CHECK dout0_5 Vdout0_5ck120 = 0.9 time = 605
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=605.025n

* CHECK dout0_6 Vdout0_6ck120 = 0.9 time = 605
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=605.025n

* CHECK dout0_7 Vdout0_7ck120 = 0.9 time = 605
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=605.025n

* CHECK dout0_8 Vdout0_8ck120 = 0 time = 605
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=605.025n

* CHECK dout0_9 Vdout0_9ck120 = 0.9 time = 605
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=605.025n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 605
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=605.025n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 605
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=605.025n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 605
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=605.025n

* CHECK dout0_13 Vdout0_13ck120 = 0 time = 605
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=605.025n

* CHECK dout0_14 Vdout0_14ck120 = 0.9 time = 605
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=605.025n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 605
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=605.025n

* CHECK dout0_16 Vdout0_16ck120 = 0.9 time = 605
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=605.025n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 605
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=605.025n

* CHECK dout0_18 Vdout0_18ck120 = 0 time = 605
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=605.025n

* CHECK dout0_19 Vdout0_19ck120 = 0 time = 605
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=605.025n

* CHECK dout0_20 Vdout0_20ck120 = 0 time = 605
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=605.025n

* CHECK dout0_21 Vdout0_21ck120 = 0 time = 605
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=605.025n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 605
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=605.025n

* CHECK dout0_23 Vdout0_23ck120 = 0.9 time = 605
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=605.025n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 605
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=605.025n

* CHECK dout0_25 Vdout0_25ck120 = 0.9 time = 605
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=605.025n

* CHECK dout0_26 Vdout0_26ck120 = 0 time = 605
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=605.025n

* CHECK dout0_27 Vdout0_27ck120 = 0.9 time = 605
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=605.025n

* CHECK dout0_28 Vdout0_28ck120 = 0.9 time = 605
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=605.025n

* CHECK dout0_29 Vdout0_29ck120 = 0 time = 605
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=605.025n

* CHECK dout0_30 Vdout0_30ck120 = 0 time = 605
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=605.025n

* CHECK dout0_31 Vdout0_31ck120 = 0.9 time = 605
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=605.025n

* CHECK dout0_32 Vdout0_32ck120 = 0.9 time = 605
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=605.025n

* CHECK dout0_33 Vdout0_33ck120 = 0.9 time = 605
.meas tran vdout0_33ck120 FIND v(dout0_33) AT=605.025n

* CHECK dout0_34 Vdout0_34ck120 = 0.9 time = 605
.meas tran vdout0_34ck120 FIND v(dout0_34) AT=605.025n

* CHECK dout0_35 Vdout0_35ck120 = 0 time = 605
.meas tran vdout0_35ck120 FIND v(dout0_35) AT=605.025n

* CHECK dout0_36 Vdout0_36ck120 = 0 time = 605
.meas tran vdout0_36ck120 FIND v(dout0_36) AT=605.025n

* CHECK dout0_37 Vdout0_37ck120 = 0.9 time = 605
.meas tran vdout0_37ck120 FIND v(dout0_37) AT=605.025n

* CHECK dout0_38 Vdout0_38ck120 = 0 time = 605
.meas tran vdout0_38ck120 FIND v(dout0_38) AT=605.025n

* CHECK dout0_39 Vdout0_39ck120 = 0.9 time = 605
.meas tran vdout0_39ck120 FIND v(dout0_39) AT=605.025n

* CHECK dout0_40 Vdout0_40ck120 = 0 time = 605
.meas tran vdout0_40ck120 FIND v(dout0_40) AT=605.025n

* CHECK dout0_41 Vdout0_41ck120 = 0 time = 605
.meas tran vdout0_41ck120 FIND v(dout0_41) AT=605.025n

* CHECK dout0_42 Vdout0_42ck120 = 0 time = 605
.meas tran vdout0_42ck120 FIND v(dout0_42) AT=605.025n

* CHECK dout0_43 Vdout0_43ck120 = 0.9 time = 605
.meas tran vdout0_43ck120 FIND v(dout0_43) AT=605.025n

* CHECK dout0_44 Vdout0_44ck120 = 0.9 time = 605
.meas tran vdout0_44ck120 FIND v(dout0_44) AT=605.025n

* CHECK dout0_45 Vdout0_45ck120 = 0.9 time = 605
.meas tran vdout0_45ck120 FIND v(dout0_45) AT=605.025n

* CHECK dout0_46 Vdout0_46ck120 = 0.9 time = 605
.meas tran vdout0_46ck120 FIND v(dout0_46) AT=605.025n

* CHECK dout0_47 Vdout0_47ck120 = 0 time = 605
.meas tran vdout0_47ck120 FIND v(dout0_47) AT=605.025n

* CHECK dout0_48 Vdout0_48ck120 = 0 time = 605
.meas tran vdout0_48ck120 FIND v(dout0_48) AT=605.025n

* CHECK dout0_49 Vdout0_49ck120 = 0 time = 605
.meas tran vdout0_49ck120 FIND v(dout0_49) AT=605.025n

* CHECK dout0_50 Vdout0_50ck120 = 0 time = 605
.meas tran vdout0_50ck120 FIND v(dout0_50) AT=605.025n

* CHECK dout0_51 Vdout0_51ck120 = 0.9 time = 605
.meas tran vdout0_51ck120 FIND v(dout0_51) AT=605.025n

* CHECK dout0_52 Vdout0_52ck120 = 0.9 time = 605
.meas tran vdout0_52ck120 FIND v(dout0_52) AT=605.025n

* CHECK dout0_53 Vdout0_53ck120 = 0.9 time = 605
.meas tran vdout0_53ck120 FIND v(dout0_53) AT=605.025n

* CHECK dout0_54 Vdout0_54ck120 = 0.9 time = 605
.meas tran vdout0_54ck120 FIND v(dout0_54) AT=605.025n

* CHECK dout0_55 Vdout0_55ck120 = 0.9 time = 605
.meas tran vdout0_55ck120 FIND v(dout0_55) AT=605.025n

* CHECK dout0_56 Vdout0_56ck120 = 0.9 time = 605
.meas tran vdout0_56ck120 FIND v(dout0_56) AT=605.025n

* CHECK dout0_57 Vdout0_57ck120 = 0 time = 605
.meas tran vdout0_57ck120 FIND v(dout0_57) AT=605.025n

* CHECK dout0_58 Vdout0_58ck120 = 0.9 time = 605
.meas tran vdout0_58ck120 FIND v(dout0_58) AT=605.025n

* CHECK dout0_59 Vdout0_59ck120 = 0.9 time = 605
.meas tran vdout0_59ck120 FIND v(dout0_59) AT=605.025n

* CHECK dout0_60 Vdout0_60ck120 = 0.9 time = 605
.meas tran vdout0_60ck120 FIND v(dout0_60) AT=605.025n

* CHECK dout0_61 Vdout0_61ck120 = 0 time = 605
.meas tran vdout0_61ck120 FIND v(dout0_61) AT=605.025n

* CHECK dout0_62 Vdout0_62ck120 = 0 time = 605
.meas tran vdout0_62ck120 FIND v(dout0_62) AT=605.025n

* CHECK dout0_63 Vdout0_63ck120 = 0 time = 605
.meas tran vdout0_63ck120 FIND v(dout0_63) AT=605.025n

* CHECK dout0_0 Vdout0_0ck121 = 0.9 time = 610
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=610.025n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 610
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=610.025n

* CHECK dout0_2 Vdout0_2ck121 = 0 time = 610
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=610.025n

* CHECK dout0_3 Vdout0_3ck121 = 0.9 time = 610
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=610.025n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 610
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=610.025n

* CHECK dout0_5 Vdout0_5ck121 = 0.9 time = 610
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=610.025n

* CHECK dout0_6 Vdout0_6ck121 = 0.9 time = 610
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=610.025n

* CHECK dout0_7 Vdout0_7ck121 = 0.9 time = 610
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=610.025n

* CHECK dout0_8 Vdout0_8ck121 = 0.9 time = 610
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=610.025n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 610
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=610.025n

* CHECK dout0_10 Vdout0_10ck121 = 0 time = 610
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=610.025n

* CHECK dout0_11 Vdout0_11ck121 = 0.9 time = 610
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=610.025n

* CHECK dout0_12 Vdout0_12ck121 = 0.9 time = 610
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=610.025n

* CHECK dout0_13 Vdout0_13ck121 = 0.9 time = 610
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=610.025n

* CHECK dout0_14 Vdout0_14ck121 = 0 time = 610
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=610.025n

* CHECK dout0_15 Vdout0_15ck121 = 0.9 time = 610
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=610.025n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 610
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=610.025n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 610
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=610.025n

* CHECK dout0_18 Vdout0_18ck121 = 0.9 time = 610
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=610.025n

* CHECK dout0_19 Vdout0_19ck121 = 0.9 time = 610
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=610.025n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 610
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=610.025n

* CHECK dout0_21 Vdout0_21ck121 = 0 time = 610
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=610.025n

* CHECK dout0_22 Vdout0_22ck121 = 0.9 time = 610
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=610.025n

* CHECK dout0_23 Vdout0_23ck121 = 0.9 time = 610
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=610.025n

* CHECK dout0_24 Vdout0_24ck121 = 0 time = 610
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=610.025n

* CHECK dout0_25 Vdout0_25ck121 = 0.9 time = 610
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=610.025n

* CHECK dout0_26 Vdout0_26ck121 = 0.9 time = 610
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=610.025n

* CHECK dout0_27 Vdout0_27ck121 = 0.9 time = 610
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=610.025n

* CHECK dout0_28 Vdout0_28ck121 = 0 time = 610
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=610.025n

* CHECK dout0_29 Vdout0_29ck121 = 0.9 time = 610
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=610.025n

* CHECK dout0_30 Vdout0_30ck121 = 0 time = 610
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=610.025n

* CHECK dout0_31 Vdout0_31ck121 = 0.9 time = 610
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=610.025n

* CHECK dout0_32 Vdout0_32ck121 = 0 time = 610
.meas tran vdout0_32ck121 FIND v(dout0_32) AT=610.025n

* CHECK dout0_33 Vdout0_33ck121 = 0 time = 610
.meas tran vdout0_33ck121 FIND v(dout0_33) AT=610.025n

* CHECK dout0_34 Vdout0_34ck121 = 0 time = 610
.meas tran vdout0_34ck121 FIND v(dout0_34) AT=610.025n

* CHECK dout0_35 Vdout0_35ck121 = 0 time = 610
.meas tran vdout0_35ck121 FIND v(dout0_35) AT=610.025n

* CHECK dout0_36 Vdout0_36ck121 = 0.9 time = 610
.meas tran vdout0_36ck121 FIND v(dout0_36) AT=610.025n

* CHECK dout0_37 Vdout0_37ck121 = 0.9 time = 610
.meas tran vdout0_37ck121 FIND v(dout0_37) AT=610.025n

* CHECK dout0_38 Vdout0_38ck121 = 0 time = 610
.meas tran vdout0_38ck121 FIND v(dout0_38) AT=610.025n

* CHECK dout0_39 Vdout0_39ck121 = 0 time = 610
.meas tran vdout0_39ck121 FIND v(dout0_39) AT=610.025n

* CHECK dout0_40 Vdout0_40ck121 = 0 time = 610
.meas tran vdout0_40ck121 FIND v(dout0_40) AT=610.025n

* CHECK dout0_41 Vdout0_41ck121 = 0 time = 610
.meas tran vdout0_41ck121 FIND v(dout0_41) AT=610.025n

* CHECK dout0_42 Vdout0_42ck121 = 0 time = 610
.meas tran vdout0_42ck121 FIND v(dout0_42) AT=610.025n

* CHECK dout0_43 Vdout0_43ck121 = 0.9 time = 610
.meas tran vdout0_43ck121 FIND v(dout0_43) AT=610.025n

* CHECK dout0_44 Vdout0_44ck121 = 0 time = 610
.meas tran vdout0_44ck121 FIND v(dout0_44) AT=610.025n

* CHECK dout0_45 Vdout0_45ck121 = 0 time = 610
.meas tran vdout0_45ck121 FIND v(dout0_45) AT=610.025n

* CHECK dout0_46 Vdout0_46ck121 = 0 time = 610
.meas tran vdout0_46ck121 FIND v(dout0_46) AT=610.025n

* CHECK dout0_47 Vdout0_47ck121 = 0.9 time = 610
.meas tran vdout0_47ck121 FIND v(dout0_47) AT=610.025n

* CHECK dout0_48 Vdout0_48ck121 = 0 time = 610
.meas tran vdout0_48ck121 FIND v(dout0_48) AT=610.025n

* CHECK dout0_49 Vdout0_49ck121 = 0.9 time = 610
.meas tran vdout0_49ck121 FIND v(dout0_49) AT=610.025n

* CHECK dout0_50 Vdout0_50ck121 = 0 time = 610
.meas tran vdout0_50ck121 FIND v(dout0_50) AT=610.025n

* CHECK dout0_51 Vdout0_51ck121 = 0.9 time = 610
.meas tran vdout0_51ck121 FIND v(dout0_51) AT=610.025n

* CHECK dout0_52 Vdout0_52ck121 = 0 time = 610
.meas tran vdout0_52ck121 FIND v(dout0_52) AT=610.025n

* CHECK dout0_53 Vdout0_53ck121 = 0.9 time = 610
.meas tran vdout0_53ck121 FIND v(dout0_53) AT=610.025n

* CHECK dout0_54 Vdout0_54ck121 = 0 time = 610
.meas tran vdout0_54ck121 FIND v(dout0_54) AT=610.025n

* CHECK dout0_55 Vdout0_55ck121 = 0 time = 610
.meas tran vdout0_55ck121 FIND v(dout0_55) AT=610.025n

* CHECK dout0_56 Vdout0_56ck121 = 0 time = 610
.meas tran vdout0_56ck121 FIND v(dout0_56) AT=610.025n

* CHECK dout0_57 Vdout0_57ck121 = 0 time = 610
.meas tran vdout0_57ck121 FIND v(dout0_57) AT=610.025n

* CHECK dout0_58 Vdout0_58ck121 = 0.9 time = 610
.meas tran vdout0_58ck121 FIND v(dout0_58) AT=610.025n

* CHECK dout0_59 Vdout0_59ck121 = 0.9 time = 610
.meas tran vdout0_59ck121 FIND v(dout0_59) AT=610.025n

* CHECK dout0_60 Vdout0_60ck121 = 0.9 time = 610
.meas tran vdout0_60ck121 FIND v(dout0_60) AT=610.025n

* CHECK dout0_61 Vdout0_61ck121 = 0 time = 610
.meas tran vdout0_61ck121 FIND v(dout0_61) AT=610.025n

* CHECK dout0_62 Vdout0_62ck121 = 0 time = 610
.meas tran vdout0_62ck121 FIND v(dout0_62) AT=610.025n

* CHECK dout0_63 Vdout0_63ck121 = 0.9 time = 610
.meas tran vdout0_63ck121 FIND v(dout0_63) AT=610.025n

* CHECK dout0_0 Vdout0_0ck122 = 0.9 time = 615
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=615.025n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 615
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=615.025n

* CHECK dout0_2 Vdout0_2ck122 = 0 time = 615
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=615.025n

* CHECK dout0_3 Vdout0_3ck122 = 0.9 time = 615
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=615.025n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 615
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=615.025n

* CHECK dout0_5 Vdout0_5ck122 = 0.9 time = 615
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=615.025n

* CHECK dout0_6 Vdout0_6ck122 = 0.9 time = 615
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=615.025n

* CHECK dout0_7 Vdout0_7ck122 = 0.9 time = 615
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=615.025n

* CHECK dout0_8 Vdout0_8ck122 = 0.9 time = 615
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=615.025n

* CHECK dout0_9 Vdout0_9ck122 = 0 time = 615
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=615.025n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 615
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=615.025n

* CHECK dout0_11 Vdout0_11ck122 = 0.9 time = 615
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=615.025n

* CHECK dout0_12 Vdout0_12ck122 = 0.9 time = 615
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=615.025n

* CHECK dout0_13 Vdout0_13ck122 = 0.9 time = 615
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=615.025n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 615
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=615.025n

* CHECK dout0_15 Vdout0_15ck122 = 0.9 time = 615
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=615.025n

* CHECK dout0_16 Vdout0_16ck122 = 0 time = 615
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=615.025n

* CHECK dout0_17 Vdout0_17ck122 = 0 time = 615
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=615.025n

* CHECK dout0_18 Vdout0_18ck122 = 0.9 time = 615
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=615.025n

* CHECK dout0_19 Vdout0_19ck122 = 0.9 time = 615
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=615.025n

* CHECK dout0_20 Vdout0_20ck122 = 0 time = 615
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=615.025n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 615
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=615.025n

* CHECK dout0_22 Vdout0_22ck122 = 0.9 time = 615
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=615.025n

* CHECK dout0_23 Vdout0_23ck122 = 0.9 time = 615
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=615.025n

* CHECK dout0_24 Vdout0_24ck122 = 0 time = 615
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=615.025n

* CHECK dout0_25 Vdout0_25ck122 = 0.9 time = 615
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=615.025n

* CHECK dout0_26 Vdout0_26ck122 = 0.9 time = 615
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=615.025n

* CHECK dout0_27 Vdout0_27ck122 = 0.9 time = 615
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=615.025n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 615
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=615.025n

* CHECK dout0_29 Vdout0_29ck122 = 0.9 time = 615
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=615.025n

* CHECK dout0_30 Vdout0_30ck122 = 0 time = 615
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=615.025n

* CHECK dout0_31 Vdout0_31ck122 = 0.9 time = 615
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=615.025n

* CHECK dout0_32 Vdout0_32ck122 = 0 time = 615
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=615.025n

* CHECK dout0_33 Vdout0_33ck122 = 0 time = 615
.meas tran vdout0_33ck122 FIND v(dout0_33) AT=615.025n

* CHECK dout0_34 Vdout0_34ck122 = 0 time = 615
.meas tran vdout0_34ck122 FIND v(dout0_34) AT=615.025n

* CHECK dout0_35 Vdout0_35ck122 = 0 time = 615
.meas tran vdout0_35ck122 FIND v(dout0_35) AT=615.025n

* CHECK dout0_36 Vdout0_36ck122 = 0.9 time = 615
.meas tran vdout0_36ck122 FIND v(dout0_36) AT=615.025n

* CHECK dout0_37 Vdout0_37ck122 = 0.9 time = 615
.meas tran vdout0_37ck122 FIND v(dout0_37) AT=615.025n

* CHECK dout0_38 Vdout0_38ck122 = 0 time = 615
.meas tran vdout0_38ck122 FIND v(dout0_38) AT=615.025n

* CHECK dout0_39 Vdout0_39ck122 = 0 time = 615
.meas tran vdout0_39ck122 FIND v(dout0_39) AT=615.025n

* CHECK dout0_40 Vdout0_40ck122 = 0 time = 615
.meas tran vdout0_40ck122 FIND v(dout0_40) AT=615.025n

* CHECK dout0_41 Vdout0_41ck122 = 0 time = 615
.meas tran vdout0_41ck122 FIND v(dout0_41) AT=615.025n

* CHECK dout0_42 Vdout0_42ck122 = 0 time = 615
.meas tran vdout0_42ck122 FIND v(dout0_42) AT=615.025n

* CHECK dout0_43 Vdout0_43ck122 = 0.9 time = 615
.meas tran vdout0_43ck122 FIND v(dout0_43) AT=615.025n

* CHECK dout0_44 Vdout0_44ck122 = 0 time = 615
.meas tran vdout0_44ck122 FIND v(dout0_44) AT=615.025n

* CHECK dout0_45 Vdout0_45ck122 = 0 time = 615
.meas tran vdout0_45ck122 FIND v(dout0_45) AT=615.025n

* CHECK dout0_46 Vdout0_46ck122 = 0 time = 615
.meas tran vdout0_46ck122 FIND v(dout0_46) AT=615.025n

* CHECK dout0_47 Vdout0_47ck122 = 0.9 time = 615
.meas tran vdout0_47ck122 FIND v(dout0_47) AT=615.025n

* CHECK dout0_48 Vdout0_48ck122 = 0 time = 615
.meas tran vdout0_48ck122 FIND v(dout0_48) AT=615.025n

* CHECK dout0_49 Vdout0_49ck122 = 0.9 time = 615
.meas tran vdout0_49ck122 FIND v(dout0_49) AT=615.025n

* CHECK dout0_50 Vdout0_50ck122 = 0 time = 615
.meas tran vdout0_50ck122 FIND v(dout0_50) AT=615.025n

* CHECK dout0_51 Vdout0_51ck122 = 0.9 time = 615
.meas tran vdout0_51ck122 FIND v(dout0_51) AT=615.025n

* CHECK dout0_52 Vdout0_52ck122 = 0 time = 615
.meas tran vdout0_52ck122 FIND v(dout0_52) AT=615.025n

* CHECK dout0_53 Vdout0_53ck122 = 0.9 time = 615
.meas tran vdout0_53ck122 FIND v(dout0_53) AT=615.025n

* CHECK dout0_54 Vdout0_54ck122 = 0 time = 615
.meas tran vdout0_54ck122 FIND v(dout0_54) AT=615.025n

* CHECK dout0_55 Vdout0_55ck122 = 0 time = 615
.meas tran vdout0_55ck122 FIND v(dout0_55) AT=615.025n

* CHECK dout0_56 Vdout0_56ck122 = 0 time = 615
.meas tran vdout0_56ck122 FIND v(dout0_56) AT=615.025n

* CHECK dout0_57 Vdout0_57ck122 = 0 time = 615
.meas tran vdout0_57ck122 FIND v(dout0_57) AT=615.025n

* CHECK dout0_58 Vdout0_58ck122 = 0.9 time = 615
.meas tran vdout0_58ck122 FIND v(dout0_58) AT=615.025n

* CHECK dout0_59 Vdout0_59ck122 = 0.9 time = 615
.meas tran vdout0_59ck122 FIND v(dout0_59) AT=615.025n

* CHECK dout0_60 Vdout0_60ck122 = 0.9 time = 615
.meas tran vdout0_60ck122 FIND v(dout0_60) AT=615.025n

* CHECK dout0_61 Vdout0_61ck122 = 0 time = 615
.meas tran vdout0_61ck122 FIND v(dout0_61) AT=615.025n

* CHECK dout0_62 Vdout0_62ck122 = 0 time = 615
.meas tran vdout0_62ck122 FIND v(dout0_62) AT=615.025n

* CHECK dout0_63 Vdout0_63ck122 = 0.9 time = 615
.meas tran vdout0_63ck122 FIND v(dout0_63) AT=615.025n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 635
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=635.025n

* CHECK dout0_1 Vdout0_1ck126 = 0.9 time = 635
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=635.025n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 635
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=635.025n

* CHECK dout0_3 Vdout0_3ck126 = 0 time = 635
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=635.025n

* CHECK dout0_4 Vdout0_4ck126 = 0.9 time = 635
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=635.025n

* CHECK dout0_5 Vdout0_5ck126 = 0.9 time = 635
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=635.025n

* CHECK dout0_6 Vdout0_6ck126 = 0.9 time = 635
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=635.025n

* CHECK dout0_7 Vdout0_7ck126 = 0.9 time = 635
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=635.025n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 635
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=635.025n

* CHECK dout0_9 Vdout0_9ck126 = 0.9 time = 635
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=635.025n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 635
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=635.025n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 635
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=635.025n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 635
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=635.025n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 635
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=635.025n

* CHECK dout0_14 Vdout0_14ck126 = 0.9 time = 635
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=635.025n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 635
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=635.025n

* CHECK dout0_16 Vdout0_16ck126 = 0.9 time = 635
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=635.025n

* CHECK dout0_17 Vdout0_17ck126 = 0 time = 635
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=635.025n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 635
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=635.025n

* CHECK dout0_19 Vdout0_19ck126 = 0 time = 635
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=635.025n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 635
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=635.025n

* CHECK dout0_21 Vdout0_21ck126 = 0 time = 635
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=635.025n

* CHECK dout0_22 Vdout0_22ck126 = 0 time = 635
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=635.025n

* CHECK dout0_23 Vdout0_23ck126 = 0.9 time = 635
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=635.025n

* CHECK dout0_24 Vdout0_24ck126 = 0 time = 635
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=635.025n

* CHECK dout0_25 Vdout0_25ck126 = 0.9 time = 635
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=635.025n

* CHECK dout0_26 Vdout0_26ck126 = 0 time = 635
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=635.025n

* CHECK dout0_27 Vdout0_27ck126 = 0.9 time = 635
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=635.025n

* CHECK dout0_28 Vdout0_28ck126 = 0.9 time = 635
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=635.025n

* CHECK dout0_29 Vdout0_29ck126 = 0 time = 635
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=635.025n

* CHECK dout0_30 Vdout0_30ck126 = 0 time = 635
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=635.025n

* CHECK dout0_31 Vdout0_31ck126 = 0.9 time = 635
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=635.025n

* CHECK dout0_32 Vdout0_32ck126 = 0.9 time = 635
.meas tran vdout0_32ck126 FIND v(dout0_32) AT=635.025n

* CHECK dout0_33 Vdout0_33ck126 = 0.9 time = 635
.meas tran vdout0_33ck126 FIND v(dout0_33) AT=635.025n

* CHECK dout0_34 Vdout0_34ck126 = 0.9 time = 635
.meas tran vdout0_34ck126 FIND v(dout0_34) AT=635.025n

* CHECK dout0_35 Vdout0_35ck126 = 0 time = 635
.meas tran vdout0_35ck126 FIND v(dout0_35) AT=635.025n

* CHECK dout0_36 Vdout0_36ck126 = 0 time = 635
.meas tran vdout0_36ck126 FIND v(dout0_36) AT=635.025n

* CHECK dout0_37 Vdout0_37ck126 = 0.9 time = 635
.meas tran vdout0_37ck126 FIND v(dout0_37) AT=635.025n

* CHECK dout0_38 Vdout0_38ck126 = 0 time = 635
.meas tran vdout0_38ck126 FIND v(dout0_38) AT=635.025n

* CHECK dout0_39 Vdout0_39ck126 = 0.9 time = 635
.meas tran vdout0_39ck126 FIND v(dout0_39) AT=635.025n

* CHECK dout0_40 Vdout0_40ck126 = 0 time = 635
.meas tran vdout0_40ck126 FIND v(dout0_40) AT=635.025n

* CHECK dout0_41 Vdout0_41ck126 = 0 time = 635
.meas tran vdout0_41ck126 FIND v(dout0_41) AT=635.025n

* CHECK dout0_42 Vdout0_42ck126 = 0 time = 635
.meas tran vdout0_42ck126 FIND v(dout0_42) AT=635.025n

* CHECK dout0_43 Vdout0_43ck126 = 0.9 time = 635
.meas tran vdout0_43ck126 FIND v(dout0_43) AT=635.025n

* CHECK dout0_44 Vdout0_44ck126 = 0.9 time = 635
.meas tran vdout0_44ck126 FIND v(dout0_44) AT=635.025n

* CHECK dout0_45 Vdout0_45ck126 = 0.9 time = 635
.meas tran vdout0_45ck126 FIND v(dout0_45) AT=635.025n

* CHECK dout0_46 Vdout0_46ck126 = 0.9 time = 635
.meas tran vdout0_46ck126 FIND v(dout0_46) AT=635.025n

* CHECK dout0_47 Vdout0_47ck126 = 0 time = 635
.meas tran vdout0_47ck126 FIND v(dout0_47) AT=635.025n

* CHECK dout0_48 Vdout0_48ck126 = 0 time = 635
.meas tran vdout0_48ck126 FIND v(dout0_48) AT=635.025n

* CHECK dout0_49 Vdout0_49ck126 = 0 time = 635
.meas tran vdout0_49ck126 FIND v(dout0_49) AT=635.025n

* CHECK dout0_50 Vdout0_50ck126 = 0 time = 635
.meas tran vdout0_50ck126 FIND v(dout0_50) AT=635.025n

* CHECK dout0_51 Vdout0_51ck126 = 0.9 time = 635
.meas tran vdout0_51ck126 FIND v(dout0_51) AT=635.025n

* CHECK dout0_52 Vdout0_52ck126 = 0.9 time = 635
.meas tran vdout0_52ck126 FIND v(dout0_52) AT=635.025n

* CHECK dout0_53 Vdout0_53ck126 = 0.9 time = 635
.meas tran vdout0_53ck126 FIND v(dout0_53) AT=635.025n

* CHECK dout0_54 Vdout0_54ck126 = 0.9 time = 635
.meas tran vdout0_54ck126 FIND v(dout0_54) AT=635.025n

* CHECK dout0_55 Vdout0_55ck126 = 0.9 time = 635
.meas tran vdout0_55ck126 FIND v(dout0_55) AT=635.025n

* CHECK dout0_56 Vdout0_56ck126 = 0.9 time = 635
.meas tran vdout0_56ck126 FIND v(dout0_56) AT=635.025n

* CHECK dout0_57 Vdout0_57ck126 = 0 time = 635
.meas tran vdout0_57ck126 FIND v(dout0_57) AT=635.025n

* CHECK dout0_58 Vdout0_58ck126 = 0.9 time = 635
.meas tran vdout0_58ck126 FIND v(dout0_58) AT=635.025n

* CHECK dout0_59 Vdout0_59ck126 = 0.9 time = 635
.meas tran vdout0_59ck126 FIND v(dout0_59) AT=635.025n

* CHECK dout0_60 Vdout0_60ck126 = 0.9 time = 635
.meas tran vdout0_60ck126 FIND v(dout0_60) AT=635.025n

* CHECK dout0_61 Vdout0_61ck126 = 0 time = 635
.meas tran vdout0_61ck126 FIND v(dout0_61) AT=635.025n

* CHECK dout0_62 Vdout0_62ck126 = 0 time = 635
.meas tran vdout0_62ck126 FIND v(dout0_62) AT=635.025n

* CHECK dout0_63 Vdout0_63ck126 = 0 time = 635
.meas tran vdout0_63ck126 FIND v(dout0_63) AT=635.025n

* CHECK dout0_0 Vdout0_0ck128 = 0 time = 645
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=645.025n

* CHECK dout0_1 Vdout0_1ck128 = 0.9 time = 645
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=645.025n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 645
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=645.025n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 645
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=645.025n

* CHECK dout0_4 Vdout0_4ck128 = 0.9 time = 645
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=645.025n

* CHECK dout0_5 Vdout0_5ck128 = 0.9 time = 645
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=645.025n

* CHECK dout0_6 Vdout0_6ck128 = 0.9 time = 645
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=645.025n

* CHECK dout0_7 Vdout0_7ck128 = 0.9 time = 645
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=645.025n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 645
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=645.025n

* CHECK dout0_9 Vdout0_9ck128 = 0.9 time = 645
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=645.025n

* CHECK dout0_10 Vdout0_10ck128 = 0 time = 645
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=645.025n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 645
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=645.025n

* CHECK dout0_12 Vdout0_12ck128 = 0 time = 645
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=645.025n

* CHECK dout0_13 Vdout0_13ck128 = 0 time = 645
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=645.025n

* CHECK dout0_14 Vdout0_14ck128 = 0.9 time = 645
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=645.025n

* CHECK dout0_15 Vdout0_15ck128 = 0 time = 645
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=645.025n

* CHECK dout0_16 Vdout0_16ck128 = 0.9 time = 645
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=645.025n

* CHECK dout0_17 Vdout0_17ck128 = 0 time = 645
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=645.025n

* CHECK dout0_18 Vdout0_18ck128 = 0 time = 645
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=645.025n

* CHECK dout0_19 Vdout0_19ck128 = 0 time = 645
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=645.025n

* CHECK dout0_20 Vdout0_20ck128 = 0 time = 645
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=645.025n

* CHECK dout0_21 Vdout0_21ck128 = 0 time = 645
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=645.025n

* CHECK dout0_22 Vdout0_22ck128 = 0 time = 645
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=645.025n

* CHECK dout0_23 Vdout0_23ck128 = 0.9 time = 645
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=645.025n

* CHECK dout0_24 Vdout0_24ck128 = 0 time = 645
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=645.025n

* CHECK dout0_25 Vdout0_25ck128 = 0.9 time = 645
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=645.025n

* CHECK dout0_26 Vdout0_26ck128 = 0 time = 645
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=645.025n

* CHECK dout0_27 Vdout0_27ck128 = 0.9 time = 645
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=645.025n

* CHECK dout0_28 Vdout0_28ck128 = 0.9 time = 645
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=645.025n

* CHECK dout0_29 Vdout0_29ck128 = 0 time = 645
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=645.025n

* CHECK dout0_30 Vdout0_30ck128 = 0 time = 645
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=645.025n

* CHECK dout0_31 Vdout0_31ck128 = 0.9 time = 645
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=645.025n

* CHECK dout0_32 Vdout0_32ck128 = 0.9 time = 645
.meas tran vdout0_32ck128 FIND v(dout0_32) AT=645.025n

* CHECK dout0_33 Vdout0_33ck128 = 0.9 time = 645
.meas tran vdout0_33ck128 FIND v(dout0_33) AT=645.025n

* CHECK dout0_34 Vdout0_34ck128 = 0.9 time = 645
.meas tran vdout0_34ck128 FIND v(dout0_34) AT=645.025n

* CHECK dout0_35 Vdout0_35ck128 = 0 time = 645
.meas tran vdout0_35ck128 FIND v(dout0_35) AT=645.025n

* CHECK dout0_36 Vdout0_36ck128 = 0 time = 645
.meas tran vdout0_36ck128 FIND v(dout0_36) AT=645.025n

* CHECK dout0_37 Vdout0_37ck128 = 0.9 time = 645
.meas tran vdout0_37ck128 FIND v(dout0_37) AT=645.025n

* CHECK dout0_38 Vdout0_38ck128 = 0 time = 645
.meas tran vdout0_38ck128 FIND v(dout0_38) AT=645.025n

* CHECK dout0_39 Vdout0_39ck128 = 0.9 time = 645
.meas tran vdout0_39ck128 FIND v(dout0_39) AT=645.025n

* CHECK dout0_40 Vdout0_40ck128 = 0 time = 645
.meas tran vdout0_40ck128 FIND v(dout0_40) AT=645.025n

* CHECK dout0_41 Vdout0_41ck128 = 0 time = 645
.meas tran vdout0_41ck128 FIND v(dout0_41) AT=645.025n

* CHECK dout0_42 Vdout0_42ck128 = 0 time = 645
.meas tran vdout0_42ck128 FIND v(dout0_42) AT=645.025n

* CHECK dout0_43 Vdout0_43ck128 = 0.9 time = 645
.meas tran vdout0_43ck128 FIND v(dout0_43) AT=645.025n

* CHECK dout0_44 Vdout0_44ck128 = 0.9 time = 645
.meas tran vdout0_44ck128 FIND v(dout0_44) AT=645.025n

* CHECK dout0_45 Vdout0_45ck128 = 0.9 time = 645
.meas tran vdout0_45ck128 FIND v(dout0_45) AT=645.025n

* CHECK dout0_46 Vdout0_46ck128 = 0.9 time = 645
.meas tran vdout0_46ck128 FIND v(dout0_46) AT=645.025n

* CHECK dout0_47 Vdout0_47ck128 = 0 time = 645
.meas tran vdout0_47ck128 FIND v(dout0_47) AT=645.025n

* CHECK dout0_48 Vdout0_48ck128 = 0 time = 645
.meas tran vdout0_48ck128 FIND v(dout0_48) AT=645.025n

* CHECK dout0_49 Vdout0_49ck128 = 0 time = 645
.meas tran vdout0_49ck128 FIND v(dout0_49) AT=645.025n

* CHECK dout0_50 Vdout0_50ck128 = 0 time = 645
.meas tran vdout0_50ck128 FIND v(dout0_50) AT=645.025n

* CHECK dout0_51 Vdout0_51ck128 = 0.9 time = 645
.meas tran vdout0_51ck128 FIND v(dout0_51) AT=645.025n

* CHECK dout0_52 Vdout0_52ck128 = 0.9 time = 645
.meas tran vdout0_52ck128 FIND v(dout0_52) AT=645.025n

* CHECK dout0_53 Vdout0_53ck128 = 0.9 time = 645
.meas tran vdout0_53ck128 FIND v(dout0_53) AT=645.025n

* CHECK dout0_54 Vdout0_54ck128 = 0.9 time = 645
.meas tran vdout0_54ck128 FIND v(dout0_54) AT=645.025n

* CHECK dout0_55 Vdout0_55ck128 = 0.9 time = 645
.meas tran vdout0_55ck128 FIND v(dout0_55) AT=645.025n

* CHECK dout0_56 Vdout0_56ck128 = 0.9 time = 645
.meas tran vdout0_56ck128 FIND v(dout0_56) AT=645.025n

* CHECK dout0_57 Vdout0_57ck128 = 0 time = 645
.meas tran vdout0_57ck128 FIND v(dout0_57) AT=645.025n

* CHECK dout0_58 Vdout0_58ck128 = 0.9 time = 645
.meas tran vdout0_58ck128 FIND v(dout0_58) AT=645.025n

* CHECK dout0_59 Vdout0_59ck128 = 0.9 time = 645
.meas tran vdout0_59ck128 FIND v(dout0_59) AT=645.025n

* CHECK dout0_60 Vdout0_60ck128 = 0.9 time = 645
.meas tran vdout0_60ck128 FIND v(dout0_60) AT=645.025n

* CHECK dout0_61 Vdout0_61ck128 = 0 time = 645
.meas tran vdout0_61ck128 FIND v(dout0_61) AT=645.025n

* CHECK dout0_62 Vdout0_62ck128 = 0 time = 645
.meas tran vdout0_62ck128 FIND v(dout0_62) AT=645.025n

* CHECK dout0_63 Vdout0_63ck128 = 0 time = 645
.meas tran vdout0_63ck128 FIND v(dout0_63) AT=645.025n

* CHECK dout0_0 Vdout0_0ck131 = 0.9 time = 660
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=660.025n

* CHECK dout0_1 Vdout0_1ck131 = 0.9 time = 660
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=660.025n

* CHECK dout0_2 Vdout0_2ck131 = 0 time = 660
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=660.025n

* CHECK dout0_3 Vdout0_3ck131 = 0 time = 660
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=660.025n

* CHECK dout0_4 Vdout0_4ck131 = 0.9 time = 660
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=660.025n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 660
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=660.025n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 660
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=660.025n

* CHECK dout0_7 Vdout0_7ck131 = 0.9 time = 660
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=660.025n

* CHECK dout0_8 Vdout0_8ck131 = 0.9 time = 660
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=660.025n

* CHECK dout0_9 Vdout0_9ck131 = 0.9 time = 660
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=660.025n

* CHECK dout0_10 Vdout0_10ck131 = 0.9 time = 660
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=660.025n

* CHECK dout0_11 Vdout0_11ck131 = 0.9 time = 660
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=660.025n

* CHECK dout0_12 Vdout0_12ck131 = 0.9 time = 660
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=660.025n

* CHECK dout0_13 Vdout0_13ck131 = 0 time = 660
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=660.025n

* CHECK dout0_14 Vdout0_14ck131 = 0 time = 660
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=660.025n

* CHECK dout0_15 Vdout0_15ck131 = 0 time = 660
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=660.025n

* CHECK dout0_16 Vdout0_16ck131 = 0 time = 660
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=660.025n

* CHECK dout0_17 Vdout0_17ck131 = 0.9 time = 660
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=660.025n

* CHECK dout0_18 Vdout0_18ck131 = 0.9 time = 660
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=660.025n

* CHECK dout0_19 Vdout0_19ck131 = 0 time = 660
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=660.025n

* CHECK dout0_20 Vdout0_20ck131 = 0 time = 660
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=660.025n

* CHECK dout0_21 Vdout0_21ck131 = 0 time = 660
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=660.025n

* CHECK dout0_22 Vdout0_22ck131 = 0 time = 660
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=660.025n

* CHECK dout0_23 Vdout0_23ck131 = 0 time = 660
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=660.025n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 660
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=660.025n

* CHECK dout0_25 Vdout0_25ck131 = 0.9 time = 660
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=660.025n

* CHECK dout0_26 Vdout0_26ck131 = 0 time = 660
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=660.025n

* CHECK dout0_27 Vdout0_27ck131 = 0.9 time = 660
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=660.025n

* CHECK dout0_28 Vdout0_28ck131 = 0 time = 660
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=660.025n

* CHECK dout0_29 Vdout0_29ck131 = 0.9 time = 660
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=660.025n

* CHECK dout0_30 Vdout0_30ck131 = 0.9 time = 660
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=660.025n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 660
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=660.025n

* CHECK dout0_32 Vdout0_32ck131 = 0 time = 660
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=660.025n

* CHECK dout0_33 Vdout0_33ck131 = 0.9 time = 660
.meas tran vdout0_33ck131 FIND v(dout0_33) AT=660.025n

* CHECK dout0_34 Vdout0_34ck131 = 0.9 time = 660
.meas tran vdout0_34ck131 FIND v(dout0_34) AT=660.025n

* CHECK dout0_35 Vdout0_35ck131 = 0.9 time = 660
.meas tran vdout0_35ck131 FIND v(dout0_35) AT=660.025n

* CHECK dout0_36 Vdout0_36ck131 = 0 time = 660
.meas tran vdout0_36ck131 FIND v(dout0_36) AT=660.025n

* CHECK dout0_37 Vdout0_37ck131 = 0.9 time = 660
.meas tran vdout0_37ck131 FIND v(dout0_37) AT=660.025n

* CHECK dout0_38 Vdout0_38ck131 = 0 time = 660
.meas tran vdout0_38ck131 FIND v(dout0_38) AT=660.025n

* CHECK dout0_39 Vdout0_39ck131 = 0.9 time = 660
.meas tran vdout0_39ck131 FIND v(dout0_39) AT=660.025n

* CHECK dout0_40 Vdout0_40ck131 = 0.9 time = 660
.meas tran vdout0_40ck131 FIND v(dout0_40) AT=660.025n

* CHECK dout0_41 Vdout0_41ck131 = 0 time = 660
.meas tran vdout0_41ck131 FIND v(dout0_41) AT=660.025n

* CHECK dout0_42 Vdout0_42ck131 = 0 time = 660
.meas tran vdout0_42ck131 FIND v(dout0_42) AT=660.025n

* CHECK dout0_43 Vdout0_43ck131 = 0.9 time = 660
.meas tran vdout0_43ck131 FIND v(dout0_43) AT=660.025n

* CHECK dout0_44 Vdout0_44ck131 = 0 time = 660
.meas tran vdout0_44ck131 FIND v(dout0_44) AT=660.025n

* CHECK dout0_45 Vdout0_45ck131 = 0 time = 660
.meas tran vdout0_45ck131 FIND v(dout0_45) AT=660.025n

* CHECK dout0_46 Vdout0_46ck131 = 0 time = 660
.meas tran vdout0_46ck131 FIND v(dout0_46) AT=660.025n

* CHECK dout0_47 Vdout0_47ck131 = 0.9 time = 660
.meas tran vdout0_47ck131 FIND v(dout0_47) AT=660.025n

* CHECK dout0_48 Vdout0_48ck131 = 0 time = 660
.meas tran vdout0_48ck131 FIND v(dout0_48) AT=660.025n

* CHECK dout0_49 Vdout0_49ck131 = 0 time = 660
.meas tran vdout0_49ck131 FIND v(dout0_49) AT=660.025n

* CHECK dout0_50 Vdout0_50ck131 = 0 time = 660
.meas tran vdout0_50ck131 FIND v(dout0_50) AT=660.025n

* CHECK dout0_51 Vdout0_51ck131 = 0 time = 660
.meas tran vdout0_51ck131 FIND v(dout0_51) AT=660.025n

* CHECK dout0_52 Vdout0_52ck131 = 0.9 time = 660
.meas tran vdout0_52ck131 FIND v(dout0_52) AT=660.025n

* CHECK dout0_53 Vdout0_53ck131 = 0 time = 660
.meas tran vdout0_53ck131 FIND v(dout0_53) AT=660.025n

* CHECK dout0_54 Vdout0_54ck131 = 0.9 time = 660
.meas tran vdout0_54ck131 FIND v(dout0_54) AT=660.025n

* CHECK dout0_55 Vdout0_55ck131 = 0 time = 660
.meas tran vdout0_55ck131 FIND v(dout0_55) AT=660.025n

* CHECK dout0_56 Vdout0_56ck131 = 0 time = 660
.meas tran vdout0_56ck131 FIND v(dout0_56) AT=660.025n

* CHECK dout0_57 Vdout0_57ck131 = 0.9 time = 660
.meas tran vdout0_57ck131 FIND v(dout0_57) AT=660.025n

* CHECK dout0_58 Vdout0_58ck131 = 0 time = 660
.meas tran vdout0_58ck131 FIND v(dout0_58) AT=660.025n

* CHECK dout0_59 Vdout0_59ck131 = 0.9 time = 660
.meas tran vdout0_59ck131 FIND v(dout0_59) AT=660.025n

* CHECK dout0_60 Vdout0_60ck131 = 0.9 time = 660
.meas tran vdout0_60ck131 FIND v(dout0_60) AT=660.025n

* CHECK dout0_61 Vdout0_61ck131 = 0 time = 660
.meas tran vdout0_61ck131 FIND v(dout0_61) AT=660.025n

* CHECK dout0_62 Vdout0_62ck131 = 0 time = 660
.meas tran vdout0_62ck131 FIND v(dout0_62) AT=660.025n

* CHECK dout0_63 Vdout0_63ck131 = 0.9 time = 660
.meas tran vdout0_63ck131 FIND v(dout0_63) AT=660.025n

* CHECK dout0_0 Vdout0_0ck133 = 0.9 time = 670
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=670.025n

* CHECK dout0_1 Vdout0_1ck133 = 0.9 time = 670
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=670.025n

* CHECK dout0_2 Vdout0_2ck133 = 0 time = 670
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=670.025n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 670
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=670.025n

* CHECK dout0_4 Vdout0_4ck133 = 0.9 time = 670
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=670.025n

* CHECK dout0_5 Vdout0_5ck133 = 0 time = 670
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=670.025n

* CHECK dout0_6 Vdout0_6ck133 = 0 time = 670
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=670.025n

* CHECK dout0_7 Vdout0_7ck133 = 0.9 time = 670
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=670.025n

* CHECK dout0_8 Vdout0_8ck133 = 0.9 time = 670
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=670.025n

* CHECK dout0_9 Vdout0_9ck133 = 0.9 time = 670
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=670.025n

* CHECK dout0_10 Vdout0_10ck133 = 0.9 time = 670
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=670.025n

* CHECK dout0_11 Vdout0_11ck133 = 0.9 time = 670
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=670.025n

* CHECK dout0_12 Vdout0_12ck133 = 0.9 time = 670
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=670.025n

* CHECK dout0_13 Vdout0_13ck133 = 0 time = 670
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=670.025n

* CHECK dout0_14 Vdout0_14ck133 = 0 time = 670
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=670.025n

* CHECK dout0_15 Vdout0_15ck133 = 0 time = 670
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=670.025n

* CHECK dout0_16 Vdout0_16ck133 = 0 time = 670
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=670.025n

* CHECK dout0_17 Vdout0_17ck133 = 0.9 time = 670
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=670.025n

* CHECK dout0_18 Vdout0_18ck133 = 0.9 time = 670
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=670.025n

* CHECK dout0_19 Vdout0_19ck133 = 0 time = 670
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=670.025n

* CHECK dout0_20 Vdout0_20ck133 = 0 time = 670
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=670.025n

* CHECK dout0_21 Vdout0_21ck133 = 0 time = 670
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=670.025n

* CHECK dout0_22 Vdout0_22ck133 = 0 time = 670
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=670.025n

* CHECK dout0_23 Vdout0_23ck133 = 0 time = 670
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=670.025n

* CHECK dout0_24 Vdout0_24ck133 = 0 time = 670
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=670.025n

* CHECK dout0_25 Vdout0_25ck133 = 0.9 time = 670
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=670.025n

* CHECK dout0_26 Vdout0_26ck133 = 0 time = 670
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=670.025n

* CHECK dout0_27 Vdout0_27ck133 = 0.9 time = 670
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=670.025n

* CHECK dout0_28 Vdout0_28ck133 = 0 time = 670
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=670.025n

* CHECK dout0_29 Vdout0_29ck133 = 0.9 time = 670
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=670.025n

* CHECK dout0_30 Vdout0_30ck133 = 0.9 time = 670
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=670.025n

* CHECK dout0_31 Vdout0_31ck133 = 0 time = 670
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=670.025n

* CHECK dout0_32 Vdout0_32ck133 = 0 time = 670
.meas tran vdout0_32ck133 FIND v(dout0_32) AT=670.025n

* CHECK dout0_33 Vdout0_33ck133 = 0.9 time = 670
.meas tran vdout0_33ck133 FIND v(dout0_33) AT=670.025n

* CHECK dout0_34 Vdout0_34ck133 = 0.9 time = 670
.meas tran vdout0_34ck133 FIND v(dout0_34) AT=670.025n

* CHECK dout0_35 Vdout0_35ck133 = 0.9 time = 670
.meas tran vdout0_35ck133 FIND v(dout0_35) AT=670.025n

* CHECK dout0_36 Vdout0_36ck133 = 0 time = 670
.meas tran vdout0_36ck133 FIND v(dout0_36) AT=670.025n

* CHECK dout0_37 Vdout0_37ck133 = 0.9 time = 670
.meas tran vdout0_37ck133 FIND v(dout0_37) AT=670.025n

* CHECK dout0_38 Vdout0_38ck133 = 0 time = 670
.meas tran vdout0_38ck133 FIND v(dout0_38) AT=670.025n

* CHECK dout0_39 Vdout0_39ck133 = 0.9 time = 670
.meas tran vdout0_39ck133 FIND v(dout0_39) AT=670.025n

* CHECK dout0_40 Vdout0_40ck133 = 0.9 time = 670
.meas tran vdout0_40ck133 FIND v(dout0_40) AT=670.025n

* CHECK dout0_41 Vdout0_41ck133 = 0 time = 670
.meas tran vdout0_41ck133 FIND v(dout0_41) AT=670.025n

* CHECK dout0_42 Vdout0_42ck133 = 0 time = 670
.meas tran vdout0_42ck133 FIND v(dout0_42) AT=670.025n

* CHECK dout0_43 Vdout0_43ck133 = 0.9 time = 670
.meas tran vdout0_43ck133 FIND v(dout0_43) AT=670.025n

* CHECK dout0_44 Vdout0_44ck133 = 0 time = 670
.meas tran vdout0_44ck133 FIND v(dout0_44) AT=670.025n

* CHECK dout0_45 Vdout0_45ck133 = 0 time = 670
.meas tran vdout0_45ck133 FIND v(dout0_45) AT=670.025n

* CHECK dout0_46 Vdout0_46ck133 = 0 time = 670
.meas tran vdout0_46ck133 FIND v(dout0_46) AT=670.025n

* CHECK dout0_47 Vdout0_47ck133 = 0.9 time = 670
.meas tran vdout0_47ck133 FIND v(dout0_47) AT=670.025n

* CHECK dout0_48 Vdout0_48ck133 = 0 time = 670
.meas tran vdout0_48ck133 FIND v(dout0_48) AT=670.025n

* CHECK dout0_49 Vdout0_49ck133 = 0 time = 670
.meas tran vdout0_49ck133 FIND v(dout0_49) AT=670.025n

* CHECK dout0_50 Vdout0_50ck133 = 0 time = 670
.meas tran vdout0_50ck133 FIND v(dout0_50) AT=670.025n

* CHECK dout0_51 Vdout0_51ck133 = 0 time = 670
.meas tran vdout0_51ck133 FIND v(dout0_51) AT=670.025n

* CHECK dout0_52 Vdout0_52ck133 = 0.9 time = 670
.meas tran vdout0_52ck133 FIND v(dout0_52) AT=670.025n

* CHECK dout0_53 Vdout0_53ck133 = 0 time = 670
.meas tran vdout0_53ck133 FIND v(dout0_53) AT=670.025n

* CHECK dout0_54 Vdout0_54ck133 = 0.9 time = 670
.meas tran vdout0_54ck133 FIND v(dout0_54) AT=670.025n

* CHECK dout0_55 Vdout0_55ck133 = 0 time = 670
.meas tran vdout0_55ck133 FIND v(dout0_55) AT=670.025n

* CHECK dout0_56 Vdout0_56ck133 = 0 time = 670
.meas tran vdout0_56ck133 FIND v(dout0_56) AT=670.025n

* CHECK dout0_57 Vdout0_57ck133 = 0.9 time = 670
.meas tran vdout0_57ck133 FIND v(dout0_57) AT=670.025n

* CHECK dout0_58 Vdout0_58ck133 = 0 time = 670
.meas tran vdout0_58ck133 FIND v(dout0_58) AT=670.025n

* CHECK dout0_59 Vdout0_59ck133 = 0.9 time = 670
.meas tran vdout0_59ck133 FIND v(dout0_59) AT=670.025n

* CHECK dout0_60 Vdout0_60ck133 = 0.9 time = 670
.meas tran vdout0_60ck133 FIND v(dout0_60) AT=670.025n

* CHECK dout0_61 Vdout0_61ck133 = 0 time = 670
.meas tran vdout0_61ck133 FIND v(dout0_61) AT=670.025n

* CHECK dout0_62 Vdout0_62ck133 = 0 time = 670
.meas tran vdout0_62ck133 FIND v(dout0_62) AT=670.025n

* CHECK dout0_63 Vdout0_63ck133 = 0.9 time = 670
.meas tran vdout0_63ck133 FIND v(dout0_63) AT=670.025n

* CHECK dout0_0 Vdout0_0ck134 = 0.9 time = 675
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=675.025n

* CHECK dout0_1 Vdout0_1ck134 = 0.9 time = 675
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=675.025n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 675
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=675.025n

* CHECK dout0_3 Vdout0_3ck134 = 0 time = 675
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=675.025n

* CHECK dout0_4 Vdout0_4ck134 = 0.9 time = 675
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=675.025n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 675
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=675.025n

* CHECK dout0_6 Vdout0_6ck134 = 0 time = 675
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=675.025n

* CHECK dout0_7 Vdout0_7ck134 = 0.9 time = 675
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=675.025n

* CHECK dout0_8 Vdout0_8ck134 = 0.9 time = 675
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=675.025n

* CHECK dout0_9 Vdout0_9ck134 = 0.9 time = 675
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=675.025n

* CHECK dout0_10 Vdout0_10ck134 = 0.9 time = 675
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=675.025n

* CHECK dout0_11 Vdout0_11ck134 = 0.9 time = 675
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=675.025n

* CHECK dout0_12 Vdout0_12ck134 = 0.9 time = 675
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=675.025n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 675
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=675.025n

* CHECK dout0_14 Vdout0_14ck134 = 0 time = 675
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=675.025n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 675
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=675.025n

* CHECK dout0_16 Vdout0_16ck134 = 0 time = 675
.meas tran vdout0_16ck134 FIND v(dout0_16) AT=675.025n

* CHECK dout0_17 Vdout0_17ck134 = 0.9 time = 675
.meas tran vdout0_17ck134 FIND v(dout0_17) AT=675.025n

* CHECK dout0_18 Vdout0_18ck134 = 0.9 time = 675
.meas tran vdout0_18ck134 FIND v(dout0_18) AT=675.025n

* CHECK dout0_19 Vdout0_19ck134 = 0 time = 675
.meas tran vdout0_19ck134 FIND v(dout0_19) AT=675.025n

* CHECK dout0_20 Vdout0_20ck134 = 0 time = 675
.meas tran vdout0_20ck134 FIND v(dout0_20) AT=675.025n

* CHECK dout0_21 Vdout0_21ck134 = 0 time = 675
.meas tran vdout0_21ck134 FIND v(dout0_21) AT=675.025n

* CHECK dout0_22 Vdout0_22ck134 = 0 time = 675
.meas tran vdout0_22ck134 FIND v(dout0_22) AT=675.025n

* CHECK dout0_23 Vdout0_23ck134 = 0 time = 675
.meas tran vdout0_23ck134 FIND v(dout0_23) AT=675.025n

* CHECK dout0_24 Vdout0_24ck134 = 0 time = 675
.meas tran vdout0_24ck134 FIND v(dout0_24) AT=675.025n

* CHECK dout0_25 Vdout0_25ck134 = 0.9 time = 675
.meas tran vdout0_25ck134 FIND v(dout0_25) AT=675.025n

* CHECK dout0_26 Vdout0_26ck134 = 0 time = 675
.meas tran vdout0_26ck134 FIND v(dout0_26) AT=675.025n

* CHECK dout0_27 Vdout0_27ck134 = 0.9 time = 675
.meas tran vdout0_27ck134 FIND v(dout0_27) AT=675.025n

* CHECK dout0_28 Vdout0_28ck134 = 0 time = 675
.meas tran vdout0_28ck134 FIND v(dout0_28) AT=675.025n

* CHECK dout0_29 Vdout0_29ck134 = 0.9 time = 675
.meas tran vdout0_29ck134 FIND v(dout0_29) AT=675.025n

* CHECK dout0_30 Vdout0_30ck134 = 0.9 time = 675
.meas tran vdout0_30ck134 FIND v(dout0_30) AT=675.025n

* CHECK dout0_31 Vdout0_31ck134 = 0 time = 675
.meas tran vdout0_31ck134 FIND v(dout0_31) AT=675.025n

* CHECK dout0_32 Vdout0_32ck134 = 0 time = 675
.meas tran vdout0_32ck134 FIND v(dout0_32) AT=675.025n

* CHECK dout0_33 Vdout0_33ck134 = 0.9 time = 675
.meas tran vdout0_33ck134 FIND v(dout0_33) AT=675.025n

* CHECK dout0_34 Vdout0_34ck134 = 0.9 time = 675
.meas tran vdout0_34ck134 FIND v(dout0_34) AT=675.025n

* CHECK dout0_35 Vdout0_35ck134 = 0.9 time = 675
.meas tran vdout0_35ck134 FIND v(dout0_35) AT=675.025n

* CHECK dout0_36 Vdout0_36ck134 = 0 time = 675
.meas tran vdout0_36ck134 FIND v(dout0_36) AT=675.025n

* CHECK dout0_37 Vdout0_37ck134 = 0.9 time = 675
.meas tran vdout0_37ck134 FIND v(dout0_37) AT=675.025n

* CHECK dout0_38 Vdout0_38ck134 = 0 time = 675
.meas tran vdout0_38ck134 FIND v(dout0_38) AT=675.025n

* CHECK dout0_39 Vdout0_39ck134 = 0.9 time = 675
.meas tran vdout0_39ck134 FIND v(dout0_39) AT=675.025n

* CHECK dout0_40 Vdout0_40ck134 = 0.9 time = 675
.meas tran vdout0_40ck134 FIND v(dout0_40) AT=675.025n

* CHECK dout0_41 Vdout0_41ck134 = 0 time = 675
.meas tran vdout0_41ck134 FIND v(dout0_41) AT=675.025n

* CHECK dout0_42 Vdout0_42ck134 = 0 time = 675
.meas tran vdout0_42ck134 FIND v(dout0_42) AT=675.025n

* CHECK dout0_43 Vdout0_43ck134 = 0.9 time = 675
.meas tran vdout0_43ck134 FIND v(dout0_43) AT=675.025n

* CHECK dout0_44 Vdout0_44ck134 = 0 time = 675
.meas tran vdout0_44ck134 FIND v(dout0_44) AT=675.025n

* CHECK dout0_45 Vdout0_45ck134 = 0 time = 675
.meas tran vdout0_45ck134 FIND v(dout0_45) AT=675.025n

* CHECK dout0_46 Vdout0_46ck134 = 0 time = 675
.meas tran vdout0_46ck134 FIND v(dout0_46) AT=675.025n

* CHECK dout0_47 Vdout0_47ck134 = 0.9 time = 675
.meas tran vdout0_47ck134 FIND v(dout0_47) AT=675.025n

* CHECK dout0_48 Vdout0_48ck134 = 0 time = 675
.meas tran vdout0_48ck134 FIND v(dout0_48) AT=675.025n

* CHECK dout0_49 Vdout0_49ck134 = 0 time = 675
.meas tran vdout0_49ck134 FIND v(dout0_49) AT=675.025n

* CHECK dout0_50 Vdout0_50ck134 = 0 time = 675
.meas tran vdout0_50ck134 FIND v(dout0_50) AT=675.025n

* CHECK dout0_51 Vdout0_51ck134 = 0 time = 675
.meas tran vdout0_51ck134 FIND v(dout0_51) AT=675.025n

* CHECK dout0_52 Vdout0_52ck134 = 0.9 time = 675
.meas tran vdout0_52ck134 FIND v(dout0_52) AT=675.025n

* CHECK dout0_53 Vdout0_53ck134 = 0 time = 675
.meas tran vdout0_53ck134 FIND v(dout0_53) AT=675.025n

* CHECK dout0_54 Vdout0_54ck134 = 0.9 time = 675
.meas tran vdout0_54ck134 FIND v(dout0_54) AT=675.025n

* CHECK dout0_55 Vdout0_55ck134 = 0 time = 675
.meas tran vdout0_55ck134 FIND v(dout0_55) AT=675.025n

* CHECK dout0_56 Vdout0_56ck134 = 0 time = 675
.meas tran vdout0_56ck134 FIND v(dout0_56) AT=675.025n

* CHECK dout0_57 Vdout0_57ck134 = 0.9 time = 675
.meas tran vdout0_57ck134 FIND v(dout0_57) AT=675.025n

* CHECK dout0_58 Vdout0_58ck134 = 0 time = 675
.meas tran vdout0_58ck134 FIND v(dout0_58) AT=675.025n

* CHECK dout0_59 Vdout0_59ck134 = 0.9 time = 675
.meas tran vdout0_59ck134 FIND v(dout0_59) AT=675.025n

* CHECK dout0_60 Vdout0_60ck134 = 0.9 time = 675
.meas tran vdout0_60ck134 FIND v(dout0_60) AT=675.025n

* CHECK dout0_61 Vdout0_61ck134 = 0 time = 675
.meas tran vdout0_61ck134 FIND v(dout0_61) AT=675.025n

* CHECK dout0_62 Vdout0_62ck134 = 0 time = 675
.meas tran vdout0_62ck134 FIND v(dout0_62) AT=675.025n

* CHECK dout0_63 Vdout0_63ck134 = 0.9 time = 675
.meas tran vdout0_63ck134 FIND v(dout0_63) AT=675.025n

* CHECK dout0_0 Vdout0_0ck135 = 0.9 time = 680
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=680.025n

* CHECK dout0_1 Vdout0_1ck135 = 0.9 time = 680
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=680.025n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 680
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=680.025n

* CHECK dout0_3 Vdout0_3ck135 = 0 time = 680
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=680.025n

* CHECK dout0_4 Vdout0_4ck135 = 0.9 time = 680
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=680.025n

* CHECK dout0_5 Vdout0_5ck135 = 0 time = 680
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=680.025n

* CHECK dout0_6 Vdout0_6ck135 = 0 time = 680
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=680.025n

* CHECK dout0_7 Vdout0_7ck135 = 0.9 time = 680
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=680.025n

* CHECK dout0_8 Vdout0_8ck135 = 0.9 time = 680
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=680.025n

* CHECK dout0_9 Vdout0_9ck135 = 0.9 time = 680
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=680.025n

* CHECK dout0_10 Vdout0_10ck135 = 0.9 time = 680
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=680.025n

* CHECK dout0_11 Vdout0_11ck135 = 0.9 time = 680
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=680.025n

* CHECK dout0_12 Vdout0_12ck135 = 0.9 time = 680
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=680.025n

* CHECK dout0_13 Vdout0_13ck135 = 0 time = 680
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=680.025n

* CHECK dout0_14 Vdout0_14ck135 = 0 time = 680
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=680.025n

* CHECK dout0_15 Vdout0_15ck135 = 0 time = 680
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=680.025n

* CHECK dout0_16 Vdout0_16ck135 = 0 time = 680
.meas tran vdout0_16ck135 FIND v(dout0_16) AT=680.025n

* CHECK dout0_17 Vdout0_17ck135 = 0.9 time = 680
.meas tran vdout0_17ck135 FIND v(dout0_17) AT=680.025n

* CHECK dout0_18 Vdout0_18ck135 = 0.9 time = 680
.meas tran vdout0_18ck135 FIND v(dout0_18) AT=680.025n

* CHECK dout0_19 Vdout0_19ck135 = 0 time = 680
.meas tran vdout0_19ck135 FIND v(dout0_19) AT=680.025n

* CHECK dout0_20 Vdout0_20ck135 = 0 time = 680
.meas tran vdout0_20ck135 FIND v(dout0_20) AT=680.025n

* CHECK dout0_21 Vdout0_21ck135 = 0 time = 680
.meas tran vdout0_21ck135 FIND v(dout0_21) AT=680.025n

* CHECK dout0_22 Vdout0_22ck135 = 0 time = 680
.meas tran vdout0_22ck135 FIND v(dout0_22) AT=680.025n

* CHECK dout0_23 Vdout0_23ck135 = 0 time = 680
.meas tran vdout0_23ck135 FIND v(dout0_23) AT=680.025n

* CHECK dout0_24 Vdout0_24ck135 = 0 time = 680
.meas tran vdout0_24ck135 FIND v(dout0_24) AT=680.025n

* CHECK dout0_25 Vdout0_25ck135 = 0.9 time = 680
.meas tran vdout0_25ck135 FIND v(dout0_25) AT=680.025n

* CHECK dout0_26 Vdout0_26ck135 = 0 time = 680
.meas tran vdout0_26ck135 FIND v(dout0_26) AT=680.025n

* CHECK dout0_27 Vdout0_27ck135 = 0.9 time = 680
.meas tran vdout0_27ck135 FIND v(dout0_27) AT=680.025n

* CHECK dout0_28 Vdout0_28ck135 = 0 time = 680
.meas tran vdout0_28ck135 FIND v(dout0_28) AT=680.025n

* CHECK dout0_29 Vdout0_29ck135 = 0.9 time = 680
.meas tran vdout0_29ck135 FIND v(dout0_29) AT=680.025n

* CHECK dout0_30 Vdout0_30ck135 = 0.9 time = 680
.meas tran vdout0_30ck135 FIND v(dout0_30) AT=680.025n

* CHECK dout0_31 Vdout0_31ck135 = 0 time = 680
.meas tran vdout0_31ck135 FIND v(dout0_31) AT=680.025n

* CHECK dout0_32 Vdout0_32ck135 = 0 time = 680
.meas tran vdout0_32ck135 FIND v(dout0_32) AT=680.025n

* CHECK dout0_33 Vdout0_33ck135 = 0.9 time = 680
.meas tran vdout0_33ck135 FIND v(dout0_33) AT=680.025n

* CHECK dout0_34 Vdout0_34ck135 = 0.9 time = 680
.meas tran vdout0_34ck135 FIND v(dout0_34) AT=680.025n

* CHECK dout0_35 Vdout0_35ck135 = 0.9 time = 680
.meas tran vdout0_35ck135 FIND v(dout0_35) AT=680.025n

* CHECK dout0_36 Vdout0_36ck135 = 0 time = 680
.meas tran vdout0_36ck135 FIND v(dout0_36) AT=680.025n

* CHECK dout0_37 Vdout0_37ck135 = 0.9 time = 680
.meas tran vdout0_37ck135 FIND v(dout0_37) AT=680.025n

* CHECK dout0_38 Vdout0_38ck135 = 0 time = 680
.meas tran vdout0_38ck135 FIND v(dout0_38) AT=680.025n

* CHECK dout0_39 Vdout0_39ck135 = 0.9 time = 680
.meas tran vdout0_39ck135 FIND v(dout0_39) AT=680.025n

* CHECK dout0_40 Vdout0_40ck135 = 0.9 time = 680
.meas tran vdout0_40ck135 FIND v(dout0_40) AT=680.025n

* CHECK dout0_41 Vdout0_41ck135 = 0 time = 680
.meas tran vdout0_41ck135 FIND v(dout0_41) AT=680.025n

* CHECK dout0_42 Vdout0_42ck135 = 0 time = 680
.meas tran vdout0_42ck135 FIND v(dout0_42) AT=680.025n

* CHECK dout0_43 Vdout0_43ck135 = 0.9 time = 680
.meas tran vdout0_43ck135 FIND v(dout0_43) AT=680.025n

* CHECK dout0_44 Vdout0_44ck135 = 0 time = 680
.meas tran vdout0_44ck135 FIND v(dout0_44) AT=680.025n

* CHECK dout0_45 Vdout0_45ck135 = 0 time = 680
.meas tran vdout0_45ck135 FIND v(dout0_45) AT=680.025n

* CHECK dout0_46 Vdout0_46ck135 = 0 time = 680
.meas tran vdout0_46ck135 FIND v(dout0_46) AT=680.025n

* CHECK dout0_47 Vdout0_47ck135 = 0.9 time = 680
.meas tran vdout0_47ck135 FIND v(dout0_47) AT=680.025n

* CHECK dout0_48 Vdout0_48ck135 = 0 time = 680
.meas tran vdout0_48ck135 FIND v(dout0_48) AT=680.025n

* CHECK dout0_49 Vdout0_49ck135 = 0 time = 680
.meas tran vdout0_49ck135 FIND v(dout0_49) AT=680.025n

* CHECK dout0_50 Vdout0_50ck135 = 0 time = 680
.meas tran vdout0_50ck135 FIND v(dout0_50) AT=680.025n

* CHECK dout0_51 Vdout0_51ck135 = 0 time = 680
.meas tran vdout0_51ck135 FIND v(dout0_51) AT=680.025n

* CHECK dout0_52 Vdout0_52ck135 = 0.9 time = 680
.meas tran vdout0_52ck135 FIND v(dout0_52) AT=680.025n

* CHECK dout0_53 Vdout0_53ck135 = 0 time = 680
.meas tran vdout0_53ck135 FIND v(dout0_53) AT=680.025n

* CHECK dout0_54 Vdout0_54ck135 = 0.9 time = 680
.meas tran vdout0_54ck135 FIND v(dout0_54) AT=680.025n

* CHECK dout0_55 Vdout0_55ck135 = 0 time = 680
.meas tran vdout0_55ck135 FIND v(dout0_55) AT=680.025n

* CHECK dout0_56 Vdout0_56ck135 = 0 time = 680
.meas tran vdout0_56ck135 FIND v(dout0_56) AT=680.025n

* CHECK dout0_57 Vdout0_57ck135 = 0.9 time = 680
.meas tran vdout0_57ck135 FIND v(dout0_57) AT=680.025n

* CHECK dout0_58 Vdout0_58ck135 = 0 time = 680
.meas tran vdout0_58ck135 FIND v(dout0_58) AT=680.025n

* CHECK dout0_59 Vdout0_59ck135 = 0.9 time = 680
.meas tran vdout0_59ck135 FIND v(dout0_59) AT=680.025n

* CHECK dout0_60 Vdout0_60ck135 = 0.9 time = 680
.meas tran vdout0_60ck135 FIND v(dout0_60) AT=680.025n

* CHECK dout0_61 Vdout0_61ck135 = 0 time = 680
.meas tran vdout0_61ck135 FIND v(dout0_61) AT=680.025n

* CHECK dout0_62 Vdout0_62ck135 = 0 time = 680
.meas tran vdout0_62ck135 FIND v(dout0_62) AT=680.025n

* CHECK dout0_63 Vdout0_63ck135 = 0.9 time = 680
.meas tran vdout0_63ck135 FIND v(dout0_63) AT=680.025n

* CHECK dout0_0 Vdout0_0ck136 = 0.9 time = 685
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=685.025n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 685
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=685.025n

* CHECK dout0_2 Vdout0_2ck136 = 0 time = 685
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=685.025n

* CHECK dout0_3 Vdout0_3ck136 = 0 time = 685
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=685.025n

* CHECK dout0_4 Vdout0_4ck136 = 0 time = 685
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=685.025n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 685
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=685.025n

* CHECK dout0_6 Vdout0_6ck136 = 0 time = 685
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=685.025n

* CHECK dout0_7 Vdout0_7ck136 = 0.9 time = 685
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=685.025n

* CHECK dout0_8 Vdout0_8ck136 = 0 time = 685
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=685.025n

* CHECK dout0_9 Vdout0_9ck136 = 0.9 time = 685
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=685.025n

* CHECK dout0_10 Vdout0_10ck136 = 0 time = 685
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=685.025n

* CHECK dout0_11 Vdout0_11ck136 = 0 time = 685
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=685.025n

* CHECK dout0_12 Vdout0_12ck136 = 0 time = 685
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=685.025n

* CHECK dout0_13 Vdout0_13ck136 = 0.9 time = 685
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=685.025n

* CHECK dout0_14 Vdout0_14ck136 = 0 time = 685
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=685.025n

* CHECK dout0_15 Vdout0_15ck136 = 0 time = 685
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=685.025n

* CHECK dout0_16 Vdout0_16ck136 = 0 time = 685
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=685.025n

* CHECK dout0_17 Vdout0_17ck136 = 0 time = 685
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=685.025n

* CHECK dout0_18 Vdout0_18ck136 = 0 time = 685
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=685.025n

* CHECK dout0_19 Vdout0_19ck136 = 0.9 time = 685
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=685.025n

* CHECK dout0_20 Vdout0_20ck136 = 0.9 time = 685
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=685.025n

* CHECK dout0_21 Vdout0_21ck136 = 0 time = 685
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=685.025n

* CHECK dout0_22 Vdout0_22ck136 = 0.9 time = 685
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=685.025n

* CHECK dout0_23 Vdout0_23ck136 = 0 time = 685
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=685.025n

* CHECK dout0_24 Vdout0_24ck136 = 0 time = 685
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=685.025n

* CHECK dout0_25 Vdout0_25ck136 = 0.9 time = 685
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=685.025n

* CHECK dout0_26 Vdout0_26ck136 = 0.9 time = 685
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=685.025n

* CHECK dout0_27 Vdout0_27ck136 = 0 time = 685
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=685.025n

* CHECK dout0_28 Vdout0_28ck136 = 0.9 time = 685
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=685.025n

* CHECK dout0_29 Vdout0_29ck136 = 0 time = 685
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=685.025n

* CHECK dout0_30 Vdout0_30ck136 = 0 time = 685
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=685.025n

* CHECK dout0_31 Vdout0_31ck136 = 0.9 time = 685
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=685.025n

* CHECK dout0_32 Vdout0_32ck136 = 0.9 time = 685
.meas tran vdout0_32ck136 FIND v(dout0_32) AT=685.025n

* CHECK dout0_33 Vdout0_33ck136 = 0.9 time = 685
.meas tran vdout0_33ck136 FIND v(dout0_33) AT=685.025n

* CHECK dout0_34 Vdout0_34ck136 = 0.9 time = 685
.meas tran vdout0_34ck136 FIND v(dout0_34) AT=685.025n

* CHECK dout0_35 Vdout0_35ck136 = 0 time = 685
.meas tran vdout0_35ck136 FIND v(dout0_35) AT=685.025n

* CHECK dout0_36 Vdout0_36ck136 = 0 time = 685
.meas tran vdout0_36ck136 FIND v(dout0_36) AT=685.025n

* CHECK dout0_37 Vdout0_37ck136 = 0 time = 685
.meas tran vdout0_37ck136 FIND v(dout0_37) AT=685.025n

* CHECK dout0_38 Vdout0_38ck136 = 0.9 time = 685
.meas tran vdout0_38ck136 FIND v(dout0_38) AT=685.025n

* CHECK dout0_39 Vdout0_39ck136 = 0.9 time = 685
.meas tran vdout0_39ck136 FIND v(dout0_39) AT=685.025n

* CHECK dout0_40 Vdout0_40ck136 = 0.9 time = 685
.meas tran vdout0_40ck136 FIND v(dout0_40) AT=685.025n

* CHECK dout0_41 Vdout0_41ck136 = 0 time = 685
.meas tran vdout0_41ck136 FIND v(dout0_41) AT=685.025n

* CHECK dout0_42 Vdout0_42ck136 = 0.9 time = 685
.meas tran vdout0_42ck136 FIND v(dout0_42) AT=685.025n

* CHECK dout0_43 Vdout0_43ck136 = 0.9 time = 685
.meas tran vdout0_43ck136 FIND v(dout0_43) AT=685.025n

* CHECK dout0_44 Vdout0_44ck136 = 0.9 time = 685
.meas tran vdout0_44ck136 FIND v(dout0_44) AT=685.025n

* CHECK dout0_45 Vdout0_45ck136 = 0 time = 685
.meas tran vdout0_45ck136 FIND v(dout0_45) AT=685.025n

* CHECK dout0_46 Vdout0_46ck136 = 0.9 time = 685
.meas tran vdout0_46ck136 FIND v(dout0_46) AT=685.025n

* CHECK dout0_47 Vdout0_47ck136 = 0.9 time = 685
.meas tran vdout0_47ck136 FIND v(dout0_47) AT=685.025n

* CHECK dout0_48 Vdout0_48ck136 = 0 time = 685
.meas tran vdout0_48ck136 FIND v(dout0_48) AT=685.025n

* CHECK dout0_49 Vdout0_49ck136 = 0 time = 685
.meas tran vdout0_49ck136 FIND v(dout0_49) AT=685.025n

* CHECK dout0_50 Vdout0_50ck136 = 0 time = 685
.meas tran vdout0_50ck136 FIND v(dout0_50) AT=685.025n

* CHECK dout0_51 Vdout0_51ck136 = 0.9 time = 685
.meas tran vdout0_51ck136 FIND v(dout0_51) AT=685.025n

* CHECK dout0_52 Vdout0_52ck136 = 0 time = 685
.meas tran vdout0_52ck136 FIND v(dout0_52) AT=685.025n

* CHECK dout0_53 Vdout0_53ck136 = 0.9 time = 685
.meas tran vdout0_53ck136 FIND v(dout0_53) AT=685.025n

* CHECK dout0_54 Vdout0_54ck136 = 0.9 time = 685
.meas tran vdout0_54ck136 FIND v(dout0_54) AT=685.025n

* CHECK dout0_55 Vdout0_55ck136 = 0.9 time = 685
.meas tran vdout0_55ck136 FIND v(dout0_55) AT=685.025n

* CHECK dout0_56 Vdout0_56ck136 = 0 time = 685
.meas tran vdout0_56ck136 FIND v(dout0_56) AT=685.025n

* CHECK dout0_57 Vdout0_57ck136 = 0 time = 685
.meas tran vdout0_57ck136 FIND v(dout0_57) AT=685.025n

* CHECK dout0_58 Vdout0_58ck136 = 0 time = 685
.meas tran vdout0_58ck136 FIND v(dout0_58) AT=685.025n

* CHECK dout0_59 Vdout0_59ck136 = 0 time = 685
.meas tran vdout0_59ck136 FIND v(dout0_59) AT=685.025n

* CHECK dout0_60 Vdout0_60ck136 = 0.9 time = 685
.meas tran vdout0_60ck136 FIND v(dout0_60) AT=685.025n

* CHECK dout0_61 Vdout0_61ck136 = 0 time = 685
.meas tran vdout0_61ck136 FIND v(dout0_61) AT=685.025n

* CHECK dout0_62 Vdout0_62ck136 = 0 time = 685
.meas tran vdout0_62ck136 FIND v(dout0_62) AT=685.025n

* CHECK dout0_63 Vdout0_63ck136 = 0 time = 685
.meas tran vdout0_63ck136 FIND v(dout0_63) AT=685.025n

* CHECK dout0_0 Vdout0_0ck137 = 0.9 time = 690
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=690.025n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 690
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=690.025n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 690
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=690.025n

* CHECK dout0_3 Vdout0_3ck137 = 0 time = 690
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=690.025n

* CHECK dout0_4 Vdout0_4ck137 = 0 time = 690
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=690.025n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 690
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=690.025n

* CHECK dout0_6 Vdout0_6ck137 = 0 time = 690
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=690.025n

* CHECK dout0_7 Vdout0_7ck137 = 0.9 time = 690
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=690.025n

* CHECK dout0_8 Vdout0_8ck137 = 0 time = 690
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=690.025n

* CHECK dout0_9 Vdout0_9ck137 = 0.9 time = 690
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=690.025n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 690
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=690.025n

* CHECK dout0_11 Vdout0_11ck137 = 0 time = 690
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=690.025n

* CHECK dout0_12 Vdout0_12ck137 = 0 time = 690
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=690.025n

* CHECK dout0_13 Vdout0_13ck137 = 0.9 time = 690
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=690.025n

* CHECK dout0_14 Vdout0_14ck137 = 0 time = 690
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=690.025n

* CHECK dout0_15 Vdout0_15ck137 = 0 time = 690
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=690.025n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 690
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=690.025n

* CHECK dout0_17 Vdout0_17ck137 = 0 time = 690
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=690.025n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 690
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=690.025n

* CHECK dout0_19 Vdout0_19ck137 = 0.9 time = 690
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=690.025n

* CHECK dout0_20 Vdout0_20ck137 = 0.9 time = 690
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=690.025n

* CHECK dout0_21 Vdout0_21ck137 = 0 time = 690
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=690.025n

* CHECK dout0_22 Vdout0_22ck137 = 0.9 time = 690
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=690.025n

* CHECK dout0_23 Vdout0_23ck137 = 0 time = 690
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=690.025n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 690
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=690.025n

* CHECK dout0_25 Vdout0_25ck137 = 0.9 time = 690
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=690.025n

* CHECK dout0_26 Vdout0_26ck137 = 0.9 time = 690
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=690.025n

* CHECK dout0_27 Vdout0_27ck137 = 0 time = 690
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=690.025n

* CHECK dout0_28 Vdout0_28ck137 = 0.9 time = 690
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=690.025n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 690
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=690.025n

* CHECK dout0_30 Vdout0_30ck137 = 0 time = 690
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=690.025n

* CHECK dout0_31 Vdout0_31ck137 = 0.9 time = 690
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=690.025n

* CHECK dout0_32 Vdout0_32ck137 = 0.9 time = 690
.meas tran vdout0_32ck137 FIND v(dout0_32) AT=690.025n

* CHECK dout0_33 Vdout0_33ck137 = 0.9 time = 690
.meas tran vdout0_33ck137 FIND v(dout0_33) AT=690.025n

* CHECK dout0_34 Vdout0_34ck137 = 0.9 time = 690
.meas tran vdout0_34ck137 FIND v(dout0_34) AT=690.025n

* CHECK dout0_35 Vdout0_35ck137 = 0 time = 690
.meas tran vdout0_35ck137 FIND v(dout0_35) AT=690.025n

* CHECK dout0_36 Vdout0_36ck137 = 0 time = 690
.meas tran vdout0_36ck137 FIND v(dout0_36) AT=690.025n

* CHECK dout0_37 Vdout0_37ck137 = 0 time = 690
.meas tran vdout0_37ck137 FIND v(dout0_37) AT=690.025n

* CHECK dout0_38 Vdout0_38ck137 = 0.9 time = 690
.meas tran vdout0_38ck137 FIND v(dout0_38) AT=690.025n

* CHECK dout0_39 Vdout0_39ck137 = 0.9 time = 690
.meas tran vdout0_39ck137 FIND v(dout0_39) AT=690.025n

* CHECK dout0_40 Vdout0_40ck137 = 0.9 time = 690
.meas tran vdout0_40ck137 FIND v(dout0_40) AT=690.025n

* CHECK dout0_41 Vdout0_41ck137 = 0 time = 690
.meas tran vdout0_41ck137 FIND v(dout0_41) AT=690.025n

* CHECK dout0_42 Vdout0_42ck137 = 0.9 time = 690
.meas tran vdout0_42ck137 FIND v(dout0_42) AT=690.025n

* CHECK dout0_43 Vdout0_43ck137 = 0.9 time = 690
.meas tran vdout0_43ck137 FIND v(dout0_43) AT=690.025n

* CHECK dout0_44 Vdout0_44ck137 = 0.9 time = 690
.meas tran vdout0_44ck137 FIND v(dout0_44) AT=690.025n

* CHECK dout0_45 Vdout0_45ck137 = 0 time = 690
.meas tran vdout0_45ck137 FIND v(dout0_45) AT=690.025n

* CHECK dout0_46 Vdout0_46ck137 = 0.9 time = 690
.meas tran vdout0_46ck137 FIND v(dout0_46) AT=690.025n

* CHECK dout0_47 Vdout0_47ck137 = 0.9 time = 690
.meas tran vdout0_47ck137 FIND v(dout0_47) AT=690.025n

* CHECK dout0_48 Vdout0_48ck137 = 0 time = 690
.meas tran vdout0_48ck137 FIND v(dout0_48) AT=690.025n

* CHECK dout0_49 Vdout0_49ck137 = 0 time = 690
.meas tran vdout0_49ck137 FIND v(dout0_49) AT=690.025n

* CHECK dout0_50 Vdout0_50ck137 = 0 time = 690
.meas tran vdout0_50ck137 FIND v(dout0_50) AT=690.025n

* CHECK dout0_51 Vdout0_51ck137 = 0.9 time = 690
.meas tran vdout0_51ck137 FIND v(dout0_51) AT=690.025n

* CHECK dout0_52 Vdout0_52ck137 = 0 time = 690
.meas tran vdout0_52ck137 FIND v(dout0_52) AT=690.025n

* CHECK dout0_53 Vdout0_53ck137 = 0.9 time = 690
.meas tran vdout0_53ck137 FIND v(dout0_53) AT=690.025n

* CHECK dout0_54 Vdout0_54ck137 = 0.9 time = 690
.meas tran vdout0_54ck137 FIND v(dout0_54) AT=690.025n

* CHECK dout0_55 Vdout0_55ck137 = 0.9 time = 690
.meas tran vdout0_55ck137 FIND v(dout0_55) AT=690.025n

* CHECK dout0_56 Vdout0_56ck137 = 0 time = 690
.meas tran vdout0_56ck137 FIND v(dout0_56) AT=690.025n

* CHECK dout0_57 Vdout0_57ck137 = 0 time = 690
.meas tran vdout0_57ck137 FIND v(dout0_57) AT=690.025n

* CHECK dout0_58 Vdout0_58ck137 = 0 time = 690
.meas tran vdout0_58ck137 FIND v(dout0_58) AT=690.025n

* CHECK dout0_59 Vdout0_59ck137 = 0 time = 690
.meas tran vdout0_59ck137 FIND v(dout0_59) AT=690.025n

* CHECK dout0_60 Vdout0_60ck137 = 0.9 time = 690
.meas tran vdout0_60ck137 FIND v(dout0_60) AT=690.025n

* CHECK dout0_61 Vdout0_61ck137 = 0 time = 690
.meas tran vdout0_61ck137 FIND v(dout0_61) AT=690.025n

* CHECK dout0_62 Vdout0_62ck137 = 0 time = 690
.meas tran vdout0_62ck137 FIND v(dout0_62) AT=690.025n

* CHECK dout0_63 Vdout0_63ck137 = 0 time = 690
.meas tran vdout0_63ck137 FIND v(dout0_63) AT=690.025n

* CHECK dout0_0 Vdout0_0ck139 = 0.9 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 0.9 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 0.9 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0.9 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 0.9 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 0.9 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0.9 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0.9 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 0.9 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 0 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0.9 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 0.9 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 0.9 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 0.9 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0.9 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0.9 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_32 Vdout0_32ck139 = 0 time = 700
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=700.025n

* CHECK dout0_33 Vdout0_33ck139 = 0.9 time = 700
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=700.025n

* CHECK dout0_34 Vdout0_34ck139 = 0.9 time = 700
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=700.025n

* CHECK dout0_35 Vdout0_35ck139 = 0.9 time = 700
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=700.025n

* CHECK dout0_36 Vdout0_36ck139 = 0 time = 700
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=700.025n

* CHECK dout0_37 Vdout0_37ck139 = 0.9 time = 700
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=700.025n

* CHECK dout0_38 Vdout0_38ck139 = 0 time = 700
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=700.025n

* CHECK dout0_39 Vdout0_39ck139 = 0.9 time = 700
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=700.025n

* CHECK dout0_40 Vdout0_40ck139 = 0.9 time = 700
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=700.025n

* CHECK dout0_41 Vdout0_41ck139 = 0 time = 700
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=700.025n

* CHECK dout0_42 Vdout0_42ck139 = 0 time = 700
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=700.025n

* CHECK dout0_43 Vdout0_43ck139 = 0.9 time = 700
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=700.025n

* CHECK dout0_44 Vdout0_44ck139 = 0 time = 700
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=700.025n

* CHECK dout0_45 Vdout0_45ck139 = 0 time = 700
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=700.025n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 700
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=700.025n

* CHECK dout0_47 Vdout0_47ck139 = 0.9 time = 700
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=700.025n

* CHECK dout0_48 Vdout0_48ck139 = 0 time = 700
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=700.025n

* CHECK dout0_49 Vdout0_49ck139 = 0 time = 700
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=700.025n

* CHECK dout0_50 Vdout0_50ck139 = 0 time = 700
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=700.025n

* CHECK dout0_51 Vdout0_51ck139 = 0 time = 700
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=700.025n

* CHECK dout0_52 Vdout0_52ck139 = 0.9 time = 700
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=700.025n

* CHECK dout0_53 Vdout0_53ck139 = 0 time = 700
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=700.025n

* CHECK dout0_54 Vdout0_54ck139 = 0.9 time = 700
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=700.025n

* CHECK dout0_55 Vdout0_55ck139 = 0 time = 700
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=700.025n

* CHECK dout0_56 Vdout0_56ck139 = 0 time = 700
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=700.025n

* CHECK dout0_57 Vdout0_57ck139 = 0.9 time = 700
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=700.025n

* CHECK dout0_58 Vdout0_58ck139 = 0 time = 700
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=700.025n

* CHECK dout0_59 Vdout0_59ck139 = 0.9 time = 700
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=700.025n

* CHECK dout0_60 Vdout0_60ck139 = 0.9 time = 700
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=700.025n

* CHECK dout0_61 Vdout0_61ck139 = 0 time = 700
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=700.025n

* CHECK dout0_62 Vdout0_62ck139 = 0 time = 700
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=700.025n

* CHECK dout0_63 Vdout0_63ck139 = 0.9 time = 700
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=700.025n

* CHECK dout0_0 Vdout0_0ck141 = 0.9 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0.9 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0.9 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 0 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 0.9 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 0 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 0 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 0 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 0.9 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 0.9 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 0 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 0.9 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 0 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 0 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 0.9 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0.9 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 0 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0.9 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 0 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 0.9 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_32 Vdout0_32ck141 = 0.9 time = 710
.meas tran vdout0_32ck141 FIND v(dout0_32) AT=710.025n

* CHECK dout0_33 Vdout0_33ck141 = 0.9 time = 710
.meas tran vdout0_33ck141 FIND v(dout0_33) AT=710.025n

* CHECK dout0_34 Vdout0_34ck141 = 0.9 time = 710
.meas tran vdout0_34ck141 FIND v(dout0_34) AT=710.025n

* CHECK dout0_35 Vdout0_35ck141 = 0 time = 710
.meas tran vdout0_35ck141 FIND v(dout0_35) AT=710.025n

* CHECK dout0_36 Vdout0_36ck141 = 0 time = 710
.meas tran vdout0_36ck141 FIND v(dout0_36) AT=710.025n

* CHECK dout0_37 Vdout0_37ck141 = 0 time = 710
.meas tran vdout0_37ck141 FIND v(dout0_37) AT=710.025n

* CHECK dout0_38 Vdout0_38ck141 = 0.9 time = 710
.meas tran vdout0_38ck141 FIND v(dout0_38) AT=710.025n

* CHECK dout0_39 Vdout0_39ck141 = 0.9 time = 710
.meas tran vdout0_39ck141 FIND v(dout0_39) AT=710.025n

* CHECK dout0_40 Vdout0_40ck141 = 0.9 time = 710
.meas tran vdout0_40ck141 FIND v(dout0_40) AT=710.025n

* CHECK dout0_41 Vdout0_41ck141 = 0 time = 710
.meas tran vdout0_41ck141 FIND v(dout0_41) AT=710.025n

* CHECK dout0_42 Vdout0_42ck141 = 0.9 time = 710
.meas tran vdout0_42ck141 FIND v(dout0_42) AT=710.025n

* CHECK dout0_43 Vdout0_43ck141 = 0.9 time = 710
.meas tran vdout0_43ck141 FIND v(dout0_43) AT=710.025n

* CHECK dout0_44 Vdout0_44ck141 = 0.9 time = 710
.meas tran vdout0_44ck141 FIND v(dout0_44) AT=710.025n

* CHECK dout0_45 Vdout0_45ck141 = 0 time = 710
.meas tran vdout0_45ck141 FIND v(dout0_45) AT=710.025n

* CHECK dout0_46 Vdout0_46ck141 = 0.9 time = 710
.meas tran vdout0_46ck141 FIND v(dout0_46) AT=710.025n

* CHECK dout0_47 Vdout0_47ck141 = 0.9 time = 710
.meas tran vdout0_47ck141 FIND v(dout0_47) AT=710.025n

* CHECK dout0_48 Vdout0_48ck141 = 0 time = 710
.meas tran vdout0_48ck141 FIND v(dout0_48) AT=710.025n

* CHECK dout0_49 Vdout0_49ck141 = 0 time = 710
.meas tran vdout0_49ck141 FIND v(dout0_49) AT=710.025n

* CHECK dout0_50 Vdout0_50ck141 = 0 time = 710
.meas tran vdout0_50ck141 FIND v(dout0_50) AT=710.025n

* CHECK dout0_51 Vdout0_51ck141 = 0.9 time = 710
.meas tran vdout0_51ck141 FIND v(dout0_51) AT=710.025n

* CHECK dout0_52 Vdout0_52ck141 = 0 time = 710
.meas tran vdout0_52ck141 FIND v(dout0_52) AT=710.025n

* CHECK dout0_53 Vdout0_53ck141 = 0.9 time = 710
.meas tran vdout0_53ck141 FIND v(dout0_53) AT=710.025n

* CHECK dout0_54 Vdout0_54ck141 = 0.9 time = 710
.meas tran vdout0_54ck141 FIND v(dout0_54) AT=710.025n

* CHECK dout0_55 Vdout0_55ck141 = 0.9 time = 710
.meas tran vdout0_55ck141 FIND v(dout0_55) AT=710.025n

* CHECK dout0_56 Vdout0_56ck141 = 0 time = 710
.meas tran vdout0_56ck141 FIND v(dout0_56) AT=710.025n

* CHECK dout0_57 Vdout0_57ck141 = 0 time = 710
.meas tran vdout0_57ck141 FIND v(dout0_57) AT=710.025n

* CHECK dout0_58 Vdout0_58ck141 = 0 time = 710
.meas tran vdout0_58ck141 FIND v(dout0_58) AT=710.025n

* CHECK dout0_59 Vdout0_59ck141 = 0 time = 710
.meas tran vdout0_59ck141 FIND v(dout0_59) AT=710.025n

* CHECK dout0_60 Vdout0_60ck141 = 0.9 time = 710
.meas tran vdout0_60ck141 FIND v(dout0_60) AT=710.025n

* CHECK dout0_61 Vdout0_61ck141 = 0 time = 710
.meas tran vdout0_61ck141 FIND v(dout0_61) AT=710.025n

* CHECK dout0_62 Vdout0_62ck141 = 0 time = 710
.meas tran vdout0_62ck141 FIND v(dout0_62) AT=710.025n

* CHECK dout0_63 Vdout0_63ck141 = 0 time = 710
.meas tran vdout0_63ck141 FIND v(dout0_63) AT=710.025n

* CHECK dout0_0 Vdout0_0ck143 = 0.9 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0.9 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 0 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 0.9 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 0.9 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 0.9 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 0.9 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0.9 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 0.9 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 0.9 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 0.9 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 0 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 0.9 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 0.9 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 0 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 0.9 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 0.9 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 0 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 0 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 0 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0.9 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 0 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 0 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_32 Vdout0_32ck143 = 0 time = 720
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=720.025n

* CHECK dout0_33 Vdout0_33ck143 = 0.9 time = 720
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=720.025n

* CHECK dout0_34 Vdout0_34ck143 = 0 time = 720
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=720.025n

* CHECK dout0_35 Vdout0_35ck143 = 0.9 time = 720
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=720.025n

* CHECK dout0_36 Vdout0_36ck143 = 0.9 time = 720
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=720.025n

* CHECK dout0_37 Vdout0_37ck143 = 0 time = 720
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=720.025n

* CHECK dout0_38 Vdout0_38ck143 = 0.9 time = 720
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=720.025n

* CHECK dout0_39 Vdout0_39ck143 = 0.9 time = 720
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=720.025n

* CHECK dout0_40 Vdout0_40ck143 = 0 time = 720
.meas tran vdout0_40ck143 FIND v(dout0_40) AT=720.025n

* CHECK dout0_41 Vdout0_41ck143 = 0 time = 720
.meas tran vdout0_41ck143 FIND v(dout0_41) AT=720.025n

* CHECK dout0_42 Vdout0_42ck143 = 0.9 time = 720
.meas tran vdout0_42ck143 FIND v(dout0_42) AT=720.025n

* CHECK dout0_43 Vdout0_43ck143 = 0.9 time = 720
.meas tran vdout0_43ck143 FIND v(dout0_43) AT=720.025n

* CHECK dout0_44 Vdout0_44ck143 = 0.9 time = 720
.meas tran vdout0_44ck143 FIND v(dout0_44) AT=720.025n

* CHECK dout0_45 Vdout0_45ck143 = 0.9 time = 720
.meas tran vdout0_45ck143 FIND v(dout0_45) AT=720.025n

* CHECK dout0_46 Vdout0_46ck143 = 0 time = 720
.meas tran vdout0_46ck143 FIND v(dout0_46) AT=720.025n

* CHECK dout0_47 Vdout0_47ck143 = 0 time = 720
.meas tran vdout0_47ck143 FIND v(dout0_47) AT=720.025n

* CHECK dout0_48 Vdout0_48ck143 = 0.9 time = 720
.meas tran vdout0_48ck143 FIND v(dout0_48) AT=720.025n

* CHECK dout0_49 Vdout0_49ck143 = 0.9 time = 720
.meas tran vdout0_49ck143 FIND v(dout0_49) AT=720.025n

* CHECK dout0_50 Vdout0_50ck143 = 0 time = 720
.meas tran vdout0_50ck143 FIND v(dout0_50) AT=720.025n

* CHECK dout0_51 Vdout0_51ck143 = 0.9 time = 720
.meas tran vdout0_51ck143 FIND v(dout0_51) AT=720.025n

* CHECK dout0_52 Vdout0_52ck143 = 0.9 time = 720
.meas tran vdout0_52ck143 FIND v(dout0_52) AT=720.025n

* CHECK dout0_53 Vdout0_53ck143 = 0.9 time = 720
.meas tran vdout0_53ck143 FIND v(dout0_53) AT=720.025n

* CHECK dout0_54 Vdout0_54ck143 = 0 time = 720
.meas tran vdout0_54ck143 FIND v(dout0_54) AT=720.025n

* CHECK dout0_55 Vdout0_55ck143 = 0 time = 720
.meas tran vdout0_55ck143 FIND v(dout0_55) AT=720.025n

* CHECK dout0_56 Vdout0_56ck143 = 0.9 time = 720
.meas tran vdout0_56ck143 FIND v(dout0_56) AT=720.025n

* CHECK dout0_57 Vdout0_57ck143 = 0.9 time = 720
.meas tran vdout0_57ck143 FIND v(dout0_57) AT=720.025n

* CHECK dout0_58 Vdout0_58ck143 = 0 time = 720
.meas tran vdout0_58ck143 FIND v(dout0_58) AT=720.025n

* CHECK dout0_59 Vdout0_59ck143 = 0 time = 720
.meas tran vdout0_59ck143 FIND v(dout0_59) AT=720.025n

* CHECK dout0_60 Vdout0_60ck143 = 0.9 time = 720
.meas tran vdout0_60ck143 FIND v(dout0_60) AT=720.025n

* CHECK dout0_61 Vdout0_61ck143 = 0.9 time = 720
.meas tran vdout0_61ck143 FIND v(dout0_61) AT=720.025n

* CHECK dout0_62 Vdout0_62ck143 = 0.9 time = 720
.meas tran vdout0_62ck143 FIND v(dout0_62) AT=720.025n

* CHECK dout0_63 Vdout0_63ck143 = 0.9 time = 720
.meas tran vdout0_63ck143 FIND v(dout0_63) AT=720.025n

* CHECK dout0_0 Vdout0_0ck147 = 0.9 time = 740
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=740.025n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 740
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=740.025n

* CHECK dout0_2 Vdout0_2ck147 = 0.9 time = 740
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=740.025n

* CHECK dout0_3 Vdout0_3ck147 = 0.9 time = 740
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=740.025n

* CHECK dout0_4 Vdout0_4ck147 = 0.9 time = 740
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=740.025n

* CHECK dout0_5 Vdout0_5ck147 = 0.9 time = 740
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=740.025n

* CHECK dout0_6 Vdout0_6ck147 = 0 time = 740
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=740.025n

* CHECK dout0_7 Vdout0_7ck147 = 0 time = 740
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=740.025n

* CHECK dout0_8 Vdout0_8ck147 = 0 time = 740
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=740.025n

* CHECK dout0_9 Vdout0_9ck147 = 0 time = 740
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=740.025n

* CHECK dout0_10 Vdout0_10ck147 = 0 time = 740
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=740.025n

* CHECK dout0_11 Vdout0_11ck147 = 0.9 time = 740
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=740.025n

* CHECK dout0_12 Vdout0_12ck147 = 0 time = 740
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=740.025n

* CHECK dout0_13 Vdout0_13ck147 = 0.9 time = 740
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=740.025n

* CHECK dout0_14 Vdout0_14ck147 = 0.9 time = 740
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=740.025n

* CHECK dout0_15 Vdout0_15ck147 = 0 time = 740
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=740.025n

* CHECK dout0_16 Vdout0_16ck147 = 0 time = 740
.meas tran vdout0_16ck147 FIND v(dout0_16) AT=740.025n

* CHECK dout0_17 Vdout0_17ck147 = 0.9 time = 740
.meas tran vdout0_17ck147 FIND v(dout0_17) AT=740.025n

* CHECK dout0_18 Vdout0_18ck147 = 0 time = 740
.meas tran vdout0_18ck147 FIND v(dout0_18) AT=740.025n

* CHECK dout0_19 Vdout0_19ck147 = 0 time = 740
.meas tran vdout0_19ck147 FIND v(dout0_19) AT=740.025n

* CHECK dout0_20 Vdout0_20ck147 = 0 time = 740
.meas tran vdout0_20ck147 FIND v(dout0_20) AT=740.025n

* CHECK dout0_21 Vdout0_21ck147 = 0 time = 740
.meas tran vdout0_21ck147 FIND v(dout0_21) AT=740.025n

* CHECK dout0_22 Vdout0_22ck147 = 0 time = 740
.meas tran vdout0_22ck147 FIND v(dout0_22) AT=740.025n

* CHECK dout0_23 Vdout0_23ck147 = 0.9 time = 740
.meas tran vdout0_23ck147 FIND v(dout0_23) AT=740.025n

* CHECK dout0_24 Vdout0_24ck147 = 0 time = 740
.meas tran vdout0_24ck147 FIND v(dout0_24) AT=740.025n

* CHECK dout0_25 Vdout0_25ck147 = 0 time = 740
.meas tran vdout0_25ck147 FIND v(dout0_25) AT=740.025n

* CHECK dout0_26 Vdout0_26ck147 = 0 time = 740
.meas tran vdout0_26ck147 FIND v(dout0_26) AT=740.025n

* CHECK dout0_27 Vdout0_27ck147 = 0.9 time = 740
.meas tran vdout0_27ck147 FIND v(dout0_27) AT=740.025n

* CHECK dout0_28 Vdout0_28ck147 = 0 time = 740
.meas tran vdout0_28ck147 FIND v(dout0_28) AT=740.025n

* CHECK dout0_29 Vdout0_29ck147 = 0.9 time = 740
.meas tran vdout0_29ck147 FIND v(dout0_29) AT=740.025n

* CHECK dout0_30 Vdout0_30ck147 = 0.9 time = 740
.meas tran vdout0_30ck147 FIND v(dout0_30) AT=740.025n

* CHECK dout0_31 Vdout0_31ck147 = 0 time = 740
.meas tran vdout0_31ck147 FIND v(dout0_31) AT=740.025n

* CHECK dout0_32 Vdout0_32ck147 = 0 time = 740
.meas tran vdout0_32ck147 FIND v(dout0_32) AT=740.025n

* CHECK dout0_33 Vdout0_33ck147 = 0.9 time = 740
.meas tran vdout0_33ck147 FIND v(dout0_33) AT=740.025n

* CHECK dout0_34 Vdout0_34ck147 = 0 time = 740
.meas tran vdout0_34ck147 FIND v(dout0_34) AT=740.025n

* CHECK dout0_35 Vdout0_35ck147 = 0.9 time = 740
.meas tran vdout0_35ck147 FIND v(dout0_35) AT=740.025n

* CHECK dout0_36 Vdout0_36ck147 = 0 time = 740
.meas tran vdout0_36ck147 FIND v(dout0_36) AT=740.025n

* CHECK dout0_37 Vdout0_37ck147 = 0.9 time = 740
.meas tran vdout0_37ck147 FIND v(dout0_37) AT=740.025n

* CHECK dout0_38 Vdout0_38ck147 = 0.9 time = 740
.meas tran vdout0_38ck147 FIND v(dout0_38) AT=740.025n

* CHECK dout0_39 Vdout0_39ck147 = 0.9 time = 740
.meas tran vdout0_39ck147 FIND v(dout0_39) AT=740.025n

* CHECK dout0_40 Vdout0_40ck147 = 0 time = 740
.meas tran vdout0_40ck147 FIND v(dout0_40) AT=740.025n

* CHECK dout0_41 Vdout0_41ck147 = 0 time = 740
.meas tran vdout0_41ck147 FIND v(dout0_41) AT=740.025n

* CHECK dout0_42 Vdout0_42ck147 = 0 time = 740
.meas tran vdout0_42ck147 FIND v(dout0_42) AT=740.025n

* CHECK dout0_43 Vdout0_43ck147 = 0.9 time = 740
.meas tran vdout0_43ck147 FIND v(dout0_43) AT=740.025n

* CHECK dout0_44 Vdout0_44ck147 = 0.9 time = 740
.meas tran vdout0_44ck147 FIND v(dout0_44) AT=740.025n

* CHECK dout0_45 Vdout0_45ck147 = 0 time = 740
.meas tran vdout0_45ck147 FIND v(dout0_45) AT=740.025n

* CHECK dout0_46 Vdout0_46ck147 = 0.9 time = 740
.meas tran vdout0_46ck147 FIND v(dout0_46) AT=740.025n

* CHECK dout0_47 Vdout0_47ck147 = 0 time = 740
.meas tran vdout0_47ck147 FIND v(dout0_47) AT=740.025n

* CHECK dout0_48 Vdout0_48ck147 = 0 time = 740
.meas tran vdout0_48ck147 FIND v(dout0_48) AT=740.025n

* CHECK dout0_49 Vdout0_49ck147 = 0.9 time = 740
.meas tran vdout0_49ck147 FIND v(dout0_49) AT=740.025n

* CHECK dout0_50 Vdout0_50ck147 = 0.9 time = 740
.meas tran vdout0_50ck147 FIND v(dout0_50) AT=740.025n

* CHECK dout0_51 Vdout0_51ck147 = 0.9 time = 740
.meas tran vdout0_51ck147 FIND v(dout0_51) AT=740.025n

* CHECK dout0_52 Vdout0_52ck147 = 0 time = 740
.meas tran vdout0_52ck147 FIND v(dout0_52) AT=740.025n

* CHECK dout0_53 Vdout0_53ck147 = 0 time = 740
.meas tran vdout0_53ck147 FIND v(dout0_53) AT=740.025n

* CHECK dout0_54 Vdout0_54ck147 = 0.9 time = 740
.meas tran vdout0_54ck147 FIND v(dout0_54) AT=740.025n

* CHECK dout0_55 Vdout0_55ck147 = 0 time = 740
.meas tran vdout0_55ck147 FIND v(dout0_55) AT=740.025n

* CHECK dout0_56 Vdout0_56ck147 = 0 time = 740
.meas tran vdout0_56ck147 FIND v(dout0_56) AT=740.025n

* CHECK dout0_57 Vdout0_57ck147 = 0 time = 740
.meas tran vdout0_57ck147 FIND v(dout0_57) AT=740.025n

* CHECK dout0_58 Vdout0_58ck147 = 0 time = 740
.meas tran vdout0_58ck147 FIND v(dout0_58) AT=740.025n

* CHECK dout0_59 Vdout0_59ck147 = 0 time = 740
.meas tran vdout0_59ck147 FIND v(dout0_59) AT=740.025n

* CHECK dout0_60 Vdout0_60ck147 = 0.9 time = 740
.meas tran vdout0_60ck147 FIND v(dout0_60) AT=740.025n

* CHECK dout0_61 Vdout0_61ck147 = 0.9 time = 740
.meas tran vdout0_61ck147 FIND v(dout0_61) AT=740.025n

* CHECK dout0_62 Vdout0_62ck147 = 0 time = 740
.meas tran vdout0_62ck147 FIND v(dout0_62) AT=740.025n

* CHECK dout0_63 Vdout0_63ck147 = 0 time = 740
.meas tran vdout0_63ck147 FIND v(dout0_63) AT=740.025n

* CHECK dout0_0 Vdout0_0ck149 = 0.9 time = 750
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=750.025n

* CHECK dout0_1 Vdout0_1ck149 = 0.9 time = 750
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=750.025n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 750
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=750.025n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 750
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=750.025n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 750
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=750.025n

* CHECK dout0_5 Vdout0_5ck149 = 0.9 time = 750
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=750.025n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 750
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=750.025n

* CHECK dout0_7 Vdout0_7ck149 = 0.9 time = 750
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=750.025n

* CHECK dout0_8 Vdout0_8ck149 = 0.9 time = 750
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=750.025n

* CHECK dout0_9 Vdout0_9ck149 = 0.9 time = 750
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=750.025n

* CHECK dout0_10 Vdout0_10ck149 = 0 time = 750
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=750.025n

* CHECK dout0_11 Vdout0_11ck149 = 0.9 time = 750
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=750.025n

* CHECK dout0_12 Vdout0_12ck149 = 0 time = 750
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=750.025n

* CHECK dout0_13 Vdout0_13ck149 = 0.9 time = 750
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=750.025n

* CHECK dout0_14 Vdout0_14ck149 = 0.9 time = 750
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=750.025n

* CHECK dout0_15 Vdout0_15ck149 = 0.9 time = 750
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=750.025n

* CHECK dout0_16 Vdout0_16ck149 = 0 time = 750
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=750.025n

* CHECK dout0_17 Vdout0_17ck149 = 0.9 time = 750
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=750.025n

* CHECK dout0_18 Vdout0_18ck149 = 0 time = 750
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=750.025n

* CHECK dout0_19 Vdout0_19ck149 = 0.9 time = 750
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=750.025n

* CHECK dout0_20 Vdout0_20ck149 = 0 time = 750
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=750.025n

* CHECK dout0_21 Vdout0_21ck149 = 0.9 time = 750
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=750.025n

* CHECK dout0_22 Vdout0_22ck149 = 0.9 time = 750
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=750.025n

* CHECK dout0_23 Vdout0_23ck149 = 0 time = 750
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=750.025n

* CHECK dout0_24 Vdout0_24ck149 = 0 time = 750
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=750.025n

* CHECK dout0_25 Vdout0_25ck149 = 0 time = 750
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=750.025n

* CHECK dout0_26 Vdout0_26ck149 = 0 time = 750
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=750.025n

* CHECK dout0_27 Vdout0_27ck149 = 0 time = 750
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=750.025n

* CHECK dout0_28 Vdout0_28ck149 = 0 time = 750
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=750.025n

* CHECK dout0_29 Vdout0_29ck149 = 0.9 time = 750
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=750.025n

* CHECK dout0_30 Vdout0_30ck149 = 0 time = 750
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=750.025n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 750
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=750.025n

* CHECK dout0_32 Vdout0_32ck149 = 0 time = 750
.meas tran vdout0_32ck149 FIND v(dout0_32) AT=750.025n

* CHECK dout0_33 Vdout0_33ck149 = 0.9 time = 750
.meas tran vdout0_33ck149 FIND v(dout0_33) AT=750.025n

* CHECK dout0_34 Vdout0_34ck149 = 0 time = 750
.meas tran vdout0_34ck149 FIND v(dout0_34) AT=750.025n

* CHECK dout0_35 Vdout0_35ck149 = 0.9 time = 750
.meas tran vdout0_35ck149 FIND v(dout0_35) AT=750.025n

* CHECK dout0_36 Vdout0_36ck149 = 0.9 time = 750
.meas tran vdout0_36ck149 FIND v(dout0_36) AT=750.025n

* CHECK dout0_37 Vdout0_37ck149 = 0 time = 750
.meas tran vdout0_37ck149 FIND v(dout0_37) AT=750.025n

* CHECK dout0_38 Vdout0_38ck149 = 0.9 time = 750
.meas tran vdout0_38ck149 FIND v(dout0_38) AT=750.025n

* CHECK dout0_39 Vdout0_39ck149 = 0.9 time = 750
.meas tran vdout0_39ck149 FIND v(dout0_39) AT=750.025n

* CHECK dout0_40 Vdout0_40ck149 = 0 time = 750
.meas tran vdout0_40ck149 FIND v(dout0_40) AT=750.025n

* CHECK dout0_41 Vdout0_41ck149 = 0 time = 750
.meas tran vdout0_41ck149 FIND v(dout0_41) AT=750.025n

* CHECK dout0_42 Vdout0_42ck149 = 0.9 time = 750
.meas tran vdout0_42ck149 FIND v(dout0_42) AT=750.025n

* CHECK dout0_43 Vdout0_43ck149 = 0.9 time = 750
.meas tran vdout0_43ck149 FIND v(dout0_43) AT=750.025n

* CHECK dout0_44 Vdout0_44ck149 = 0.9 time = 750
.meas tran vdout0_44ck149 FIND v(dout0_44) AT=750.025n

* CHECK dout0_45 Vdout0_45ck149 = 0.9 time = 750
.meas tran vdout0_45ck149 FIND v(dout0_45) AT=750.025n

* CHECK dout0_46 Vdout0_46ck149 = 0 time = 750
.meas tran vdout0_46ck149 FIND v(dout0_46) AT=750.025n

* CHECK dout0_47 Vdout0_47ck149 = 0 time = 750
.meas tran vdout0_47ck149 FIND v(dout0_47) AT=750.025n

* CHECK dout0_48 Vdout0_48ck149 = 0.9 time = 750
.meas tran vdout0_48ck149 FIND v(dout0_48) AT=750.025n

* CHECK dout0_49 Vdout0_49ck149 = 0.9 time = 750
.meas tran vdout0_49ck149 FIND v(dout0_49) AT=750.025n

* CHECK dout0_50 Vdout0_50ck149 = 0 time = 750
.meas tran vdout0_50ck149 FIND v(dout0_50) AT=750.025n

* CHECK dout0_51 Vdout0_51ck149 = 0.9 time = 750
.meas tran vdout0_51ck149 FIND v(dout0_51) AT=750.025n

* CHECK dout0_52 Vdout0_52ck149 = 0.9 time = 750
.meas tran vdout0_52ck149 FIND v(dout0_52) AT=750.025n

* CHECK dout0_53 Vdout0_53ck149 = 0.9 time = 750
.meas tran vdout0_53ck149 FIND v(dout0_53) AT=750.025n

* CHECK dout0_54 Vdout0_54ck149 = 0 time = 750
.meas tran vdout0_54ck149 FIND v(dout0_54) AT=750.025n

* CHECK dout0_55 Vdout0_55ck149 = 0 time = 750
.meas tran vdout0_55ck149 FIND v(dout0_55) AT=750.025n

* CHECK dout0_56 Vdout0_56ck149 = 0.9 time = 750
.meas tran vdout0_56ck149 FIND v(dout0_56) AT=750.025n

* CHECK dout0_57 Vdout0_57ck149 = 0.9 time = 750
.meas tran vdout0_57ck149 FIND v(dout0_57) AT=750.025n

* CHECK dout0_58 Vdout0_58ck149 = 0 time = 750
.meas tran vdout0_58ck149 FIND v(dout0_58) AT=750.025n

* CHECK dout0_59 Vdout0_59ck149 = 0 time = 750
.meas tran vdout0_59ck149 FIND v(dout0_59) AT=750.025n

* CHECK dout0_60 Vdout0_60ck149 = 0.9 time = 750
.meas tran vdout0_60ck149 FIND v(dout0_60) AT=750.025n

* CHECK dout0_61 Vdout0_61ck149 = 0.9 time = 750
.meas tran vdout0_61ck149 FIND v(dout0_61) AT=750.025n

* CHECK dout0_62 Vdout0_62ck149 = 0.9 time = 750
.meas tran vdout0_62ck149 FIND v(dout0_62) AT=750.025n

* CHECK dout0_63 Vdout0_63ck149 = 0.9 time = 750
.meas tran vdout0_63ck149 FIND v(dout0_63) AT=750.025n

* CHECK dout0_0 Vdout0_0ck150 = 0.9 time = 755
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=755.025n

* CHECK dout0_1 Vdout0_1ck150 = 0 time = 755
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=755.025n

* CHECK dout0_2 Vdout0_2ck150 = 0.9 time = 755
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=755.025n

* CHECK dout0_3 Vdout0_3ck150 = 0.9 time = 755
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=755.025n

* CHECK dout0_4 Vdout0_4ck150 = 0.9 time = 755
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=755.025n

* CHECK dout0_5 Vdout0_5ck150 = 0.9 time = 755
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=755.025n

* CHECK dout0_6 Vdout0_6ck150 = 0 time = 755
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=755.025n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 755
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=755.025n

* CHECK dout0_8 Vdout0_8ck150 = 0 time = 755
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=755.025n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 755
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=755.025n

* CHECK dout0_10 Vdout0_10ck150 = 0 time = 755
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=755.025n

* CHECK dout0_11 Vdout0_11ck150 = 0.9 time = 755
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=755.025n

* CHECK dout0_12 Vdout0_12ck150 = 0 time = 755
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=755.025n

* CHECK dout0_13 Vdout0_13ck150 = 0.9 time = 755
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=755.025n

* CHECK dout0_14 Vdout0_14ck150 = 0.9 time = 755
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=755.025n

* CHECK dout0_15 Vdout0_15ck150 = 0 time = 755
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=755.025n

* CHECK dout0_16 Vdout0_16ck150 = 0 time = 755
.meas tran vdout0_16ck150 FIND v(dout0_16) AT=755.025n

* CHECK dout0_17 Vdout0_17ck150 = 0.9 time = 755
.meas tran vdout0_17ck150 FIND v(dout0_17) AT=755.025n

* CHECK dout0_18 Vdout0_18ck150 = 0 time = 755
.meas tran vdout0_18ck150 FIND v(dout0_18) AT=755.025n

* CHECK dout0_19 Vdout0_19ck150 = 0 time = 755
.meas tran vdout0_19ck150 FIND v(dout0_19) AT=755.025n

* CHECK dout0_20 Vdout0_20ck150 = 0 time = 755
.meas tran vdout0_20ck150 FIND v(dout0_20) AT=755.025n

* CHECK dout0_21 Vdout0_21ck150 = 0 time = 755
.meas tran vdout0_21ck150 FIND v(dout0_21) AT=755.025n

* CHECK dout0_22 Vdout0_22ck150 = 0 time = 755
.meas tran vdout0_22ck150 FIND v(dout0_22) AT=755.025n

* CHECK dout0_23 Vdout0_23ck150 = 0.9 time = 755
.meas tran vdout0_23ck150 FIND v(dout0_23) AT=755.025n

* CHECK dout0_24 Vdout0_24ck150 = 0 time = 755
.meas tran vdout0_24ck150 FIND v(dout0_24) AT=755.025n

* CHECK dout0_25 Vdout0_25ck150 = 0 time = 755
.meas tran vdout0_25ck150 FIND v(dout0_25) AT=755.025n

* CHECK dout0_26 Vdout0_26ck150 = 0 time = 755
.meas tran vdout0_26ck150 FIND v(dout0_26) AT=755.025n

* CHECK dout0_27 Vdout0_27ck150 = 0.9 time = 755
.meas tran vdout0_27ck150 FIND v(dout0_27) AT=755.025n

* CHECK dout0_28 Vdout0_28ck150 = 0 time = 755
.meas tran vdout0_28ck150 FIND v(dout0_28) AT=755.025n

* CHECK dout0_29 Vdout0_29ck150 = 0.9 time = 755
.meas tran vdout0_29ck150 FIND v(dout0_29) AT=755.025n

* CHECK dout0_30 Vdout0_30ck150 = 0.9 time = 755
.meas tran vdout0_30ck150 FIND v(dout0_30) AT=755.025n

* CHECK dout0_31 Vdout0_31ck150 = 0 time = 755
.meas tran vdout0_31ck150 FIND v(dout0_31) AT=755.025n

* CHECK dout0_32 Vdout0_32ck150 = 0 time = 755
.meas tran vdout0_32ck150 FIND v(dout0_32) AT=755.025n

* CHECK dout0_33 Vdout0_33ck150 = 0.9 time = 755
.meas tran vdout0_33ck150 FIND v(dout0_33) AT=755.025n

* CHECK dout0_34 Vdout0_34ck150 = 0 time = 755
.meas tran vdout0_34ck150 FIND v(dout0_34) AT=755.025n

* CHECK dout0_35 Vdout0_35ck150 = 0.9 time = 755
.meas tran vdout0_35ck150 FIND v(dout0_35) AT=755.025n

* CHECK dout0_36 Vdout0_36ck150 = 0 time = 755
.meas tran vdout0_36ck150 FIND v(dout0_36) AT=755.025n

* CHECK dout0_37 Vdout0_37ck150 = 0.9 time = 755
.meas tran vdout0_37ck150 FIND v(dout0_37) AT=755.025n

* CHECK dout0_38 Vdout0_38ck150 = 0.9 time = 755
.meas tran vdout0_38ck150 FIND v(dout0_38) AT=755.025n

* CHECK dout0_39 Vdout0_39ck150 = 0.9 time = 755
.meas tran vdout0_39ck150 FIND v(dout0_39) AT=755.025n

* CHECK dout0_40 Vdout0_40ck150 = 0 time = 755
.meas tran vdout0_40ck150 FIND v(dout0_40) AT=755.025n

* CHECK dout0_41 Vdout0_41ck150 = 0 time = 755
.meas tran vdout0_41ck150 FIND v(dout0_41) AT=755.025n

* CHECK dout0_42 Vdout0_42ck150 = 0 time = 755
.meas tran vdout0_42ck150 FIND v(dout0_42) AT=755.025n

* CHECK dout0_43 Vdout0_43ck150 = 0.9 time = 755
.meas tran vdout0_43ck150 FIND v(dout0_43) AT=755.025n

* CHECK dout0_44 Vdout0_44ck150 = 0.9 time = 755
.meas tran vdout0_44ck150 FIND v(dout0_44) AT=755.025n

* CHECK dout0_45 Vdout0_45ck150 = 0 time = 755
.meas tran vdout0_45ck150 FIND v(dout0_45) AT=755.025n

* CHECK dout0_46 Vdout0_46ck150 = 0.9 time = 755
.meas tran vdout0_46ck150 FIND v(dout0_46) AT=755.025n

* CHECK dout0_47 Vdout0_47ck150 = 0 time = 755
.meas tran vdout0_47ck150 FIND v(dout0_47) AT=755.025n

* CHECK dout0_48 Vdout0_48ck150 = 0 time = 755
.meas tran vdout0_48ck150 FIND v(dout0_48) AT=755.025n

* CHECK dout0_49 Vdout0_49ck150 = 0.9 time = 755
.meas tran vdout0_49ck150 FIND v(dout0_49) AT=755.025n

* CHECK dout0_50 Vdout0_50ck150 = 0.9 time = 755
.meas tran vdout0_50ck150 FIND v(dout0_50) AT=755.025n

* CHECK dout0_51 Vdout0_51ck150 = 0.9 time = 755
.meas tran vdout0_51ck150 FIND v(dout0_51) AT=755.025n

* CHECK dout0_52 Vdout0_52ck150 = 0 time = 755
.meas tran vdout0_52ck150 FIND v(dout0_52) AT=755.025n

* CHECK dout0_53 Vdout0_53ck150 = 0 time = 755
.meas tran vdout0_53ck150 FIND v(dout0_53) AT=755.025n

* CHECK dout0_54 Vdout0_54ck150 = 0.9 time = 755
.meas tran vdout0_54ck150 FIND v(dout0_54) AT=755.025n

* CHECK dout0_55 Vdout0_55ck150 = 0 time = 755
.meas tran vdout0_55ck150 FIND v(dout0_55) AT=755.025n

* CHECK dout0_56 Vdout0_56ck150 = 0 time = 755
.meas tran vdout0_56ck150 FIND v(dout0_56) AT=755.025n

* CHECK dout0_57 Vdout0_57ck150 = 0 time = 755
.meas tran vdout0_57ck150 FIND v(dout0_57) AT=755.025n

* CHECK dout0_58 Vdout0_58ck150 = 0 time = 755
.meas tran vdout0_58ck150 FIND v(dout0_58) AT=755.025n

* CHECK dout0_59 Vdout0_59ck150 = 0 time = 755
.meas tran vdout0_59ck150 FIND v(dout0_59) AT=755.025n

* CHECK dout0_60 Vdout0_60ck150 = 0.9 time = 755
.meas tran vdout0_60ck150 FIND v(dout0_60) AT=755.025n

* CHECK dout0_61 Vdout0_61ck150 = 0.9 time = 755
.meas tran vdout0_61ck150 FIND v(dout0_61) AT=755.025n

* CHECK dout0_62 Vdout0_62ck150 = 0 time = 755
.meas tran vdout0_62ck150 FIND v(dout0_62) AT=755.025n

* CHECK dout0_63 Vdout0_63ck150 = 0 time = 755
.meas tran vdout0_63ck150 FIND v(dout0_63) AT=755.025n

* CHECK dout0_0 Vdout0_0ck151 = 0.9 time = 760
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=760.025n

* CHECK dout0_1 Vdout0_1ck151 = 0.9 time = 760
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=760.025n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 760
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=760.025n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 760
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=760.025n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 760
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=760.025n

* CHECK dout0_5 Vdout0_5ck151 = 0.9 time = 760
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=760.025n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 760
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=760.025n

* CHECK dout0_7 Vdout0_7ck151 = 0.9 time = 760
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=760.025n

* CHECK dout0_8 Vdout0_8ck151 = 0.9 time = 760
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=760.025n

* CHECK dout0_9 Vdout0_9ck151 = 0.9 time = 760
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=760.025n

* CHECK dout0_10 Vdout0_10ck151 = 0 time = 760
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=760.025n

* CHECK dout0_11 Vdout0_11ck151 = 0.9 time = 760
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=760.025n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 760
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=760.025n

* CHECK dout0_13 Vdout0_13ck151 = 0.9 time = 760
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=760.025n

* CHECK dout0_14 Vdout0_14ck151 = 0.9 time = 760
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=760.025n

* CHECK dout0_15 Vdout0_15ck151 = 0.9 time = 760
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=760.025n

* CHECK dout0_16 Vdout0_16ck151 = 0 time = 760
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=760.025n

* CHECK dout0_17 Vdout0_17ck151 = 0.9 time = 760
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=760.025n

* CHECK dout0_18 Vdout0_18ck151 = 0 time = 760
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=760.025n

* CHECK dout0_19 Vdout0_19ck151 = 0.9 time = 760
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=760.025n

* CHECK dout0_20 Vdout0_20ck151 = 0 time = 760
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=760.025n

* CHECK dout0_21 Vdout0_21ck151 = 0.9 time = 760
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=760.025n

* CHECK dout0_22 Vdout0_22ck151 = 0.9 time = 760
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=760.025n

* CHECK dout0_23 Vdout0_23ck151 = 0 time = 760
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=760.025n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 760
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=760.025n

* CHECK dout0_25 Vdout0_25ck151 = 0 time = 760
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=760.025n

* CHECK dout0_26 Vdout0_26ck151 = 0 time = 760
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=760.025n

* CHECK dout0_27 Vdout0_27ck151 = 0 time = 760
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=760.025n

* CHECK dout0_28 Vdout0_28ck151 = 0 time = 760
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=760.025n

* CHECK dout0_29 Vdout0_29ck151 = 0.9 time = 760
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=760.025n

* CHECK dout0_30 Vdout0_30ck151 = 0 time = 760
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=760.025n

* CHECK dout0_31 Vdout0_31ck151 = 0 time = 760
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=760.025n

* CHECK dout0_32 Vdout0_32ck151 = 0 time = 760
.meas tran vdout0_32ck151 FIND v(dout0_32) AT=760.025n

* CHECK dout0_33 Vdout0_33ck151 = 0.9 time = 760
.meas tran vdout0_33ck151 FIND v(dout0_33) AT=760.025n

* CHECK dout0_34 Vdout0_34ck151 = 0 time = 760
.meas tran vdout0_34ck151 FIND v(dout0_34) AT=760.025n

* CHECK dout0_35 Vdout0_35ck151 = 0.9 time = 760
.meas tran vdout0_35ck151 FIND v(dout0_35) AT=760.025n

* CHECK dout0_36 Vdout0_36ck151 = 0.9 time = 760
.meas tran vdout0_36ck151 FIND v(dout0_36) AT=760.025n

* CHECK dout0_37 Vdout0_37ck151 = 0 time = 760
.meas tran vdout0_37ck151 FIND v(dout0_37) AT=760.025n

* CHECK dout0_38 Vdout0_38ck151 = 0.9 time = 760
.meas tran vdout0_38ck151 FIND v(dout0_38) AT=760.025n

* CHECK dout0_39 Vdout0_39ck151 = 0.9 time = 760
.meas tran vdout0_39ck151 FIND v(dout0_39) AT=760.025n

* CHECK dout0_40 Vdout0_40ck151 = 0 time = 760
.meas tran vdout0_40ck151 FIND v(dout0_40) AT=760.025n

* CHECK dout0_41 Vdout0_41ck151 = 0 time = 760
.meas tran vdout0_41ck151 FIND v(dout0_41) AT=760.025n

* CHECK dout0_42 Vdout0_42ck151 = 0.9 time = 760
.meas tran vdout0_42ck151 FIND v(dout0_42) AT=760.025n

* CHECK dout0_43 Vdout0_43ck151 = 0.9 time = 760
.meas tran vdout0_43ck151 FIND v(dout0_43) AT=760.025n

* CHECK dout0_44 Vdout0_44ck151 = 0.9 time = 760
.meas tran vdout0_44ck151 FIND v(dout0_44) AT=760.025n

* CHECK dout0_45 Vdout0_45ck151 = 0.9 time = 760
.meas tran vdout0_45ck151 FIND v(dout0_45) AT=760.025n

* CHECK dout0_46 Vdout0_46ck151 = 0 time = 760
.meas tran vdout0_46ck151 FIND v(dout0_46) AT=760.025n

* CHECK dout0_47 Vdout0_47ck151 = 0 time = 760
.meas tran vdout0_47ck151 FIND v(dout0_47) AT=760.025n

* CHECK dout0_48 Vdout0_48ck151 = 0.9 time = 760
.meas tran vdout0_48ck151 FIND v(dout0_48) AT=760.025n

* CHECK dout0_49 Vdout0_49ck151 = 0.9 time = 760
.meas tran vdout0_49ck151 FIND v(dout0_49) AT=760.025n

* CHECK dout0_50 Vdout0_50ck151 = 0 time = 760
.meas tran vdout0_50ck151 FIND v(dout0_50) AT=760.025n

* CHECK dout0_51 Vdout0_51ck151 = 0.9 time = 760
.meas tran vdout0_51ck151 FIND v(dout0_51) AT=760.025n

* CHECK dout0_52 Vdout0_52ck151 = 0.9 time = 760
.meas tran vdout0_52ck151 FIND v(dout0_52) AT=760.025n

* CHECK dout0_53 Vdout0_53ck151 = 0.9 time = 760
.meas tran vdout0_53ck151 FIND v(dout0_53) AT=760.025n

* CHECK dout0_54 Vdout0_54ck151 = 0 time = 760
.meas tran vdout0_54ck151 FIND v(dout0_54) AT=760.025n

* CHECK dout0_55 Vdout0_55ck151 = 0 time = 760
.meas tran vdout0_55ck151 FIND v(dout0_55) AT=760.025n

* CHECK dout0_56 Vdout0_56ck151 = 0.9 time = 760
.meas tran vdout0_56ck151 FIND v(dout0_56) AT=760.025n

* CHECK dout0_57 Vdout0_57ck151 = 0.9 time = 760
.meas tran vdout0_57ck151 FIND v(dout0_57) AT=760.025n

* CHECK dout0_58 Vdout0_58ck151 = 0 time = 760
.meas tran vdout0_58ck151 FIND v(dout0_58) AT=760.025n

* CHECK dout0_59 Vdout0_59ck151 = 0 time = 760
.meas tran vdout0_59ck151 FIND v(dout0_59) AT=760.025n

* CHECK dout0_60 Vdout0_60ck151 = 0.9 time = 760
.meas tran vdout0_60ck151 FIND v(dout0_60) AT=760.025n

* CHECK dout0_61 Vdout0_61ck151 = 0.9 time = 760
.meas tran vdout0_61ck151 FIND v(dout0_61) AT=760.025n

* CHECK dout0_62 Vdout0_62ck151 = 0.9 time = 760
.meas tran vdout0_62ck151 FIND v(dout0_62) AT=760.025n

* CHECK dout0_63 Vdout0_63ck151 = 0.9 time = 760
.meas tran vdout0_63ck151 FIND v(dout0_63) AT=760.025n

* CHECK dout0_0 Vdout0_0ck154 = 0 time = 775
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=775.025n

* CHECK dout0_1 Vdout0_1ck154 = 0.9 time = 775
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=775.025n

* CHECK dout0_2 Vdout0_2ck154 = 0 time = 775
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=775.025n

* CHECK dout0_3 Vdout0_3ck154 = 0.9 time = 775
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=775.025n

* CHECK dout0_4 Vdout0_4ck154 = 0.9 time = 775
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=775.025n

* CHECK dout0_5 Vdout0_5ck154 = 0.9 time = 775
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=775.025n

* CHECK dout0_6 Vdout0_6ck154 = 0.9 time = 775
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=775.025n

* CHECK dout0_7 Vdout0_7ck154 = 0.9 time = 775
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=775.025n

* CHECK dout0_8 Vdout0_8ck154 = 0.9 time = 775
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=775.025n

* CHECK dout0_9 Vdout0_9ck154 = 0.9 time = 775
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=775.025n

* CHECK dout0_10 Vdout0_10ck154 = 0 time = 775
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=775.025n

* CHECK dout0_11 Vdout0_11ck154 = 0 time = 775
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=775.025n

* CHECK dout0_12 Vdout0_12ck154 = 0 time = 775
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=775.025n

* CHECK dout0_13 Vdout0_13ck154 = 0 time = 775
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=775.025n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 775
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=775.025n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 775
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=775.025n

* CHECK dout0_16 Vdout0_16ck154 = 0.9 time = 775
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=775.025n

* CHECK dout0_17 Vdout0_17ck154 = 0.9 time = 775
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=775.025n

* CHECK dout0_18 Vdout0_18ck154 = 0.9 time = 775
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=775.025n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 775
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=775.025n

* CHECK dout0_20 Vdout0_20ck154 = 0.9 time = 775
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=775.025n

* CHECK dout0_21 Vdout0_21ck154 = 0 time = 775
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=775.025n

* CHECK dout0_22 Vdout0_22ck154 = 0 time = 775
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=775.025n

* CHECK dout0_23 Vdout0_23ck154 = 0.9 time = 775
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=775.025n

* CHECK dout0_24 Vdout0_24ck154 = 0.9 time = 775
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=775.025n

* CHECK dout0_25 Vdout0_25ck154 = 0.9 time = 775
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=775.025n

* CHECK dout0_26 Vdout0_26ck154 = 0 time = 775
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=775.025n

* CHECK dout0_27 Vdout0_27ck154 = 0 time = 775
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=775.025n

* CHECK dout0_28 Vdout0_28ck154 = 0 time = 775
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=775.025n

* CHECK dout0_29 Vdout0_29ck154 = 0 time = 775
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=775.025n

* CHECK dout0_30 Vdout0_30ck154 = 0.9 time = 775
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=775.025n

* CHECK dout0_31 Vdout0_31ck154 = 0 time = 775
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=775.025n

* CHECK dout0_32 Vdout0_32ck154 = 0 time = 775
.meas tran vdout0_32ck154 FIND v(dout0_32) AT=775.025n

* CHECK dout0_33 Vdout0_33ck154 = 0 time = 775
.meas tran vdout0_33ck154 FIND v(dout0_33) AT=775.025n

* CHECK dout0_34 Vdout0_34ck154 = 0 time = 775
.meas tran vdout0_34ck154 FIND v(dout0_34) AT=775.025n

* CHECK dout0_35 Vdout0_35ck154 = 0 time = 775
.meas tran vdout0_35ck154 FIND v(dout0_35) AT=775.025n

* CHECK dout0_36 Vdout0_36ck154 = 0 time = 775
.meas tran vdout0_36ck154 FIND v(dout0_36) AT=775.025n

* CHECK dout0_37 Vdout0_37ck154 = 0.9 time = 775
.meas tran vdout0_37ck154 FIND v(dout0_37) AT=775.025n

* CHECK dout0_38 Vdout0_38ck154 = 0 time = 775
.meas tran vdout0_38ck154 FIND v(dout0_38) AT=775.025n

* CHECK dout0_39 Vdout0_39ck154 = 0.9 time = 775
.meas tran vdout0_39ck154 FIND v(dout0_39) AT=775.025n

* CHECK dout0_40 Vdout0_40ck154 = 0.9 time = 775
.meas tran vdout0_40ck154 FIND v(dout0_40) AT=775.025n

* CHECK dout0_41 Vdout0_41ck154 = 0 time = 775
.meas tran vdout0_41ck154 FIND v(dout0_41) AT=775.025n

* CHECK dout0_42 Vdout0_42ck154 = 0 time = 775
.meas tran vdout0_42ck154 FIND v(dout0_42) AT=775.025n

* CHECK dout0_43 Vdout0_43ck154 = 0 time = 775
.meas tran vdout0_43ck154 FIND v(dout0_43) AT=775.025n

* CHECK dout0_44 Vdout0_44ck154 = 0 time = 775
.meas tran vdout0_44ck154 FIND v(dout0_44) AT=775.025n

* CHECK dout0_45 Vdout0_45ck154 = 0 time = 775
.meas tran vdout0_45ck154 FIND v(dout0_45) AT=775.025n

* CHECK dout0_46 Vdout0_46ck154 = 0.9 time = 775
.meas tran vdout0_46ck154 FIND v(dout0_46) AT=775.025n

* CHECK dout0_47 Vdout0_47ck154 = 0 time = 775
.meas tran vdout0_47ck154 FIND v(dout0_47) AT=775.025n

* CHECK dout0_48 Vdout0_48ck154 = 0 time = 775
.meas tran vdout0_48ck154 FIND v(dout0_48) AT=775.025n

* CHECK dout0_49 Vdout0_49ck154 = 0.9 time = 775
.meas tran vdout0_49ck154 FIND v(dout0_49) AT=775.025n

* CHECK dout0_50 Vdout0_50ck154 = 0 time = 775
.meas tran vdout0_50ck154 FIND v(dout0_50) AT=775.025n

* CHECK dout0_51 Vdout0_51ck154 = 0.9 time = 775
.meas tran vdout0_51ck154 FIND v(dout0_51) AT=775.025n

* CHECK dout0_52 Vdout0_52ck154 = 0.9 time = 775
.meas tran vdout0_52ck154 FIND v(dout0_52) AT=775.025n

* CHECK dout0_53 Vdout0_53ck154 = 0 time = 775
.meas tran vdout0_53ck154 FIND v(dout0_53) AT=775.025n

* CHECK dout0_54 Vdout0_54ck154 = 0 time = 775
.meas tran vdout0_54ck154 FIND v(dout0_54) AT=775.025n

* CHECK dout0_55 Vdout0_55ck154 = 0 time = 775
.meas tran vdout0_55ck154 FIND v(dout0_55) AT=775.025n

* CHECK dout0_56 Vdout0_56ck154 = 0.9 time = 775
.meas tran vdout0_56ck154 FIND v(dout0_56) AT=775.025n

* CHECK dout0_57 Vdout0_57ck154 = 0.9 time = 775
.meas tran vdout0_57ck154 FIND v(dout0_57) AT=775.025n

* CHECK dout0_58 Vdout0_58ck154 = 0 time = 775
.meas tran vdout0_58ck154 FIND v(dout0_58) AT=775.025n

* CHECK dout0_59 Vdout0_59ck154 = 0.9 time = 775
.meas tran vdout0_59ck154 FIND v(dout0_59) AT=775.025n

* CHECK dout0_60 Vdout0_60ck154 = 0.9 time = 775
.meas tran vdout0_60ck154 FIND v(dout0_60) AT=775.025n

* CHECK dout0_61 Vdout0_61ck154 = 0 time = 775
.meas tran vdout0_61ck154 FIND v(dout0_61) AT=775.025n

* CHECK dout0_62 Vdout0_62ck154 = 0.9 time = 775
.meas tran vdout0_62ck154 FIND v(dout0_62) AT=775.025n

* CHECK dout0_63 Vdout0_63ck154 = 0.9 time = 775
.meas tran vdout0_63ck154 FIND v(dout0_63) AT=775.025n

* CHECK dout0_0 Vdout0_0ck155 = 0 time = 780
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=780.025n

* CHECK dout0_1 Vdout0_1ck155 = 0.9 time = 780
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=780.025n

* CHECK dout0_2 Vdout0_2ck155 = 0 time = 780
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=780.025n

* CHECK dout0_3 Vdout0_3ck155 = 0.9 time = 780
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=780.025n

* CHECK dout0_4 Vdout0_4ck155 = 0.9 time = 780
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=780.025n

* CHECK dout0_5 Vdout0_5ck155 = 0.9 time = 780
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=780.025n

* CHECK dout0_6 Vdout0_6ck155 = 0.9 time = 780
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=780.025n

* CHECK dout0_7 Vdout0_7ck155 = 0.9 time = 780
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=780.025n

* CHECK dout0_8 Vdout0_8ck155 = 0.9 time = 780
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=780.025n

* CHECK dout0_9 Vdout0_9ck155 = 0.9 time = 780
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=780.025n

* CHECK dout0_10 Vdout0_10ck155 = 0 time = 780
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=780.025n

* CHECK dout0_11 Vdout0_11ck155 = 0 time = 780
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=780.025n

* CHECK dout0_12 Vdout0_12ck155 = 0 time = 780
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=780.025n

* CHECK dout0_13 Vdout0_13ck155 = 0 time = 780
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=780.025n

* CHECK dout0_14 Vdout0_14ck155 = 0 time = 780
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=780.025n

* CHECK dout0_15 Vdout0_15ck155 = 0 time = 780
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=780.025n

* CHECK dout0_16 Vdout0_16ck155 = 0.9 time = 780
.meas tran vdout0_16ck155 FIND v(dout0_16) AT=780.025n

* CHECK dout0_17 Vdout0_17ck155 = 0.9 time = 780
.meas tran vdout0_17ck155 FIND v(dout0_17) AT=780.025n

* CHECK dout0_18 Vdout0_18ck155 = 0.9 time = 780
.meas tran vdout0_18ck155 FIND v(dout0_18) AT=780.025n

* CHECK dout0_19 Vdout0_19ck155 = 0 time = 780
.meas tran vdout0_19ck155 FIND v(dout0_19) AT=780.025n

* CHECK dout0_20 Vdout0_20ck155 = 0.9 time = 780
.meas tran vdout0_20ck155 FIND v(dout0_20) AT=780.025n

* CHECK dout0_21 Vdout0_21ck155 = 0 time = 780
.meas tran vdout0_21ck155 FIND v(dout0_21) AT=780.025n

* CHECK dout0_22 Vdout0_22ck155 = 0 time = 780
.meas tran vdout0_22ck155 FIND v(dout0_22) AT=780.025n

* CHECK dout0_23 Vdout0_23ck155 = 0.9 time = 780
.meas tran vdout0_23ck155 FIND v(dout0_23) AT=780.025n

* CHECK dout0_24 Vdout0_24ck155 = 0.9 time = 780
.meas tran vdout0_24ck155 FIND v(dout0_24) AT=780.025n

* CHECK dout0_25 Vdout0_25ck155 = 0.9 time = 780
.meas tran vdout0_25ck155 FIND v(dout0_25) AT=780.025n

* CHECK dout0_26 Vdout0_26ck155 = 0 time = 780
.meas tran vdout0_26ck155 FIND v(dout0_26) AT=780.025n

* CHECK dout0_27 Vdout0_27ck155 = 0 time = 780
.meas tran vdout0_27ck155 FIND v(dout0_27) AT=780.025n

* CHECK dout0_28 Vdout0_28ck155 = 0 time = 780
.meas tran vdout0_28ck155 FIND v(dout0_28) AT=780.025n

* CHECK dout0_29 Vdout0_29ck155 = 0 time = 780
.meas tran vdout0_29ck155 FIND v(dout0_29) AT=780.025n

* CHECK dout0_30 Vdout0_30ck155 = 0.9 time = 780
.meas tran vdout0_30ck155 FIND v(dout0_30) AT=780.025n

* CHECK dout0_31 Vdout0_31ck155 = 0 time = 780
.meas tran vdout0_31ck155 FIND v(dout0_31) AT=780.025n

* CHECK dout0_32 Vdout0_32ck155 = 0 time = 780
.meas tran vdout0_32ck155 FIND v(dout0_32) AT=780.025n

* CHECK dout0_33 Vdout0_33ck155 = 0 time = 780
.meas tran vdout0_33ck155 FIND v(dout0_33) AT=780.025n

* CHECK dout0_34 Vdout0_34ck155 = 0 time = 780
.meas tran vdout0_34ck155 FIND v(dout0_34) AT=780.025n

* CHECK dout0_35 Vdout0_35ck155 = 0 time = 780
.meas tran vdout0_35ck155 FIND v(dout0_35) AT=780.025n

* CHECK dout0_36 Vdout0_36ck155 = 0 time = 780
.meas tran vdout0_36ck155 FIND v(dout0_36) AT=780.025n

* CHECK dout0_37 Vdout0_37ck155 = 0.9 time = 780
.meas tran vdout0_37ck155 FIND v(dout0_37) AT=780.025n

* CHECK dout0_38 Vdout0_38ck155 = 0 time = 780
.meas tran vdout0_38ck155 FIND v(dout0_38) AT=780.025n

* CHECK dout0_39 Vdout0_39ck155 = 0.9 time = 780
.meas tran vdout0_39ck155 FIND v(dout0_39) AT=780.025n

* CHECK dout0_40 Vdout0_40ck155 = 0.9 time = 780
.meas tran vdout0_40ck155 FIND v(dout0_40) AT=780.025n

* CHECK dout0_41 Vdout0_41ck155 = 0 time = 780
.meas tran vdout0_41ck155 FIND v(dout0_41) AT=780.025n

* CHECK dout0_42 Vdout0_42ck155 = 0 time = 780
.meas tran vdout0_42ck155 FIND v(dout0_42) AT=780.025n

* CHECK dout0_43 Vdout0_43ck155 = 0 time = 780
.meas tran vdout0_43ck155 FIND v(dout0_43) AT=780.025n

* CHECK dout0_44 Vdout0_44ck155 = 0 time = 780
.meas tran vdout0_44ck155 FIND v(dout0_44) AT=780.025n

* CHECK dout0_45 Vdout0_45ck155 = 0 time = 780
.meas tran vdout0_45ck155 FIND v(dout0_45) AT=780.025n

* CHECK dout0_46 Vdout0_46ck155 = 0.9 time = 780
.meas tran vdout0_46ck155 FIND v(dout0_46) AT=780.025n

* CHECK dout0_47 Vdout0_47ck155 = 0 time = 780
.meas tran vdout0_47ck155 FIND v(dout0_47) AT=780.025n

* CHECK dout0_48 Vdout0_48ck155 = 0 time = 780
.meas tran vdout0_48ck155 FIND v(dout0_48) AT=780.025n

* CHECK dout0_49 Vdout0_49ck155 = 0.9 time = 780
.meas tran vdout0_49ck155 FIND v(dout0_49) AT=780.025n

* CHECK dout0_50 Vdout0_50ck155 = 0 time = 780
.meas tran vdout0_50ck155 FIND v(dout0_50) AT=780.025n

* CHECK dout0_51 Vdout0_51ck155 = 0.9 time = 780
.meas tran vdout0_51ck155 FIND v(dout0_51) AT=780.025n

* CHECK dout0_52 Vdout0_52ck155 = 0.9 time = 780
.meas tran vdout0_52ck155 FIND v(dout0_52) AT=780.025n

* CHECK dout0_53 Vdout0_53ck155 = 0 time = 780
.meas tran vdout0_53ck155 FIND v(dout0_53) AT=780.025n

* CHECK dout0_54 Vdout0_54ck155 = 0 time = 780
.meas tran vdout0_54ck155 FIND v(dout0_54) AT=780.025n

* CHECK dout0_55 Vdout0_55ck155 = 0 time = 780
.meas tran vdout0_55ck155 FIND v(dout0_55) AT=780.025n

* CHECK dout0_56 Vdout0_56ck155 = 0.9 time = 780
.meas tran vdout0_56ck155 FIND v(dout0_56) AT=780.025n

* CHECK dout0_57 Vdout0_57ck155 = 0.9 time = 780
.meas tran vdout0_57ck155 FIND v(dout0_57) AT=780.025n

* CHECK dout0_58 Vdout0_58ck155 = 0 time = 780
.meas tran vdout0_58ck155 FIND v(dout0_58) AT=780.025n

* CHECK dout0_59 Vdout0_59ck155 = 0.9 time = 780
.meas tran vdout0_59ck155 FIND v(dout0_59) AT=780.025n

* CHECK dout0_60 Vdout0_60ck155 = 0.9 time = 780
.meas tran vdout0_60ck155 FIND v(dout0_60) AT=780.025n

* CHECK dout0_61 Vdout0_61ck155 = 0 time = 780
.meas tran vdout0_61ck155 FIND v(dout0_61) AT=780.025n

* CHECK dout0_62 Vdout0_62ck155 = 0.9 time = 780
.meas tran vdout0_62ck155 FIND v(dout0_62) AT=780.025n

* CHECK dout0_63 Vdout0_63ck155 = 0.9 time = 780
.meas tran vdout0_63ck155 FIND v(dout0_63) AT=780.025n

* CHECK dout0_0 Vdout0_0ck157 = 0.9 time = 790
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=790.025n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 790
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=790.025n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 790
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=790.025n

* CHECK dout0_3 Vdout0_3ck157 = 0 time = 790
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=790.025n

* CHECK dout0_4 Vdout0_4ck157 = 0 time = 790
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=790.025n

* CHECK dout0_5 Vdout0_5ck157 = 0.9 time = 790
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=790.025n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 790
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=790.025n

* CHECK dout0_7 Vdout0_7ck157 = 0.9 time = 790
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=790.025n

* CHECK dout0_8 Vdout0_8ck157 = 0 time = 790
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=790.025n

* CHECK dout0_9 Vdout0_9ck157 = 0.9 time = 790
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=790.025n

* CHECK dout0_10 Vdout0_10ck157 = 0.9 time = 790
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=790.025n

* CHECK dout0_11 Vdout0_11ck157 = 0.9 time = 790
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=790.025n

* CHECK dout0_12 Vdout0_12ck157 = 0.9 time = 790
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=790.025n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 790
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=790.025n

* CHECK dout0_14 Vdout0_14ck157 = 0.9 time = 790
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=790.025n

* CHECK dout0_15 Vdout0_15ck157 = 0.9 time = 790
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=790.025n

* CHECK dout0_16 Vdout0_16ck157 = 0.9 time = 790
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=790.025n

* CHECK dout0_17 Vdout0_17ck157 = 0 time = 790
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=790.025n

* CHECK dout0_18 Vdout0_18ck157 = 0.9 time = 790
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=790.025n

* CHECK dout0_19 Vdout0_19ck157 = 0.9 time = 790
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=790.025n

* CHECK dout0_20 Vdout0_20ck157 = 0.9 time = 790
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=790.025n

* CHECK dout0_21 Vdout0_21ck157 = 0.9 time = 790
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=790.025n

* CHECK dout0_22 Vdout0_22ck157 = 0.9 time = 790
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=790.025n

* CHECK dout0_23 Vdout0_23ck157 = 0.9 time = 790
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=790.025n

* CHECK dout0_24 Vdout0_24ck157 = 0 time = 790
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=790.025n

* CHECK dout0_25 Vdout0_25ck157 = 0 time = 790
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=790.025n

* CHECK dout0_26 Vdout0_26ck157 = 0 time = 790
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=790.025n

* CHECK dout0_27 Vdout0_27ck157 = 0 time = 790
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=790.025n

* CHECK dout0_28 Vdout0_28ck157 = 0.9 time = 790
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=790.025n

* CHECK dout0_29 Vdout0_29ck157 = 0 time = 790
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=790.025n

* CHECK dout0_30 Vdout0_30ck157 = 0.9 time = 790
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=790.025n

* CHECK dout0_31 Vdout0_31ck157 = 0 time = 790
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=790.025n

* CHECK dout0_32 Vdout0_32ck157 = 0.9 time = 790
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=790.025n

* CHECK dout0_33 Vdout0_33ck157 = 0.9 time = 790
.meas tran vdout0_33ck157 FIND v(dout0_33) AT=790.025n

* CHECK dout0_34 Vdout0_34ck157 = 0.9 time = 790
.meas tran vdout0_34ck157 FIND v(dout0_34) AT=790.025n

* CHECK dout0_35 Vdout0_35ck157 = 0 time = 790
.meas tran vdout0_35ck157 FIND v(dout0_35) AT=790.025n

* CHECK dout0_36 Vdout0_36ck157 = 0.9 time = 790
.meas tran vdout0_36ck157 FIND v(dout0_36) AT=790.025n

* CHECK dout0_37 Vdout0_37ck157 = 0 time = 790
.meas tran vdout0_37ck157 FIND v(dout0_37) AT=790.025n

* CHECK dout0_38 Vdout0_38ck157 = 0.9 time = 790
.meas tran vdout0_38ck157 FIND v(dout0_38) AT=790.025n

* CHECK dout0_39 Vdout0_39ck157 = 0 time = 790
.meas tran vdout0_39ck157 FIND v(dout0_39) AT=790.025n

* CHECK dout0_40 Vdout0_40ck157 = 0 time = 790
.meas tran vdout0_40ck157 FIND v(dout0_40) AT=790.025n

* CHECK dout0_41 Vdout0_41ck157 = 0 time = 790
.meas tran vdout0_41ck157 FIND v(dout0_41) AT=790.025n

* CHECK dout0_42 Vdout0_42ck157 = 0.9 time = 790
.meas tran vdout0_42ck157 FIND v(dout0_42) AT=790.025n

* CHECK dout0_43 Vdout0_43ck157 = 0.9 time = 790
.meas tran vdout0_43ck157 FIND v(dout0_43) AT=790.025n

* CHECK dout0_44 Vdout0_44ck157 = 0 time = 790
.meas tran vdout0_44ck157 FIND v(dout0_44) AT=790.025n

* CHECK dout0_45 Vdout0_45ck157 = 0.9 time = 790
.meas tran vdout0_45ck157 FIND v(dout0_45) AT=790.025n

* CHECK dout0_46 Vdout0_46ck157 = 0 time = 790
.meas tran vdout0_46ck157 FIND v(dout0_46) AT=790.025n

* CHECK dout0_47 Vdout0_47ck157 = 0.9 time = 790
.meas tran vdout0_47ck157 FIND v(dout0_47) AT=790.025n

* CHECK dout0_48 Vdout0_48ck157 = 0 time = 790
.meas tran vdout0_48ck157 FIND v(dout0_48) AT=790.025n

* CHECK dout0_49 Vdout0_49ck157 = 0.9 time = 790
.meas tran vdout0_49ck157 FIND v(dout0_49) AT=790.025n

* CHECK dout0_50 Vdout0_50ck157 = 0.9 time = 790
.meas tran vdout0_50ck157 FIND v(dout0_50) AT=790.025n

* CHECK dout0_51 Vdout0_51ck157 = 0 time = 790
.meas tran vdout0_51ck157 FIND v(dout0_51) AT=790.025n

* CHECK dout0_52 Vdout0_52ck157 = 0 time = 790
.meas tran vdout0_52ck157 FIND v(dout0_52) AT=790.025n

* CHECK dout0_53 Vdout0_53ck157 = 0 time = 790
.meas tran vdout0_53ck157 FIND v(dout0_53) AT=790.025n

* CHECK dout0_54 Vdout0_54ck157 = 0 time = 790
.meas tran vdout0_54ck157 FIND v(dout0_54) AT=790.025n

* CHECK dout0_55 Vdout0_55ck157 = 0 time = 790
.meas tran vdout0_55ck157 FIND v(dout0_55) AT=790.025n

* CHECK dout0_56 Vdout0_56ck157 = 0 time = 790
.meas tran vdout0_56ck157 FIND v(dout0_56) AT=790.025n

* CHECK dout0_57 Vdout0_57ck157 = 0 time = 790
.meas tran vdout0_57ck157 FIND v(dout0_57) AT=790.025n

* CHECK dout0_58 Vdout0_58ck157 = 0.9 time = 790
.meas tran vdout0_58ck157 FIND v(dout0_58) AT=790.025n

* CHECK dout0_59 Vdout0_59ck157 = 0.9 time = 790
.meas tran vdout0_59ck157 FIND v(dout0_59) AT=790.025n

* CHECK dout0_60 Vdout0_60ck157 = 0 time = 790
.meas tran vdout0_60ck157 FIND v(dout0_60) AT=790.025n

* CHECK dout0_61 Vdout0_61ck157 = 0 time = 790
.meas tran vdout0_61ck157 FIND v(dout0_61) AT=790.025n

* CHECK dout0_62 Vdout0_62ck157 = 0.9 time = 790
.meas tran vdout0_62ck157 FIND v(dout0_62) AT=790.025n

* CHECK dout0_63 Vdout0_63ck157 = 0.9 time = 790
.meas tran vdout0_63ck157 FIND v(dout0_63) AT=790.025n

* CHECK dout0_0 Vdout0_0ck159 = 0 time = 800
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=800.025n

* CHECK dout0_1 Vdout0_1ck159 = 0.9 time = 800
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=800.025n

* CHECK dout0_2 Vdout0_2ck159 = 0 time = 800
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=800.025n

* CHECK dout0_3 Vdout0_3ck159 = 0.9 time = 800
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=800.025n

* CHECK dout0_4 Vdout0_4ck159 = 0.9 time = 800
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=800.025n

* CHECK dout0_5 Vdout0_5ck159 = 0.9 time = 800
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=800.025n

* CHECK dout0_6 Vdout0_6ck159 = 0.9 time = 800
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=800.025n

* CHECK dout0_7 Vdout0_7ck159 = 0.9 time = 800
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=800.025n

* CHECK dout0_8 Vdout0_8ck159 = 0.9 time = 800
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=800.025n

* CHECK dout0_9 Vdout0_9ck159 = 0.9 time = 800
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=800.025n

* CHECK dout0_10 Vdout0_10ck159 = 0 time = 800
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=800.025n

* CHECK dout0_11 Vdout0_11ck159 = 0 time = 800
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=800.025n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 800
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=800.025n

* CHECK dout0_13 Vdout0_13ck159 = 0 time = 800
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=800.025n

* CHECK dout0_14 Vdout0_14ck159 = 0 time = 800
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=800.025n

* CHECK dout0_15 Vdout0_15ck159 = 0 time = 800
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=800.025n

* CHECK dout0_16 Vdout0_16ck159 = 0.9 time = 800
.meas tran vdout0_16ck159 FIND v(dout0_16) AT=800.025n

* CHECK dout0_17 Vdout0_17ck159 = 0.9 time = 800
.meas tran vdout0_17ck159 FIND v(dout0_17) AT=800.025n

* CHECK dout0_18 Vdout0_18ck159 = 0.9 time = 800
.meas tran vdout0_18ck159 FIND v(dout0_18) AT=800.025n

* CHECK dout0_19 Vdout0_19ck159 = 0 time = 800
.meas tran vdout0_19ck159 FIND v(dout0_19) AT=800.025n

* CHECK dout0_20 Vdout0_20ck159 = 0.9 time = 800
.meas tran vdout0_20ck159 FIND v(dout0_20) AT=800.025n

* CHECK dout0_21 Vdout0_21ck159 = 0 time = 800
.meas tran vdout0_21ck159 FIND v(dout0_21) AT=800.025n

* CHECK dout0_22 Vdout0_22ck159 = 0 time = 800
.meas tran vdout0_22ck159 FIND v(dout0_22) AT=800.025n

* CHECK dout0_23 Vdout0_23ck159 = 0.9 time = 800
.meas tran vdout0_23ck159 FIND v(dout0_23) AT=800.025n

* CHECK dout0_24 Vdout0_24ck159 = 0.9 time = 800
.meas tran vdout0_24ck159 FIND v(dout0_24) AT=800.025n

* CHECK dout0_25 Vdout0_25ck159 = 0.9 time = 800
.meas tran vdout0_25ck159 FIND v(dout0_25) AT=800.025n

* CHECK dout0_26 Vdout0_26ck159 = 0 time = 800
.meas tran vdout0_26ck159 FIND v(dout0_26) AT=800.025n

* CHECK dout0_27 Vdout0_27ck159 = 0 time = 800
.meas tran vdout0_27ck159 FIND v(dout0_27) AT=800.025n

* CHECK dout0_28 Vdout0_28ck159 = 0 time = 800
.meas tran vdout0_28ck159 FIND v(dout0_28) AT=800.025n

* CHECK dout0_29 Vdout0_29ck159 = 0 time = 800
.meas tran vdout0_29ck159 FIND v(dout0_29) AT=800.025n

* CHECK dout0_30 Vdout0_30ck159 = 0.9 time = 800
.meas tran vdout0_30ck159 FIND v(dout0_30) AT=800.025n

* CHECK dout0_31 Vdout0_31ck159 = 0 time = 800
.meas tran vdout0_31ck159 FIND v(dout0_31) AT=800.025n

* CHECK dout0_32 Vdout0_32ck159 = 0 time = 800
.meas tran vdout0_32ck159 FIND v(dout0_32) AT=800.025n

* CHECK dout0_33 Vdout0_33ck159 = 0 time = 800
.meas tran vdout0_33ck159 FIND v(dout0_33) AT=800.025n

* CHECK dout0_34 Vdout0_34ck159 = 0 time = 800
.meas tran vdout0_34ck159 FIND v(dout0_34) AT=800.025n

* CHECK dout0_35 Vdout0_35ck159 = 0 time = 800
.meas tran vdout0_35ck159 FIND v(dout0_35) AT=800.025n

* CHECK dout0_36 Vdout0_36ck159 = 0 time = 800
.meas tran vdout0_36ck159 FIND v(dout0_36) AT=800.025n

* CHECK dout0_37 Vdout0_37ck159 = 0.9 time = 800
.meas tran vdout0_37ck159 FIND v(dout0_37) AT=800.025n

* CHECK dout0_38 Vdout0_38ck159 = 0 time = 800
.meas tran vdout0_38ck159 FIND v(dout0_38) AT=800.025n

* CHECK dout0_39 Vdout0_39ck159 = 0.9 time = 800
.meas tran vdout0_39ck159 FIND v(dout0_39) AT=800.025n

* CHECK dout0_40 Vdout0_40ck159 = 0.9 time = 800
.meas tran vdout0_40ck159 FIND v(dout0_40) AT=800.025n

* CHECK dout0_41 Vdout0_41ck159 = 0 time = 800
.meas tran vdout0_41ck159 FIND v(dout0_41) AT=800.025n

* CHECK dout0_42 Vdout0_42ck159 = 0 time = 800
.meas tran vdout0_42ck159 FIND v(dout0_42) AT=800.025n

* CHECK dout0_43 Vdout0_43ck159 = 0 time = 800
.meas tran vdout0_43ck159 FIND v(dout0_43) AT=800.025n

* CHECK dout0_44 Vdout0_44ck159 = 0 time = 800
.meas tran vdout0_44ck159 FIND v(dout0_44) AT=800.025n

* CHECK dout0_45 Vdout0_45ck159 = 0 time = 800
.meas tran vdout0_45ck159 FIND v(dout0_45) AT=800.025n

* CHECK dout0_46 Vdout0_46ck159 = 0.9 time = 800
.meas tran vdout0_46ck159 FIND v(dout0_46) AT=800.025n

* CHECK dout0_47 Vdout0_47ck159 = 0 time = 800
.meas tran vdout0_47ck159 FIND v(dout0_47) AT=800.025n

* CHECK dout0_48 Vdout0_48ck159 = 0 time = 800
.meas tran vdout0_48ck159 FIND v(dout0_48) AT=800.025n

* CHECK dout0_49 Vdout0_49ck159 = 0.9 time = 800
.meas tran vdout0_49ck159 FIND v(dout0_49) AT=800.025n

* CHECK dout0_50 Vdout0_50ck159 = 0 time = 800
.meas tran vdout0_50ck159 FIND v(dout0_50) AT=800.025n

* CHECK dout0_51 Vdout0_51ck159 = 0.9 time = 800
.meas tran vdout0_51ck159 FIND v(dout0_51) AT=800.025n

* CHECK dout0_52 Vdout0_52ck159 = 0.9 time = 800
.meas tran vdout0_52ck159 FIND v(dout0_52) AT=800.025n

* CHECK dout0_53 Vdout0_53ck159 = 0 time = 800
.meas tran vdout0_53ck159 FIND v(dout0_53) AT=800.025n

* CHECK dout0_54 Vdout0_54ck159 = 0 time = 800
.meas tran vdout0_54ck159 FIND v(dout0_54) AT=800.025n

* CHECK dout0_55 Vdout0_55ck159 = 0 time = 800
.meas tran vdout0_55ck159 FIND v(dout0_55) AT=800.025n

* CHECK dout0_56 Vdout0_56ck159 = 0.9 time = 800
.meas tran vdout0_56ck159 FIND v(dout0_56) AT=800.025n

* CHECK dout0_57 Vdout0_57ck159 = 0.9 time = 800
.meas tran vdout0_57ck159 FIND v(dout0_57) AT=800.025n

* CHECK dout0_58 Vdout0_58ck159 = 0 time = 800
.meas tran vdout0_58ck159 FIND v(dout0_58) AT=800.025n

* CHECK dout0_59 Vdout0_59ck159 = 0.9 time = 800
.meas tran vdout0_59ck159 FIND v(dout0_59) AT=800.025n

* CHECK dout0_60 Vdout0_60ck159 = 0.9 time = 800
.meas tran vdout0_60ck159 FIND v(dout0_60) AT=800.025n

* CHECK dout0_61 Vdout0_61ck159 = 0 time = 800
.meas tran vdout0_61ck159 FIND v(dout0_61) AT=800.025n

* CHECK dout0_62 Vdout0_62ck159 = 0.9 time = 800
.meas tran vdout0_62ck159 FIND v(dout0_62) AT=800.025n

* CHECK dout0_63 Vdout0_63ck159 = 0.9 time = 800
.meas tran vdout0_63ck159 FIND v(dout0_63) AT=800.025n

* CHECK dout0_0 Vdout0_0ck165 = 0.9 time = 830
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=830.025n

* CHECK dout0_1 Vdout0_1ck165 = 0.9 time = 830
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=830.025n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 830
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=830.025n

* CHECK dout0_3 Vdout0_3ck165 = 0.9 time = 830
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=830.025n

* CHECK dout0_4 Vdout0_4ck165 = 0.9 time = 830
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=830.025n

* CHECK dout0_5 Vdout0_5ck165 = 0 time = 830
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=830.025n

* CHECK dout0_6 Vdout0_6ck165 = 0.9 time = 830
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=830.025n

* CHECK dout0_7 Vdout0_7ck165 = 0.9 time = 830
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=830.025n

* CHECK dout0_8 Vdout0_8ck165 = 0.9 time = 830
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=830.025n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 830
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=830.025n

* CHECK dout0_10 Vdout0_10ck165 = 0.9 time = 830
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=830.025n

* CHECK dout0_11 Vdout0_11ck165 = 0.9 time = 830
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=830.025n

* CHECK dout0_12 Vdout0_12ck165 = 0.9 time = 830
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=830.025n

* CHECK dout0_13 Vdout0_13ck165 = 0.9 time = 830
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=830.025n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 830
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=830.025n

* CHECK dout0_15 Vdout0_15ck165 = 0.9 time = 830
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=830.025n

* CHECK dout0_16 Vdout0_16ck165 = 0.9 time = 830
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=830.025n

* CHECK dout0_17 Vdout0_17ck165 = 0.9 time = 830
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=830.025n

* CHECK dout0_18 Vdout0_18ck165 = 0.9 time = 830
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=830.025n

* CHECK dout0_19 Vdout0_19ck165 = 0.9 time = 830
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=830.025n

* CHECK dout0_20 Vdout0_20ck165 = 0.9 time = 830
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=830.025n

* CHECK dout0_21 Vdout0_21ck165 = 0.9 time = 830
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=830.025n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 830
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=830.025n

* CHECK dout0_23 Vdout0_23ck165 = 0 time = 830
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=830.025n

* CHECK dout0_24 Vdout0_24ck165 = 0.9 time = 830
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=830.025n

* CHECK dout0_25 Vdout0_25ck165 = 0.9 time = 830
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=830.025n

* CHECK dout0_26 Vdout0_26ck165 = 0.9 time = 830
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=830.025n

* CHECK dout0_27 Vdout0_27ck165 = 0 time = 830
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=830.025n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 830
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=830.025n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 830
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=830.025n

* CHECK dout0_30 Vdout0_30ck165 = 0.9 time = 830
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=830.025n

* CHECK dout0_31 Vdout0_31ck165 = 0 time = 830
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=830.025n

* CHECK dout0_32 Vdout0_32ck165 = 0.9 time = 830
.meas tran vdout0_32ck165 FIND v(dout0_32) AT=830.025n

* CHECK dout0_33 Vdout0_33ck165 = 0 time = 830
.meas tran vdout0_33ck165 FIND v(dout0_33) AT=830.025n

* CHECK dout0_34 Vdout0_34ck165 = 0 time = 830
.meas tran vdout0_34ck165 FIND v(dout0_34) AT=830.025n

* CHECK dout0_35 Vdout0_35ck165 = 0 time = 830
.meas tran vdout0_35ck165 FIND v(dout0_35) AT=830.025n

* CHECK dout0_36 Vdout0_36ck165 = 0 time = 830
.meas tran vdout0_36ck165 FIND v(dout0_36) AT=830.025n

* CHECK dout0_37 Vdout0_37ck165 = 0.9 time = 830
.meas tran vdout0_37ck165 FIND v(dout0_37) AT=830.025n

* CHECK dout0_38 Vdout0_38ck165 = 0.9 time = 830
.meas tran vdout0_38ck165 FIND v(dout0_38) AT=830.025n

* CHECK dout0_39 Vdout0_39ck165 = 0.9 time = 830
.meas tran vdout0_39ck165 FIND v(dout0_39) AT=830.025n

* CHECK dout0_40 Vdout0_40ck165 = 0 time = 830
.meas tran vdout0_40ck165 FIND v(dout0_40) AT=830.025n

* CHECK dout0_41 Vdout0_41ck165 = 0 time = 830
.meas tran vdout0_41ck165 FIND v(dout0_41) AT=830.025n

* CHECK dout0_42 Vdout0_42ck165 = 0.9 time = 830
.meas tran vdout0_42ck165 FIND v(dout0_42) AT=830.025n

* CHECK dout0_43 Vdout0_43ck165 = 0 time = 830
.meas tran vdout0_43ck165 FIND v(dout0_43) AT=830.025n

* CHECK dout0_44 Vdout0_44ck165 = 0.9 time = 830
.meas tran vdout0_44ck165 FIND v(dout0_44) AT=830.025n

* CHECK dout0_45 Vdout0_45ck165 = 0.9 time = 830
.meas tran vdout0_45ck165 FIND v(dout0_45) AT=830.025n

* CHECK dout0_46 Vdout0_46ck165 = 0 time = 830
.meas tran vdout0_46ck165 FIND v(dout0_46) AT=830.025n

* CHECK dout0_47 Vdout0_47ck165 = 0.9 time = 830
.meas tran vdout0_47ck165 FIND v(dout0_47) AT=830.025n

* CHECK dout0_48 Vdout0_48ck165 = 0.9 time = 830
.meas tran vdout0_48ck165 FIND v(dout0_48) AT=830.025n

* CHECK dout0_49 Vdout0_49ck165 = 0 time = 830
.meas tran vdout0_49ck165 FIND v(dout0_49) AT=830.025n

* CHECK dout0_50 Vdout0_50ck165 = 0.9 time = 830
.meas tran vdout0_50ck165 FIND v(dout0_50) AT=830.025n

* CHECK dout0_51 Vdout0_51ck165 = 0.9 time = 830
.meas tran vdout0_51ck165 FIND v(dout0_51) AT=830.025n

* CHECK dout0_52 Vdout0_52ck165 = 0.9 time = 830
.meas tran vdout0_52ck165 FIND v(dout0_52) AT=830.025n

* CHECK dout0_53 Vdout0_53ck165 = 0.9 time = 830
.meas tran vdout0_53ck165 FIND v(dout0_53) AT=830.025n

* CHECK dout0_54 Vdout0_54ck165 = 0 time = 830
.meas tran vdout0_54ck165 FIND v(dout0_54) AT=830.025n

* CHECK dout0_55 Vdout0_55ck165 = 0.9 time = 830
.meas tran vdout0_55ck165 FIND v(dout0_55) AT=830.025n

* CHECK dout0_56 Vdout0_56ck165 = 0.9 time = 830
.meas tran vdout0_56ck165 FIND v(dout0_56) AT=830.025n

* CHECK dout0_57 Vdout0_57ck165 = 0 time = 830
.meas tran vdout0_57ck165 FIND v(dout0_57) AT=830.025n

* CHECK dout0_58 Vdout0_58ck165 = 0 time = 830
.meas tran vdout0_58ck165 FIND v(dout0_58) AT=830.025n

* CHECK dout0_59 Vdout0_59ck165 = 0 time = 830
.meas tran vdout0_59ck165 FIND v(dout0_59) AT=830.025n

* CHECK dout0_60 Vdout0_60ck165 = 0 time = 830
.meas tran vdout0_60ck165 FIND v(dout0_60) AT=830.025n

* CHECK dout0_61 Vdout0_61ck165 = 0 time = 830
.meas tran vdout0_61ck165 FIND v(dout0_61) AT=830.025n

* CHECK dout0_62 Vdout0_62ck165 = 0 time = 830
.meas tran vdout0_62ck165 FIND v(dout0_62) AT=830.025n

* CHECK dout0_63 Vdout0_63ck165 = 0.9 time = 830
.meas tran vdout0_63ck165 FIND v(dout0_63) AT=830.025n

* CHECK dout0_0 Vdout0_0ck166 = 0.9 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 0.9 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 0.9 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 0.9 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 0 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 0.9 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0.9 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 0.9 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0.9 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 0.9 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0.9 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 0.9 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 0.9 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 0.9 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 0.9 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0.9 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 0.9 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 0.9 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0.9 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 0 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 0.9 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0.9 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 0.9 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 0 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 0.9 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_32 Vdout0_32ck166 = 0.9 time = 835
.meas tran vdout0_32ck166 FIND v(dout0_32) AT=835.025n

* CHECK dout0_33 Vdout0_33ck166 = 0 time = 835
.meas tran vdout0_33ck166 FIND v(dout0_33) AT=835.025n

* CHECK dout0_34 Vdout0_34ck166 = 0 time = 835
.meas tran vdout0_34ck166 FIND v(dout0_34) AT=835.025n

* CHECK dout0_35 Vdout0_35ck166 = 0 time = 835
.meas tran vdout0_35ck166 FIND v(dout0_35) AT=835.025n

* CHECK dout0_36 Vdout0_36ck166 = 0 time = 835
.meas tran vdout0_36ck166 FIND v(dout0_36) AT=835.025n

* CHECK dout0_37 Vdout0_37ck166 = 0.9 time = 835
.meas tran vdout0_37ck166 FIND v(dout0_37) AT=835.025n

* CHECK dout0_38 Vdout0_38ck166 = 0.9 time = 835
.meas tran vdout0_38ck166 FIND v(dout0_38) AT=835.025n

* CHECK dout0_39 Vdout0_39ck166 = 0.9 time = 835
.meas tran vdout0_39ck166 FIND v(dout0_39) AT=835.025n

* CHECK dout0_40 Vdout0_40ck166 = 0 time = 835
.meas tran vdout0_40ck166 FIND v(dout0_40) AT=835.025n

* CHECK dout0_41 Vdout0_41ck166 = 0 time = 835
.meas tran vdout0_41ck166 FIND v(dout0_41) AT=835.025n

* CHECK dout0_42 Vdout0_42ck166 = 0.9 time = 835
.meas tran vdout0_42ck166 FIND v(dout0_42) AT=835.025n

* CHECK dout0_43 Vdout0_43ck166 = 0 time = 835
.meas tran vdout0_43ck166 FIND v(dout0_43) AT=835.025n

* CHECK dout0_44 Vdout0_44ck166 = 0.9 time = 835
.meas tran vdout0_44ck166 FIND v(dout0_44) AT=835.025n

* CHECK dout0_45 Vdout0_45ck166 = 0.9 time = 835
.meas tran vdout0_45ck166 FIND v(dout0_45) AT=835.025n

* CHECK dout0_46 Vdout0_46ck166 = 0 time = 835
.meas tran vdout0_46ck166 FIND v(dout0_46) AT=835.025n

* CHECK dout0_47 Vdout0_47ck166 = 0.9 time = 835
.meas tran vdout0_47ck166 FIND v(dout0_47) AT=835.025n

* CHECK dout0_48 Vdout0_48ck166 = 0.9 time = 835
.meas tran vdout0_48ck166 FIND v(dout0_48) AT=835.025n

* CHECK dout0_49 Vdout0_49ck166 = 0 time = 835
.meas tran vdout0_49ck166 FIND v(dout0_49) AT=835.025n

* CHECK dout0_50 Vdout0_50ck166 = 0.9 time = 835
.meas tran vdout0_50ck166 FIND v(dout0_50) AT=835.025n

* CHECK dout0_51 Vdout0_51ck166 = 0.9 time = 835
.meas tran vdout0_51ck166 FIND v(dout0_51) AT=835.025n

* CHECK dout0_52 Vdout0_52ck166 = 0.9 time = 835
.meas tran vdout0_52ck166 FIND v(dout0_52) AT=835.025n

* CHECK dout0_53 Vdout0_53ck166 = 0.9 time = 835
.meas tran vdout0_53ck166 FIND v(dout0_53) AT=835.025n

* CHECK dout0_54 Vdout0_54ck166 = 0 time = 835
.meas tran vdout0_54ck166 FIND v(dout0_54) AT=835.025n

* CHECK dout0_55 Vdout0_55ck166 = 0.9 time = 835
.meas tran vdout0_55ck166 FIND v(dout0_55) AT=835.025n

* CHECK dout0_56 Vdout0_56ck166 = 0.9 time = 835
.meas tran vdout0_56ck166 FIND v(dout0_56) AT=835.025n

* CHECK dout0_57 Vdout0_57ck166 = 0 time = 835
.meas tran vdout0_57ck166 FIND v(dout0_57) AT=835.025n

* CHECK dout0_58 Vdout0_58ck166 = 0 time = 835
.meas tran vdout0_58ck166 FIND v(dout0_58) AT=835.025n

* CHECK dout0_59 Vdout0_59ck166 = 0 time = 835
.meas tran vdout0_59ck166 FIND v(dout0_59) AT=835.025n

* CHECK dout0_60 Vdout0_60ck166 = 0 time = 835
.meas tran vdout0_60ck166 FIND v(dout0_60) AT=835.025n

* CHECK dout0_61 Vdout0_61ck166 = 0 time = 835
.meas tran vdout0_61ck166 FIND v(dout0_61) AT=835.025n

* CHECK dout0_62 Vdout0_62ck166 = 0 time = 835
.meas tran vdout0_62ck166 FIND v(dout0_62) AT=835.025n

* CHECK dout0_63 Vdout0_63ck166 = 0.9 time = 835
.meas tran vdout0_63ck166 FIND v(dout0_63) AT=835.025n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 840
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=840.025n

* CHECK dout0_1 Vdout0_1ck167 = 0.9 time = 840
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=840.025n

* CHECK dout0_2 Vdout0_2ck167 = 0 time = 840
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=840.025n

* CHECK dout0_3 Vdout0_3ck167 = 0.9 time = 840
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=840.025n

* CHECK dout0_4 Vdout0_4ck167 = 0.9 time = 840
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=840.025n

* CHECK dout0_5 Vdout0_5ck167 = 0.9 time = 840
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=840.025n

* CHECK dout0_6 Vdout0_6ck167 = 0.9 time = 840
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=840.025n

* CHECK dout0_7 Vdout0_7ck167 = 0.9 time = 840
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=840.025n

* CHECK dout0_8 Vdout0_8ck167 = 0.9 time = 840
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=840.025n

* CHECK dout0_9 Vdout0_9ck167 = 0.9 time = 840
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=840.025n

* CHECK dout0_10 Vdout0_10ck167 = 0 time = 840
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=840.025n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 840
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=840.025n

* CHECK dout0_12 Vdout0_12ck167 = 0 time = 840
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=840.025n

* CHECK dout0_13 Vdout0_13ck167 = 0 time = 840
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=840.025n

* CHECK dout0_14 Vdout0_14ck167 = 0 time = 840
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=840.025n

* CHECK dout0_15 Vdout0_15ck167 = 0 time = 840
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=840.025n

* CHECK dout0_16 Vdout0_16ck167 = 0.9 time = 840
.meas tran vdout0_16ck167 FIND v(dout0_16) AT=840.025n

* CHECK dout0_17 Vdout0_17ck167 = 0.9 time = 840
.meas tran vdout0_17ck167 FIND v(dout0_17) AT=840.025n

* CHECK dout0_18 Vdout0_18ck167 = 0.9 time = 840
.meas tran vdout0_18ck167 FIND v(dout0_18) AT=840.025n

* CHECK dout0_19 Vdout0_19ck167 = 0 time = 840
.meas tran vdout0_19ck167 FIND v(dout0_19) AT=840.025n

* CHECK dout0_20 Vdout0_20ck167 = 0.9 time = 840
.meas tran vdout0_20ck167 FIND v(dout0_20) AT=840.025n

* CHECK dout0_21 Vdout0_21ck167 = 0 time = 840
.meas tran vdout0_21ck167 FIND v(dout0_21) AT=840.025n

* CHECK dout0_22 Vdout0_22ck167 = 0 time = 840
.meas tran vdout0_22ck167 FIND v(dout0_22) AT=840.025n

* CHECK dout0_23 Vdout0_23ck167 = 0.9 time = 840
.meas tran vdout0_23ck167 FIND v(dout0_23) AT=840.025n

* CHECK dout0_24 Vdout0_24ck167 = 0.9 time = 840
.meas tran vdout0_24ck167 FIND v(dout0_24) AT=840.025n

* CHECK dout0_25 Vdout0_25ck167 = 0.9 time = 840
.meas tran vdout0_25ck167 FIND v(dout0_25) AT=840.025n

* CHECK dout0_26 Vdout0_26ck167 = 0 time = 840
.meas tran vdout0_26ck167 FIND v(dout0_26) AT=840.025n

* CHECK dout0_27 Vdout0_27ck167 = 0 time = 840
.meas tran vdout0_27ck167 FIND v(dout0_27) AT=840.025n

* CHECK dout0_28 Vdout0_28ck167 = 0 time = 840
.meas tran vdout0_28ck167 FIND v(dout0_28) AT=840.025n

* CHECK dout0_29 Vdout0_29ck167 = 0 time = 840
.meas tran vdout0_29ck167 FIND v(dout0_29) AT=840.025n

* CHECK dout0_30 Vdout0_30ck167 = 0.9 time = 840
.meas tran vdout0_30ck167 FIND v(dout0_30) AT=840.025n

* CHECK dout0_31 Vdout0_31ck167 = 0 time = 840
.meas tran vdout0_31ck167 FIND v(dout0_31) AT=840.025n

* CHECK dout0_32 Vdout0_32ck167 = 0 time = 840
.meas tran vdout0_32ck167 FIND v(dout0_32) AT=840.025n

* CHECK dout0_33 Vdout0_33ck167 = 0 time = 840
.meas tran vdout0_33ck167 FIND v(dout0_33) AT=840.025n

* CHECK dout0_34 Vdout0_34ck167 = 0 time = 840
.meas tran vdout0_34ck167 FIND v(dout0_34) AT=840.025n

* CHECK dout0_35 Vdout0_35ck167 = 0 time = 840
.meas tran vdout0_35ck167 FIND v(dout0_35) AT=840.025n

* CHECK dout0_36 Vdout0_36ck167 = 0 time = 840
.meas tran vdout0_36ck167 FIND v(dout0_36) AT=840.025n

* CHECK dout0_37 Vdout0_37ck167 = 0.9 time = 840
.meas tran vdout0_37ck167 FIND v(dout0_37) AT=840.025n

* CHECK dout0_38 Vdout0_38ck167 = 0 time = 840
.meas tran vdout0_38ck167 FIND v(dout0_38) AT=840.025n

* CHECK dout0_39 Vdout0_39ck167 = 0.9 time = 840
.meas tran vdout0_39ck167 FIND v(dout0_39) AT=840.025n

* CHECK dout0_40 Vdout0_40ck167 = 0.9 time = 840
.meas tran vdout0_40ck167 FIND v(dout0_40) AT=840.025n

* CHECK dout0_41 Vdout0_41ck167 = 0 time = 840
.meas tran vdout0_41ck167 FIND v(dout0_41) AT=840.025n

* CHECK dout0_42 Vdout0_42ck167 = 0 time = 840
.meas tran vdout0_42ck167 FIND v(dout0_42) AT=840.025n

* CHECK dout0_43 Vdout0_43ck167 = 0 time = 840
.meas tran vdout0_43ck167 FIND v(dout0_43) AT=840.025n

* CHECK dout0_44 Vdout0_44ck167 = 0 time = 840
.meas tran vdout0_44ck167 FIND v(dout0_44) AT=840.025n

* CHECK dout0_45 Vdout0_45ck167 = 0 time = 840
.meas tran vdout0_45ck167 FIND v(dout0_45) AT=840.025n

* CHECK dout0_46 Vdout0_46ck167 = 0.9 time = 840
.meas tran vdout0_46ck167 FIND v(dout0_46) AT=840.025n

* CHECK dout0_47 Vdout0_47ck167 = 0 time = 840
.meas tran vdout0_47ck167 FIND v(dout0_47) AT=840.025n

* CHECK dout0_48 Vdout0_48ck167 = 0 time = 840
.meas tran vdout0_48ck167 FIND v(dout0_48) AT=840.025n

* CHECK dout0_49 Vdout0_49ck167 = 0.9 time = 840
.meas tran vdout0_49ck167 FIND v(dout0_49) AT=840.025n

* CHECK dout0_50 Vdout0_50ck167 = 0 time = 840
.meas tran vdout0_50ck167 FIND v(dout0_50) AT=840.025n

* CHECK dout0_51 Vdout0_51ck167 = 0.9 time = 840
.meas tran vdout0_51ck167 FIND v(dout0_51) AT=840.025n

* CHECK dout0_52 Vdout0_52ck167 = 0.9 time = 840
.meas tran vdout0_52ck167 FIND v(dout0_52) AT=840.025n

* CHECK dout0_53 Vdout0_53ck167 = 0 time = 840
.meas tran vdout0_53ck167 FIND v(dout0_53) AT=840.025n

* CHECK dout0_54 Vdout0_54ck167 = 0 time = 840
.meas tran vdout0_54ck167 FIND v(dout0_54) AT=840.025n

* CHECK dout0_55 Vdout0_55ck167 = 0 time = 840
.meas tran vdout0_55ck167 FIND v(dout0_55) AT=840.025n

* CHECK dout0_56 Vdout0_56ck167 = 0.9 time = 840
.meas tran vdout0_56ck167 FIND v(dout0_56) AT=840.025n

* CHECK dout0_57 Vdout0_57ck167 = 0.9 time = 840
.meas tran vdout0_57ck167 FIND v(dout0_57) AT=840.025n

* CHECK dout0_58 Vdout0_58ck167 = 0 time = 840
.meas tran vdout0_58ck167 FIND v(dout0_58) AT=840.025n

* CHECK dout0_59 Vdout0_59ck167 = 0.9 time = 840
.meas tran vdout0_59ck167 FIND v(dout0_59) AT=840.025n

* CHECK dout0_60 Vdout0_60ck167 = 0.9 time = 840
.meas tran vdout0_60ck167 FIND v(dout0_60) AT=840.025n

* CHECK dout0_61 Vdout0_61ck167 = 0 time = 840
.meas tran vdout0_61ck167 FIND v(dout0_61) AT=840.025n

* CHECK dout0_62 Vdout0_62ck167 = 0.9 time = 840
.meas tran vdout0_62ck167 FIND v(dout0_62) AT=840.025n

* CHECK dout0_63 Vdout0_63ck167 = 0.9 time = 840
.meas tran vdout0_63ck167 FIND v(dout0_63) AT=840.025n

* CHECK dout0_0 Vdout0_0ck168 = 0.9 time = 845
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=845.025n

* CHECK dout0_1 Vdout0_1ck168 = 0.9 time = 845
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=845.025n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 845
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=845.025n

* CHECK dout0_3 Vdout0_3ck168 = 0.9 time = 845
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=845.025n

* CHECK dout0_4 Vdout0_4ck168 = 0.9 time = 845
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=845.025n

* CHECK dout0_5 Vdout0_5ck168 = 0 time = 845
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=845.025n

* CHECK dout0_6 Vdout0_6ck168 = 0.9 time = 845
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=845.025n

* CHECK dout0_7 Vdout0_7ck168 = 0.9 time = 845
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=845.025n

* CHECK dout0_8 Vdout0_8ck168 = 0.9 time = 845
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=845.025n

* CHECK dout0_9 Vdout0_9ck168 = 0 time = 845
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=845.025n

* CHECK dout0_10 Vdout0_10ck168 = 0.9 time = 845
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=845.025n

* CHECK dout0_11 Vdout0_11ck168 = 0.9 time = 845
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=845.025n

* CHECK dout0_12 Vdout0_12ck168 = 0.9 time = 845
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=845.025n

* CHECK dout0_13 Vdout0_13ck168 = 0.9 time = 845
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=845.025n

* CHECK dout0_14 Vdout0_14ck168 = 0 time = 845
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=845.025n

* CHECK dout0_15 Vdout0_15ck168 = 0.9 time = 845
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=845.025n

* CHECK dout0_16 Vdout0_16ck168 = 0.9 time = 845
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=845.025n

* CHECK dout0_17 Vdout0_17ck168 = 0.9 time = 845
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=845.025n

* CHECK dout0_18 Vdout0_18ck168 = 0.9 time = 845
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=845.025n

* CHECK dout0_19 Vdout0_19ck168 = 0.9 time = 845
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=845.025n

* CHECK dout0_20 Vdout0_20ck168 = 0.9 time = 845
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=845.025n

* CHECK dout0_21 Vdout0_21ck168 = 0.9 time = 845
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=845.025n

* CHECK dout0_22 Vdout0_22ck168 = 0 time = 845
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=845.025n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 845
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=845.025n

* CHECK dout0_24 Vdout0_24ck168 = 0.9 time = 845
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=845.025n

* CHECK dout0_25 Vdout0_25ck168 = 0.9 time = 845
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=845.025n

* CHECK dout0_26 Vdout0_26ck168 = 0.9 time = 845
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=845.025n

* CHECK dout0_27 Vdout0_27ck168 = 0 time = 845
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=845.025n

* CHECK dout0_28 Vdout0_28ck168 = 0 time = 845
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=845.025n

* CHECK dout0_29 Vdout0_29ck168 = 0 time = 845
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=845.025n

* CHECK dout0_30 Vdout0_30ck168 = 0.9 time = 845
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=845.025n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 845
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=845.025n

* CHECK dout0_32 Vdout0_32ck168 = 0.9 time = 845
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=845.025n

* CHECK dout0_33 Vdout0_33ck168 = 0 time = 845
.meas tran vdout0_33ck168 FIND v(dout0_33) AT=845.025n

* CHECK dout0_34 Vdout0_34ck168 = 0 time = 845
.meas tran vdout0_34ck168 FIND v(dout0_34) AT=845.025n

* CHECK dout0_35 Vdout0_35ck168 = 0 time = 845
.meas tran vdout0_35ck168 FIND v(dout0_35) AT=845.025n

* CHECK dout0_36 Vdout0_36ck168 = 0 time = 845
.meas tran vdout0_36ck168 FIND v(dout0_36) AT=845.025n

* CHECK dout0_37 Vdout0_37ck168 = 0.9 time = 845
.meas tran vdout0_37ck168 FIND v(dout0_37) AT=845.025n

* CHECK dout0_38 Vdout0_38ck168 = 0.9 time = 845
.meas tran vdout0_38ck168 FIND v(dout0_38) AT=845.025n

* CHECK dout0_39 Vdout0_39ck168 = 0.9 time = 845
.meas tran vdout0_39ck168 FIND v(dout0_39) AT=845.025n

* CHECK dout0_40 Vdout0_40ck168 = 0 time = 845
.meas tran vdout0_40ck168 FIND v(dout0_40) AT=845.025n

* CHECK dout0_41 Vdout0_41ck168 = 0 time = 845
.meas tran vdout0_41ck168 FIND v(dout0_41) AT=845.025n

* CHECK dout0_42 Vdout0_42ck168 = 0.9 time = 845
.meas tran vdout0_42ck168 FIND v(dout0_42) AT=845.025n

* CHECK dout0_43 Vdout0_43ck168 = 0 time = 845
.meas tran vdout0_43ck168 FIND v(dout0_43) AT=845.025n

* CHECK dout0_44 Vdout0_44ck168 = 0.9 time = 845
.meas tran vdout0_44ck168 FIND v(dout0_44) AT=845.025n

* CHECK dout0_45 Vdout0_45ck168 = 0.9 time = 845
.meas tran vdout0_45ck168 FIND v(dout0_45) AT=845.025n

* CHECK dout0_46 Vdout0_46ck168 = 0 time = 845
.meas tran vdout0_46ck168 FIND v(dout0_46) AT=845.025n

* CHECK dout0_47 Vdout0_47ck168 = 0.9 time = 845
.meas tran vdout0_47ck168 FIND v(dout0_47) AT=845.025n

* CHECK dout0_48 Vdout0_48ck168 = 0.9 time = 845
.meas tran vdout0_48ck168 FIND v(dout0_48) AT=845.025n

* CHECK dout0_49 Vdout0_49ck168 = 0 time = 845
.meas tran vdout0_49ck168 FIND v(dout0_49) AT=845.025n

* CHECK dout0_50 Vdout0_50ck168 = 0.9 time = 845
.meas tran vdout0_50ck168 FIND v(dout0_50) AT=845.025n

* CHECK dout0_51 Vdout0_51ck168 = 0.9 time = 845
.meas tran vdout0_51ck168 FIND v(dout0_51) AT=845.025n

* CHECK dout0_52 Vdout0_52ck168 = 0.9 time = 845
.meas tran vdout0_52ck168 FIND v(dout0_52) AT=845.025n

* CHECK dout0_53 Vdout0_53ck168 = 0.9 time = 845
.meas tran vdout0_53ck168 FIND v(dout0_53) AT=845.025n

* CHECK dout0_54 Vdout0_54ck168 = 0 time = 845
.meas tran vdout0_54ck168 FIND v(dout0_54) AT=845.025n

* CHECK dout0_55 Vdout0_55ck168 = 0.9 time = 845
.meas tran vdout0_55ck168 FIND v(dout0_55) AT=845.025n

* CHECK dout0_56 Vdout0_56ck168 = 0.9 time = 845
.meas tran vdout0_56ck168 FIND v(dout0_56) AT=845.025n

* CHECK dout0_57 Vdout0_57ck168 = 0 time = 845
.meas tran vdout0_57ck168 FIND v(dout0_57) AT=845.025n

* CHECK dout0_58 Vdout0_58ck168 = 0 time = 845
.meas tran vdout0_58ck168 FIND v(dout0_58) AT=845.025n

* CHECK dout0_59 Vdout0_59ck168 = 0 time = 845
.meas tran vdout0_59ck168 FIND v(dout0_59) AT=845.025n

* CHECK dout0_60 Vdout0_60ck168 = 0 time = 845
.meas tran vdout0_60ck168 FIND v(dout0_60) AT=845.025n

* CHECK dout0_61 Vdout0_61ck168 = 0 time = 845
.meas tran vdout0_61ck168 FIND v(dout0_61) AT=845.025n

* CHECK dout0_62 Vdout0_62ck168 = 0 time = 845
.meas tran vdout0_62ck168 FIND v(dout0_62) AT=845.025n

* CHECK dout0_63 Vdout0_63ck168 = 0.9 time = 845
.meas tran vdout0_63ck168 FIND v(dout0_63) AT=845.025n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 850
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=850.025n

* CHECK dout0_1 Vdout0_1ck169 = 0.9 time = 850
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=850.025n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 850
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=850.025n

* CHECK dout0_3 Vdout0_3ck169 = 0.9 time = 850
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=850.025n

* CHECK dout0_4 Vdout0_4ck169 = 0.9 time = 850
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=850.025n

* CHECK dout0_5 Vdout0_5ck169 = 0.9 time = 850
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=850.025n

* CHECK dout0_6 Vdout0_6ck169 = 0.9 time = 850
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=850.025n

* CHECK dout0_7 Vdout0_7ck169 = 0.9 time = 850
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=850.025n

* CHECK dout0_8 Vdout0_8ck169 = 0.9 time = 850
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=850.025n

* CHECK dout0_9 Vdout0_9ck169 = 0.9 time = 850
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=850.025n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 850
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=850.025n

* CHECK dout0_11 Vdout0_11ck169 = 0 time = 850
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=850.025n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 850
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=850.025n

* CHECK dout0_13 Vdout0_13ck169 = 0 time = 850
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=850.025n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 850
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=850.025n

* CHECK dout0_15 Vdout0_15ck169 = 0 time = 850
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=850.025n

* CHECK dout0_16 Vdout0_16ck169 = 0.9 time = 850
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=850.025n

* CHECK dout0_17 Vdout0_17ck169 = 0.9 time = 850
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=850.025n

* CHECK dout0_18 Vdout0_18ck169 = 0.9 time = 850
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=850.025n

* CHECK dout0_19 Vdout0_19ck169 = 0 time = 850
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=850.025n

* CHECK dout0_20 Vdout0_20ck169 = 0.9 time = 850
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=850.025n

* CHECK dout0_21 Vdout0_21ck169 = 0 time = 850
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=850.025n

* CHECK dout0_22 Vdout0_22ck169 = 0 time = 850
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=850.025n

* CHECK dout0_23 Vdout0_23ck169 = 0.9 time = 850
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=850.025n

* CHECK dout0_24 Vdout0_24ck169 = 0.9 time = 850
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=850.025n

* CHECK dout0_25 Vdout0_25ck169 = 0.9 time = 850
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=850.025n

* CHECK dout0_26 Vdout0_26ck169 = 0 time = 850
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=850.025n

* CHECK dout0_27 Vdout0_27ck169 = 0 time = 850
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=850.025n

* CHECK dout0_28 Vdout0_28ck169 = 0 time = 850
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=850.025n

* CHECK dout0_29 Vdout0_29ck169 = 0 time = 850
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=850.025n

* CHECK dout0_30 Vdout0_30ck169 = 0.9 time = 850
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=850.025n

* CHECK dout0_31 Vdout0_31ck169 = 0 time = 850
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=850.025n

* CHECK dout0_32 Vdout0_32ck169 = 0 time = 850
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=850.025n

* CHECK dout0_33 Vdout0_33ck169 = 0 time = 850
.meas tran vdout0_33ck169 FIND v(dout0_33) AT=850.025n

* CHECK dout0_34 Vdout0_34ck169 = 0 time = 850
.meas tran vdout0_34ck169 FIND v(dout0_34) AT=850.025n

* CHECK dout0_35 Vdout0_35ck169 = 0 time = 850
.meas tran vdout0_35ck169 FIND v(dout0_35) AT=850.025n

* CHECK dout0_36 Vdout0_36ck169 = 0 time = 850
.meas tran vdout0_36ck169 FIND v(dout0_36) AT=850.025n

* CHECK dout0_37 Vdout0_37ck169 = 0.9 time = 850
.meas tran vdout0_37ck169 FIND v(dout0_37) AT=850.025n

* CHECK dout0_38 Vdout0_38ck169 = 0 time = 850
.meas tran vdout0_38ck169 FIND v(dout0_38) AT=850.025n

* CHECK dout0_39 Vdout0_39ck169 = 0.9 time = 850
.meas tran vdout0_39ck169 FIND v(dout0_39) AT=850.025n

* CHECK dout0_40 Vdout0_40ck169 = 0.9 time = 850
.meas tran vdout0_40ck169 FIND v(dout0_40) AT=850.025n

* CHECK dout0_41 Vdout0_41ck169 = 0 time = 850
.meas tran vdout0_41ck169 FIND v(dout0_41) AT=850.025n

* CHECK dout0_42 Vdout0_42ck169 = 0 time = 850
.meas tran vdout0_42ck169 FIND v(dout0_42) AT=850.025n

* CHECK dout0_43 Vdout0_43ck169 = 0 time = 850
.meas tran vdout0_43ck169 FIND v(dout0_43) AT=850.025n

* CHECK dout0_44 Vdout0_44ck169 = 0 time = 850
.meas tran vdout0_44ck169 FIND v(dout0_44) AT=850.025n

* CHECK dout0_45 Vdout0_45ck169 = 0 time = 850
.meas tran vdout0_45ck169 FIND v(dout0_45) AT=850.025n

* CHECK dout0_46 Vdout0_46ck169 = 0.9 time = 850
.meas tran vdout0_46ck169 FIND v(dout0_46) AT=850.025n

* CHECK dout0_47 Vdout0_47ck169 = 0 time = 850
.meas tran vdout0_47ck169 FIND v(dout0_47) AT=850.025n

* CHECK dout0_48 Vdout0_48ck169 = 0 time = 850
.meas tran vdout0_48ck169 FIND v(dout0_48) AT=850.025n

* CHECK dout0_49 Vdout0_49ck169 = 0.9 time = 850
.meas tran vdout0_49ck169 FIND v(dout0_49) AT=850.025n

* CHECK dout0_50 Vdout0_50ck169 = 0 time = 850
.meas tran vdout0_50ck169 FIND v(dout0_50) AT=850.025n

* CHECK dout0_51 Vdout0_51ck169 = 0.9 time = 850
.meas tran vdout0_51ck169 FIND v(dout0_51) AT=850.025n

* CHECK dout0_52 Vdout0_52ck169 = 0.9 time = 850
.meas tran vdout0_52ck169 FIND v(dout0_52) AT=850.025n

* CHECK dout0_53 Vdout0_53ck169 = 0 time = 850
.meas tran vdout0_53ck169 FIND v(dout0_53) AT=850.025n

* CHECK dout0_54 Vdout0_54ck169 = 0 time = 850
.meas tran vdout0_54ck169 FIND v(dout0_54) AT=850.025n

* CHECK dout0_55 Vdout0_55ck169 = 0 time = 850
.meas tran vdout0_55ck169 FIND v(dout0_55) AT=850.025n

* CHECK dout0_56 Vdout0_56ck169 = 0.9 time = 850
.meas tran vdout0_56ck169 FIND v(dout0_56) AT=850.025n

* CHECK dout0_57 Vdout0_57ck169 = 0.9 time = 850
.meas tran vdout0_57ck169 FIND v(dout0_57) AT=850.025n

* CHECK dout0_58 Vdout0_58ck169 = 0 time = 850
.meas tran vdout0_58ck169 FIND v(dout0_58) AT=850.025n

* CHECK dout0_59 Vdout0_59ck169 = 0.9 time = 850
.meas tran vdout0_59ck169 FIND v(dout0_59) AT=850.025n

* CHECK dout0_60 Vdout0_60ck169 = 0.9 time = 850
.meas tran vdout0_60ck169 FIND v(dout0_60) AT=850.025n

* CHECK dout0_61 Vdout0_61ck169 = 0 time = 850
.meas tran vdout0_61ck169 FIND v(dout0_61) AT=850.025n

* CHECK dout0_62 Vdout0_62ck169 = 0.9 time = 850
.meas tran vdout0_62ck169 FIND v(dout0_62) AT=850.025n

* CHECK dout0_63 Vdout0_63ck169 = 0.9 time = 850
.meas tran vdout0_63ck169 FIND v(dout0_63) AT=850.025n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 865
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=865.025n

* CHECK dout0_1 Vdout0_1ck172 = 0.9 time = 865
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=865.025n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 865
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=865.025n

* CHECK dout0_3 Vdout0_3ck172 = 0.9 time = 865
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=865.025n

* CHECK dout0_4 Vdout0_4ck172 = 0.9 time = 865
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=865.025n

* CHECK dout0_5 Vdout0_5ck172 = 0.9 time = 865
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=865.025n

* CHECK dout0_6 Vdout0_6ck172 = 0.9 time = 865
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=865.025n

* CHECK dout0_7 Vdout0_7ck172 = 0.9 time = 865
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=865.025n

* CHECK dout0_8 Vdout0_8ck172 = 0.9 time = 865
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=865.025n

* CHECK dout0_9 Vdout0_9ck172 = 0.9 time = 865
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=865.025n

* CHECK dout0_10 Vdout0_10ck172 = 0 time = 865
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=865.025n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 865
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=865.025n

* CHECK dout0_12 Vdout0_12ck172 = 0 time = 865
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=865.025n

* CHECK dout0_13 Vdout0_13ck172 = 0 time = 865
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=865.025n

* CHECK dout0_14 Vdout0_14ck172 = 0 time = 865
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=865.025n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 865
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=865.025n

* CHECK dout0_16 Vdout0_16ck172 = 0.9 time = 865
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=865.025n

* CHECK dout0_17 Vdout0_17ck172 = 0.9 time = 865
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=865.025n

* CHECK dout0_18 Vdout0_18ck172 = 0.9 time = 865
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=865.025n

* CHECK dout0_19 Vdout0_19ck172 = 0 time = 865
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=865.025n

* CHECK dout0_20 Vdout0_20ck172 = 0.9 time = 865
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=865.025n

* CHECK dout0_21 Vdout0_21ck172 = 0 time = 865
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=865.025n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 865
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=865.025n

* CHECK dout0_23 Vdout0_23ck172 = 0.9 time = 865
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=865.025n

* CHECK dout0_24 Vdout0_24ck172 = 0.9 time = 865
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=865.025n

* CHECK dout0_25 Vdout0_25ck172 = 0.9 time = 865
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=865.025n

* CHECK dout0_26 Vdout0_26ck172 = 0 time = 865
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=865.025n

* CHECK dout0_27 Vdout0_27ck172 = 0 time = 865
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=865.025n

* CHECK dout0_28 Vdout0_28ck172 = 0 time = 865
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=865.025n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 865
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=865.025n

* CHECK dout0_30 Vdout0_30ck172 = 0.9 time = 865
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=865.025n

* CHECK dout0_31 Vdout0_31ck172 = 0 time = 865
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=865.025n

* CHECK dout0_32 Vdout0_32ck172 = 0 time = 865
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=865.025n

* CHECK dout0_33 Vdout0_33ck172 = 0 time = 865
.meas tran vdout0_33ck172 FIND v(dout0_33) AT=865.025n

* CHECK dout0_34 Vdout0_34ck172 = 0 time = 865
.meas tran vdout0_34ck172 FIND v(dout0_34) AT=865.025n

* CHECK dout0_35 Vdout0_35ck172 = 0 time = 865
.meas tran vdout0_35ck172 FIND v(dout0_35) AT=865.025n

* CHECK dout0_36 Vdout0_36ck172 = 0 time = 865
.meas tran vdout0_36ck172 FIND v(dout0_36) AT=865.025n

* CHECK dout0_37 Vdout0_37ck172 = 0.9 time = 865
.meas tran vdout0_37ck172 FIND v(dout0_37) AT=865.025n

* CHECK dout0_38 Vdout0_38ck172 = 0 time = 865
.meas tran vdout0_38ck172 FIND v(dout0_38) AT=865.025n

* CHECK dout0_39 Vdout0_39ck172 = 0.9 time = 865
.meas tran vdout0_39ck172 FIND v(dout0_39) AT=865.025n

* CHECK dout0_40 Vdout0_40ck172 = 0.9 time = 865
.meas tran vdout0_40ck172 FIND v(dout0_40) AT=865.025n

* CHECK dout0_41 Vdout0_41ck172 = 0 time = 865
.meas tran vdout0_41ck172 FIND v(dout0_41) AT=865.025n

* CHECK dout0_42 Vdout0_42ck172 = 0 time = 865
.meas tran vdout0_42ck172 FIND v(dout0_42) AT=865.025n

* CHECK dout0_43 Vdout0_43ck172 = 0 time = 865
.meas tran vdout0_43ck172 FIND v(dout0_43) AT=865.025n

* CHECK dout0_44 Vdout0_44ck172 = 0 time = 865
.meas tran vdout0_44ck172 FIND v(dout0_44) AT=865.025n

* CHECK dout0_45 Vdout0_45ck172 = 0 time = 865
.meas tran vdout0_45ck172 FIND v(dout0_45) AT=865.025n

* CHECK dout0_46 Vdout0_46ck172 = 0.9 time = 865
.meas tran vdout0_46ck172 FIND v(dout0_46) AT=865.025n

* CHECK dout0_47 Vdout0_47ck172 = 0 time = 865
.meas tran vdout0_47ck172 FIND v(dout0_47) AT=865.025n

* CHECK dout0_48 Vdout0_48ck172 = 0 time = 865
.meas tran vdout0_48ck172 FIND v(dout0_48) AT=865.025n

* CHECK dout0_49 Vdout0_49ck172 = 0.9 time = 865
.meas tran vdout0_49ck172 FIND v(dout0_49) AT=865.025n

* CHECK dout0_50 Vdout0_50ck172 = 0 time = 865
.meas tran vdout0_50ck172 FIND v(dout0_50) AT=865.025n

* CHECK dout0_51 Vdout0_51ck172 = 0.9 time = 865
.meas tran vdout0_51ck172 FIND v(dout0_51) AT=865.025n

* CHECK dout0_52 Vdout0_52ck172 = 0.9 time = 865
.meas tran vdout0_52ck172 FIND v(dout0_52) AT=865.025n

* CHECK dout0_53 Vdout0_53ck172 = 0 time = 865
.meas tran vdout0_53ck172 FIND v(dout0_53) AT=865.025n

* CHECK dout0_54 Vdout0_54ck172 = 0 time = 865
.meas tran vdout0_54ck172 FIND v(dout0_54) AT=865.025n

* CHECK dout0_55 Vdout0_55ck172 = 0 time = 865
.meas tran vdout0_55ck172 FIND v(dout0_55) AT=865.025n

* CHECK dout0_56 Vdout0_56ck172 = 0.9 time = 865
.meas tran vdout0_56ck172 FIND v(dout0_56) AT=865.025n

* CHECK dout0_57 Vdout0_57ck172 = 0.9 time = 865
.meas tran vdout0_57ck172 FIND v(dout0_57) AT=865.025n

* CHECK dout0_58 Vdout0_58ck172 = 0 time = 865
.meas tran vdout0_58ck172 FIND v(dout0_58) AT=865.025n

* CHECK dout0_59 Vdout0_59ck172 = 0.9 time = 865
.meas tran vdout0_59ck172 FIND v(dout0_59) AT=865.025n

* CHECK dout0_60 Vdout0_60ck172 = 0.9 time = 865
.meas tran vdout0_60ck172 FIND v(dout0_60) AT=865.025n

* CHECK dout0_61 Vdout0_61ck172 = 0 time = 865
.meas tran vdout0_61ck172 FIND v(dout0_61) AT=865.025n

* CHECK dout0_62 Vdout0_62ck172 = 0.9 time = 865
.meas tran vdout0_62ck172 FIND v(dout0_62) AT=865.025n

* CHECK dout0_63 Vdout0_63ck172 = 0.9 time = 865
.meas tran vdout0_63ck172 FIND v(dout0_63) AT=865.025n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 870
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=870.025n

* CHECK dout0_1 Vdout0_1ck173 = 0.9 time = 870
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=870.025n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 870
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=870.025n

* CHECK dout0_3 Vdout0_3ck173 = 0.9 time = 870
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=870.025n

* CHECK dout0_4 Vdout0_4ck173 = 0.9 time = 870
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=870.025n

* CHECK dout0_5 Vdout0_5ck173 = 0.9 time = 870
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=870.025n

* CHECK dout0_6 Vdout0_6ck173 = 0.9 time = 870
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=870.025n

* CHECK dout0_7 Vdout0_7ck173 = 0.9 time = 870
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=870.025n

* CHECK dout0_8 Vdout0_8ck173 = 0.9 time = 870
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=870.025n

* CHECK dout0_9 Vdout0_9ck173 = 0.9 time = 870
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=870.025n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 870
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=870.025n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 870
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=870.025n

* CHECK dout0_12 Vdout0_12ck173 = 0 time = 870
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=870.025n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 870
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=870.025n

* CHECK dout0_14 Vdout0_14ck173 = 0 time = 870
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=870.025n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 870
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=870.025n

* CHECK dout0_16 Vdout0_16ck173 = 0.9 time = 870
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=870.025n

* CHECK dout0_17 Vdout0_17ck173 = 0.9 time = 870
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=870.025n

* CHECK dout0_18 Vdout0_18ck173 = 0.9 time = 870
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=870.025n

* CHECK dout0_19 Vdout0_19ck173 = 0 time = 870
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=870.025n

* CHECK dout0_20 Vdout0_20ck173 = 0.9 time = 870
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=870.025n

* CHECK dout0_21 Vdout0_21ck173 = 0 time = 870
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=870.025n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 870
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=870.025n

* CHECK dout0_23 Vdout0_23ck173 = 0.9 time = 870
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=870.025n

* CHECK dout0_24 Vdout0_24ck173 = 0.9 time = 870
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=870.025n

* CHECK dout0_25 Vdout0_25ck173 = 0.9 time = 870
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=870.025n

* CHECK dout0_26 Vdout0_26ck173 = 0 time = 870
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=870.025n

* CHECK dout0_27 Vdout0_27ck173 = 0 time = 870
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=870.025n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 870
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=870.025n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 870
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=870.025n

* CHECK dout0_30 Vdout0_30ck173 = 0.9 time = 870
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=870.025n

* CHECK dout0_31 Vdout0_31ck173 = 0 time = 870
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=870.025n

* CHECK dout0_32 Vdout0_32ck173 = 0 time = 870
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=870.025n

* CHECK dout0_33 Vdout0_33ck173 = 0 time = 870
.meas tran vdout0_33ck173 FIND v(dout0_33) AT=870.025n

* CHECK dout0_34 Vdout0_34ck173 = 0 time = 870
.meas tran vdout0_34ck173 FIND v(dout0_34) AT=870.025n

* CHECK dout0_35 Vdout0_35ck173 = 0 time = 870
.meas tran vdout0_35ck173 FIND v(dout0_35) AT=870.025n

* CHECK dout0_36 Vdout0_36ck173 = 0 time = 870
.meas tran vdout0_36ck173 FIND v(dout0_36) AT=870.025n

* CHECK dout0_37 Vdout0_37ck173 = 0.9 time = 870
.meas tran vdout0_37ck173 FIND v(dout0_37) AT=870.025n

* CHECK dout0_38 Vdout0_38ck173 = 0 time = 870
.meas tran vdout0_38ck173 FIND v(dout0_38) AT=870.025n

* CHECK dout0_39 Vdout0_39ck173 = 0.9 time = 870
.meas tran vdout0_39ck173 FIND v(dout0_39) AT=870.025n

* CHECK dout0_40 Vdout0_40ck173 = 0.9 time = 870
.meas tran vdout0_40ck173 FIND v(dout0_40) AT=870.025n

* CHECK dout0_41 Vdout0_41ck173 = 0 time = 870
.meas tran vdout0_41ck173 FIND v(dout0_41) AT=870.025n

* CHECK dout0_42 Vdout0_42ck173 = 0 time = 870
.meas tran vdout0_42ck173 FIND v(dout0_42) AT=870.025n

* CHECK dout0_43 Vdout0_43ck173 = 0 time = 870
.meas tran vdout0_43ck173 FIND v(dout0_43) AT=870.025n

* CHECK dout0_44 Vdout0_44ck173 = 0 time = 870
.meas tran vdout0_44ck173 FIND v(dout0_44) AT=870.025n

* CHECK dout0_45 Vdout0_45ck173 = 0 time = 870
.meas tran vdout0_45ck173 FIND v(dout0_45) AT=870.025n

* CHECK dout0_46 Vdout0_46ck173 = 0.9 time = 870
.meas tran vdout0_46ck173 FIND v(dout0_46) AT=870.025n

* CHECK dout0_47 Vdout0_47ck173 = 0 time = 870
.meas tran vdout0_47ck173 FIND v(dout0_47) AT=870.025n

* CHECK dout0_48 Vdout0_48ck173 = 0 time = 870
.meas tran vdout0_48ck173 FIND v(dout0_48) AT=870.025n

* CHECK dout0_49 Vdout0_49ck173 = 0.9 time = 870
.meas tran vdout0_49ck173 FIND v(dout0_49) AT=870.025n

* CHECK dout0_50 Vdout0_50ck173 = 0 time = 870
.meas tran vdout0_50ck173 FIND v(dout0_50) AT=870.025n

* CHECK dout0_51 Vdout0_51ck173 = 0.9 time = 870
.meas tran vdout0_51ck173 FIND v(dout0_51) AT=870.025n

* CHECK dout0_52 Vdout0_52ck173 = 0.9 time = 870
.meas tran vdout0_52ck173 FIND v(dout0_52) AT=870.025n

* CHECK dout0_53 Vdout0_53ck173 = 0 time = 870
.meas tran vdout0_53ck173 FIND v(dout0_53) AT=870.025n

* CHECK dout0_54 Vdout0_54ck173 = 0 time = 870
.meas tran vdout0_54ck173 FIND v(dout0_54) AT=870.025n

* CHECK dout0_55 Vdout0_55ck173 = 0 time = 870
.meas tran vdout0_55ck173 FIND v(dout0_55) AT=870.025n

* CHECK dout0_56 Vdout0_56ck173 = 0.9 time = 870
.meas tran vdout0_56ck173 FIND v(dout0_56) AT=870.025n

* CHECK dout0_57 Vdout0_57ck173 = 0.9 time = 870
.meas tran vdout0_57ck173 FIND v(dout0_57) AT=870.025n

* CHECK dout0_58 Vdout0_58ck173 = 0 time = 870
.meas tran vdout0_58ck173 FIND v(dout0_58) AT=870.025n

* CHECK dout0_59 Vdout0_59ck173 = 0.9 time = 870
.meas tran vdout0_59ck173 FIND v(dout0_59) AT=870.025n

* CHECK dout0_60 Vdout0_60ck173 = 0.9 time = 870
.meas tran vdout0_60ck173 FIND v(dout0_60) AT=870.025n

* CHECK dout0_61 Vdout0_61ck173 = 0 time = 870
.meas tran vdout0_61ck173 FIND v(dout0_61) AT=870.025n

* CHECK dout0_62 Vdout0_62ck173 = 0.9 time = 870
.meas tran vdout0_62ck173 FIND v(dout0_62) AT=870.025n

* CHECK dout0_63 Vdout0_63ck173 = 0.9 time = 870
.meas tran vdout0_63ck173 FIND v(dout0_63) AT=870.025n

* CHECK dout0_0 Vdout0_0ck174 = 0.9 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 0.9 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 0.9 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 0.9 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0.9 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 0.9 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 0.9 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 0.9 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 0.9 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 0.9 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 0.9 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 0 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 0.9 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 0.9 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0.9 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 0.9 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 0.9 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 0.9 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 0.9 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 0 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 0.9 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 0.9 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 0.9 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 0 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 0 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 0.9 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 0 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_32 Vdout0_32ck174 = 0.9 time = 875
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=875.025n

* CHECK dout0_33 Vdout0_33ck174 = 0 time = 875
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=875.025n

* CHECK dout0_34 Vdout0_34ck174 = 0 time = 875
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=875.025n

* CHECK dout0_35 Vdout0_35ck174 = 0 time = 875
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=875.025n

* CHECK dout0_36 Vdout0_36ck174 = 0 time = 875
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=875.025n

* CHECK dout0_37 Vdout0_37ck174 = 0.9 time = 875
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=875.025n

* CHECK dout0_38 Vdout0_38ck174 = 0.9 time = 875
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=875.025n

* CHECK dout0_39 Vdout0_39ck174 = 0.9 time = 875
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=875.025n

* CHECK dout0_40 Vdout0_40ck174 = 0 time = 875
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=875.025n

* CHECK dout0_41 Vdout0_41ck174 = 0 time = 875
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=875.025n

* CHECK dout0_42 Vdout0_42ck174 = 0.9 time = 875
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=875.025n

* CHECK dout0_43 Vdout0_43ck174 = 0 time = 875
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=875.025n

* CHECK dout0_44 Vdout0_44ck174 = 0.9 time = 875
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=875.025n

* CHECK dout0_45 Vdout0_45ck174 = 0.9 time = 875
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=875.025n

* CHECK dout0_46 Vdout0_46ck174 = 0 time = 875
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=875.025n

* CHECK dout0_47 Vdout0_47ck174 = 0.9 time = 875
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=875.025n

* CHECK dout0_48 Vdout0_48ck174 = 0.9 time = 875
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=875.025n

* CHECK dout0_49 Vdout0_49ck174 = 0 time = 875
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=875.025n

* CHECK dout0_50 Vdout0_50ck174 = 0.9 time = 875
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=875.025n

* CHECK dout0_51 Vdout0_51ck174 = 0.9 time = 875
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=875.025n

* CHECK dout0_52 Vdout0_52ck174 = 0.9 time = 875
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=875.025n

* CHECK dout0_53 Vdout0_53ck174 = 0.9 time = 875
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=875.025n

* CHECK dout0_54 Vdout0_54ck174 = 0 time = 875
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=875.025n

* CHECK dout0_55 Vdout0_55ck174 = 0.9 time = 875
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=875.025n

* CHECK dout0_56 Vdout0_56ck174 = 0.9 time = 875
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=875.025n

* CHECK dout0_57 Vdout0_57ck174 = 0 time = 875
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=875.025n

* CHECK dout0_58 Vdout0_58ck174 = 0 time = 875
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=875.025n

* CHECK dout0_59 Vdout0_59ck174 = 0 time = 875
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=875.025n

* CHECK dout0_60 Vdout0_60ck174 = 0 time = 875
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=875.025n

* CHECK dout0_61 Vdout0_61ck174 = 0 time = 875
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=875.025n

* CHECK dout0_62 Vdout0_62ck174 = 0 time = 875
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=875.025n

* CHECK dout0_63 Vdout0_63ck174 = 0.9 time = 875
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=875.025n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 880
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=880.025n

* CHECK dout0_1 Vdout0_1ck175 = 0.9 time = 880
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=880.025n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 880
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=880.025n

* CHECK dout0_3 Vdout0_3ck175 = 0.9 time = 880
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=880.025n

* CHECK dout0_4 Vdout0_4ck175 = 0.9 time = 880
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=880.025n

* CHECK dout0_5 Vdout0_5ck175 = 0.9 time = 880
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=880.025n

* CHECK dout0_6 Vdout0_6ck175 = 0.9 time = 880
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=880.025n

* CHECK dout0_7 Vdout0_7ck175 = 0.9 time = 880
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=880.025n

* CHECK dout0_8 Vdout0_8ck175 = 0.9 time = 880
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=880.025n

* CHECK dout0_9 Vdout0_9ck175 = 0.9 time = 880
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=880.025n

* CHECK dout0_10 Vdout0_10ck175 = 0 time = 880
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=880.025n

* CHECK dout0_11 Vdout0_11ck175 = 0 time = 880
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=880.025n

* CHECK dout0_12 Vdout0_12ck175 = 0 time = 880
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=880.025n

* CHECK dout0_13 Vdout0_13ck175 = 0 time = 880
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=880.025n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 880
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=880.025n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 880
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=880.025n

* CHECK dout0_16 Vdout0_16ck175 = 0.9 time = 880
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=880.025n

* CHECK dout0_17 Vdout0_17ck175 = 0.9 time = 880
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=880.025n

* CHECK dout0_18 Vdout0_18ck175 = 0.9 time = 880
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=880.025n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 880
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=880.025n

* CHECK dout0_20 Vdout0_20ck175 = 0.9 time = 880
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=880.025n

* CHECK dout0_21 Vdout0_21ck175 = 0 time = 880
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=880.025n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 880
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=880.025n

* CHECK dout0_23 Vdout0_23ck175 = 0.9 time = 880
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=880.025n

* CHECK dout0_24 Vdout0_24ck175 = 0.9 time = 880
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=880.025n

* CHECK dout0_25 Vdout0_25ck175 = 0.9 time = 880
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=880.025n

* CHECK dout0_26 Vdout0_26ck175 = 0 time = 880
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=880.025n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 880
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=880.025n

* CHECK dout0_28 Vdout0_28ck175 = 0 time = 880
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=880.025n

* CHECK dout0_29 Vdout0_29ck175 = 0 time = 880
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=880.025n

* CHECK dout0_30 Vdout0_30ck175 = 0.9 time = 880
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=880.025n

* CHECK dout0_31 Vdout0_31ck175 = 0 time = 880
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=880.025n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 880
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=880.025n

* CHECK dout0_33 Vdout0_33ck175 = 0 time = 880
.meas tran vdout0_33ck175 FIND v(dout0_33) AT=880.025n

* CHECK dout0_34 Vdout0_34ck175 = 0 time = 880
.meas tran vdout0_34ck175 FIND v(dout0_34) AT=880.025n

* CHECK dout0_35 Vdout0_35ck175 = 0 time = 880
.meas tran vdout0_35ck175 FIND v(dout0_35) AT=880.025n

* CHECK dout0_36 Vdout0_36ck175 = 0 time = 880
.meas tran vdout0_36ck175 FIND v(dout0_36) AT=880.025n

* CHECK dout0_37 Vdout0_37ck175 = 0.9 time = 880
.meas tran vdout0_37ck175 FIND v(dout0_37) AT=880.025n

* CHECK dout0_38 Vdout0_38ck175 = 0 time = 880
.meas tran vdout0_38ck175 FIND v(dout0_38) AT=880.025n

* CHECK dout0_39 Vdout0_39ck175 = 0.9 time = 880
.meas tran vdout0_39ck175 FIND v(dout0_39) AT=880.025n

* CHECK dout0_40 Vdout0_40ck175 = 0.9 time = 880
.meas tran vdout0_40ck175 FIND v(dout0_40) AT=880.025n

* CHECK dout0_41 Vdout0_41ck175 = 0 time = 880
.meas tran vdout0_41ck175 FIND v(dout0_41) AT=880.025n

* CHECK dout0_42 Vdout0_42ck175 = 0 time = 880
.meas tran vdout0_42ck175 FIND v(dout0_42) AT=880.025n

* CHECK dout0_43 Vdout0_43ck175 = 0 time = 880
.meas tran vdout0_43ck175 FIND v(dout0_43) AT=880.025n

* CHECK dout0_44 Vdout0_44ck175 = 0 time = 880
.meas tran vdout0_44ck175 FIND v(dout0_44) AT=880.025n

* CHECK dout0_45 Vdout0_45ck175 = 0 time = 880
.meas tran vdout0_45ck175 FIND v(dout0_45) AT=880.025n

* CHECK dout0_46 Vdout0_46ck175 = 0.9 time = 880
.meas tran vdout0_46ck175 FIND v(dout0_46) AT=880.025n

* CHECK dout0_47 Vdout0_47ck175 = 0 time = 880
.meas tran vdout0_47ck175 FIND v(dout0_47) AT=880.025n

* CHECK dout0_48 Vdout0_48ck175 = 0 time = 880
.meas tran vdout0_48ck175 FIND v(dout0_48) AT=880.025n

* CHECK dout0_49 Vdout0_49ck175 = 0.9 time = 880
.meas tran vdout0_49ck175 FIND v(dout0_49) AT=880.025n

* CHECK dout0_50 Vdout0_50ck175 = 0 time = 880
.meas tran vdout0_50ck175 FIND v(dout0_50) AT=880.025n

* CHECK dout0_51 Vdout0_51ck175 = 0.9 time = 880
.meas tran vdout0_51ck175 FIND v(dout0_51) AT=880.025n

* CHECK dout0_52 Vdout0_52ck175 = 0.9 time = 880
.meas tran vdout0_52ck175 FIND v(dout0_52) AT=880.025n

* CHECK dout0_53 Vdout0_53ck175 = 0 time = 880
.meas tran vdout0_53ck175 FIND v(dout0_53) AT=880.025n

* CHECK dout0_54 Vdout0_54ck175 = 0 time = 880
.meas tran vdout0_54ck175 FIND v(dout0_54) AT=880.025n

* CHECK dout0_55 Vdout0_55ck175 = 0 time = 880
.meas tran vdout0_55ck175 FIND v(dout0_55) AT=880.025n

* CHECK dout0_56 Vdout0_56ck175 = 0.9 time = 880
.meas tran vdout0_56ck175 FIND v(dout0_56) AT=880.025n

* CHECK dout0_57 Vdout0_57ck175 = 0.9 time = 880
.meas tran vdout0_57ck175 FIND v(dout0_57) AT=880.025n

* CHECK dout0_58 Vdout0_58ck175 = 0 time = 880
.meas tran vdout0_58ck175 FIND v(dout0_58) AT=880.025n

* CHECK dout0_59 Vdout0_59ck175 = 0.9 time = 880
.meas tran vdout0_59ck175 FIND v(dout0_59) AT=880.025n

* CHECK dout0_60 Vdout0_60ck175 = 0.9 time = 880
.meas tran vdout0_60ck175 FIND v(dout0_60) AT=880.025n

* CHECK dout0_61 Vdout0_61ck175 = 0 time = 880
.meas tran vdout0_61ck175 FIND v(dout0_61) AT=880.025n

* CHECK dout0_62 Vdout0_62ck175 = 0.9 time = 880
.meas tran vdout0_62ck175 FIND v(dout0_62) AT=880.025n

* CHECK dout0_63 Vdout0_63ck175 = 0.9 time = 880
.meas tran vdout0_63ck175 FIND v(dout0_63) AT=880.025n

* CHECK dout0_0 Vdout0_0ck177 = 0.9 time = 890
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=890.025n

* CHECK dout0_1 Vdout0_1ck177 = 0.9 time = 890
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=890.025n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 890
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=890.025n

* CHECK dout0_3 Vdout0_3ck177 = 0.9 time = 890
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=890.025n

* CHECK dout0_4 Vdout0_4ck177 = 0.9 time = 890
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=890.025n

* CHECK dout0_5 Vdout0_5ck177 = 0 time = 890
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=890.025n

* CHECK dout0_6 Vdout0_6ck177 = 0.9 time = 890
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=890.025n

* CHECK dout0_7 Vdout0_7ck177 = 0.9 time = 890
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=890.025n

* CHECK dout0_8 Vdout0_8ck177 = 0.9 time = 890
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=890.025n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 890
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=890.025n

* CHECK dout0_10 Vdout0_10ck177 = 0.9 time = 890
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=890.025n

* CHECK dout0_11 Vdout0_11ck177 = 0.9 time = 890
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=890.025n

* CHECK dout0_12 Vdout0_12ck177 = 0.9 time = 890
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=890.025n

* CHECK dout0_13 Vdout0_13ck177 = 0.9 time = 890
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=890.025n

* CHECK dout0_14 Vdout0_14ck177 = 0 time = 890
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=890.025n

* CHECK dout0_15 Vdout0_15ck177 = 0.9 time = 890
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=890.025n

* CHECK dout0_16 Vdout0_16ck177 = 0.9 time = 890
.meas tran vdout0_16ck177 FIND v(dout0_16) AT=890.025n

* CHECK dout0_17 Vdout0_17ck177 = 0.9 time = 890
.meas tran vdout0_17ck177 FIND v(dout0_17) AT=890.025n

* CHECK dout0_18 Vdout0_18ck177 = 0.9 time = 890
.meas tran vdout0_18ck177 FIND v(dout0_18) AT=890.025n

* CHECK dout0_19 Vdout0_19ck177 = 0.9 time = 890
.meas tran vdout0_19ck177 FIND v(dout0_19) AT=890.025n

* CHECK dout0_20 Vdout0_20ck177 = 0.9 time = 890
.meas tran vdout0_20ck177 FIND v(dout0_20) AT=890.025n

* CHECK dout0_21 Vdout0_21ck177 = 0.9 time = 890
.meas tran vdout0_21ck177 FIND v(dout0_21) AT=890.025n

* CHECK dout0_22 Vdout0_22ck177 = 0 time = 890
.meas tran vdout0_22ck177 FIND v(dout0_22) AT=890.025n

* CHECK dout0_23 Vdout0_23ck177 = 0 time = 890
.meas tran vdout0_23ck177 FIND v(dout0_23) AT=890.025n

* CHECK dout0_24 Vdout0_24ck177 = 0.9 time = 890
.meas tran vdout0_24ck177 FIND v(dout0_24) AT=890.025n

* CHECK dout0_25 Vdout0_25ck177 = 0.9 time = 890
.meas tran vdout0_25ck177 FIND v(dout0_25) AT=890.025n

* CHECK dout0_26 Vdout0_26ck177 = 0.9 time = 890
.meas tran vdout0_26ck177 FIND v(dout0_26) AT=890.025n

* CHECK dout0_27 Vdout0_27ck177 = 0 time = 890
.meas tran vdout0_27ck177 FIND v(dout0_27) AT=890.025n

* CHECK dout0_28 Vdout0_28ck177 = 0 time = 890
.meas tran vdout0_28ck177 FIND v(dout0_28) AT=890.025n

* CHECK dout0_29 Vdout0_29ck177 = 0 time = 890
.meas tran vdout0_29ck177 FIND v(dout0_29) AT=890.025n

* CHECK dout0_30 Vdout0_30ck177 = 0.9 time = 890
.meas tran vdout0_30ck177 FIND v(dout0_30) AT=890.025n

* CHECK dout0_31 Vdout0_31ck177 = 0 time = 890
.meas tran vdout0_31ck177 FIND v(dout0_31) AT=890.025n

* CHECK dout0_32 Vdout0_32ck177 = 0.9 time = 890
.meas tran vdout0_32ck177 FIND v(dout0_32) AT=890.025n

* CHECK dout0_33 Vdout0_33ck177 = 0 time = 890
.meas tran vdout0_33ck177 FIND v(dout0_33) AT=890.025n

* CHECK dout0_34 Vdout0_34ck177 = 0 time = 890
.meas tran vdout0_34ck177 FIND v(dout0_34) AT=890.025n

* CHECK dout0_35 Vdout0_35ck177 = 0 time = 890
.meas tran vdout0_35ck177 FIND v(dout0_35) AT=890.025n

* CHECK dout0_36 Vdout0_36ck177 = 0 time = 890
.meas tran vdout0_36ck177 FIND v(dout0_36) AT=890.025n

* CHECK dout0_37 Vdout0_37ck177 = 0.9 time = 890
.meas tran vdout0_37ck177 FIND v(dout0_37) AT=890.025n

* CHECK dout0_38 Vdout0_38ck177 = 0.9 time = 890
.meas tran vdout0_38ck177 FIND v(dout0_38) AT=890.025n

* CHECK dout0_39 Vdout0_39ck177 = 0.9 time = 890
.meas tran vdout0_39ck177 FIND v(dout0_39) AT=890.025n

* CHECK dout0_40 Vdout0_40ck177 = 0 time = 890
.meas tran vdout0_40ck177 FIND v(dout0_40) AT=890.025n

* CHECK dout0_41 Vdout0_41ck177 = 0 time = 890
.meas tran vdout0_41ck177 FIND v(dout0_41) AT=890.025n

* CHECK dout0_42 Vdout0_42ck177 = 0.9 time = 890
.meas tran vdout0_42ck177 FIND v(dout0_42) AT=890.025n

* CHECK dout0_43 Vdout0_43ck177 = 0 time = 890
.meas tran vdout0_43ck177 FIND v(dout0_43) AT=890.025n

* CHECK dout0_44 Vdout0_44ck177 = 0.9 time = 890
.meas tran vdout0_44ck177 FIND v(dout0_44) AT=890.025n

* CHECK dout0_45 Vdout0_45ck177 = 0.9 time = 890
.meas tran vdout0_45ck177 FIND v(dout0_45) AT=890.025n

* CHECK dout0_46 Vdout0_46ck177 = 0 time = 890
.meas tran vdout0_46ck177 FIND v(dout0_46) AT=890.025n

* CHECK dout0_47 Vdout0_47ck177 = 0.9 time = 890
.meas tran vdout0_47ck177 FIND v(dout0_47) AT=890.025n

* CHECK dout0_48 Vdout0_48ck177 = 0.9 time = 890
.meas tran vdout0_48ck177 FIND v(dout0_48) AT=890.025n

* CHECK dout0_49 Vdout0_49ck177 = 0 time = 890
.meas tran vdout0_49ck177 FIND v(dout0_49) AT=890.025n

* CHECK dout0_50 Vdout0_50ck177 = 0.9 time = 890
.meas tran vdout0_50ck177 FIND v(dout0_50) AT=890.025n

* CHECK dout0_51 Vdout0_51ck177 = 0.9 time = 890
.meas tran vdout0_51ck177 FIND v(dout0_51) AT=890.025n

* CHECK dout0_52 Vdout0_52ck177 = 0.9 time = 890
.meas tran vdout0_52ck177 FIND v(dout0_52) AT=890.025n

* CHECK dout0_53 Vdout0_53ck177 = 0.9 time = 890
.meas tran vdout0_53ck177 FIND v(dout0_53) AT=890.025n

* CHECK dout0_54 Vdout0_54ck177 = 0 time = 890
.meas tran vdout0_54ck177 FIND v(dout0_54) AT=890.025n

* CHECK dout0_55 Vdout0_55ck177 = 0.9 time = 890
.meas tran vdout0_55ck177 FIND v(dout0_55) AT=890.025n

* CHECK dout0_56 Vdout0_56ck177 = 0.9 time = 890
.meas tran vdout0_56ck177 FIND v(dout0_56) AT=890.025n

* CHECK dout0_57 Vdout0_57ck177 = 0 time = 890
.meas tran vdout0_57ck177 FIND v(dout0_57) AT=890.025n

* CHECK dout0_58 Vdout0_58ck177 = 0 time = 890
.meas tran vdout0_58ck177 FIND v(dout0_58) AT=890.025n

* CHECK dout0_59 Vdout0_59ck177 = 0 time = 890
.meas tran vdout0_59ck177 FIND v(dout0_59) AT=890.025n

* CHECK dout0_60 Vdout0_60ck177 = 0 time = 890
.meas tran vdout0_60ck177 FIND v(dout0_60) AT=890.025n

* CHECK dout0_61 Vdout0_61ck177 = 0 time = 890
.meas tran vdout0_61ck177 FIND v(dout0_61) AT=890.025n

* CHECK dout0_62 Vdout0_62ck177 = 0 time = 890
.meas tran vdout0_62ck177 FIND v(dout0_62) AT=890.025n

* CHECK dout0_63 Vdout0_63ck177 = 0.9 time = 890
.meas tran vdout0_63ck177 FIND v(dout0_63) AT=890.025n

* CHECK dout0_0 Vdout0_0ck179 = 0.9 time = 900
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=900.025n

* CHECK dout0_1 Vdout0_1ck179 = 0.9 time = 900
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=900.025n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 900
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=900.025n

* CHECK dout0_3 Vdout0_3ck179 = 0.9 time = 900
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=900.025n

* CHECK dout0_4 Vdout0_4ck179 = 0.9 time = 900
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=900.025n

* CHECK dout0_5 Vdout0_5ck179 = 0 time = 900
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=900.025n

* CHECK dout0_6 Vdout0_6ck179 = 0.9 time = 900
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=900.025n

* CHECK dout0_7 Vdout0_7ck179 = 0.9 time = 900
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=900.025n

* CHECK dout0_8 Vdout0_8ck179 = 0.9 time = 900
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=900.025n

* CHECK dout0_9 Vdout0_9ck179 = 0 time = 900
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=900.025n

* CHECK dout0_10 Vdout0_10ck179 = 0.9 time = 900
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=900.025n

* CHECK dout0_11 Vdout0_11ck179 = 0.9 time = 900
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=900.025n

* CHECK dout0_12 Vdout0_12ck179 = 0.9 time = 900
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=900.025n

* CHECK dout0_13 Vdout0_13ck179 = 0.9 time = 900
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=900.025n

* CHECK dout0_14 Vdout0_14ck179 = 0 time = 900
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=900.025n

* CHECK dout0_15 Vdout0_15ck179 = 0.9 time = 900
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=900.025n

* CHECK dout0_16 Vdout0_16ck179 = 0.9 time = 900
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=900.025n

* CHECK dout0_17 Vdout0_17ck179 = 0.9 time = 900
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=900.025n

* CHECK dout0_18 Vdout0_18ck179 = 0.9 time = 900
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=900.025n

* CHECK dout0_19 Vdout0_19ck179 = 0.9 time = 900
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=900.025n

* CHECK dout0_20 Vdout0_20ck179 = 0.9 time = 900
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=900.025n

* CHECK dout0_21 Vdout0_21ck179 = 0.9 time = 900
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=900.025n

* CHECK dout0_22 Vdout0_22ck179 = 0 time = 900
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=900.025n

* CHECK dout0_23 Vdout0_23ck179 = 0 time = 900
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=900.025n

* CHECK dout0_24 Vdout0_24ck179 = 0.9 time = 900
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=900.025n

* CHECK dout0_25 Vdout0_25ck179 = 0.9 time = 900
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=900.025n

* CHECK dout0_26 Vdout0_26ck179 = 0.9 time = 900
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=900.025n

* CHECK dout0_27 Vdout0_27ck179 = 0 time = 900
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=900.025n

* CHECK dout0_28 Vdout0_28ck179 = 0 time = 900
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=900.025n

* CHECK dout0_29 Vdout0_29ck179 = 0 time = 900
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=900.025n

* CHECK dout0_30 Vdout0_30ck179 = 0.9 time = 900
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=900.025n

* CHECK dout0_31 Vdout0_31ck179 = 0 time = 900
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=900.025n

* CHECK dout0_32 Vdout0_32ck179 = 0.9 time = 900
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=900.025n

* CHECK dout0_33 Vdout0_33ck179 = 0 time = 900
.meas tran vdout0_33ck179 FIND v(dout0_33) AT=900.025n

* CHECK dout0_34 Vdout0_34ck179 = 0 time = 900
.meas tran vdout0_34ck179 FIND v(dout0_34) AT=900.025n

* CHECK dout0_35 Vdout0_35ck179 = 0 time = 900
.meas tran vdout0_35ck179 FIND v(dout0_35) AT=900.025n

* CHECK dout0_36 Vdout0_36ck179 = 0 time = 900
.meas tran vdout0_36ck179 FIND v(dout0_36) AT=900.025n

* CHECK dout0_37 Vdout0_37ck179 = 0.9 time = 900
.meas tran vdout0_37ck179 FIND v(dout0_37) AT=900.025n

* CHECK dout0_38 Vdout0_38ck179 = 0.9 time = 900
.meas tran vdout0_38ck179 FIND v(dout0_38) AT=900.025n

* CHECK dout0_39 Vdout0_39ck179 = 0.9 time = 900
.meas tran vdout0_39ck179 FIND v(dout0_39) AT=900.025n

* CHECK dout0_40 Vdout0_40ck179 = 0 time = 900
.meas tran vdout0_40ck179 FIND v(dout0_40) AT=900.025n

* CHECK dout0_41 Vdout0_41ck179 = 0 time = 900
.meas tran vdout0_41ck179 FIND v(dout0_41) AT=900.025n

* CHECK dout0_42 Vdout0_42ck179 = 0.9 time = 900
.meas tran vdout0_42ck179 FIND v(dout0_42) AT=900.025n

* CHECK dout0_43 Vdout0_43ck179 = 0 time = 900
.meas tran vdout0_43ck179 FIND v(dout0_43) AT=900.025n

* CHECK dout0_44 Vdout0_44ck179 = 0.9 time = 900
.meas tran vdout0_44ck179 FIND v(dout0_44) AT=900.025n

* CHECK dout0_45 Vdout0_45ck179 = 0.9 time = 900
.meas tran vdout0_45ck179 FIND v(dout0_45) AT=900.025n

* CHECK dout0_46 Vdout0_46ck179 = 0 time = 900
.meas tran vdout0_46ck179 FIND v(dout0_46) AT=900.025n

* CHECK dout0_47 Vdout0_47ck179 = 0.9 time = 900
.meas tran vdout0_47ck179 FIND v(dout0_47) AT=900.025n

* CHECK dout0_48 Vdout0_48ck179 = 0.9 time = 900
.meas tran vdout0_48ck179 FIND v(dout0_48) AT=900.025n

* CHECK dout0_49 Vdout0_49ck179 = 0 time = 900
.meas tran vdout0_49ck179 FIND v(dout0_49) AT=900.025n

* CHECK dout0_50 Vdout0_50ck179 = 0.9 time = 900
.meas tran vdout0_50ck179 FIND v(dout0_50) AT=900.025n

* CHECK dout0_51 Vdout0_51ck179 = 0.9 time = 900
.meas tran vdout0_51ck179 FIND v(dout0_51) AT=900.025n

* CHECK dout0_52 Vdout0_52ck179 = 0.9 time = 900
.meas tran vdout0_52ck179 FIND v(dout0_52) AT=900.025n

* CHECK dout0_53 Vdout0_53ck179 = 0.9 time = 900
.meas tran vdout0_53ck179 FIND v(dout0_53) AT=900.025n

* CHECK dout0_54 Vdout0_54ck179 = 0 time = 900
.meas tran vdout0_54ck179 FIND v(dout0_54) AT=900.025n

* CHECK dout0_55 Vdout0_55ck179 = 0.9 time = 900
.meas tran vdout0_55ck179 FIND v(dout0_55) AT=900.025n

* CHECK dout0_56 Vdout0_56ck179 = 0.9 time = 900
.meas tran vdout0_56ck179 FIND v(dout0_56) AT=900.025n

* CHECK dout0_57 Vdout0_57ck179 = 0 time = 900
.meas tran vdout0_57ck179 FIND v(dout0_57) AT=900.025n

* CHECK dout0_58 Vdout0_58ck179 = 0 time = 900
.meas tran vdout0_58ck179 FIND v(dout0_58) AT=900.025n

* CHECK dout0_59 Vdout0_59ck179 = 0 time = 900
.meas tran vdout0_59ck179 FIND v(dout0_59) AT=900.025n

* CHECK dout0_60 Vdout0_60ck179 = 0 time = 900
.meas tran vdout0_60ck179 FIND v(dout0_60) AT=900.025n

* CHECK dout0_61 Vdout0_61ck179 = 0 time = 900
.meas tran vdout0_61ck179 FIND v(dout0_61) AT=900.025n

* CHECK dout0_62 Vdout0_62ck179 = 0 time = 900
.meas tran vdout0_62ck179 FIND v(dout0_62) AT=900.025n

* CHECK dout0_63 Vdout0_63ck179 = 0.9 time = 900
.meas tran vdout0_63ck179 FIND v(dout0_63) AT=900.025n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 905
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=905.025n

* CHECK dout0_1 Vdout0_1ck180 = 0.9 time = 905
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=905.025n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 905
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=905.025n

* CHECK dout0_3 Vdout0_3ck180 = 0.9 time = 905
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=905.025n

* CHECK dout0_4 Vdout0_4ck180 = 0.9 time = 905
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=905.025n

* CHECK dout0_5 Vdout0_5ck180 = 0.9 time = 905
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=905.025n

* CHECK dout0_6 Vdout0_6ck180 = 0.9 time = 905
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=905.025n

* CHECK dout0_7 Vdout0_7ck180 = 0.9 time = 905
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=905.025n

* CHECK dout0_8 Vdout0_8ck180 = 0.9 time = 905
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=905.025n

* CHECK dout0_9 Vdout0_9ck180 = 0.9 time = 905
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=905.025n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 905
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=905.025n

* CHECK dout0_11 Vdout0_11ck180 = 0 time = 905
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=905.025n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 905
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=905.025n

* CHECK dout0_13 Vdout0_13ck180 = 0 time = 905
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=905.025n

* CHECK dout0_14 Vdout0_14ck180 = 0 time = 905
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=905.025n

* CHECK dout0_15 Vdout0_15ck180 = 0 time = 905
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=905.025n

* CHECK dout0_16 Vdout0_16ck180 = 0.9 time = 905
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=905.025n

* CHECK dout0_17 Vdout0_17ck180 = 0.9 time = 905
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=905.025n

* CHECK dout0_18 Vdout0_18ck180 = 0.9 time = 905
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=905.025n

* CHECK dout0_19 Vdout0_19ck180 = 0 time = 905
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=905.025n

* CHECK dout0_20 Vdout0_20ck180 = 0.9 time = 905
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=905.025n

* CHECK dout0_21 Vdout0_21ck180 = 0 time = 905
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=905.025n

* CHECK dout0_22 Vdout0_22ck180 = 0 time = 905
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=905.025n

* CHECK dout0_23 Vdout0_23ck180 = 0.9 time = 905
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=905.025n

* CHECK dout0_24 Vdout0_24ck180 = 0.9 time = 905
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=905.025n

* CHECK dout0_25 Vdout0_25ck180 = 0.9 time = 905
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=905.025n

* CHECK dout0_26 Vdout0_26ck180 = 0 time = 905
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=905.025n

* CHECK dout0_27 Vdout0_27ck180 = 0 time = 905
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=905.025n

* CHECK dout0_28 Vdout0_28ck180 = 0 time = 905
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=905.025n

* CHECK dout0_29 Vdout0_29ck180 = 0 time = 905
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=905.025n

* CHECK dout0_30 Vdout0_30ck180 = 0.9 time = 905
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=905.025n

* CHECK dout0_31 Vdout0_31ck180 = 0 time = 905
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=905.025n

* CHECK dout0_32 Vdout0_32ck180 = 0 time = 905
.meas tran vdout0_32ck180 FIND v(dout0_32) AT=905.025n

* CHECK dout0_33 Vdout0_33ck180 = 0 time = 905
.meas tran vdout0_33ck180 FIND v(dout0_33) AT=905.025n

* CHECK dout0_34 Vdout0_34ck180 = 0 time = 905
.meas tran vdout0_34ck180 FIND v(dout0_34) AT=905.025n

* CHECK dout0_35 Vdout0_35ck180 = 0 time = 905
.meas tran vdout0_35ck180 FIND v(dout0_35) AT=905.025n

* CHECK dout0_36 Vdout0_36ck180 = 0 time = 905
.meas tran vdout0_36ck180 FIND v(dout0_36) AT=905.025n

* CHECK dout0_37 Vdout0_37ck180 = 0.9 time = 905
.meas tran vdout0_37ck180 FIND v(dout0_37) AT=905.025n

* CHECK dout0_38 Vdout0_38ck180 = 0 time = 905
.meas tran vdout0_38ck180 FIND v(dout0_38) AT=905.025n

* CHECK dout0_39 Vdout0_39ck180 = 0.9 time = 905
.meas tran vdout0_39ck180 FIND v(dout0_39) AT=905.025n

* CHECK dout0_40 Vdout0_40ck180 = 0.9 time = 905
.meas tran vdout0_40ck180 FIND v(dout0_40) AT=905.025n

* CHECK dout0_41 Vdout0_41ck180 = 0 time = 905
.meas tran vdout0_41ck180 FIND v(dout0_41) AT=905.025n

* CHECK dout0_42 Vdout0_42ck180 = 0 time = 905
.meas tran vdout0_42ck180 FIND v(dout0_42) AT=905.025n

* CHECK dout0_43 Vdout0_43ck180 = 0 time = 905
.meas tran vdout0_43ck180 FIND v(dout0_43) AT=905.025n

* CHECK dout0_44 Vdout0_44ck180 = 0 time = 905
.meas tran vdout0_44ck180 FIND v(dout0_44) AT=905.025n

* CHECK dout0_45 Vdout0_45ck180 = 0 time = 905
.meas tran vdout0_45ck180 FIND v(dout0_45) AT=905.025n

* CHECK dout0_46 Vdout0_46ck180 = 0.9 time = 905
.meas tran vdout0_46ck180 FIND v(dout0_46) AT=905.025n

* CHECK dout0_47 Vdout0_47ck180 = 0 time = 905
.meas tran vdout0_47ck180 FIND v(dout0_47) AT=905.025n

* CHECK dout0_48 Vdout0_48ck180 = 0 time = 905
.meas tran vdout0_48ck180 FIND v(dout0_48) AT=905.025n

* CHECK dout0_49 Vdout0_49ck180 = 0.9 time = 905
.meas tran vdout0_49ck180 FIND v(dout0_49) AT=905.025n

* CHECK dout0_50 Vdout0_50ck180 = 0 time = 905
.meas tran vdout0_50ck180 FIND v(dout0_50) AT=905.025n

* CHECK dout0_51 Vdout0_51ck180 = 0.9 time = 905
.meas tran vdout0_51ck180 FIND v(dout0_51) AT=905.025n

* CHECK dout0_52 Vdout0_52ck180 = 0.9 time = 905
.meas tran vdout0_52ck180 FIND v(dout0_52) AT=905.025n

* CHECK dout0_53 Vdout0_53ck180 = 0 time = 905
.meas tran vdout0_53ck180 FIND v(dout0_53) AT=905.025n

* CHECK dout0_54 Vdout0_54ck180 = 0 time = 905
.meas tran vdout0_54ck180 FIND v(dout0_54) AT=905.025n

* CHECK dout0_55 Vdout0_55ck180 = 0 time = 905
.meas tran vdout0_55ck180 FIND v(dout0_55) AT=905.025n

* CHECK dout0_56 Vdout0_56ck180 = 0.9 time = 905
.meas tran vdout0_56ck180 FIND v(dout0_56) AT=905.025n

* CHECK dout0_57 Vdout0_57ck180 = 0.9 time = 905
.meas tran vdout0_57ck180 FIND v(dout0_57) AT=905.025n

* CHECK dout0_58 Vdout0_58ck180 = 0 time = 905
.meas tran vdout0_58ck180 FIND v(dout0_58) AT=905.025n

* CHECK dout0_59 Vdout0_59ck180 = 0.9 time = 905
.meas tran vdout0_59ck180 FIND v(dout0_59) AT=905.025n

* CHECK dout0_60 Vdout0_60ck180 = 0.9 time = 905
.meas tran vdout0_60ck180 FIND v(dout0_60) AT=905.025n

* CHECK dout0_61 Vdout0_61ck180 = 0 time = 905
.meas tran vdout0_61ck180 FIND v(dout0_61) AT=905.025n

* CHECK dout0_62 Vdout0_62ck180 = 0.9 time = 905
.meas tran vdout0_62ck180 FIND v(dout0_62) AT=905.025n

* CHECK dout0_63 Vdout0_63ck180 = 0.9 time = 905
.meas tran vdout0_63ck180 FIND v(dout0_63) AT=905.025n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0.9 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 0 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0.9 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 0.9 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 0.9 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0.9 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0.9 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0.9 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0.9 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 0 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 0 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0.9 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 0.9 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0.9 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 0.9 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 0 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 0.9 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0.9 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 0.9 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 0 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0.9 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_32 Vdout0_32ck181 = 0 time = 910
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=910.025n

* CHECK dout0_33 Vdout0_33ck181 = 0 time = 910
.meas tran vdout0_33ck181 FIND v(dout0_33) AT=910.025n

* CHECK dout0_34 Vdout0_34ck181 = 0 time = 910
.meas tran vdout0_34ck181 FIND v(dout0_34) AT=910.025n

* CHECK dout0_35 Vdout0_35ck181 = 0 time = 910
.meas tran vdout0_35ck181 FIND v(dout0_35) AT=910.025n

* CHECK dout0_36 Vdout0_36ck181 = 0 time = 910
.meas tran vdout0_36ck181 FIND v(dout0_36) AT=910.025n

* CHECK dout0_37 Vdout0_37ck181 = 0.9 time = 910
.meas tran vdout0_37ck181 FIND v(dout0_37) AT=910.025n

* CHECK dout0_38 Vdout0_38ck181 = 0 time = 910
.meas tran vdout0_38ck181 FIND v(dout0_38) AT=910.025n

* CHECK dout0_39 Vdout0_39ck181 = 0.9 time = 910
.meas tran vdout0_39ck181 FIND v(dout0_39) AT=910.025n

* CHECK dout0_40 Vdout0_40ck181 = 0.9 time = 910
.meas tran vdout0_40ck181 FIND v(dout0_40) AT=910.025n

* CHECK dout0_41 Vdout0_41ck181 = 0 time = 910
.meas tran vdout0_41ck181 FIND v(dout0_41) AT=910.025n

* CHECK dout0_42 Vdout0_42ck181 = 0 time = 910
.meas tran vdout0_42ck181 FIND v(dout0_42) AT=910.025n

* CHECK dout0_43 Vdout0_43ck181 = 0 time = 910
.meas tran vdout0_43ck181 FIND v(dout0_43) AT=910.025n

* CHECK dout0_44 Vdout0_44ck181 = 0 time = 910
.meas tran vdout0_44ck181 FIND v(dout0_44) AT=910.025n

* CHECK dout0_45 Vdout0_45ck181 = 0 time = 910
.meas tran vdout0_45ck181 FIND v(dout0_45) AT=910.025n

* CHECK dout0_46 Vdout0_46ck181 = 0.9 time = 910
.meas tran vdout0_46ck181 FIND v(dout0_46) AT=910.025n

* CHECK dout0_47 Vdout0_47ck181 = 0 time = 910
.meas tran vdout0_47ck181 FIND v(dout0_47) AT=910.025n

* CHECK dout0_48 Vdout0_48ck181 = 0 time = 910
.meas tran vdout0_48ck181 FIND v(dout0_48) AT=910.025n

* CHECK dout0_49 Vdout0_49ck181 = 0.9 time = 910
.meas tran vdout0_49ck181 FIND v(dout0_49) AT=910.025n

* CHECK dout0_50 Vdout0_50ck181 = 0 time = 910
.meas tran vdout0_50ck181 FIND v(dout0_50) AT=910.025n

* CHECK dout0_51 Vdout0_51ck181 = 0.9 time = 910
.meas tran vdout0_51ck181 FIND v(dout0_51) AT=910.025n

* CHECK dout0_52 Vdout0_52ck181 = 0.9 time = 910
.meas tran vdout0_52ck181 FIND v(dout0_52) AT=910.025n

* CHECK dout0_53 Vdout0_53ck181 = 0 time = 910
.meas tran vdout0_53ck181 FIND v(dout0_53) AT=910.025n

* CHECK dout0_54 Vdout0_54ck181 = 0 time = 910
.meas tran vdout0_54ck181 FIND v(dout0_54) AT=910.025n

* CHECK dout0_55 Vdout0_55ck181 = 0 time = 910
.meas tran vdout0_55ck181 FIND v(dout0_55) AT=910.025n

* CHECK dout0_56 Vdout0_56ck181 = 0.9 time = 910
.meas tran vdout0_56ck181 FIND v(dout0_56) AT=910.025n

* CHECK dout0_57 Vdout0_57ck181 = 0.9 time = 910
.meas tran vdout0_57ck181 FIND v(dout0_57) AT=910.025n

* CHECK dout0_58 Vdout0_58ck181 = 0 time = 910
.meas tran vdout0_58ck181 FIND v(dout0_58) AT=910.025n

* CHECK dout0_59 Vdout0_59ck181 = 0.9 time = 910
.meas tran vdout0_59ck181 FIND v(dout0_59) AT=910.025n

* CHECK dout0_60 Vdout0_60ck181 = 0.9 time = 910
.meas tran vdout0_60ck181 FIND v(dout0_60) AT=910.025n

* CHECK dout0_61 Vdout0_61ck181 = 0 time = 910
.meas tran vdout0_61ck181 FIND v(dout0_61) AT=910.025n

* CHECK dout0_62 Vdout0_62ck181 = 0.9 time = 910
.meas tran vdout0_62ck181 FIND v(dout0_62) AT=910.025n

* CHECK dout0_63 Vdout0_63ck181 = 0.9 time = 910
.meas tran vdout0_63ck181 FIND v(dout0_63) AT=910.025n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 915
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=915.025n

* CHECK dout0_1 Vdout0_1ck182 = 0.9 time = 915
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=915.025n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 915
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=915.025n

* CHECK dout0_3 Vdout0_3ck182 = 0.9 time = 915
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=915.025n

* CHECK dout0_4 Vdout0_4ck182 = 0.9 time = 915
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=915.025n

* CHECK dout0_5 Vdout0_5ck182 = 0.9 time = 915
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=915.025n

* CHECK dout0_6 Vdout0_6ck182 = 0.9 time = 915
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=915.025n

* CHECK dout0_7 Vdout0_7ck182 = 0.9 time = 915
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=915.025n

* CHECK dout0_8 Vdout0_8ck182 = 0.9 time = 915
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=915.025n

* CHECK dout0_9 Vdout0_9ck182 = 0.9 time = 915
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=915.025n

* CHECK dout0_10 Vdout0_10ck182 = 0 time = 915
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=915.025n

* CHECK dout0_11 Vdout0_11ck182 = 0 time = 915
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=915.025n

* CHECK dout0_12 Vdout0_12ck182 = 0 time = 915
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=915.025n

* CHECK dout0_13 Vdout0_13ck182 = 0 time = 915
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=915.025n

* CHECK dout0_14 Vdout0_14ck182 = 0 time = 915
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=915.025n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 915
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=915.025n

* CHECK dout0_16 Vdout0_16ck182 = 0.9 time = 915
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=915.025n

* CHECK dout0_17 Vdout0_17ck182 = 0.9 time = 915
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=915.025n

* CHECK dout0_18 Vdout0_18ck182 = 0.9 time = 915
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=915.025n

* CHECK dout0_19 Vdout0_19ck182 = 0 time = 915
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=915.025n

* CHECK dout0_20 Vdout0_20ck182 = 0.9 time = 915
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=915.025n

* CHECK dout0_21 Vdout0_21ck182 = 0 time = 915
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=915.025n

* CHECK dout0_22 Vdout0_22ck182 = 0 time = 915
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=915.025n

* CHECK dout0_23 Vdout0_23ck182 = 0.9 time = 915
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=915.025n

* CHECK dout0_24 Vdout0_24ck182 = 0.9 time = 915
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=915.025n

* CHECK dout0_25 Vdout0_25ck182 = 0.9 time = 915
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=915.025n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 915
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=915.025n

* CHECK dout0_27 Vdout0_27ck182 = 0 time = 915
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=915.025n

* CHECK dout0_28 Vdout0_28ck182 = 0 time = 915
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=915.025n

* CHECK dout0_29 Vdout0_29ck182 = 0 time = 915
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=915.025n

* CHECK dout0_30 Vdout0_30ck182 = 0.9 time = 915
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=915.025n

* CHECK dout0_31 Vdout0_31ck182 = 0 time = 915
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=915.025n

* CHECK dout0_32 Vdout0_32ck182 = 0 time = 915
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=915.025n

* CHECK dout0_33 Vdout0_33ck182 = 0 time = 915
.meas tran vdout0_33ck182 FIND v(dout0_33) AT=915.025n

* CHECK dout0_34 Vdout0_34ck182 = 0 time = 915
.meas tran vdout0_34ck182 FIND v(dout0_34) AT=915.025n

* CHECK dout0_35 Vdout0_35ck182 = 0 time = 915
.meas tran vdout0_35ck182 FIND v(dout0_35) AT=915.025n

* CHECK dout0_36 Vdout0_36ck182 = 0 time = 915
.meas tran vdout0_36ck182 FIND v(dout0_36) AT=915.025n

* CHECK dout0_37 Vdout0_37ck182 = 0.9 time = 915
.meas tran vdout0_37ck182 FIND v(dout0_37) AT=915.025n

* CHECK dout0_38 Vdout0_38ck182 = 0 time = 915
.meas tran vdout0_38ck182 FIND v(dout0_38) AT=915.025n

* CHECK dout0_39 Vdout0_39ck182 = 0.9 time = 915
.meas tran vdout0_39ck182 FIND v(dout0_39) AT=915.025n

* CHECK dout0_40 Vdout0_40ck182 = 0.9 time = 915
.meas tran vdout0_40ck182 FIND v(dout0_40) AT=915.025n

* CHECK dout0_41 Vdout0_41ck182 = 0 time = 915
.meas tran vdout0_41ck182 FIND v(dout0_41) AT=915.025n

* CHECK dout0_42 Vdout0_42ck182 = 0 time = 915
.meas tran vdout0_42ck182 FIND v(dout0_42) AT=915.025n

* CHECK dout0_43 Vdout0_43ck182 = 0 time = 915
.meas tran vdout0_43ck182 FIND v(dout0_43) AT=915.025n

* CHECK dout0_44 Vdout0_44ck182 = 0 time = 915
.meas tran vdout0_44ck182 FIND v(dout0_44) AT=915.025n

* CHECK dout0_45 Vdout0_45ck182 = 0 time = 915
.meas tran vdout0_45ck182 FIND v(dout0_45) AT=915.025n

* CHECK dout0_46 Vdout0_46ck182 = 0.9 time = 915
.meas tran vdout0_46ck182 FIND v(dout0_46) AT=915.025n

* CHECK dout0_47 Vdout0_47ck182 = 0 time = 915
.meas tran vdout0_47ck182 FIND v(dout0_47) AT=915.025n

* CHECK dout0_48 Vdout0_48ck182 = 0 time = 915
.meas tran vdout0_48ck182 FIND v(dout0_48) AT=915.025n

* CHECK dout0_49 Vdout0_49ck182 = 0.9 time = 915
.meas tran vdout0_49ck182 FIND v(dout0_49) AT=915.025n

* CHECK dout0_50 Vdout0_50ck182 = 0 time = 915
.meas tran vdout0_50ck182 FIND v(dout0_50) AT=915.025n

* CHECK dout0_51 Vdout0_51ck182 = 0.9 time = 915
.meas tran vdout0_51ck182 FIND v(dout0_51) AT=915.025n

* CHECK dout0_52 Vdout0_52ck182 = 0.9 time = 915
.meas tran vdout0_52ck182 FIND v(dout0_52) AT=915.025n

* CHECK dout0_53 Vdout0_53ck182 = 0 time = 915
.meas tran vdout0_53ck182 FIND v(dout0_53) AT=915.025n

* CHECK dout0_54 Vdout0_54ck182 = 0 time = 915
.meas tran vdout0_54ck182 FIND v(dout0_54) AT=915.025n

* CHECK dout0_55 Vdout0_55ck182 = 0 time = 915
.meas tran vdout0_55ck182 FIND v(dout0_55) AT=915.025n

* CHECK dout0_56 Vdout0_56ck182 = 0.9 time = 915
.meas tran vdout0_56ck182 FIND v(dout0_56) AT=915.025n

* CHECK dout0_57 Vdout0_57ck182 = 0.9 time = 915
.meas tran vdout0_57ck182 FIND v(dout0_57) AT=915.025n

* CHECK dout0_58 Vdout0_58ck182 = 0 time = 915
.meas tran vdout0_58ck182 FIND v(dout0_58) AT=915.025n

* CHECK dout0_59 Vdout0_59ck182 = 0.9 time = 915
.meas tran vdout0_59ck182 FIND v(dout0_59) AT=915.025n

* CHECK dout0_60 Vdout0_60ck182 = 0.9 time = 915
.meas tran vdout0_60ck182 FIND v(dout0_60) AT=915.025n

* CHECK dout0_61 Vdout0_61ck182 = 0 time = 915
.meas tran vdout0_61ck182 FIND v(dout0_61) AT=915.025n

* CHECK dout0_62 Vdout0_62ck182 = 0.9 time = 915
.meas tran vdout0_62ck182 FIND v(dout0_62) AT=915.025n

* CHECK dout0_63 Vdout0_63ck182 = 0.9 time = 915
.meas tran vdout0_63ck182 FIND v(dout0_63) AT=915.025n

* CHECK dout0_0 Vdout0_0ck184 = 0.9 time = 925
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=925.025n

* CHECK dout0_1 Vdout0_1ck184 = 0.9 time = 925
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=925.025n

* CHECK dout0_2 Vdout0_2ck184 = 0 time = 925
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=925.025n

* CHECK dout0_3 Vdout0_3ck184 = 0.9 time = 925
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=925.025n

* CHECK dout0_4 Vdout0_4ck184 = 0.9 time = 925
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=925.025n

* CHECK dout0_5 Vdout0_5ck184 = 0 time = 925
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=925.025n

* CHECK dout0_6 Vdout0_6ck184 = 0.9 time = 925
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=925.025n

* CHECK dout0_7 Vdout0_7ck184 = 0.9 time = 925
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=925.025n

* CHECK dout0_8 Vdout0_8ck184 = 0.9 time = 925
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=925.025n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 925
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=925.025n

* CHECK dout0_10 Vdout0_10ck184 = 0.9 time = 925
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=925.025n

* CHECK dout0_11 Vdout0_11ck184 = 0.9 time = 925
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=925.025n

* CHECK dout0_12 Vdout0_12ck184 = 0.9 time = 925
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=925.025n

* CHECK dout0_13 Vdout0_13ck184 = 0.9 time = 925
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=925.025n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 925
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=925.025n

* CHECK dout0_15 Vdout0_15ck184 = 0.9 time = 925
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=925.025n

* CHECK dout0_16 Vdout0_16ck184 = 0.9 time = 925
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=925.025n

* CHECK dout0_17 Vdout0_17ck184 = 0.9 time = 925
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=925.025n

* CHECK dout0_18 Vdout0_18ck184 = 0.9 time = 925
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=925.025n

* CHECK dout0_19 Vdout0_19ck184 = 0.9 time = 925
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=925.025n

* CHECK dout0_20 Vdout0_20ck184 = 0.9 time = 925
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=925.025n

* CHECK dout0_21 Vdout0_21ck184 = 0.9 time = 925
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=925.025n

* CHECK dout0_22 Vdout0_22ck184 = 0 time = 925
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=925.025n

* CHECK dout0_23 Vdout0_23ck184 = 0 time = 925
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=925.025n

* CHECK dout0_24 Vdout0_24ck184 = 0.9 time = 925
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=925.025n

* CHECK dout0_25 Vdout0_25ck184 = 0.9 time = 925
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=925.025n

* CHECK dout0_26 Vdout0_26ck184 = 0.9 time = 925
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=925.025n

* CHECK dout0_27 Vdout0_27ck184 = 0 time = 925
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=925.025n

* CHECK dout0_28 Vdout0_28ck184 = 0 time = 925
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=925.025n

* CHECK dout0_29 Vdout0_29ck184 = 0 time = 925
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=925.025n

* CHECK dout0_30 Vdout0_30ck184 = 0.9 time = 925
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=925.025n

* CHECK dout0_31 Vdout0_31ck184 = 0 time = 925
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=925.025n

* CHECK dout0_32 Vdout0_32ck184 = 0.9 time = 925
.meas tran vdout0_32ck184 FIND v(dout0_32) AT=925.025n

* CHECK dout0_33 Vdout0_33ck184 = 0 time = 925
.meas tran vdout0_33ck184 FIND v(dout0_33) AT=925.025n

* CHECK dout0_34 Vdout0_34ck184 = 0 time = 925
.meas tran vdout0_34ck184 FIND v(dout0_34) AT=925.025n

* CHECK dout0_35 Vdout0_35ck184 = 0 time = 925
.meas tran vdout0_35ck184 FIND v(dout0_35) AT=925.025n

* CHECK dout0_36 Vdout0_36ck184 = 0 time = 925
.meas tran vdout0_36ck184 FIND v(dout0_36) AT=925.025n

* CHECK dout0_37 Vdout0_37ck184 = 0.9 time = 925
.meas tran vdout0_37ck184 FIND v(dout0_37) AT=925.025n

* CHECK dout0_38 Vdout0_38ck184 = 0.9 time = 925
.meas tran vdout0_38ck184 FIND v(dout0_38) AT=925.025n

* CHECK dout0_39 Vdout0_39ck184 = 0.9 time = 925
.meas tran vdout0_39ck184 FIND v(dout0_39) AT=925.025n

* CHECK dout0_40 Vdout0_40ck184 = 0 time = 925
.meas tran vdout0_40ck184 FIND v(dout0_40) AT=925.025n

* CHECK dout0_41 Vdout0_41ck184 = 0 time = 925
.meas tran vdout0_41ck184 FIND v(dout0_41) AT=925.025n

* CHECK dout0_42 Vdout0_42ck184 = 0.9 time = 925
.meas tran vdout0_42ck184 FIND v(dout0_42) AT=925.025n

* CHECK dout0_43 Vdout0_43ck184 = 0 time = 925
.meas tran vdout0_43ck184 FIND v(dout0_43) AT=925.025n

* CHECK dout0_44 Vdout0_44ck184 = 0.9 time = 925
.meas tran vdout0_44ck184 FIND v(dout0_44) AT=925.025n

* CHECK dout0_45 Vdout0_45ck184 = 0.9 time = 925
.meas tran vdout0_45ck184 FIND v(dout0_45) AT=925.025n

* CHECK dout0_46 Vdout0_46ck184 = 0 time = 925
.meas tran vdout0_46ck184 FIND v(dout0_46) AT=925.025n

* CHECK dout0_47 Vdout0_47ck184 = 0.9 time = 925
.meas tran vdout0_47ck184 FIND v(dout0_47) AT=925.025n

* CHECK dout0_48 Vdout0_48ck184 = 0.9 time = 925
.meas tran vdout0_48ck184 FIND v(dout0_48) AT=925.025n

* CHECK dout0_49 Vdout0_49ck184 = 0 time = 925
.meas tran vdout0_49ck184 FIND v(dout0_49) AT=925.025n

* CHECK dout0_50 Vdout0_50ck184 = 0.9 time = 925
.meas tran vdout0_50ck184 FIND v(dout0_50) AT=925.025n

* CHECK dout0_51 Vdout0_51ck184 = 0.9 time = 925
.meas tran vdout0_51ck184 FIND v(dout0_51) AT=925.025n

* CHECK dout0_52 Vdout0_52ck184 = 0.9 time = 925
.meas tran vdout0_52ck184 FIND v(dout0_52) AT=925.025n

* CHECK dout0_53 Vdout0_53ck184 = 0.9 time = 925
.meas tran vdout0_53ck184 FIND v(dout0_53) AT=925.025n

* CHECK dout0_54 Vdout0_54ck184 = 0 time = 925
.meas tran vdout0_54ck184 FIND v(dout0_54) AT=925.025n

* CHECK dout0_55 Vdout0_55ck184 = 0.9 time = 925
.meas tran vdout0_55ck184 FIND v(dout0_55) AT=925.025n

* CHECK dout0_56 Vdout0_56ck184 = 0.9 time = 925
.meas tran vdout0_56ck184 FIND v(dout0_56) AT=925.025n

* CHECK dout0_57 Vdout0_57ck184 = 0 time = 925
.meas tran vdout0_57ck184 FIND v(dout0_57) AT=925.025n

* CHECK dout0_58 Vdout0_58ck184 = 0 time = 925
.meas tran vdout0_58ck184 FIND v(dout0_58) AT=925.025n

* CHECK dout0_59 Vdout0_59ck184 = 0 time = 925
.meas tran vdout0_59ck184 FIND v(dout0_59) AT=925.025n

* CHECK dout0_60 Vdout0_60ck184 = 0 time = 925
.meas tran vdout0_60ck184 FIND v(dout0_60) AT=925.025n

* CHECK dout0_61 Vdout0_61ck184 = 0 time = 925
.meas tran vdout0_61ck184 FIND v(dout0_61) AT=925.025n

* CHECK dout0_62 Vdout0_62ck184 = 0 time = 925
.meas tran vdout0_62ck184 FIND v(dout0_62) AT=925.025n

* CHECK dout0_63 Vdout0_63ck184 = 0.9 time = 925
.meas tran vdout0_63ck184 FIND v(dout0_63) AT=925.025n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 930
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=930.025n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 930
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=930.025n

* CHECK dout0_2 Vdout0_2ck185 = 0 time = 930
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=930.025n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 930
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=930.025n

* CHECK dout0_4 Vdout0_4ck185 = 0 time = 930
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=930.025n

* CHECK dout0_5 Vdout0_5ck185 = 0.9 time = 930
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=930.025n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 930
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=930.025n

* CHECK dout0_7 Vdout0_7ck185 = 0 time = 930
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=930.025n

* CHECK dout0_8 Vdout0_8ck185 = 0.9 time = 930
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=930.025n

* CHECK dout0_9 Vdout0_9ck185 = 0.9 time = 930
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=930.025n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 930
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=930.025n

* CHECK dout0_11 Vdout0_11ck185 = 0.9 time = 930
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=930.025n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 930
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=930.025n

* CHECK dout0_13 Vdout0_13ck185 = 0.9 time = 930
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=930.025n

* CHECK dout0_14 Vdout0_14ck185 = 0.9 time = 930
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=930.025n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 930
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=930.025n

* CHECK dout0_16 Vdout0_16ck185 = 0 time = 930
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=930.025n

* CHECK dout0_17 Vdout0_17ck185 = 0.9 time = 930
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=930.025n

* CHECK dout0_18 Vdout0_18ck185 = 0 time = 930
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=930.025n

* CHECK dout0_19 Vdout0_19ck185 = 0 time = 930
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=930.025n

* CHECK dout0_20 Vdout0_20ck185 = 0.9 time = 930
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=930.025n

* CHECK dout0_21 Vdout0_21ck185 = 0 time = 930
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=930.025n

* CHECK dout0_22 Vdout0_22ck185 = 0 time = 930
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=930.025n

* CHECK dout0_23 Vdout0_23ck185 = 0 time = 930
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=930.025n

* CHECK dout0_24 Vdout0_24ck185 = 0.9 time = 930
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=930.025n

* CHECK dout0_25 Vdout0_25ck185 = 0.9 time = 930
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=930.025n

* CHECK dout0_26 Vdout0_26ck185 = 0 time = 930
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=930.025n

* CHECK dout0_27 Vdout0_27ck185 = 0.9 time = 930
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=930.025n

* CHECK dout0_28 Vdout0_28ck185 = 0.9 time = 930
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=930.025n

* CHECK dout0_29 Vdout0_29ck185 = 0 time = 930
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=930.025n

* CHECK dout0_30 Vdout0_30ck185 = 0.9 time = 930
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=930.025n

* CHECK dout0_31 Vdout0_31ck185 = 0 time = 930
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=930.025n

* CHECK dout0_32 Vdout0_32ck185 = 0.9 time = 930
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=930.025n

* CHECK dout0_33 Vdout0_33ck185 = 0 time = 930
.meas tran vdout0_33ck185 FIND v(dout0_33) AT=930.025n

* CHECK dout0_34 Vdout0_34ck185 = 0 time = 930
.meas tran vdout0_34ck185 FIND v(dout0_34) AT=930.025n

* CHECK dout0_35 Vdout0_35ck185 = 0 time = 930
.meas tran vdout0_35ck185 FIND v(dout0_35) AT=930.025n

* CHECK dout0_36 Vdout0_36ck185 = 0 time = 930
.meas tran vdout0_36ck185 FIND v(dout0_36) AT=930.025n

* CHECK dout0_37 Vdout0_37ck185 = 0.9 time = 930
.meas tran vdout0_37ck185 FIND v(dout0_37) AT=930.025n

* CHECK dout0_38 Vdout0_38ck185 = 0 time = 930
.meas tran vdout0_38ck185 FIND v(dout0_38) AT=930.025n

* CHECK dout0_39 Vdout0_39ck185 = 0 time = 930
.meas tran vdout0_39ck185 FIND v(dout0_39) AT=930.025n

* CHECK dout0_40 Vdout0_40ck185 = 0.9 time = 930
.meas tran vdout0_40ck185 FIND v(dout0_40) AT=930.025n

* CHECK dout0_41 Vdout0_41ck185 = 0.9 time = 930
.meas tran vdout0_41ck185 FIND v(dout0_41) AT=930.025n

* CHECK dout0_42 Vdout0_42ck185 = 0.9 time = 930
.meas tran vdout0_42ck185 FIND v(dout0_42) AT=930.025n

* CHECK dout0_43 Vdout0_43ck185 = 0.9 time = 930
.meas tran vdout0_43ck185 FIND v(dout0_43) AT=930.025n

* CHECK dout0_44 Vdout0_44ck185 = 0.9 time = 930
.meas tran vdout0_44ck185 FIND v(dout0_44) AT=930.025n

* CHECK dout0_45 Vdout0_45ck185 = 0 time = 930
.meas tran vdout0_45ck185 FIND v(dout0_45) AT=930.025n

* CHECK dout0_46 Vdout0_46ck185 = 0 time = 930
.meas tran vdout0_46ck185 FIND v(dout0_46) AT=930.025n

* CHECK dout0_47 Vdout0_47ck185 = 0.9 time = 930
.meas tran vdout0_47ck185 FIND v(dout0_47) AT=930.025n

* CHECK dout0_48 Vdout0_48ck185 = 0.9 time = 930
.meas tran vdout0_48ck185 FIND v(dout0_48) AT=930.025n

* CHECK dout0_49 Vdout0_49ck185 = 0 time = 930
.meas tran vdout0_49ck185 FIND v(dout0_49) AT=930.025n

* CHECK dout0_50 Vdout0_50ck185 = 0 time = 930
.meas tran vdout0_50ck185 FIND v(dout0_50) AT=930.025n

* CHECK dout0_51 Vdout0_51ck185 = 0 time = 930
.meas tran vdout0_51ck185 FIND v(dout0_51) AT=930.025n

* CHECK dout0_52 Vdout0_52ck185 = 0.9 time = 930
.meas tran vdout0_52ck185 FIND v(dout0_52) AT=930.025n

* CHECK dout0_53 Vdout0_53ck185 = 0.9 time = 930
.meas tran vdout0_53ck185 FIND v(dout0_53) AT=930.025n

* CHECK dout0_54 Vdout0_54ck185 = 0.9 time = 930
.meas tran vdout0_54ck185 FIND v(dout0_54) AT=930.025n

* CHECK dout0_55 Vdout0_55ck185 = 0.9 time = 930
.meas tran vdout0_55ck185 FIND v(dout0_55) AT=930.025n

* CHECK dout0_56 Vdout0_56ck185 = 0 time = 930
.meas tran vdout0_56ck185 FIND v(dout0_56) AT=930.025n

* CHECK dout0_57 Vdout0_57ck185 = 0.9 time = 930
.meas tran vdout0_57ck185 FIND v(dout0_57) AT=930.025n

* CHECK dout0_58 Vdout0_58ck185 = 0.9 time = 930
.meas tran vdout0_58ck185 FIND v(dout0_58) AT=930.025n

* CHECK dout0_59 Vdout0_59ck185 = 0 time = 930
.meas tran vdout0_59ck185 FIND v(dout0_59) AT=930.025n

* CHECK dout0_60 Vdout0_60ck185 = 0.9 time = 930
.meas tran vdout0_60ck185 FIND v(dout0_60) AT=930.025n

* CHECK dout0_61 Vdout0_61ck185 = 0.9 time = 930
.meas tran vdout0_61ck185 FIND v(dout0_61) AT=930.025n

* CHECK dout0_62 Vdout0_62ck185 = 0 time = 930
.meas tran vdout0_62ck185 FIND v(dout0_62) AT=930.025n

* CHECK dout0_63 Vdout0_63ck185 = 0 time = 930
.meas tran vdout0_63ck185 FIND v(dout0_63) AT=930.025n

* CHECK dout0_0 Vdout0_0ck186 = 0 time = 935
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=935.025n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 935
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=935.025n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 935
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=935.025n

* CHECK dout0_3 Vdout0_3ck186 = 0 time = 935
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=935.025n

* CHECK dout0_4 Vdout0_4ck186 = 0 time = 935
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=935.025n

* CHECK dout0_5 Vdout0_5ck186 = 0.9 time = 935
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=935.025n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 935
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=935.025n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 935
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=935.025n

* CHECK dout0_8 Vdout0_8ck186 = 0.9 time = 935
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=935.025n

* CHECK dout0_9 Vdout0_9ck186 = 0.9 time = 935
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=935.025n

* CHECK dout0_10 Vdout0_10ck186 = 0 time = 935
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=935.025n

* CHECK dout0_11 Vdout0_11ck186 = 0.9 time = 935
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=935.025n

* CHECK dout0_12 Vdout0_12ck186 = 0 time = 935
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=935.025n

* CHECK dout0_13 Vdout0_13ck186 = 0.9 time = 935
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=935.025n

* CHECK dout0_14 Vdout0_14ck186 = 0.9 time = 935
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=935.025n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 935
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=935.025n

* CHECK dout0_16 Vdout0_16ck186 = 0 time = 935
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=935.025n

* CHECK dout0_17 Vdout0_17ck186 = 0.9 time = 935
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=935.025n

* CHECK dout0_18 Vdout0_18ck186 = 0 time = 935
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=935.025n

* CHECK dout0_19 Vdout0_19ck186 = 0 time = 935
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=935.025n

* CHECK dout0_20 Vdout0_20ck186 = 0.9 time = 935
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=935.025n

* CHECK dout0_21 Vdout0_21ck186 = 0 time = 935
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=935.025n

* CHECK dout0_22 Vdout0_22ck186 = 0 time = 935
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=935.025n

* CHECK dout0_23 Vdout0_23ck186 = 0 time = 935
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=935.025n

* CHECK dout0_24 Vdout0_24ck186 = 0.9 time = 935
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=935.025n

* CHECK dout0_25 Vdout0_25ck186 = 0.9 time = 935
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=935.025n

* CHECK dout0_26 Vdout0_26ck186 = 0 time = 935
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=935.025n

* CHECK dout0_27 Vdout0_27ck186 = 0.9 time = 935
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=935.025n

* CHECK dout0_28 Vdout0_28ck186 = 0.9 time = 935
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=935.025n

* CHECK dout0_29 Vdout0_29ck186 = 0 time = 935
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=935.025n

* CHECK dout0_30 Vdout0_30ck186 = 0.9 time = 935
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=935.025n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 935
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=935.025n

* CHECK dout0_32 Vdout0_32ck186 = 0.9 time = 935
.meas tran vdout0_32ck186 FIND v(dout0_32) AT=935.025n

* CHECK dout0_33 Vdout0_33ck186 = 0 time = 935
.meas tran vdout0_33ck186 FIND v(dout0_33) AT=935.025n

* CHECK dout0_34 Vdout0_34ck186 = 0 time = 935
.meas tran vdout0_34ck186 FIND v(dout0_34) AT=935.025n

* CHECK dout0_35 Vdout0_35ck186 = 0 time = 935
.meas tran vdout0_35ck186 FIND v(dout0_35) AT=935.025n

* CHECK dout0_36 Vdout0_36ck186 = 0 time = 935
.meas tran vdout0_36ck186 FIND v(dout0_36) AT=935.025n

* CHECK dout0_37 Vdout0_37ck186 = 0.9 time = 935
.meas tran vdout0_37ck186 FIND v(dout0_37) AT=935.025n

* CHECK dout0_38 Vdout0_38ck186 = 0 time = 935
.meas tran vdout0_38ck186 FIND v(dout0_38) AT=935.025n

* CHECK dout0_39 Vdout0_39ck186 = 0 time = 935
.meas tran vdout0_39ck186 FIND v(dout0_39) AT=935.025n

* CHECK dout0_40 Vdout0_40ck186 = 0.9 time = 935
.meas tran vdout0_40ck186 FIND v(dout0_40) AT=935.025n

* CHECK dout0_41 Vdout0_41ck186 = 0.9 time = 935
.meas tran vdout0_41ck186 FIND v(dout0_41) AT=935.025n

* CHECK dout0_42 Vdout0_42ck186 = 0.9 time = 935
.meas tran vdout0_42ck186 FIND v(dout0_42) AT=935.025n

* CHECK dout0_43 Vdout0_43ck186 = 0.9 time = 935
.meas tran vdout0_43ck186 FIND v(dout0_43) AT=935.025n

* CHECK dout0_44 Vdout0_44ck186 = 0.9 time = 935
.meas tran vdout0_44ck186 FIND v(dout0_44) AT=935.025n

* CHECK dout0_45 Vdout0_45ck186 = 0 time = 935
.meas tran vdout0_45ck186 FIND v(dout0_45) AT=935.025n

* CHECK dout0_46 Vdout0_46ck186 = 0 time = 935
.meas tran vdout0_46ck186 FIND v(dout0_46) AT=935.025n

* CHECK dout0_47 Vdout0_47ck186 = 0.9 time = 935
.meas tran vdout0_47ck186 FIND v(dout0_47) AT=935.025n

* CHECK dout0_48 Vdout0_48ck186 = 0.9 time = 935
.meas tran vdout0_48ck186 FIND v(dout0_48) AT=935.025n

* CHECK dout0_49 Vdout0_49ck186 = 0 time = 935
.meas tran vdout0_49ck186 FIND v(dout0_49) AT=935.025n

* CHECK dout0_50 Vdout0_50ck186 = 0 time = 935
.meas tran vdout0_50ck186 FIND v(dout0_50) AT=935.025n

* CHECK dout0_51 Vdout0_51ck186 = 0 time = 935
.meas tran vdout0_51ck186 FIND v(dout0_51) AT=935.025n

* CHECK dout0_52 Vdout0_52ck186 = 0.9 time = 935
.meas tran vdout0_52ck186 FIND v(dout0_52) AT=935.025n

* CHECK dout0_53 Vdout0_53ck186 = 0.9 time = 935
.meas tran vdout0_53ck186 FIND v(dout0_53) AT=935.025n

* CHECK dout0_54 Vdout0_54ck186 = 0.9 time = 935
.meas tran vdout0_54ck186 FIND v(dout0_54) AT=935.025n

* CHECK dout0_55 Vdout0_55ck186 = 0.9 time = 935
.meas tran vdout0_55ck186 FIND v(dout0_55) AT=935.025n

* CHECK dout0_56 Vdout0_56ck186 = 0 time = 935
.meas tran vdout0_56ck186 FIND v(dout0_56) AT=935.025n

* CHECK dout0_57 Vdout0_57ck186 = 0.9 time = 935
.meas tran vdout0_57ck186 FIND v(dout0_57) AT=935.025n

* CHECK dout0_58 Vdout0_58ck186 = 0.9 time = 935
.meas tran vdout0_58ck186 FIND v(dout0_58) AT=935.025n

* CHECK dout0_59 Vdout0_59ck186 = 0 time = 935
.meas tran vdout0_59ck186 FIND v(dout0_59) AT=935.025n

* CHECK dout0_60 Vdout0_60ck186 = 0.9 time = 935
.meas tran vdout0_60ck186 FIND v(dout0_60) AT=935.025n

* CHECK dout0_61 Vdout0_61ck186 = 0.9 time = 935
.meas tran vdout0_61ck186 FIND v(dout0_61) AT=935.025n

* CHECK dout0_62 Vdout0_62ck186 = 0 time = 935
.meas tran vdout0_62ck186 FIND v(dout0_62) AT=935.025n

* CHECK dout0_63 Vdout0_63ck186 = 0 time = 935
.meas tran vdout0_63ck186 FIND v(dout0_63) AT=935.025n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 940
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=940.025n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 940
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=940.025n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 940
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=940.025n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 940
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=940.025n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 940
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=940.025n

* CHECK dout0_5 Vdout0_5ck187 = 0.9 time = 940
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=940.025n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 940
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=940.025n

* CHECK dout0_7 Vdout0_7ck187 = 0 time = 940
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=940.025n

* CHECK dout0_8 Vdout0_8ck187 = 0.9 time = 940
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=940.025n

* CHECK dout0_9 Vdout0_9ck187 = 0.9 time = 940
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=940.025n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 940
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=940.025n

* CHECK dout0_11 Vdout0_11ck187 = 0.9 time = 940
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=940.025n

* CHECK dout0_12 Vdout0_12ck187 = 0 time = 940
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=940.025n

* CHECK dout0_13 Vdout0_13ck187 = 0.9 time = 940
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=940.025n

* CHECK dout0_14 Vdout0_14ck187 = 0.9 time = 940
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=940.025n

* CHECK dout0_15 Vdout0_15ck187 = 0 time = 940
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=940.025n

* CHECK dout0_16 Vdout0_16ck187 = 0 time = 940
.meas tran vdout0_16ck187 FIND v(dout0_16) AT=940.025n

* CHECK dout0_17 Vdout0_17ck187 = 0.9 time = 940
.meas tran vdout0_17ck187 FIND v(dout0_17) AT=940.025n

* CHECK dout0_18 Vdout0_18ck187 = 0 time = 940
.meas tran vdout0_18ck187 FIND v(dout0_18) AT=940.025n

* CHECK dout0_19 Vdout0_19ck187 = 0 time = 940
.meas tran vdout0_19ck187 FIND v(dout0_19) AT=940.025n

* CHECK dout0_20 Vdout0_20ck187 = 0.9 time = 940
.meas tran vdout0_20ck187 FIND v(dout0_20) AT=940.025n

* CHECK dout0_21 Vdout0_21ck187 = 0 time = 940
.meas tran vdout0_21ck187 FIND v(dout0_21) AT=940.025n

* CHECK dout0_22 Vdout0_22ck187 = 0 time = 940
.meas tran vdout0_22ck187 FIND v(dout0_22) AT=940.025n

* CHECK dout0_23 Vdout0_23ck187 = 0 time = 940
.meas tran vdout0_23ck187 FIND v(dout0_23) AT=940.025n

* CHECK dout0_24 Vdout0_24ck187 = 0.9 time = 940
.meas tran vdout0_24ck187 FIND v(dout0_24) AT=940.025n

* CHECK dout0_25 Vdout0_25ck187 = 0.9 time = 940
.meas tran vdout0_25ck187 FIND v(dout0_25) AT=940.025n

* CHECK dout0_26 Vdout0_26ck187 = 0 time = 940
.meas tran vdout0_26ck187 FIND v(dout0_26) AT=940.025n

* CHECK dout0_27 Vdout0_27ck187 = 0.9 time = 940
.meas tran vdout0_27ck187 FIND v(dout0_27) AT=940.025n

* CHECK dout0_28 Vdout0_28ck187 = 0.9 time = 940
.meas tran vdout0_28ck187 FIND v(dout0_28) AT=940.025n

* CHECK dout0_29 Vdout0_29ck187 = 0 time = 940
.meas tran vdout0_29ck187 FIND v(dout0_29) AT=940.025n

* CHECK dout0_30 Vdout0_30ck187 = 0.9 time = 940
.meas tran vdout0_30ck187 FIND v(dout0_30) AT=940.025n

* CHECK dout0_31 Vdout0_31ck187 = 0 time = 940
.meas tran vdout0_31ck187 FIND v(dout0_31) AT=940.025n

* CHECK dout0_32 Vdout0_32ck187 = 0.9 time = 940
.meas tran vdout0_32ck187 FIND v(dout0_32) AT=940.025n

* CHECK dout0_33 Vdout0_33ck187 = 0 time = 940
.meas tran vdout0_33ck187 FIND v(dout0_33) AT=940.025n

* CHECK dout0_34 Vdout0_34ck187 = 0 time = 940
.meas tran vdout0_34ck187 FIND v(dout0_34) AT=940.025n

* CHECK dout0_35 Vdout0_35ck187 = 0 time = 940
.meas tran vdout0_35ck187 FIND v(dout0_35) AT=940.025n

* CHECK dout0_36 Vdout0_36ck187 = 0 time = 940
.meas tran vdout0_36ck187 FIND v(dout0_36) AT=940.025n

* CHECK dout0_37 Vdout0_37ck187 = 0.9 time = 940
.meas tran vdout0_37ck187 FIND v(dout0_37) AT=940.025n

* CHECK dout0_38 Vdout0_38ck187 = 0 time = 940
.meas tran vdout0_38ck187 FIND v(dout0_38) AT=940.025n

* CHECK dout0_39 Vdout0_39ck187 = 0 time = 940
.meas tran vdout0_39ck187 FIND v(dout0_39) AT=940.025n

* CHECK dout0_40 Vdout0_40ck187 = 0.9 time = 940
.meas tran vdout0_40ck187 FIND v(dout0_40) AT=940.025n

* CHECK dout0_41 Vdout0_41ck187 = 0.9 time = 940
.meas tran vdout0_41ck187 FIND v(dout0_41) AT=940.025n

* CHECK dout0_42 Vdout0_42ck187 = 0.9 time = 940
.meas tran vdout0_42ck187 FIND v(dout0_42) AT=940.025n

* CHECK dout0_43 Vdout0_43ck187 = 0.9 time = 940
.meas tran vdout0_43ck187 FIND v(dout0_43) AT=940.025n

* CHECK dout0_44 Vdout0_44ck187 = 0.9 time = 940
.meas tran vdout0_44ck187 FIND v(dout0_44) AT=940.025n

* CHECK dout0_45 Vdout0_45ck187 = 0 time = 940
.meas tran vdout0_45ck187 FIND v(dout0_45) AT=940.025n

* CHECK dout0_46 Vdout0_46ck187 = 0 time = 940
.meas tran vdout0_46ck187 FIND v(dout0_46) AT=940.025n

* CHECK dout0_47 Vdout0_47ck187 = 0.9 time = 940
.meas tran vdout0_47ck187 FIND v(dout0_47) AT=940.025n

* CHECK dout0_48 Vdout0_48ck187 = 0.9 time = 940
.meas tran vdout0_48ck187 FIND v(dout0_48) AT=940.025n

* CHECK dout0_49 Vdout0_49ck187 = 0 time = 940
.meas tran vdout0_49ck187 FIND v(dout0_49) AT=940.025n

* CHECK dout0_50 Vdout0_50ck187 = 0 time = 940
.meas tran vdout0_50ck187 FIND v(dout0_50) AT=940.025n

* CHECK dout0_51 Vdout0_51ck187 = 0 time = 940
.meas tran vdout0_51ck187 FIND v(dout0_51) AT=940.025n

* CHECK dout0_52 Vdout0_52ck187 = 0.9 time = 940
.meas tran vdout0_52ck187 FIND v(dout0_52) AT=940.025n

* CHECK dout0_53 Vdout0_53ck187 = 0.9 time = 940
.meas tran vdout0_53ck187 FIND v(dout0_53) AT=940.025n

* CHECK dout0_54 Vdout0_54ck187 = 0.9 time = 940
.meas tran vdout0_54ck187 FIND v(dout0_54) AT=940.025n

* CHECK dout0_55 Vdout0_55ck187 = 0.9 time = 940
.meas tran vdout0_55ck187 FIND v(dout0_55) AT=940.025n

* CHECK dout0_56 Vdout0_56ck187 = 0 time = 940
.meas tran vdout0_56ck187 FIND v(dout0_56) AT=940.025n

* CHECK dout0_57 Vdout0_57ck187 = 0.9 time = 940
.meas tran vdout0_57ck187 FIND v(dout0_57) AT=940.025n

* CHECK dout0_58 Vdout0_58ck187 = 0.9 time = 940
.meas tran vdout0_58ck187 FIND v(dout0_58) AT=940.025n

* CHECK dout0_59 Vdout0_59ck187 = 0 time = 940
.meas tran vdout0_59ck187 FIND v(dout0_59) AT=940.025n

* CHECK dout0_60 Vdout0_60ck187 = 0.9 time = 940
.meas tran vdout0_60ck187 FIND v(dout0_60) AT=940.025n

* CHECK dout0_61 Vdout0_61ck187 = 0.9 time = 940
.meas tran vdout0_61ck187 FIND v(dout0_61) AT=940.025n

* CHECK dout0_62 Vdout0_62ck187 = 0 time = 940
.meas tran vdout0_62ck187 FIND v(dout0_62) AT=940.025n

* CHECK dout0_63 Vdout0_63ck187 = 0 time = 940
.meas tran vdout0_63ck187 FIND v(dout0_63) AT=940.025n

* CHECK dout0_0 Vdout0_0ck190 = 0.9 time = 955
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=955.025n

* CHECK dout0_1 Vdout0_1ck190 = 0.9 time = 955
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=955.025n

* CHECK dout0_2 Vdout0_2ck190 = 0.9 time = 955
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=955.025n

* CHECK dout0_3 Vdout0_3ck190 = 0.9 time = 955
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=955.025n

* CHECK dout0_4 Vdout0_4ck190 = 0 time = 955
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=955.025n

* CHECK dout0_5 Vdout0_5ck190 = 0.9 time = 955
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=955.025n

* CHECK dout0_6 Vdout0_6ck190 = 0.9 time = 955
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=955.025n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 955
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=955.025n

* CHECK dout0_8 Vdout0_8ck190 = 0 time = 955
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=955.025n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 955
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=955.025n

* CHECK dout0_10 Vdout0_10ck190 = 0.9 time = 955
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=955.025n

* CHECK dout0_11 Vdout0_11ck190 = 0 time = 955
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=955.025n

* CHECK dout0_12 Vdout0_12ck190 = 0.9 time = 955
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=955.025n

* CHECK dout0_13 Vdout0_13ck190 = 0.9 time = 955
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=955.025n

* CHECK dout0_14 Vdout0_14ck190 = 0.9 time = 955
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=955.025n

* CHECK dout0_15 Vdout0_15ck190 = 0 time = 955
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=955.025n

* CHECK dout0_16 Vdout0_16ck190 = 0.9 time = 955
.meas tran vdout0_16ck190 FIND v(dout0_16) AT=955.025n

* CHECK dout0_17 Vdout0_17ck190 = 0 time = 955
.meas tran vdout0_17ck190 FIND v(dout0_17) AT=955.025n

* CHECK dout0_18 Vdout0_18ck190 = 0.9 time = 955
.meas tran vdout0_18ck190 FIND v(dout0_18) AT=955.025n

* CHECK dout0_19 Vdout0_19ck190 = 0 time = 955
.meas tran vdout0_19ck190 FIND v(dout0_19) AT=955.025n

* CHECK dout0_20 Vdout0_20ck190 = 0.9 time = 955
.meas tran vdout0_20ck190 FIND v(dout0_20) AT=955.025n

* CHECK dout0_21 Vdout0_21ck190 = 0.9 time = 955
.meas tran vdout0_21ck190 FIND v(dout0_21) AT=955.025n

* CHECK dout0_22 Vdout0_22ck190 = 0 time = 955
.meas tran vdout0_22ck190 FIND v(dout0_22) AT=955.025n

* CHECK dout0_23 Vdout0_23ck190 = 0.9 time = 955
.meas tran vdout0_23ck190 FIND v(dout0_23) AT=955.025n

* CHECK dout0_24 Vdout0_24ck190 = 0 time = 955
.meas tran vdout0_24ck190 FIND v(dout0_24) AT=955.025n

* CHECK dout0_25 Vdout0_25ck190 = 0 time = 955
.meas tran vdout0_25ck190 FIND v(dout0_25) AT=955.025n

* CHECK dout0_26 Vdout0_26ck190 = 0 time = 955
.meas tran vdout0_26ck190 FIND v(dout0_26) AT=955.025n

* CHECK dout0_27 Vdout0_27ck190 = 0 time = 955
.meas tran vdout0_27ck190 FIND v(dout0_27) AT=955.025n

* CHECK dout0_28 Vdout0_28ck190 = 0.9 time = 955
.meas tran vdout0_28ck190 FIND v(dout0_28) AT=955.025n

* CHECK dout0_29 Vdout0_29ck190 = 0.9 time = 955
.meas tran vdout0_29ck190 FIND v(dout0_29) AT=955.025n

* CHECK dout0_30 Vdout0_30ck190 = 0.9 time = 955
.meas tran vdout0_30ck190 FIND v(dout0_30) AT=955.025n

* CHECK dout0_31 Vdout0_31ck190 = 0.9 time = 955
.meas tran vdout0_31ck190 FIND v(dout0_31) AT=955.025n

* CHECK dout0_32 Vdout0_32ck190 = 0.9 time = 955
.meas tran vdout0_32ck190 FIND v(dout0_32) AT=955.025n

* CHECK dout0_33 Vdout0_33ck190 = 0 time = 955
.meas tran vdout0_33ck190 FIND v(dout0_33) AT=955.025n

* CHECK dout0_34 Vdout0_34ck190 = 0 time = 955
.meas tran vdout0_34ck190 FIND v(dout0_34) AT=955.025n

* CHECK dout0_35 Vdout0_35ck190 = 0 time = 955
.meas tran vdout0_35ck190 FIND v(dout0_35) AT=955.025n

* CHECK dout0_36 Vdout0_36ck190 = 0.9 time = 955
.meas tran vdout0_36ck190 FIND v(dout0_36) AT=955.025n

* CHECK dout0_37 Vdout0_37ck190 = 0.9 time = 955
.meas tran vdout0_37ck190 FIND v(dout0_37) AT=955.025n

* CHECK dout0_38 Vdout0_38ck190 = 0.9 time = 955
.meas tran vdout0_38ck190 FIND v(dout0_38) AT=955.025n

* CHECK dout0_39 Vdout0_39ck190 = 0 time = 955
.meas tran vdout0_39ck190 FIND v(dout0_39) AT=955.025n

* CHECK dout0_40 Vdout0_40ck190 = 0.9 time = 955
.meas tran vdout0_40ck190 FIND v(dout0_40) AT=955.025n

* CHECK dout0_41 Vdout0_41ck190 = 0 time = 955
.meas tran vdout0_41ck190 FIND v(dout0_41) AT=955.025n

* CHECK dout0_42 Vdout0_42ck190 = 0 time = 955
.meas tran vdout0_42ck190 FIND v(dout0_42) AT=955.025n

* CHECK dout0_43 Vdout0_43ck190 = 0.9 time = 955
.meas tran vdout0_43ck190 FIND v(dout0_43) AT=955.025n

* CHECK dout0_44 Vdout0_44ck190 = 0.9 time = 955
.meas tran vdout0_44ck190 FIND v(dout0_44) AT=955.025n

* CHECK dout0_45 Vdout0_45ck190 = 0.9 time = 955
.meas tran vdout0_45ck190 FIND v(dout0_45) AT=955.025n

* CHECK dout0_46 Vdout0_46ck190 = 0.9 time = 955
.meas tran vdout0_46ck190 FIND v(dout0_46) AT=955.025n

* CHECK dout0_47 Vdout0_47ck190 = 0.9 time = 955
.meas tran vdout0_47ck190 FIND v(dout0_47) AT=955.025n

* CHECK dout0_48 Vdout0_48ck190 = 0.9 time = 955
.meas tran vdout0_48ck190 FIND v(dout0_48) AT=955.025n

* CHECK dout0_49 Vdout0_49ck190 = 0.9 time = 955
.meas tran vdout0_49ck190 FIND v(dout0_49) AT=955.025n

* CHECK dout0_50 Vdout0_50ck190 = 0 time = 955
.meas tran vdout0_50ck190 FIND v(dout0_50) AT=955.025n

* CHECK dout0_51 Vdout0_51ck190 = 0 time = 955
.meas tran vdout0_51ck190 FIND v(dout0_51) AT=955.025n

* CHECK dout0_52 Vdout0_52ck190 = 0.9 time = 955
.meas tran vdout0_52ck190 FIND v(dout0_52) AT=955.025n

* CHECK dout0_53 Vdout0_53ck190 = 0.9 time = 955
.meas tran vdout0_53ck190 FIND v(dout0_53) AT=955.025n

* CHECK dout0_54 Vdout0_54ck190 = 0.9 time = 955
.meas tran vdout0_54ck190 FIND v(dout0_54) AT=955.025n

* CHECK dout0_55 Vdout0_55ck190 = 0 time = 955
.meas tran vdout0_55ck190 FIND v(dout0_55) AT=955.025n

* CHECK dout0_56 Vdout0_56ck190 = 0 time = 955
.meas tran vdout0_56ck190 FIND v(dout0_56) AT=955.025n

* CHECK dout0_57 Vdout0_57ck190 = 0 time = 955
.meas tran vdout0_57ck190 FIND v(dout0_57) AT=955.025n

* CHECK dout0_58 Vdout0_58ck190 = 0.9 time = 955
.meas tran vdout0_58ck190 FIND v(dout0_58) AT=955.025n

* CHECK dout0_59 Vdout0_59ck190 = 0 time = 955
.meas tran vdout0_59ck190 FIND v(dout0_59) AT=955.025n

* CHECK dout0_60 Vdout0_60ck190 = 0.9 time = 955
.meas tran vdout0_60ck190 FIND v(dout0_60) AT=955.025n

* CHECK dout0_61 Vdout0_61ck190 = 0.9 time = 955
.meas tran vdout0_61ck190 FIND v(dout0_61) AT=955.025n

* CHECK dout0_62 Vdout0_62ck190 = 0 time = 955
.meas tran vdout0_62ck190 FIND v(dout0_62) AT=955.025n

* CHECK dout0_63 Vdout0_63ck190 = 0 time = 955
.meas tran vdout0_63ck190 FIND v(dout0_63) AT=955.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0.9 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0.9 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0.9 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 0.9 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 0 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 0.9 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0.9 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0.9 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0.9 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0.9 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0.9 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0.9 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0.9 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_32 Vdout0_32ck193 = 0 time = 970
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=970.025n

* CHECK dout0_33 Vdout0_33ck193 = 0 time = 970
.meas tran vdout0_33ck193 FIND v(dout0_33) AT=970.025n

* CHECK dout0_34 Vdout0_34ck193 = 0.9 time = 970
.meas tran vdout0_34ck193 FIND v(dout0_34) AT=970.025n

* CHECK dout0_35 Vdout0_35ck193 = 0.9 time = 970
.meas tran vdout0_35ck193 FIND v(dout0_35) AT=970.025n

* CHECK dout0_36 Vdout0_36ck193 = 0.9 time = 970
.meas tran vdout0_36ck193 FIND v(dout0_36) AT=970.025n

* CHECK dout0_37 Vdout0_37ck193 = 0 time = 970
.meas tran vdout0_37ck193 FIND v(dout0_37) AT=970.025n

* CHECK dout0_38 Vdout0_38ck193 = 0.9 time = 970
.meas tran vdout0_38ck193 FIND v(dout0_38) AT=970.025n

* CHECK dout0_39 Vdout0_39ck193 = 0.9 time = 970
.meas tran vdout0_39ck193 FIND v(dout0_39) AT=970.025n

* CHECK dout0_40 Vdout0_40ck193 = 0.9 time = 970
.meas tran vdout0_40ck193 FIND v(dout0_40) AT=970.025n

* CHECK dout0_41 Vdout0_41ck193 = 0 time = 970
.meas tran vdout0_41ck193 FIND v(dout0_41) AT=970.025n

* CHECK dout0_42 Vdout0_42ck193 = 0.9 time = 970
.meas tran vdout0_42ck193 FIND v(dout0_42) AT=970.025n

* CHECK dout0_43 Vdout0_43ck193 = 0.9 time = 970
.meas tran vdout0_43ck193 FIND v(dout0_43) AT=970.025n

* CHECK dout0_44 Vdout0_44ck193 = 0 time = 970
.meas tran vdout0_44ck193 FIND v(dout0_44) AT=970.025n

* CHECK dout0_45 Vdout0_45ck193 = 0 time = 970
.meas tran vdout0_45ck193 FIND v(dout0_45) AT=970.025n

* CHECK dout0_46 Vdout0_46ck193 = 0.9 time = 970
.meas tran vdout0_46ck193 FIND v(dout0_46) AT=970.025n

* CHECK dout0_47 Vdout0_47ck193 = 0 time = 970
.meas tran vdout0_47ck193 FIND v(dout0_47) AT=970.025n

* CHECK dout0_48 Vdout0_48ck193 = 0 time = 970
.meas tran vdout0_48ck193 FIND v(dout0_48) AT=970.025n

* CHECK dout0_49 Vdout0_49ck193 = 0.9 time = 970
.meas tran vdout0_49ck193 FIND v(dout0_49) AT=970.025n

* CHECK dout0_50 Vdout0_50ck193 = 0.9 time = 970
.meas tran vdout0_50ck193 FIND v(dout0_50) AT=970.025n

* CHECK dout0_51 Vdout0_51ck193 = 0.9 time = 970
.meas tran vdout0_51ck193 FIND v(dout0_51) AT=970.025n

* CHECK dout0_52 Vdout0_52ck193 = 0 time = 970
.meas tran vdout0_52ck193 FIND v(dout0_52) AT=970.025n

* CHECK dout0_53 Vdout0_53ck193 = 0 time = 970
.meas tran vdout0_53ck193 FIND v(dout0_53) AT=970.025n

* CHECK dout0_54 Vdout0_54ck193 = 0 time = 970
.meas tran vdout0_54ck193 FIND v(dout0_54) AT=970.025n

* CHECK dout0_55 Vdout0_55ck193 = 0.9 time = 970
.meas tran vdout0_55ck193 FIND v(dout0_55) AT=970.025n

* CHECK dout0_56 Vdout0_56ck193 = 0 time = 970
.meas tran vdout0_56ck193 FIND v(dout0_56) AT=970.025n

* CHECK dout0_57 Vdout0_57ck193 = 0 time = 970
.meas tran vdout0_57ck193 FIND v(dout0_57) AT=970.025n

* CHECK dout0_58 Vdout0_58ck193 = 0.9 time = 970
.meas tran vdout0_58ck193 FIND v(dout0_58) AT=970.025n

* CHECK dout0_59 Vdout0_59ck193 = 0 time = 970
.meas tran vdout0_59ck193 FIND v(dout0_59) AT=970.025n

* CHECK dout0_60 Vdout0_60ck193 = 0 time = 970
.meas tran vdout0_60ck193 FIND v(dout0_60) AT=970.025n

* CHECK dout0_61 Vdout0_61ck193 = 0 time = 970
.meas tran vdout0_61ck193 FIND v(dout0_61) AT=970.025n

* CHECK dout0_62 Vdout0_62ck193 = 0 time = 970
.meas tran vdout0_62ck193 FIND v(dout0_62) AT=970.025n

* CHECK dout0_63 Vdout0_63ck193 = 0 time = 970
.meas tran vdout0_63ck193 FIND v(dout0_63) AT=970.025n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 980
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=980.025n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 980
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=980.025n

* CHECK dout0_2 Vdout0_2ck195 = 0.9 time = 980
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=980.025n

* CHECK dout0_3 Vdout0_3ck195 = 0.9 time = 980
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=980.025n

* CHECK dout0_4 Vdout0_4ck195 = 0.9 time = 980
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=980.025n

* CHECK dout0_5 Vdout0_5ck195 = 0.9 time = 980
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=980.025n

* CHECK dout0_6 Vdout0_6ck195 = 0.9 time = 980
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=980.025n

* CHECK dout0_7 Vdout0_7ck195 = 0.9 time = 980
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=980.025n

* CHECK dout0_8 Vdout0_8ck195 = 0 time = 980
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=980.025n

* CHECK dout0_9 Vdout0_9ck195 = 0.9 time = 980
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=980.025n

* CHECK dout0_10 Vdout0_10ck195 = 0.9 time = 980
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=980.025n

* CHECK dout0_11 Vdout0_11ck195 = 0 time = 980
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=980.025n

* CHECK dout0_12 Vdout0_12ck195 = 0 time = 980
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=980.025n

* CHECK dout0_13 Vdout0_13ck195 = 0 time = 980
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=980.025n

* CHECK dout0_14 Vdout0_14ck195 = 0 time = 980
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=980.025n

* CHECK dout0_15 Vdout0_15ck195 = 0.9 time = 980
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=980.025n

* CHECK dout0_16 Vdout0_16ck195 = 0.9 time = 980
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=980.025n

* CHECK dout0_17 Vdout0_17ck195 = 0.9 time = 980
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=980.025n

* CHECK dout0_18 Vdout0_18ck195 = 0 time = 980
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=980.025n

* CHECK dout0_19 Vdout0_19ck195 = 0.9 time = 980
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=980.025n

* CHECK dout0_20 Vdout0_20ck195 = 0 time = 980
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=980.025n

* CHECK dout0_21 Vdout0_21ck195 = 0.9 time = 980
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=980.025n

* CHECK dout0_22 Vdout0_22ck195 = 0.9 time = 980
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=980.025n

* CHECK dout0_23 Vdout0_23ck195 = 0 time = 980
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=980.025n

* CHECK dout0_24 Vdout0_24ck195 = 0 time = 980
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=980.025n

* CHECK dout0_25 Vdout0_25ck195 = 0 time = 980
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=980.025n

* CHECK dout0_26 Vdout0_26ck195 = 0.9 time = 980
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=980.025n

* CHECK dout0_27 Vdout0_27ck195 = 0.9 time = 980
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=980.025n

* CHECK dout0_28 Vdout0_28ck195 = 0 time = 980
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=980.025n

* CHECK dout0_29 Vdout0_29ck195 = 0.9 time = 980
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=980.025n

* CHECK dout0_30 Vdout0_30ck195 = 0 time = 980
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=980.025n

* CHECK dout0_31 Vdout0_31ck195 = 0.9 time = 980
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=980.025n

* CHECK dout0_32 Vdout0_32ck195 = 0 time = 980
.meas tran vdout0_32ck195 FIND v(dout0_32) AT=980.025n

* CHECK dout0_33 Vdout0_33ck195 = 0 time = 980
.meas tran vdout0_33ck195 FIND v(dout0_33) AT=980.025n

* CHECK dout0_34 Vdout0_34ck195 = 0.9 time = 980
.meas tran vdout0_34ck195 FIND v(dout0_34) AT=980.025n

* CHECK dout0_35 Vdout0_35ck195 = 0 time = 980
.meas tran vdout0_35ck195 FIND v(dout0_35) AT=980.025n

* CHECK dout0_36 Vdout0_36ck195 = 0 time = 980
.meas tran vdout0_36ck195 FIND v(dout0_36) AT=980.025n

* CHECK dout0_37 Vdout0_37ck195 = 0 time = 980
.meas tran vdout0_37ck195 FIND v(dout0_37) AT=980.025n

* CHECK dout0_38 Vdout0_38ck195 = 0 time = 980
.meas tran vdout0_38ck195 FIND v(dout0_38) AT=980.025n

* CHECK dout0_39 Vdout0_39ck195 = 0.9 time = 980
.meas tran vdout0_39ck195 FIND v(dout0_39) AT=980.025n

* CHECK dout0_40 Vdout0_40ck195 = 0 time = 980
.meas tran vdout0_40ck195 FIND v(dout0_40) AT=980.025n

* CHECK dout0_41 Vdout0_41ck195 = 0 time = 980
.meas tran vdout0_41ck195 FIND v(dout0_41) AT=980.025n

* CHECK dout0_42 Vdout0_42ck195 = 0.9 time = 980
.meas tran vdout0_42ck195 FIND v(dout0_42) AT=980.025n

* CHECK dout0_43 Vdout0_43ck195 = 0.9 time = 980
.meas tran vdout0_43ck195 FIND v(dout0_43) AT=980.025n

* CHECK dout0_44 Vdout0_44ck195 = 0 time = 980
.meas tran vdout0_44ck195 FIND v(dout0_44) AT=980.025n

* CHECK dout0_45 Vdout0_45ck195 = 0.9 time = 980
.meas tran vdout0_45ck195 FIND v(dout0_45) AT=980.025n

* CHECK dout0_46 Vdout0_46ck195 = 0.9 time = 980
.meas tran vdout0_46ck195 FIND v(dout0_46) AT=980.025n

* CHECK dout0_47 Vdout0_47ck195 = 0.9 time = 980
.meas tran vdout0_47ck195 FIND v(dout0_47) AT=980.025n

* CHECK dout0_48 Vdout0_48ck195 = 0.9 time = 980
.meas tran vdout0_48ck195 FIND v(dout0_48) AT=980.025n

* CHECK dout0_49 Vdout0_49ck195 = 0.9 time = 980
.meas tran vdout0_49ck195 FIND v(dout0_49) AT=980.025n

* CHECK dout0_50 Vdout0_50ck195 = 0.9 time = 980
.meas tran vdout0_50ck195 FIND v(dout0_50) AT=980.025n

* CHECK dout0_51 Vdout0_51ck195 = 0 time = 980
.meas tran vdout0_51ck195 FIND v(dout0_51) AT=980.025n

* CHECK dout0_52 Vdout0_52ck195 = 0 time = 980
.meas tran vdout0_52ck195 FIND v(dout0_52) AT=980.025n

* CHECK dout0_53 Vdout0_53ck195 = 0.9 time = 980
.meas tran vdout0_53ck195 FIND v(dout0_53) AT=980.025n

* CHECK dout0_54 Vdout0_54ck195 = 0 time = 980
.meas tran vdout0_54ck195 FIND v(dout0_54) AT=980.025n

* CHECK dout0_55 Vdout0_55ck195 = 0.9 time = 980
.meas tran vdout0_55ck195 FIND v(dout0_55) AT=980.025n

* CHECK dout0_56 Vdout0_56ck195 = 0 time = 980
.meas tran vdout0_56ck195 FIND v(dout0_56) AT=980.025n

* CHECK dout0_57 Vdout0_57ck195 = 0.9 time = 980
.meas tran vdout0_57ck195 FIND v(dout0_57) AT=980.025n

* CHECK dout0_58 Vdout0_58ck195 = 0 time = 980
.meas tran vdout0_58ck195 FIND v(dout0_58) AT=980.025n

* CHECK dout0_59 Vdout0_59ck195 = 0.9 time = 980
.meas tran vdout0_59ck195 FIND v(dout0_59) AT=980.025n

* CHECK dout0_60 Vdout0_60ck195 = 0.9 time = 980
.meas tran vdout0_60ck195 FIND v(dout0_60) AT=980.025n

* CHECK dout0_61 Vdout0_61ck195 = 0.9 time = 980
.meas tran vdout0_61ck195 FIND v(dout0_61) AT=980.025n

* CHECK dout0_62 Vdout0_62ck195 = 0.9 time = 980
.meas tran vdout0_62ck195 FIND v(dout0_62) AT=980.025n

* CHECK dout0_63 Vdout0_63ck195 = 0 time = 980
.meas tran vdout0_63ck195 FIND v(dout0_63) AT=980.025n

* CHECK dout0_0 Vdout0_0ck198 = 0.9 time = 995
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=995.025n

* CHECK dout0_1 Vdout0_1ck198 = 0.9 time = 995
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=995.025n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 995
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=995.025n

* CHECK dout0_3 Vdout0_3ck198 = 0.9 time = 995
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=995.025n

* CHECK dout0_4 Vdout0_4ck198 = 0.9 time = 995
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=995.025n

* CHECK dout0_5 Vdout0_5ck198 = 0 time = 995
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=995.025n

* CHECK dout0_6 Vdout0_6ck198 = 0.9 time = 995
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=995.025n

* CHECK dout0_7 Vdout0_7ck198 = 0.9 time = 995
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=995.025n

* CHECK dout0_8 Vdout0_8ck198 = 0.9 time = 995
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=995.025n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 995
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=995.025n

* CHECK dout0_10 Vdout0_10ck198 = 0.9 time = 995
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=995.025n

* CHECK dout0_11 Vdout0_11ck198 = 0.9 time = 995
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=995.025n

* CHECK dout0_12 Vdout0_12ck198 = 0.9 time = 995
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=995.025n

* CHECK dout0_13 Vdout0_13ck198 = 0.9 time = 995
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=995.025n

* CHECK dout0_14 Vdout0_14ck198 = 0 time = 995
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=995.025n

* CHECK dout0_15 Vdout0_15ck198 = 0.9 time = 995
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=995.025n

* CHECK dout0_16 Vdout0_16ck198 = 0.9 time = 995
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=995.025n

* CHECK dout0_17 Vdout0_17ck198 = 0.9 time = 995
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=995.025n

* CHECK dout0_18 Vdout0_18ck198 = 0.9 time = 995
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=995.025n

* CHECK dout0_19 Vdout0_19ck198 = 0.9 time = 995
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=995.025n

* CHECK dout0_20 Vdout0_20ck198 = 0.9 time = 995
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=995.025n

* CHECK dout0_21 Vdout0_21ck198 = 0.9 time = 995
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=995.025n

* CHECK dout0_22 Vdout0_22ck198 = 0 time = 995
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=995.025n

* CHECK dout0_23 Vdout0_23ck198 = 0 time = 995
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=995.025n

* CHECK dout0_24 Vdout0_24ck198 = 0.9 time = 995
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=995.025n

* CHECK dout0_25 Vdout0_25ck198 = 0.9 time = 995
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=995.025n

* CHECK dout0_26 Vdout0_26ck198 = 0.9 time = 995
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=995.025n

* CHECK dout0_27 Vdout0_27ck198 = 0 time = 995
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=995.025n

* CHECK dout0_28 Vdout0_28ck198 = 0 time = 995
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=995.025n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 995
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=995.025n

* CHECK dout0_30 Vdout0_30ck198 = 0.9 time = 995
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=995.025n

* CHECK dout0_31 Vdout0_31ck198 = 0 time = 995
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=995.025n

* CHECK dout0_32 Vdout0_32ck198 = 0.9 time = 995
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=995.025n

* CHECK dout0_33 Vdout0_33ck198 = 0 time = 995
.meas tran vdout0_33ck198 FIND v(dout0_33) AT=995.025n

* CHECK dout0_34 Vdout0_34ck198 = 0 time = 995
.meas tran vdout0_34ck198 FIND v(dout0_34) AT=995.025n

* CHECK dout0_35 Vdout0_35ck198 = 0 time = 995
.meas tran vdout0_35ck198 FIND v(dout0_35) AT=995.025n

* CHECK dout0_36 Vdout0_36ck198 = 0 time = 995
.meas tran vdout0_36ck198 FIND v(dout0_36) AT=995.025n

* CHECK dout0_37 Vdout0_37ck198 = 0.9 time = 995
.meas tran vdout0_37ck198 FIND v(dout0_37) AT=995.025n

* CHECK dout0_38 Vdout0_38ck198 = 0.9 time = 995
.meas tran vdout0_38ck198 FIND v(dout0_38) AT=995.025n

* CHECK dout0_39 Vdout0_39ck198 = 0.9 time = 995
.meas tran vdout0_39ck198 FIND v(dout0_39) AT=995.025n

* CHECK dout0_40 Vdout0_40ck198 = 0 time = 995
.meas tran vdout0_40ck198 FIND v(dout0_40) AT=995.025n

* CHECK dout0_41 Vdout0_41ck198 = 0 time = 995
.meas tran vdout0_41ck198 FIND v(dout0_41) AT=995.025n

* CHECK dout0_42 Vdout0_42ck198 = 0.9 time = 995
.meas tran vdout0_42ck198 FIND v(dout0_42) AT=995.025n

* CHECK dout0_43 Vdout0_43ck198 = 0 time = 995
.meas tran vdout0_43ck198 FIND v(dout0_43) AT=995.025n

* CHECK dout0_44 Vdout0_44ck198 = 0.9 time = 995
.meas tran vdout0_44ck198 FIND v(dout0_44) AT=995.025n

* CHECK dout0_45 Vdout0_45ck198 = 0.9 time = 995
.meas tran vdout0_45ck198 FIND v(dout0_45) AT=995.025n

* CHECK dout0_46 Vdout0_46ck198 = 0 time = 995
.meas tran vdout0_46ck198 FIND v(dout0_46) AT=995.025n

* CHECK dout0_47 Vdout0_47ck198 = 0.9 time = 995
.meas tran vdout0_47ck198 FIND v(dout0_47) AT=995.025n

* CHECK dout0_48 Vdout0_48ck198 = 0.9 time = 995
.meas tran vdout0_48ck198 FIND v(dout0_48) AT=995.025n

* CHECK dout0_49 Vdout0_49ck198 = 0 time = 995
.meas tran vdout0_49ck198 FIND v(dout0_49) AT=995.025n

* CHECK dout0_50 Vdout0_50ck198 = 0.9 time = 995
.meas tran vdout0_50ck198 FIND v(dout0_50) AT=995.025n

* CHECK dout0_51 Vdout0_51ck198 = 0.9 time = 995
.meas tran vdout0_51ck198 FIND v(dout0_51) AT=995.025n

* CHECK dout0_52 Vdout0_52ck198 = 0.9 time = 995
.meas tran vdout0_52ck198 FIND v(dout0_52) AT=995.025n

* CHECK dout0_53 Vdout0_53ck198 = 0.9 time = 995
.meas tran vdout0_53ck198 FIND v(dout0_53) AT=995.025n

* CHECK dout0_54 Vdout0_54ck198 = 0 time = 995
.meas tran vdout0_54ck198 FIND v(dout0_54) AT=995.025n

* CHECK dout0_55 Vdout0_55ck198 = 0.9 time = 995
.meas tran vdout0_55ck198 FIND v(dout0_55) AT=995.025n

* CHECK dout0_56 Vdout0_56ck198 = 0.9 time = 995
.meas tran vdout0_56ck198 FIND v(dout0_56) AT=995.025n

* CHECK dout0_57 Vdout0_57ck198 = 0 time = 995
.meas tran vdout0_57ck198 FIND v(dout0_57) AT=995.025n

* CHECK dout0_58 Vdout0_58ck198 = 0 time = 995
.meas tran vdout0_58ck198 FIND v(dout0_58) AT=995.025n

* CHECK dout0_59 Vdout0_59ck198 = 0 time = 995
.meas tran vdout0_59ck198 FIND v(dout0_59) AT=995.025n

* CHECK dout0_60 Vdout0_60ck198 = 0 time = 995
.meas tran vdout0_60ck198 FIND v(dout0_60) AT=995.025n

* CHECK dout0_61 Vdout0_61ck198 = 0 time = 995
.meas tran vdout0_61ck198 FIND v(dout0_61) AT=995.025n

* CHECK dout0_62 Vdout0_62ck198 = 0 time = 995
.meas tran vdout0_62ck198 FIND v(dout0_62) AT=995.025n

* CHECK dout0_63 Vdout0_63ck198 = 0.9 time = 995
.meas tran vdout0_63ck198 FIND v(dout0_63) AT=995.025n

* CHECK dout0_0 Vdout0_0ck201 = 0.9 time = 1010
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=1010.025n

* CHECK dout0_1 Vdout0_1ck201 = 0.9 time = 1010
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=1010.025n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 1010
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=1010.025n

* CHECK dout0_3 Vdout0_3ck201 = 0.9 time = 1010
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=1010.025n

* CHECK dout0_4 Vdout0_4ck201 = 0.9 time = 1010
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=1010.025n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 1010
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=1010.025n

* CHECK dout0_6 Vdout0_6ck201 = 0.9 time = 1010
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=1010.025n

* CHECK dout0_7 Vdout0_7ck201 = 0.9 time = 1010
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=1010.025n

* CHECK dout0_8 Vdout0_8ck201 = 0.9 time = 1010
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=1010.025n

* CHECK dout0_9 Vdout0_9ck201 = 0 time = 1010
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=1010.025n

* CHECK dout0_10 Vdout0_10ck201 = 0.9 time = 1010
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=1010.025n

* CHECK dout0_11 Vdout0_11ck201 = 0.9 time = 1010
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=1010.025n

* CHECK dout0_12 Vdout0_12ck201 = 0.9 time = 1010
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=1010.025n

* CHECK dout0_13 Vdout0_13ck201 = 0.9 time = 1010
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=1010.025n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 1010
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=1010.025n

* CHECK dout0_15 Vdout0_15ck201 = 0.9 time = 1010
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=1010.025n

* CHECK dout0_16 Vdout0_16ck201 = 0.9 time = 1010
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=1010.025n

* CHECK dout0_17 Vdout0_17ck201 = 0.9 time = 1010
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=1010.025n

* CHECK dout0_18 Vdout0_18ck201 = 0.9 time = 1010
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=1010.025n

* CHECK dout0_19 Vdout0_19ck201 = 0.9 time = 1010
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=1010.025n

* CHECK dout0_20 Vdout0_20ck201 = 0.9 time = 1010
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=1010.025n

* CHECK dout0_21 Vdout0_21ck201 = 0.9 time = 1010
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=1010.025n

* CHECK dout0_22 Vdout0_22ck201 = 0 time = 1010
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=1010.025n

* CHECK dout0_23 Vdout0_23ck201 = 0 time = 1010
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=1010.025n

* CHECK dout0_24 Vdout0_24ck201 = 0.9 time = 1010
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=1010.025n

* CHECK dout0_25 Vdout0_25ck201 = 0.9 time = 1010
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=1010.025n

* CHECK dout0_26 Vdout0_26ck201 = 0.9 time = 1010
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=1010.025n

* CHECK dout0_27 Vdout0_27ck201 = 0 time = 1010
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=1010.025n

* CHECK dout0_28 Vdout0_28ck201 = 0 time = 1010
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=1010.025n

* CHECK dout0_29 Vdout0_29ck201 = 0 time = 1010
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=1010.025n

* CHECK dout0_30 Vdout0_30ck201 = 0.9 time = 1010
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=1010.025n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 1010
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=1010.025n

* CHECK dout0_32 Vdout0_32ck201 = 0.9 time = 1010
.meas tran vdout0_32ck201 FIND v(dout0_32) AT=1010.025n

* CHECK dout0_33 Vdout0_33ck201 = 0 time = 1010
.meas tran vdout0_33ck201 FIND v(dout0_33) AT=1010.025n

* CHECK dout0_34 Vdout0_34ck201 = 0 time = 1010
.meas tran vdout0_34ck201 FIND v(dout0_34) AT=1010.025n

* CHECK dout0_35 Vdout0_35ck201 = 0 time = 1010
.meas tran vdout0_35ck201 FIND v(dout0_35) AT=1010.025n

* CHECK dout0_36 Vdout0_36ck201 = 0 time = 1010
.meas tran vdout0_36ck201 FIND v(dout0_36) AT=1010.025n

* CHECK dout0_37 Vdout0_37ck201 = 0.9 time = 1010
.meas tran vdout0_37ck201 FIND v(dout0_37) AT=1010.025n

* CHECK dout0_38 Vdout0_38ck201 = 0.9 time = 1010
.meas tran vdout0_38ck201 FIND v(dout0_38) AT=1010.025n

* CHECK dout0_39 Vdout0_39ck201 = 0.9 time = 1010
.meas tran vdout0_39ck201 FIND v(dout0_39) AT=1010.025n

* CHECK dout0_40 Vdout0_40ck201 = 0 time = 1010
.meas tran vdout0_40ck201 FIND v(dout0_40) AT=1010.025n

* CHECK dout0_41 Vdout0_41ck201 = 0 time = 1010
.meas tran vdout0_41ck201 FIND v(dout0_41) AT=1010.025n

* CHECK dout0_42 Vdout0_42ck201 = 0.9 time = 1010
.meas tran vdout0_42ck201 FIND v(dout0_42) AT=1010.025n

* CHECK dout0_43 Vdout0_43ck201 = 0 time = 1010
.meas tran vdout0_43ck201 FIND v(dout0_43) AT=1010.025n

* CHECK dout0_44 Vdout0_44ck201 = 0.9 time = 1010
.meas tran vdout0_44ck201 FIND v(dout0_44) AT=1010.025n

* CHECK dout0_45 Vdout0_45ck201 = 0.9 time = 1010
.meas tran vdout0_45ck201 FIND v(dout0_45) AT=1010.025n

* CHECK dout0_46 Vdout0_46ck201 = 0 time = 1010
.meas tran vdout0_46ck201 FIND v(dout0_46) AT=1010.025n

* CHECK dout0_47 Vdout0_47ck201 = 0.9 time = 1010
.meas tran vdout0_47ck201 FIND v(dout0_47) AT=1010.025n

* CHECK dout0_48 Vdout0_48ck201 = 0.9 time = 1010
.meas tran vdout0_48ck201 FIND v(dout0_48) AT=1010.025n

* CHECK dout0_49 Vdout0_49ck201 = 0 time = 1010
.meas tran vdout0_49ck201 FIND v(dout0_49) AT=1010.025n

* CHECK dout0_50 Vdout0_50ck201 = 0.9 time = 1010
.meas tran vdout0_50ck201 FIND v(dout0_50) AT=1010.025n

* CHECK dout0_51 Vdout0_51ck201 = 0.9 time = 1010
.meas tran vdout0_51ck201 FIND v(dout0_51) AT=1010.025n

* CHECK dout0_52 Vdout0_52ck201 = 0.9 time = 1010
.meas tran vdout0_52ck201 FIND v(dout0_52) AT=1010.025n

* CHECK dout0_53 Vdout0_53ck201 = 0.9 time = 1010
.meas tran vdout0_53ck201 FIND v(dout0_53) AT=1010.025n

* CHECK dout0_54 Vdout0_54ck201 = 0 time = 1010
.meas tran vdout0_54ck201 FIND v(dout0_54) AT=1010.025n

* CHECK dout0_55 Vdout0_55ck201 = 0.9 time = 1010
.meas tran vdout0_55ck201 FIND v(dout0_55) AT=1010.025n

* CHECK dout0_56 Vdout0_56ck201 = 0.9 time = 1010
.meas tran vdout0_56ck201 FIND v(dout0_56) AT=1010.025n

* CHECK dout0_57 Vdout0_57ck201 = 0 time = 1010
.meas tran vdout0_57ck201 FIND v(dout0_57) AT=1010.025n

* CHECK dout0_58 Vdout0_58ck201 = 0 time = 1010
.meas tran vdout0_58ck201 FIND v(dout0_58) AT=1010.025n

* CHECK dout0_59 Vdout0_59ck201 = 0 time = 1010
.meas tran vdout0_59ck201 FIND v(dout0_59) AT=1010.025n

* CHECK dout0_60 Vdout0_60ck201 = 0 time = 1010
.meas tran vdout0_60ck201 FIND v(dout0_60) AT=1010.025n

* CHECK dout0_61 Vdout0_61ck201 = 0 time = 1010
.meas tran vdout0_61ck201 FIND v(dout0_61) AT=1010.025n

* CHECK dout0_62 Vdout0_62ck201 = 0 time = 1010
.meas tran vdout0_62ck201 FIND v(dout0_62) AT=1010.025n

* CHECK dout0_63 Vdout0_63ck201 = 0.9 time = 1010
.meas tran vdout0_63ck201 FIND v(dout0_63) AT=1010.025n

* CHECK dout0_0 Vdout0_0ck202 = 0.9 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0.9 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0.9 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 0.9 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 0.9 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 0.9 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 0.9 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 0.9 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 0.9 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0.9 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 0.9 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 0 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 0.9 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 0.9 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 0.9 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 0.9 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 0 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 0 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_32 Vdout0_32ck202 = 0 time = 1015
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=1015.025n

* CHECK dout0_33 Vdout0_33ck202 = 0.9 time = 1015
.meas tran vdout0_33ck202 FIND v(dout0_33) AT=1015.025n

* CHECK dout0_34 Vdout0_34ck202 = 0.9 time = 1015
.meas tran vdout0_34ck202 FIND v(dout0_34) AT=1015.025n

* CHECK dout0_35 Vdout0_35ck202 = 0 time = 1015
.meas tran vdout0_35ck202 FIND v(dout0_35) AT=1015.025n

* CHECK dout0_36 Vdout0_36ck202 = 0.9 time = 1015
.meas tran vdout0_36ck202 FIND v(dout0_36) AT=1015.025n

* CHECK dout0_37 Vdout0_37ck202 = 0.9 time = 1015
.meas tran vdout0_37ck202 FIND v(dout0_37) AT=1015.025n

* CHECK dout0_38 Vdout0_38ck202 = 0 time = 1015
.meas tran vdout0_38ck202 FIND v(dout0_38) AT=1015.025n

* CHECK dout0_39 Vdout0_39ck202 = 0 time = 1015
.meas tran vdout0_39ck202 FIND v(dout0_39) AT=1015.025n

* CHECK dout0_40 Vdout0_40ck202 = 0 time = 1015
.meas tran vdout0_40ck202 FIND v(dout0_40) AT=1015.025n

* CHECK dout0_41 Vdout0_41ck202 = 0 time = 1015
.meas tran vdout0_41ck202 FIND v(dout0_41) AT=1015.025n

* CHECK dout0_42 Vdout0_42ck202 = 0 time = 1015
.meas tran vdout0_42ck202 FIND v(dout0_42) AT=1015.025n

* CHECK dout0_43 Vdout0_43ck202 = 0.9 time = 1015
.meas tran vdout0_43ck202 FIND v(dout0_43) AT=1015.025n

* CHECK dout0_44 Vdout0_44ck202 = 0 time = 1015
.meas tran vdout0_44ck202 FIND v(dout0_44) AT=1015.025n

* CHECK dout0_45 Vdout0_45ck202 = 0 time = 1015
.meas tran vdout0_45ck202 FIND v(dout0_45) AT=1015.025n

* CHECK dout0_46 Vdout0_46ck202 = 0.9 time = 1015
.meas tran vdout0_46ck202 FIND v(dout0_46) AT=1015.025n

* CHECK dout0_47 Vdout0_47ck202 = 0 time = 1015
.meas tran vdout0_47ck202 FIND v(dout0_47) AT=1015.025n

* CHECK dout0_48 Vdout0_48ck202 = 0.9 time = 1015
.meas tran vdout0_48ck202 FIND v(dout0_48) AT=1015.025n

* CHECK dout0_49 Vdout0_49ck202 = 0.9 time = 1015
.meas tran vdout0_49ck202 FIND v(dout0_49) AT=1015.025n

* CHECK dout0_50 Vdout0_50ck202 = 0.9 time = 1015
.meas tran vdout0_50ck202 FIND v(dout0_50) AT=1015.025n

* CHECK dout0_51 Vdout0_51ck202 = 0.9 time = 1015
.meas tran vdout0_51ck202 FIND v(dout0_51) AT=1015.025n

* CHECK dout0_52 Vdout0_52ck202 = 0.9 time = 1015
.meas tran vdout0_52ck202 FIND v(dout0_52) AT=1015.025n

* CHECK dout0_53 Vdout0_53ck202 = 0 time = 1015
.meas tran vdout0_53ck202 FIND v(dout0_53) AT=1015.025n

* CHECK dout0_54 Vdout0_54ck202 = 0.9 time = 1015
.meas tran vdout0_54ck202 FIND v(dout0_54) AT=1015.025n

* CHECK dout0_55 Vdout0_55ck202 = 0.9 time = 1015
.meas tran vdout0_55ck202 FIND v(dout0_55) AT=1015.025n

* CHECK dout0_56 Vdout0_56ck202 = 0.9 time = 1015
.meas tran vdout0_56ck202 FIND v(dout0_56) AT=1015.025n

* CHECK dout0_57 Vdout0_57ck202 = 0.9 time = 1015
.meas tran vdout0_57ck202 FIND v(dout0_57) AT=1015.025n

* CHECK dout0_58 Vdout0_58ck202 = 0 time = 1015
.meas tran vdout0_58ck202 FIND v(dout0_58) AT=1015.025n

* CHECK dout0_59 Vdout0_59ck202 = 0 time = 1015
.meas tran vdout0_59ck202 FIND v(dout0_59) AT=1015.025n

* CHECK dout0_60 Vdout0_60ck202 = 0 time = 1015
.meas tran vdout0_60ck202 FIND v(dout0_60) AT=1015.025n

* CHECK dout0_61 Vdout0_61ck202 = 0.9 time = 1015
.meas tran vdout0_61ck202 FIND v(dout0_61) AT=1015.025n

* CHECK dout0_62 Vdout0_62ck202 = 0 time = 1015
.meas tran vdout0_62ck202 FIND v(dout0_62) AT=1015.025n

* CHECK dout0_63 Vdout0_63ck202 = 0 time = 1015
.meas tran vdout0_63ck202 FIND v(dout0_63) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck203 = 0.9 time = 1020
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=1020.025n

* CHECK dout0_1 Vdout0_1ck203 = 0.9 time = 1020
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=1020.025n

* CHECK dout0_2 Vdout0_2ck203 = 0 time = 1020
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=1020.025n

* CHECK dout0_3 Vdout0_3ck203 = 0.9 time = 1020
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=1020.025n

* CHECK dout0_4 Vdout0_4ck203 = 0.9 time = 1020
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=1020.025n

* CHECK dout0_5 Vdout0_5ck203 = 0 time = 1020
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=1020.025n

* CHECK dout0_6 Vdout0_6ck203 = 0.9 time = 1020
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=1020.025n

* CHECK dout0_7 Vdout0_7ck203 = 0.9 time = 1020
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=1020.025n

* CHECK dout0_8 Vdout0_8ck203 = 0.9 time = 1020
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=1020.025n

* CHECK dout0_9 Vdout0_9ck203 = 0 time = 1020
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=1020.025n

* CHECK dout0_10 Vdout0_10ck203 = 0.9 time = 1020
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=1020.025n

* CHECK dout0_11 Vdout0_11ck203 = 0.9 time = 1020
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=1020.025n

* CHECK dout0_12 Vdout0_12ck203 = 0.9 time = 1020
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=1020.025n

* CHECK dout0_13 Vdout0_13ck203 = 0.9 time = 1020
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=1020.025n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 1020
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=1020.025n

* CHECK dout0_15 Vdout0_15ck203 = 0.9 time = 1020
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=1020.025n

* CHECK dout0_16 Vdout0_16ck203 = 0.9 time = 1020
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=1020.025n

* CHECK dout0_17 Vdout0_17ck203 = 0.9 time = 1020
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=1020.025n

* CHECK dout0_18 Vdout0_18ck203 = 0.9 time = 1020
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=1020.025n

* CHECK dout0_19 Vdout0_19ck203 = 0.9 time = 1020
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=1020.025n

* CHECK dout0_20 Vdout0_20ck203 = 0.9 time = 1020
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=1020.025n

* CHECK dout0_21 Vdout0_21ck203 = 0.9 time = 1020
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=1020.025n

* CHECK dout0_22 Vdout0_22ck203 = 0 time = 1020
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=1020.025n

* CHECK dout0_23 Vdout0_23ck203 = 0 time = 1020
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=1020.025n

* CHECK dout0_24 Vdout0_24ck203 = 0.9 time = 1020
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=1020.025n

* CHECK dout0_25 Vdout0_25ck203 = 0.9 time = 1020
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=1020.025n

* CHECK dout0_26 Vdout0_26ck203 = 0.9 time = 1020
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=1020.025n

* CHECK dout0_27 Vdout0_27ck203 = 0 time = 1020
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=1020.025n

* CHECK dout0_28 Vdout0_28ck203 = 0 time = 1020
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=1020.025n

* CHECK dout0_29 Vdout0_29ck203 = 0 time = 1020
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=1020.025n

* CHECK dout0_30 Vdout0_30ck203 = 0.9 time = 1020
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=1020.025n

* CHECK dout0_31 Vdout0_31ck203 = 0 time = 1020
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=1020.025n

* CHECK dout0_32 Vdout0_32ck203 = 0.9 time = 1020
.meas tran vdout0_32ck203 FIND v(dout0_32) AT=1020.025n

* CHECK dout0_33 Vdout0_33ck203 = 0 time = 1020
.meas tran vdout0_33ck203 FIND v(dout0_33) AT=1020.025n

* CHECK dout0_34 Vdout0_34ck203 = 0 time = 1020
.meas tran vdout0_34ck203 FIND v(dout0_34) AT=1020.025n

* CHECK dout0_35 Vdout0_35ck203 = 0 time = 1020
.meas tran vdout0_35ck203 FIND v(dout0_35) AT=1020.025n

* CHECK dout0_36 Vdout0_36ck203 = 0 time = 1020
.meas tran vdout0_36ck203 FIND v(dout0_36) AT=1020.025n

* CHECK dout0_37 Vdout0_37ck203 = 0.9 time = 1020
.meas tran vdout0_37ck203 FIND v(dout0_37) AT=1020.025n

* CHECK dout0_38 Vdout0_38ck203 = 0.9 time = 1020
.meas tran vdout0_38ck203 FIND v(dout0_38) AT=1020.025n

* CHECK dout0_39 Vdout0_39ck203 = 0.9 time = 1020
.meas tran vdout0_39ck203 FIND v(dout0_39) AT=1020.025n

* CHECK dout0_40 Vdout0_40ck203 = 0 time = 1020
.meas tran vdout0_40ck203 FIND v(dout0_40) AT=1020.025n

* CHECK dout0_41 Vdout0_41ck203 = 0 time = 1020
.meas tran vdout0_41ck203 FIND v(dout0_41) AT=1020.025n

* CHECK dout0_42 Vdout0_42ck203 = 0.9 time = 1020
.meas tran vdout0_42ck203 FIND v(dout0_42) AT=1020.025n

* CHECK dout0_43 Vdout0_43ck203 = 0 time = 1020
.meas tran vdout0_43ck203 FIND v(dout0_43) AT=1020.025n

* CHECK dout0_44 Vdout0_44ck203 = 0.9 time = 1020
.meas tran vdout0_44ck203 FIND v(dout0_44) AT=1020.025n

* CHECK dout0_45 Vdout0_45ck203 = 0.9 time = 1020
.meas tran vdout0_45ck203 FIND v(dout0_45) AT=1020.025n

* CHECK dout0_46 Vdout0_46ck203 = 0 time = 1020
.meas tran vdout0_46ck203 FIND v(dout0_46) AT=1020.025n

* CHECK dout0_47 Vdout0_47ck203 = 0.9 time = 1020
.meas tran vdout0_47ck203 FIND v(dout0_47) AT=1020.025n

* CHECK dout0_48 Vdout0_48ck203 = 0.9 time = 1020
.meas tran vdout0_48ck203 FIND v(dout0_48) AT=1020.025n

* CHECK dout0_49 Vdout0_49ck203 = 0 time = 1020
.meas tran vdout0_49ck203 FIND v(dout0_49) AT=1020.025n

* CHECK dout0_50 Vdout0_50ck203 = 0.9 time = 1020
.meas tran vdout0_50ck203 FIND v(dout0_50) AT=1020.025n

* CHECK dout0_51 Vdout0_51ck203 = 0.9 time = 1020
.meas tran vdout0_51ck203 FIND v(dout0_51) AT=1020.025n

* CHECK dout0_52 Vdout0_52ck203 = 0.9 time = 1020
.meas tran vdout0_52ck203 FIND v(dout0_52) AT=1020.025n

* CHECK dout0_53 Vdout0_53ck203 = 0.9 time = 1020
.meas tran vdout0_53ck203 FIND v(dout0_53) AT=1020.025n

* CHECK dout0_54 Vdout0_54ck203 = 0 time = 1020
.meas tran vdout0_54ck203 FIND v(dout0_54) AT=1020.025n

* CHECK dout0_55 Vdout0_55ck203 = 0.9 time = 1020
.meas tran vdout0_55ck203 FIND v(dout0_55) AT=1020.025n

* CHECK dout0_56 Vdout0_56ck203 = 0.9 time = 1020
.meas tran vdout0_56ck203 FIND v(dout0_56) AT=1020.025n

* CHECK dout0_57 Vdout0_57ck203 = 0 time = 1020
.meas tran vdout0_57ck203 FIND v(dout0_57) AT=1020.025n

* CHECK dout0_58 Vdout0_58ck203 = 0 time = 1020
.meas tran vdout0_58ck203 FIND v(dout0_58) AT=1020.025n

* CHECK dout0_59 Vdout0_59ck203 = 0 time = 1020
.meas tran vdout0_59ck203 FIND v(dout0_59) AT=1020.025n

* CHECK dout0_60 Vdout0_60ck203 = 0 time = 1020
.meas tran vdout0_60ck203 FIND v(dout0_60) AT=1020.025n

* CHECK dout0_61 Vdout0_61ck203 = 0 time = 1020
.meas tran vdout0_61ck203 FIND v(dout0_61) AT=1020.025n

* CHECK dout0_62 Vdout0_62ck203 = 0 time = 1020
.meas tran vdout0_62ck203 FIND v(dout0_62) AT=1020.025n

* CHECK dout0_63 Vdout0_63ck203 = 0.9 time = 1020
.meas tran vdout0_63ck203 FIND v(dout0_63) AT=1020.025n

* CHECK dout0_0 Vdout0_0ck204 = 0.9 time = 1025
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=1025.025n

* CHECK dout0_1 Vdout0_1ck204 = 0.9 time = 1025
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=1025.025n

* CHECK dout0_2 Vdout0_2ck204 = 0 time = 1025
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=1025.025n

* CHECK dout0_3 Vdout0_3ck204 = 0.9 time = 1025
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=1025.025n

* CHECK dout0_4 Vdout0_4ck204 = 0.9 time = 1025
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=1025.025n

* CHECK dout0_5 Vdout0_5ck204 = 0 time = 1025
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=1025.025n

* CHECK dout0_6 Vdout0_6ck204 = 0.9 time = 1025
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=1025.025n

* CHECK dout0_7 Vdout0_7ck204 = 0.9 time = 1025
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=1025.025n

* CHECK dout0_8 Vdout0_8ck204 = 0.9 time = 1025
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=1025.025n

* CHECK dout0_9 Vdout0_9ck204 = 0 time = 1025
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=1025.025n

* CHECK dout0_10 Vdout0_10ck204 = 0.9 time = 1025
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=1025.025n

* CHECK dout0_11 Vdout0_11ck204 = 0.9 time = 1025
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=1025.025n

* CHECK dout0_12 Vdout0_12ck204 = 0.9 time = 1025
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=1025.025n

* CHECK dout0_13 Vdout0_13ck204 = 0.9 time = 1025
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=1025.025n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 1025
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=1025.025n

* CHECK dout0_15 Vdout0_15ck204 = 0.9 time = 1025
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=1025.025n

* CHECK dout0_16 Vdout0_16ck204 = 0.9 time = 1025
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=1025.025n

* CHECK dout0_17 Vdout0_17ck204 = 0.9 time = 1025
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=1025.025n

* CHECK dout0_18 Vdout0_18ck204 = 0.9 time = 1025
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=1025.025n

* CHECK dout0_19 Vdout0_19ck204 = 0.9 time = 1025
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=1025.025n

* CHECK dout0_20 Vdout0_20ck204 = 0.9 time = 1025
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=1025.025n

* CHECK dout0_21 Vdout0_21ck204 = 0.9 time = 1025
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=1025.025n

* CHECK dout0_22 Vdout0_22ck204 = 0 time = 1025
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=1025.025n

* CHECK dout0_23 Vdout0_23ck204 = 0 time = 1025
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=1025.025n

* CHECK dout0_24 Vdout0_24ck204 = 0.9 time = 1025
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=1025.025n

* CHECK dout0_25 Vdout0_25ck204 = 0.9 time = 1025
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=1025.025n

* CHECK dout0_26 Vdout0_26ck204 = 0.9 time = 1025
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=1025.025n

* CHECK dout0_27 Vdout0_27ck204 = 0 time = 1025
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=1025.025n

* CHECK dout0_28 Vdout0_28ck204 = 0 time = 1025
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=1025.025n

* CHECK dout0_29 Vdout0_29ck204 = 0 time = 1025
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=1025.025n

* CHECK dout0_30 Vdout0_30ck204 = 0.9 time = 1025
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=1025.025n

* CHECK dout0_31 Vdout0_31ck204 = 0 time = 1025
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=1025.025n

* CHECK dout0_32 Vdout0_32ck204 = 0.9 time = 1025
.meas tran vdout0_32ck204 FIND v(dout0_32) AT=1025.025n

* CHECK dout0_33 Vdout0_33ck204 = 0 time = 1025
.meas tran vdout0_33ck204 FIND v(dout0_33) AT=1025.025n

* CHECK dout0_34 Vdout0_34ck204 = 0 time = 1025
.meas tran vdout0_34ck204 FIND v(dout0_34) AT=1025.025n

* CHECK dout0_35 Vdout0_35ck204 = 0 time = 1025
.meas tran vdout0_35ck204 FIND v(dout0_35) AT=1025.025n

* CHECK dout0_36 Vdout0_36ck204 = 0 time = 1025
.meas tran vdout0_36ck204 FIND v(dout0_36) AT=1025.025n

* CHECK dout0_37 Vdout0_37ck204 = 0.9 time = 1025
.meas tran vdout0_37ck204 FIND v(dout0_37) AT=1025.025n

* CHECK dout0_38 Vdout0_38ck204 = 0.9 time = 1025
.meas tran vdout0_38ck204 FIND v(dout0_38) AT=1025.025n

* CHECK dout0_39 Vdout0_39ck204 = 0.9 time = 1025
.meas tran vdout0_39ck204 FIND v(dout0_39) AT=1025.025n

* CHECK dout0_40 Vdout0_40ck204 = 0 time = 1025
.meas tran vdout0_40ck204 FIND v(dout0_40) AT=1025.025n

* CHECK dout0_41 Vdout0_41ck204 = 0 time = 1025
.meas tran vdout0_41ck204 FIND v(dout0_41) AT=1025.025n

* CHECK dout0_42 Vdout0_42ck204 = 0.9 time = 1025
.meas tran vdout0_42ck204 FIND v(dout0_42) AT=1025.025n

* CHECK dout0_43 Vdout0_43ck204 = 0 time = 1025
.meas tran vdout0_43ck204 FIND v(dout0_43) AT=1025.025n

* CHECK dout0_44 Vdout0_44ck204 = 0.9 time = 1025
.meas tran vdout0_44ck204 FIND v(dout0_44) AT=1025.025n

* CHECK dout0_45 Vdout0_45ck204 = 0.9 time = 1025
.meas tran vdout0_45ck204 FIND v(dout0_45) AT=1025.025n

* CHECK dout0_46 Vdout0_46ck204 = 0 time = 1025
.meas tran vdout0_46ck204 FIND v(dout0_46) AT=1025.025n

* CHECK dout0_47 Vdout0_47ck204 = 0.9 time = 1025
.meas tran vdout0_47ck204 FIND v(dout0_47) AT=1025.025n

* CHECK dout0_48 Vdout0_48ck204 = 0.9 time = 1025
.meas tran vdout0_48ck204 FIND v(dout0_48) AT=1025.025n

* CHECK dout0_49 Vdout0_49ck204 = 0 time = 1025
.meas tran vdout0_49ck204 FIND v(dout0_49) AT=1025.025n

* CHECK dout0_50 Vdout0_50ck204 = 0.9 time = 1025
.meas tran vdout0_50ck204 FIND v(dout0_50) AT=1025.025n

* CHECK dout0_51 Vdout0_51ck204 = 0.9 time = 1025
.meas tran vdout0_51ck204 FIND v(dout0_51) AT=1025.025n

* CHECK dout0_52 Vdout0_52ck204 = 0.9 time = 1025
.meas tran vdout0_52ck204 FIND v(dout0_52) AT=1025.025n

* CHECK dout0_53 Vdout0_53ck204 = 0.9 time = 1025
.meas tran vdout0_53ck204 FIND v(dout0_53) AT=1025.025n

* CHECK dout0_54 Vdout0_54ck204 = 0 time = 1025
.meas tran vdout0_54ck204 FIND v(dout0_54) AT=1025.025n

* CHECK dout0_55 Vdout0_55ck204 = 0.9 time = 1025
.meas tran vdout0_55ck204 FIND v(dout0_55) AT=1025.025n

* CHECK dout0_56 Vdout0_56ck204 = 0.9 time = 1025
.meas tran vdout0_56ck204 FIND v(dout0_56) AT=1025.025n

* CHECK dout0_57 Vdout0_57ck204 = 0 time = 1025
.meas tran vdout0_57ck204 FIND v(dout0_57) AT=1025.025n

* CHECK dout0_58 Vdout0_58ck204 = 0 time = 1025
.meas tran vdout0_58ck204 FIND v(dout0_58) AT=1025.025n

* CHECK dout0_59 Vdout0_59ck204 = 0 time = 1025
.meas tran vdout0_59ck204 FIND v(dout0_59) AT=1025.025n

* CHECK dout0_60 Vdout0_60ck204 = 0 time = 1025
.meas tran vdout0_60ck204 FIND v(dout0_60) AT=1025.025n

* CHECK dout0_61 Vdout0_61ck204 = 0 time = 1025
.meas tran vdout0_61ck204 FIND v(dout0_61) AT=1025.025n

* CHECK dout0_62 Vdout0_62ck204 = 0 time = 1025
.meas tran vdout0_62ck204 FIND v(dout0_62) AT=1025.025n

* CHECK dout0_63 Vdout0_63ck204 = 0.9 time = 1025
.meas tran vdout0_63ck204 FIND v(dout0_63) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
