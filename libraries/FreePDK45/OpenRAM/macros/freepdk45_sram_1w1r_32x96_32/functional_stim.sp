* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_32x96_32.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_32x96_32 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 din0_80 din0_81 din0_82 din0_83 din0_84 din0_85 din0_86 din0_87 din0_88 din0_89 din0_90 din0_91 din0_92 din0_93 din0_94 din0_95 a0_0 a0_1 a0_2 a0_3 a0_4 a1_0 a1_1 a1_2 a1_3 a1_4 CSB0 CSB1 clk0 clk1 WMASK0_0 WMASK0_1 WMASK0_2 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 dout1_72 dout1_73 dout1_74 dout1_75 dout1_76 dout1_77 dout1_78 dout1_79 dout1_80 dout1_81 dout1_82 dout1_83 dout1_84 dout1_85 dout1_86 dout1_87 dout1_88 dout1_89 dout1_90 dout1_91 dout1_92 dout1_93 dout1_94 dout1_95 vdd gnd freepdk45_sram_1w1r_32x96_32

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f
CD164 dout1_64  0 0.8364f
CD165 dout1_65  0 0.8364f
CD166 dout1_66  0 0.8364f
CD167 dout1_67  0 0.8364f
CD168 dout1_68  0 0.8364f
CD169 dout1_69  0 0.8364f
CD170 dout1_70  0 0.8364f
CD171 dout1_71  0 0.8364f
CD172 dout1_72  0 0.8364f
CD173 dout1_73  0 0.8364f
CD174 dout1_74  0 0.8364f
CD175 dout1_75  0 0.8364f
CD176 dout1_76  0 0.8364f
CD177 dout1_77  0 0.8364f
CD178 dout1_78  0 0.8364f
CD179 dout1_79  0 0.8364f
CD180 dout1_80  0 0.8364f
CD181 dout1_81  0 0.8364f
CD182 dout1_82  0 0.8364f
CD183 dout1_83  0 0.8364f
CD184 dout1_84  0 0.8364f
CD185 dout1_85  0 0.8364f
CD186 dout1_86  0 0.8364f
CD187 dout1_87  0 0.8364f
CD188 dout1_88  0 0.8364f
CD189 dout1_89  0 0.8364f
CD190 dout1_90  0 0.8364f
CD191 dout1_91  0 0.8364f
CD192 dout1_92  0 0.8364f
CD193 dout1_93  0 0.8364f
CD194 dout1_94  0 0.8364f
CD195 dout1_95  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_32x96_32.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_32x96_32.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_32x96_32.s_en
* q:	xfreepdk45_sram_1w1r_32x96_32.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_32x96_32.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 110000100000111101101000101111001000010000001100100110100011000101101010010011000101100111101010  to  address 00000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 000110010101101001110011010001000010111101011111110001110110010010000111110111011000011101000001  to  address 11110 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 110101001010011111101000111101000100110000001111000101101111000111011000100001011101000011000111  to  address 11110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 110101001010011111101000111101000100110000001111000101101111000111011000100001011101000011000111 from address 11110 (from port 1) during cycle 4 (20ns - 25ns)
*	Reading 110000100000111101101000101111001000010000001100100110100011000101101010010011000101100111101010 from address 00000 (from port 1) during cycle 5 (25ns - 30ns)
*	Writing 111111000011001010001110010110000001011010111010001110110010001111110111000011110010111110100111  to  address 00000 (from port 0) during cycle 6 (30ns - 35ns)
*	Writing 001000001111100111001100100100111001001011001101011100111000011011011110110101010011101010101011  to  address 00000 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing 011100010111100001010111100101101010111101100011100000111111100100101100001010100001001010001111  to  address 11110 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing 001000010010011100101001100100000010000000110000011101011011100110000011110100010101010001110010  to  address 00000 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing (partial) 111010100110000110001010100111101000111001000100110001010100011100111100011101000100111011110101  to  address 11110 with mask bit 010 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 001000010010011100101001100100000010000000110000011101011011100110000011110100010101010001110010 from address 00000 (from port 1) during cycle 11 (55ns - 60ns)
*	Writing 000110111110000010001110101000100001010111011101010000110001011111000000001111001111110100001100  to  address 00000 (from port 0) during cycle 12 (60ns - 65ns)
*	Writing (partial) 011100100000101100000111111011101010010011111110100100011101000110101111011000001110110110111101  to  address 11110 with mask bit 010 (from port 0) during cycle 13 (65ns - 70ns)
*	Writing (partial) 110101011000110101010100100011000101100001001101010100011000011110011111001011011011010111100000  to  address 11110 with mask bit 100 (from port 0) during cycle 14 (70ns - 75ns)
*	Writing (partial) 101111001011110101001001010010100110010001011000100010011111110000101001111011011000101101011000  to  address 00000 with mask bit 001 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing 110011011101011111111110001100011111011000010000010111000100011101011101010000100010010000111001  to  address 11110 (from port 0) during cycle 17 (85ns - 90ns)
*	Writing 001010101100111001111111001000101000100001011000101010011011000011111010011111111000010001001000  to  address 11110 (from port 0) during cycle 18 (90ns - 95ns)
*	Writing (partial) 011010001111010011100110110010011000111101011000100010101000101110010101101011111111101101100111  to  address 11110 with mask bit 110 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 000110111110000010001110101000100001010111011101010000110001011100101001111011011000101101011000 from address 00000 (from port 1) during cycle 19 (95ns - 100ns)
*	Writing (partial) 001101000011110100100100101010000000101100100101010001010110111110110111110001101100100100010100  to  address 00000 with mask bit 001 (from port 0) during cycle 20 (100ns - 105ns)
*	Writing 000011100100111110100010000000101011111000110101111001000011110100110010110100101101110100001001  to  address 11110 (from port 0) during cycle 23 (115ns - 120ns)
*	Writing 101100011000100001111101001011011100000000010110000010010001001011100100000001100011010101011001  to  address 11110 (from port 0) during cycle 25 (125ns - 130ns)
*	Reading 000110111110000010001110101000100001010111011101010000110001011110110111110001101100100100010100 from address 00000 (from port 1) during cycle 25 (125ns - 130ns)
*	Writing 010111111111010010101111111101011100110000010101000100110101100100111100100101110011001101110111  to  address 11110 (from port 0) during cycle 27 (135ns - 140ns)
*	Writing (partial) 110100000101001101011111101001010001100010100100111010110110011001000011100001100111111011000011  to  address 11110 with mask bit 100 (from port 0) during cycle 28 (140ns - 145ns)
*	Writing 110000000110100011011000101111111010111001110111010110100110001001001000000000010100001000100110  to  address 11110 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 000110111110000010001110101000100001010111011101010000110001011110110111110001101100100100010100 from address 00000 (from port 1) during cycle 29 (145ns - 150ns)
*	Writing (partial) 010000001110101010100101011000011000010101101111011010110000001000100011110110010001011101011110  to  address 11110 with mask bit 101 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 000110111110000010001110101000100001010111011101010000110001011110110111110001101100100100010100 from address 00000 (from port 1) during cycle 30 (150ns - 155ns)
*	Writing (partial) 100011100010101011101111110011001000010110101111000111110100010011100111100101000101010010101100  to  address 11110 with mask bit 100 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 000110111110000010001110101000100001010111011101010000110001011110110111110001101100100100010100 from address 00000 (from port 1) during cycle 32 (160ns - 165ns)
*	Writing 101110010100010010110100110011001110110101000100001000111100110111001100010100000000100011110111  to  address 11110 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 000110111110000010001110101000100001010111011101010000110001011110110111110001101100100100010100 from address 00000 (from port 1) during cycle 33 (165ns - 170ns)
*	Writing (partial) 110111100011000000010000100110111000100010100110111010001111001011010111000000100111111111110110  to  address 00000 with mask bit 100 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 100100110001001010000100001111110100111110110110010000110101111100011101100111000000110101001100  to  address 00000 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 101110010100010010110100110011001110110101000100001000111100110111001100010100000000100011110111 from address 11110 (from port 1) during cycle 36 (180ns - 185ns)
*	Writing (partial) 110100011100010101010111000001101000101001111011000011011110011101010110011010000001110101010100  to  address 11110 with mask bit 100 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 111101010011100011101111110110000000010011111011001011000010010110001100101000110001001000100011  to  address 11110 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing 010100111001011111010110000000110100010010101111001111101001111011111111001101101100101100001100  to  address 11110 (from port 0) during cycle 41 (205ns - 210ns)
*	Writing 001010011001111111000101101100000110110110111010101011100000111000110100111110101010100110001011  to  address 11110 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing 010011011111111111010011010000000000010010111001100001101111011110011001111000000111011000110010  to  address 11110 (from port 0) during cycle 44 (220ns - 225ns)
*	Reading 010011011111111111010011010000000000010010111001100001101111011110011001111000000111011000110010 from address 11110 (from port 1) during cycle 45 (225ns - 230ns)
*	Writing (partial) 011111011111011100100001111101001011001011000000101000110101010001101001011111000011111100101111  to  address 11110 with mask bit 101 (from port 0) during cycle 46 (230ns - 235ns)
*	Writing 111001111000101110100000001101001000110010000001000011001001111011001011010101111000011100010111  to  address 00000 (from port 0) during cycle 47 (235ns - 240ns)
*	Writing (partial) 111000110010110011111010001101001110111011001010111111000001011111110010110100011100100000001001  to  address 00000 with mask bit 100 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 101111001100001011000010010110110101011001110111011111011011111100111010001111111000110010010001  to  address 00000 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing (partial) 100001010010100010011000000010010101111110010101111001101100101000011000001001100010111010100001  to  address 11110 with mask bit 110 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 101111001100001011000010010110110101011001110111011111011011111100111010001111111000110010010001 from address 00000 (from port 1) during cycle 50 (250ns - 255ns)
*	Writing 001111111101010101101000101110101111100110100010001010010001101110010001011111011011111110001011  to  address 11110 (from port 0) during cycle 52 (260ns - 265ns)
*	Writing (partial) 100101010110001001010101100101011111111110000100000111010001000101101010011101110111111000010101  to  address 11110 with mask bit 110 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing 100110000010001011011001001000000010111001100000011101101111100011010101100011101101000101101101  to  address 11110 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing 111101100000111001010001101110100110101111000001001001100001111011010010011100111110110111101111  to  address 11110 (from port 0) during cycle 55 (275ns - 280ns)
*	Reading 101111001100001011000010010110110101011001110111011111011011111100111010001111111000110010010001 from address 00000 (from port 1) during cycle 55 (275ns - 280ns)
*	Reading 111101100000111001010001101110100110101111000001001001100001111011010010011100111110110111101111 from address 11110 (from port 1) during cycle 56 (280ns - 285ns)
*	Writing (partial) 010110100111111100101001110101010111011010000110101100110101111111011010011001111011010110001101  to  address 00000 with mask bit 100 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing 101001000011101001110011111001000111111110101000111111001101010011110011000000011101101000000000  to  address 00000 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing (partial) 010100001010000110010010001010100100000001011100001010101010111101001101111110000011111001110100  to  address 11110 with mask bit 101 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 010101101011110101010100101101000000101000000001000000010011010010101000011010010011011010010111  to  address 11110 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 110001110011001010000100000100001011000001111100111110111001011101100000100000110110101011101010  to  address 11110 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 101001000011101001110011111001000111111110101000111111001101010011110011000000011101101000000000 from address 00000 (from port 1) during cycle 61 (305ns - 310ns)
*	Writing 010111111100111100000110011000001111001001010110100110011110011000011001110011100011100100111010  to  address 11110 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing (partial) 001100001011001111000000001000100011110011001000001100010110111100111110100101010110101111010111  to  address 00000 with mask bit 010 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 110101111001101010011001100010110111011010110010000100111111010101100101001011011000010011011110  to  address 11110 (from port 0) during cycle 64 (320ns - 325ns)
*	Writing 000001110111110111010111101111100010101111000111100010101110001100111101101100011110010100101011  to  address 11110 (from port 0) during cycle 66 (330ns - 335ns)
*	Reading 101001000011101001110011111001000011110011001000001100010110111111110011000000011101101000000000 from address 00000 (from port 1) during cycle 66 (330ns - 335ns)
*	Reading 000001110111110111010111101111100010101111000111100010101110001100111101101100011110010100101011 from address 11110 (from port 1) during cycle 67 (335ns - 340ns)
*	Writing 010000100101111110001000010001111111101111010110001010011100000101010011000001100110010111101101  to  address 00000 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 000001110111110111010111101111100010101111000111100010101110001100111101101100011110010100101011 from address 11110 (from port 1) during cycle 68 (340ns - 345ns)
*	Writing (partial) 000000011010100000101010010100001110100011110101010101101001101010000110000111001111100100101100  to  address 11110 with mask bit 101 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 010000100101111110001000010001111111101111010110001010011100000101010011000001100110010111101101 from address 00000 (from port 1) during cycle 71 (355ns - 360ns)
*	Reading 000000011010100000101010010100000010101111000111100010101110001110000110000111001111100100101100 from address 11110 (from port 1) during cycle 72 (360ns - 365ns)
*	Writing 101100111111111000110101011010111111010010100100110100100111011000110010101011011100001000011101  to  address 00000 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 000000011010100000101010010100000010101111000111100010101110001110000110000111001111100100101100 from address 11110 (from port 1) during cycle 74 (370ns - 375ns)
*	Writing (partial) 001110001001001000110011100000111100001001101001011010100011001011000100010011000000100100001101  to  address 00000 with mask bit 101 (from port 0) during cycle 75 (375ns - 380ns)
*	Writing (partial) 001111010000111100100011010100001101010001010101111010111110101000111101100101000001001000100000  to  address 00000 with mask bit 110 (from port 0) during cycle 76 (380ns - 385ns)
*	Writing (partial) 000001010000100111100011110100000011000101110101111100110000001110101011011110011010111001100000  to  address 00000 with mask bit 010 (from port 0) during cycle 77 (385ns - 390ns)
*	Writing (partial) 101011000110100011110010101111010100000110010011110101101101101101110010100001110101111010100110  to  address 00000 with mask bit 010 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing 001100100110110110100011001000100101010111010100000010100111000110110110000001100000100000111000  to  address 00000 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 000000011010100000101010010100000010101111000111100010101110001110000110000111001111100100101100 from address 11110 (from port 1) during cycle 79 (395ns - 400ns)
*	Writing 011111110110010010100000010100110110111100011001100101000101101000001101101001111101011101011101  to  address 11110 (from port 0) during cycle 80 (400ns - 405ns)
*	Writing (partial) 010011100111001001001110100111110101100111011001100111000110010110101111100111101001000001001101  to  address 00000 with mask bit 011 (from port 0) during cycle 81 (405ns - 410ns)
*	Reading 011111110110010010100000010100110110111100011001100101000101101000001101101001111101011101011101 from address 11110 (from port 1) during cycle 81 (405ns - 410ns)
*	Writing (partial) 101001000100100000000101111000011111110110011110011101001010010110010000001000011110110011001100  to  address 00000 with mask bit 110 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing (partial) 100110011111001011011010011001001110111100001100111011111101101101110000110011111100010100111100  to  address 00000 with mask bit 101 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 100110011111001011011010011001001111110110011110011101001010010101110000110011111100010100111100 from address 00000 (from port 1) during cycle 84 (420ns - 425ns)
*	Reading 011111110110010010100000010100110110111100011001100101000101101000001101101001111101011101011101 from address 11110 (from port 1) during cycle 85 (425ns - 430ns)
*	Reading 100110011111001011011010011001001111110110011110011101001010010101110000110011111100010100111100 from address 00000 (from port 1) during cycle 86 (430ns - 435ns)
*	Writing (partial) 100011101010011100110000010100011010010011000000100101111000100110101111111001101111101001101101  to  address 11110 with mask bit 010 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing 011111110011001111010110000001110110111011001011001000100101111010111110101110010110001011110001  to  address 00000 (from port 0) during cycle 88 (440ns - 445ns)
*	Writing (partial) 010001010111000111001100010101100101011110110100010011001011010111111001001010011110010100110001  to  address 11110 with mask bit 100 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 011111110011001111010110000001110110111011001011001000100101111010111110101110010110001011110001 from address 00000 (from port 1) during cycle 90 (450ns - 455ns)
*	Writing (partial) 111010110111111101011001110100000001110000100101001101111010101001100110000100110100010000000111  to  address 00000 with mask bit 101 (from port 0) during cycle 91 (455ns - 460ns)
*	Writing (partial) 011011101011110001101011111000010110111110000101111000010101000010010011101011011000010001000000  to  address 11110 with mask bit 011 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 111010110111111101011001110100000110111011001011001000100101111001100110000100110100010000000111 from address 00000 (from port 1) during cycle 93 (465ns - 470ns)
*	Reading 111010110111111101011001110100000110111011001011001000100101111001100110000100110100010000000111 from address 00000 (from port 1) during cycle 96 (480ns - 485ns)
*	Writing (partial) 110010010111010011100010101110001110000110111101110101101110100000011011100101101001101010010110  to  address 11110 with mask bit 011 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 100111100011011101101101101000111011010011001100100111010110100110000101101001010100000100101100  to  address 11110 (from port 0) during cycle 99 (495ns - 500ns)
*	Writing (partial) 001110000110000000011011011000000100001110011100101011100111101001010011111111011000100001011110  to  address 11110 with mask bit 011 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing 110100011110001100101011101111000010010111101111000001111000100001000011001000001000111000111100  to  address 00000 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 100111100011011101101101101000110100001110011100101011100111101001010011111111011000100001011110 from address 11110 (from port 1) during cycle 101 (505ns - 510ns)
*	Writing (partial) 000110001111100110110001100011110100100101010101111100110101001100010000100011100111010000000000  to  address 11110 with mask bit 101 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 110100011110001100101011101111000010010111101111000001111000100001000011001000001000111000111100 from address 00000 (from port 1) during cycle 103 (515ns - 520ns)
*	Reading 000110001111100110110001100011110100001110011100101011100111101000010000100011100111010000000000 from address 11110 (from port 1) during cycle 105 (525ns - 530ns)
*	Writing (partial) 101111010011001110100011000111010111001010111000101110110110010100101100010011111111110010001011  to  address 11110 with mask bit 010 (from port 0) during cycle 106 (530ns - 535ns)
*	Writing (partial) 010110111111001101101010010110100001101001110101010111000100100111101010000011111101010111110111  to  address 00000 with mask bit 011 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 000110001111100110110001100011110111001010111000101110110110010100010000100011100111010000000000 from address 11110 (from port 1) during cycle 107 (535ns - 540ns)
*	Writing (partial) 010001001101000001001010010101111110100101100101001111110010010101010001001000011011010111110011  to  address 11110 with mask bit 101 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 010001001101000001001010010101110111001010111000101110110110010101010001001000011011010111110011 from address 11110 (from port 1) during cycle 110 (550ns - 555ns)
*	Writing (partial) 001100101010101100010101101111010101100111000001100001101100011111111111010001010110011100011000  to  address 00000 with mask bit 100 (from port 0) during cycle 111 (555ns - 560ns)
*	Writing 010000101100110101110010000010001110010011010000100001000111000010111001010110011100001010100100  to  address 11110 (from port 0) during cycle 112 (560ns - 565ns)
*	Writing 111011001000000000111110010010001001111110001000111010001010100010111000101011010010110100101011  to  address 11110 (from port 0) during cycle 113 (565ns - 570ns)
*	Reading 001100101010101100010101101111010001101001110101010111000100100111101010000011111101010111110111 from address 00000 (from port 1) during cycle 113 (565ns - 570ns)
*	Writing (partial) 111010101100000110000110000001010110011110100100110000001010001011101001000001100110001111100010  to  address 11110 with mask bit 110 (from port 0) during cycle 114 (570ns - 575ns)
*	Writing (partial) 111110111101111010100001110101001010000111000011000110010000001110000110001100111100100000001000  to  address 11110 with mask bit 100 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 010010001011011001110100111110111011101110111110111111111101110110111001000011001111001000001111  to  address 11110 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing (partial) 001010011111010111000000110001001010111010110001101101111001010101011001010100010011101000011110  to  address 00000 with mask bit 110 (from port 0) during cycle 117 (585ns - 590ns)
*	Writing 011111011000000001000111101011101111000011010001001101010001000111001100000001000111011100110001  to  address 11110 (from port 0) during cycle 118 (590ns - 595ns)
*	Writing 101001010011110001101101001010011011010100000010110000010100001111011000011110001000100101011010  to  address 11110 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 001010011111010111000000110001001010111010110001101101111001010111101010000011111101010111110111 from address 00000 (from port 1) during cycle 120 (600ns - 605ns)
*	Writing (partial) 101011011010011001110000001111011010001001110111011000011000101101011001001110011000011110100010  to  address 00000 with mask bit 010 (from port 0) during cycle 121 (605ns - 610ns)
*	Writing 011110010110100111011000101001001010001111110110000000010001001110101111100111111110110000100011  to  address 11110 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 001010011111010111000000110001001010001001110111011000011000101111101010000011111101010111110111 from address 00000 (from port 1) during cycle 122 (610ns - 615ns)
*	Writing (partial) 010111001100110100011100010000101111011011011111110010101010011101010111000101011110111001110101  to  address 00000 with mask bit 110 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing (partial) 001110010110110001010011010000101111101001110001011101000100011100000101110011010010001100011111  to  address 00000 with mask bit 110 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing (partial) 100001011001110110001010111100110101101001011110111101001100101101111000111001100010101001001001  to  address 00000 with mask bit 100 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing (partial) 110111011110100111100101001100011110111011000001101111111110111010001101101111100111001100001011  to  address 11110 with mask bit 001 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing (partial) 100110110100000101100111010001001101010100011001000001101011010000101010001011101010010000001000  to  address 00000 with mask bit 100 (from port 0) during cycle 129 (645ns - 650ns)
*	Writing (partial) 001110001101101001000001001010011110011100111111111000000001010011010011100000010001110110010110  to  address 11110 with mask bit 101 (from port 0) during cycle 130 (650ns - 655ns)
*	Reading 100110110100000101100111010001001111101001110001011101000100011111101010000011111101010111110111 from address 00000 (from port 1) during cycle 130 (650ns - 655ns)
*	Writing (partial) 000011000001110011001101010001110100001110111000100110111011101110011101100100001011110011100110  to  address 11110 with mask bit 011 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 100110110100000101100111010001001111101001110001011101000100011111101010000011111101010111110111 from address 00000 (from port 1) during cycle 131 (655ns - 660ns)
*	Reading 100110110100000101100111010001001111101001110001011101000100011111101010000011111101010111110111 from address 00000 (from port 1) during cycle 133 (665ns - 670ns)
*	Writing (partial) 011000101100001110111101111001001011011010110000011000001010100001100101100110000000000001100110  to  address 11110 with mask bit 110 (from port 0) during cycle 134 (670ns - 675ns)
*	Writing (partial) 010011011001000011100111100011011010101011100001000001010111000111000101101010101010100100101111  to  address 11110 with mask bit 011 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing (partial) 110010100110100011010010000010001000111011111100011111011011111010001110000001110010101001111110  to  address 00000 with mask bit 011 (from port 0) during cycle 137 (685ns - 690ns)
*	Writing 100011010111110011110010011100111100111001001110101011110001010011110010001100100110000000001101  to  address 00000 (from port 0) during cycle 138 (690ns - 695ns)
*	Writing (partial) 111110010001010100010111010001111100000110101000101101011100011000100110101000000000010010101111  to  address 00000 with mask bit 010 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 101110100111101110100010011001101001100111011010010001111111000101011100010100110100000011101110  to  address 11110 (from port 0) during cycle 140 (700ns - 705ns)
*	Writing (partial) 100101011101110110111011011111110111101110110101010101100001011111110010100010111101010101010010  to  address 11110 with mask bit 001 (from port 0) during cycle 142 (710ns - 715ns)
*	Writing (partial) 010011010010010011000100110001001111100101111010010000011101011000011010010110111101101010010011  to  address 11110 with mask bit 010 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 100011010111110011110010011100111100000110101000101101011100011011110010001100100110000000001101 from address 00000 (from port 1) during cycle 143 (715ns - 720ns)
*	Writing (partial) 111110111100111011011111010110101001111101010110110100010010100011010111111100000011101111011111  to  address 00000 with mask bit 100 (from port 0) during cycle 144 (720ns - 725ns)
*	Reading 101110100111101110100010011001101111100101111010010000011101011011110010100010111101010101010010 from address 11110 (from port 1) during cycle 144 (720ns - 725ns)
*	Writing 110100000010110111111011010110101000100001001001100101100010111100000100100001100011000100110100  to  address 00000 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing (partial) 101001110001000010101100001010010010011101111001011101101000110101011010010010111011011111011111  to  address 11110 with mask bit 001 (from port 0) during cycle 147 (735ns - 740ns)
*	Writing (partial) 010001111001011010010111101111111001100101011101011000100001000011111010101010000001110101110001  to  address 11110 with mask bit 110 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing 100101100110001111100110010000001010101001101101111011001111110110110100001000111001011001010110  to  address 00000 (from port 0) during cycle 150 (750ns - 755ns)
*	Writing 001100110100100101011100010101111111111001110101110110011011011101000101100100010011110000110111  to  address 00000 (from port 0) during cycle 151 (755ns - 760ns)
*	Writing 111011101101001111011110010010000010111000110010000001100100101001110010101000101000001100000111  to  address 00000 (from port 0) during cycle 153 (765ns - 770ns)
*	Writing (partial) 111000001101001000101010111100111111110001101111000101100110100001001101101111111101110001000110  to  address 00000 with mask bit 001 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 010001111001011010010111101111111001100101011101011000100001000001011010010010111011011111011111 from address 11110 (from port 1) during cycle 155 (775ns - 780ns)
*	Writing 000110100001001001010010110011000111100011001010110001111101011010111001110010101001111100100110  to  address 00000 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 000110100001001001010010110011000111100011001010110001111101011010111001110010101001111100100110 from address 00000 (from port 1) during cycle 157 (785ns - 790ns)
*	Writing 110011001111001011001111100111111111010000000011100111000100000100001101010001101001001100001101  to  address 11110 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 111101111011110111110110110101101101001011101101111100010000001100001010010011101000110110100000  to  address 11110 (from port 0) during cycle 159 (795ns - 800ns)
*	Writing (partial) 011101010000000111101101001100001100001001111001001101111111101101101010001101001101110001110101  to  address 11110 with mask bit 010 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 111101111011110111110110110101101100001001111001001101111111101100001010010011101000110110100000 from address 11110 (from port 1) during cycle 161 (805ns - 810ns)
*	Writing 101111100100001111100110000000110100011001001000100101101100010100010011101000110000111011010010  to  address 00000 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 101111100100001111100110000000110100011001001000100101101100010100010011101000110000111011010010 from address 00000 (from port 1) during cycle 164 (820ns - 825ns)
*	Writing (partial) 110111010100110011101000101110100100111110100010101110101011011101001100111100011100001101001000  to  address 00000 with mask bit 010 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 111101111011110111110110110101101100001001111001001101111111101100001010010011101000110110100000 from address 11110 (from port 1) during cycle 165 (825ns - 830ns)
*	Writing 001000000011000011010110100010001000111000000110111001110101111000001100100100011111110000011100  to  address 00000 (from port 0) during cycle 166 (830ns - 835ns)
*	Writing (partial) 111101110111010110101010100101101001111100011000001110011100101111010110111010001001111010010000  to  address 11110 with mask bit 010 (from port 0) during cycle 169 (845ns - 850ns)
*	Writing 110110101011010100110101101100001111011100010010111010011000011101000101100101001110100111110011  to  address 00000 (from port 0) during cycle 171 (855ns - 860ns)
*	Writing (partial) 111111010000110011100010010010010101011111000100010110010010101001110011100000111100010000000111  to  address 00000 with mask bit 010 (from port 0) during cycle 173 (865ns - 870ns)
*	Writing (partial) 001110111011001000101011001101110100111111100010111101110000010011110010010001101110001111111011  to  address 11110 with mask bit 001 (from port 0) during cycle 174 (870ns - 875ns)
*	Writing (partial) 110011010010111101111011010110010100111101110110010100001101110000010110011000101111010010110010  to  address 11110 with mask bit 100 (from port 0) during cycle 175 (875ns - 880ns)
*	Writing 001100110010111011110111111110110001111101011011000010011100001001110011001011011000000000011010  to  address 00000 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing 100100001001010011101111111010100010101100111011101101100100010101010110011100101100110111110110  to  address 00000 (from port 0) during cycle 177 (885ns - 890ns)
*	Reading 110011010010111101111011010110011001111100011000001110011100101111110010010001101110001111111011 from address 11110 (from port 1) during cycle 177 (885ns - 890ns)
*	Writing (partial) 011011000110101011010110010011000001111010000000110101101010000001110110111011000001000011110110  to  address 11110 with mask bit 100 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing (partial) 110101011101010001111101011110101010010111111100000111011101111011100000101001000000101110000100  to  address 11110 with mask bit 011 (from port 0) during cycle 180 (900ns - 905ns)
*	Writing (partial) 001111000010101101000100111111011111011111111100110000000011000100011100000110001000000110001100  to  address 00000 with mask bit 100 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 000110111110100010110101011100011011100010010011011111111111011100101100011001010110011001110101  to  address 00000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 011011000110101011010110010011001010010111111100000111011101111011100000101001000000101110000100 from address 11110 (from port 1) during cycle 182 (910ns - 915ns)
*	Writing 111100110100001111000100011100101100111111110100010000011111100001101011001100011000111101111000  to  address 11110 (from port 0) during cycle 183 (915ns - 920ns)
*	Reading 111100110100001111000100011100101100111111110100010000011111100001101011001100011000111101111000 from address 11110 (from port 1) during cycle 184 (920ns - 925ns)
*	Writing (partial) 010110100101111011100111001100110011010111011110011011111001110000010001101111001001000011100011  to  address 11110 with mask bit 101 (from port 0) during cycle 185 (925ns - 930ns)
*	Writing (partial) 100111011111101011101111111111111111100000110111101000000100111101111110011111100011010011110111  to  address 00000 with mask bit 100 (from port 0) during cycle 186 (930ns - 935ns)
*	Writing (partial) 011001001010100110010110110010000100010000010011010110001000100110000101010111001110110011101101  to  address 11110 with mask bit 010 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 100000010100110111000111011100100100010101110000011010011011000111111010101101111000101101101101  to  address 11110 (from port 0) during cycle 188 (940ns - 945ns)
*	Writing (partial) 010100000000101111010101100110110011000111100110100101001001001110100001011000010001111100110000  to  address 00000 with mask bit 001 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 101011110011011001111001100011010111110110101000010111001100011010000011100010111011111100010000  to  address 11110 (from port 0) during cycle 192 (960ns - 965ns)
*	Writing 111111011100100101000101111100010100110100011110110101001000101110100111000110001110010101100000  to  address 11110 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 111111011100100101000101111100010100110100011110110101001000101110100111000110001110010101100000 from address 11110 (from port 1) during cycle 195 (975ns - 980ns)
*	Writing (partial) 001000101010001011001110011110100111100111011111101011111110111101001001000000000100110001110011  to  address 00000 with mask bit 011 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 111111011100100101000101111100010100110100011110110101001000101110100111000110001110010101100000 from address 11110 (from port 1) during cycle 196 (980ns - 985ns)
*	Writing (partial) 111011001011000010000010000000001010110011100110001111011001000100110011100000001110100011110001  to  address 00000 with mask bit 011 (from port 0) during cycle 197 (985ns - 990ns)
*	Writing 001101011110010100101110000000110101111110110000011011000000001001000011010010100010010101010101  to  address 00000 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 111111011100100101000101111100010100110100011110110101001000101110100111000110001110010101100000 from address 11110 (from port 1) during cycle 201 (1005ns - 1010ns)
*	Writing 100010100000100100010000101001001101111110011110100110000011000010100011001000110010110111000011  to  address 11110 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Writing 010111110001010011110111110010111011011000110111101011000001001000011100010011111100110111010000  to  address 00000 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 100010100000100100010000101001001101111110011110100110000011000010100011001000110010110111000011 from address 11110 (from port 1) during cycle 203 (1015ns - 1020ns)
*	Writing 100011100010100011100100110000010001110110001111111101000101101111110011101000011001000101101111  to  address 00000 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_80  din0_80  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_81  din0_81  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_82  din0_82  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_83  din0_83  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_84  din0_84  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_85  din0_85  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_86  din0_86  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_87  din0_87  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_88  din0_88  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_89  din0_89  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_90  din0_90  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_91  din0_91  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_92  din0_92  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_93  din0_93  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_94  din0_94  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_95  din0_95  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_4  a1_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 1), (340, 0), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 0), (520, 1), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0.9 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0.9 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0.9 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0.9 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0.9 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0.9 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0.9 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0.9 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0.9 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0.9 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0.9 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0.9 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0.9 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0.9 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0.9 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0.9 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0.9 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0.9 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0.9 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0.9 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0.9 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0.9 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0.9 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0.9 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0.9 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0.9 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0.9 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0.9 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_64 Vdout1_64ck4 = 0 time = 25
.meas tran vdout1_64ck4 FIND v(dout1_64) AT=25.025n

* CHECK dout1_65 Vdout1_65ck4 = 0 time = 25
.meas tran vdout1_65ck4 FIND v(dout1_65) AT=25.025n

* CHECK dout1_66 Vdout1_66ck4 = 0.9 time = 25
.meas tran vdout1_66ck4 FIND v(dout1_66) AT=25.025n

* CHECK dout1_67 Vdout1_67ck4 = 0 time = 25
.meas tran vdout1_67ck4 FIND v(dout1_67) AT=25.025n

* CHECK dout1_68 Vdout1_68ck4 = 0.9 time = 25
.meas tran vdout1_68ck4 FIND v(dout1_68) AT=25.025n

* CHECK dout1_69 Vdout1_69ck4 = 0.9 time = 25
.meas tran vdout1_69ck4 FIND v(dout1_69) AT=25.025n

* CHECK dout1_70 Vdout1_70ck4 = 0.9 time = 25
.meas tran vdout1_70ck4 FIND v(dout1_70) AT=25.025n

* CHECK dout1_71 Vdout1_71ck4 = 0.9 time = 25
.meas tran vdout1_71ck4 FIND v(dout1_71) AT=25.025n

* CHECK dout1_72 Vdout1_72ck4 = 0 time = 25
.meas tran vdout1_72ck4 FIND v(dout1_72) AT=25.025n

* CHECK dout1_73 Vdout1_73ck4 = 0 time = 25
.meas tran vdout1_73ck4 FIND v(dout1_73) AT=25.025n

* CHECK dout1_74 Vdout1_74ck4 = 0 time = 25
.meas tran vdout1_74ck4 FIND v(dout1_74) AT=25.025n

* CHECK dout1_75 Vdout1_75ck4 = 0.9 time = 25
.meas tran vdout1_75ck4 FIND v(dout1_75) AT=25.025n

* CHECK dout1_76 Vdout1_76ck4 = 0 time = 25
.meas tran vdout1_76ck4 FIND v(dout1_76) AT=25.025n

* CHECK dout1_77 Vdout1_77ck4 = 0.9 time = 25
.meas tran vdout1_77ck4 FIND v(dout1_77) AT=25.025n

* CHECK dout1_78 Vdout1_78ck4 = 0.9 time = 25
.meas tran vdout1_78ck4 FIND v(dout1_78) AT=25.025n

* CHECK dout1_79 Vdout1_79ck4 = 0.9 time = 25
.meas tran vdout1_79ck4 FIND v(dout1_79) AT=25.025n

* CHECK dout1_80 Vdout1_80ck4 = 0.9 time = 25
.meas tran vdout1_80ck4 FIND v(dout1_80) AT=25.025n

* CHECK dout1_81 Vdout1_81ck4 = 0.9 time = 25
.meas tran vdout1_81ck4 FIND v(dout1_81) AT=25.025n

* CHECK dout1_82 Vdout1_82ck4 = 0.9 time = 25
.meas tran vdout1_82ck4 FIND v(dout1_82) AT=25.025n

* CHECK dout1_83 Vdout1_83ck4 = 0 time = 25
.meas tran vdout1_83ck4 FIND v(dout1_83) AT=25.025n

* CHECK dout1_84 Vdout1_84ck4 = 0 time = 25
.meas tran vdout1_84ck4 FIND v(dout1_84) AT=25.025n

* CHECK dout1_85 Vdout1_85ck4 = 0.9 time = 25
.meas tran vdout1_85ck4 FIND v(dout1_85) AT=25.025n

* CHECK dout1_86 Vdout1_86ck4 = 0 time = 25
.meas tran vdout1_86ck4 FIND v(dout1_86) AT=25.025n

* CHECK dout1_87 Vdout1_87ck4 = 0.9 time = 25
.meas tran vdout1_87ck4 FIND v(dout1_87) AT=25.025n

* CHECK dout1_88 Vdout1_88ck4 = 0 time = 25
.meas tran vdout1_88ck4 FIND v(dout1_88) AT=25.025n

* CHECK dout1_89 Vdout1_89ck4 = 0 time = 25
.meas tran vdout1_89ck4 FIND v(dout1_89) AT=25.025n

* CHECK dout1_90 Vdout1_90ck4 = 0.9 time = 25
.meas tran vdout1_90ck4 FIND v(dout1_90) AT=25.025n

* CHECK dout1_91 Vdout1_91ck4 = 0 time = 25
.meas tran vdout1_91ck4 FIND v(dout1_91) AT=25.025n

* CHECK dout1_92 Vdout1_92ck4 = 0.9 time = 25
.meas tran vdout1_92ck4 FIND v(dout1_92) AT=25.025n

* CHECK dout1_93 Vdout1_93ck4 = 0 time = 25
.meas tran vdout1_93ck4 FIND v(dout1_93) AT=25.025n

* CHECK dout1_94 Vdout1_94ck4 = 0.9 time = 25
.meas tran vdout1_94ck4 FIND v(dout1_94) AT=25.025n

* CHECK dout1_95 Vdout1_95ck4 = 0.9 time = 25
.meas tran vdout1_95ck4 FIND v(dout1_95) AT=25.025n

* CHECK dout1_0 Vdout1_0ck5 = 0 time = 30
.meas tran vdout1_0ck5 FIND v(dout1_0) AT=30.025n

* CHECK dout1_1 Vdout1_1ck5 = 0.9 time = 30
.meas tran vdout1_1ck5 FIND v(dout1_1) AT=30.025n

* CHECK dout1_2 Vdout1_2ck5 = 0 time = 30
.meas tran vdout1_2ck5 FIND v(dout1_2) AT=30.025n

* CHECK dout1_3 Vdout1_3ck5 = 0.9 time = 30
.meas tran vdout1_3ck5 FIND v(dout1_3) AT=30.025n

* CHECK dout1_4 Vdout1_4ck5 = 0 time = 30
.meas tran vdout1_4ck5 FIND v(dout1_4) AT=30.025n

* CHECK dout1_5 Vdout1_5ck5 = 0.9 time = 30
.meas tran vdout1_5ck5 FIND v(dout1_5) AT=30.025n

* CHECK dout1_6 Vdout1_6ck5 = 0.9 time = 30
.meas tran vdout1_6ck5 FIND v(dout1_6) AT=30.025n

* CHECK dout1_7 Vdout1_7ck5 = 0.9 time = 30
.meas tran vdout1_7ck5 FIND v(dout1_7) AT=30.025n

* CHECK dout1_8 Vdout1_8ck5 = 0.9 time = 30
.meas tran vdout1_8ck5 FIND v(dout1_8) AT=30.025n

* CHECK dout1_9 Vdout1_9ck5 = 0 time = 30
.meas tran vdout1_9ck5 FIND v(dout1_9) AT=30.025n

* CHECK dout1_10 Vdout1_10ck5 = 0 time = 30
.meas tran vdout1_10ck5 FIND v(dout1_10) AT=30.025n

* CHECK dout1_11 Vdout1_11ck5 = 0.9 time = 30
.meas tran vdout1_11ck5 FIND v(dout1_11) AT=30.025n

* CHECK dout1_12 Vdout1_12ck5 = 0.9 time = 30
.meas tran vdout1_12ck5 FIND v(dout1_12) AT=30.025n

* CHECK dout1_13 Vdout1_13ck5 = 0 time = 30
.meas tran vdout1_13ck5 FIND v(dout1_13) AT=30.025n

* CHECK dout1_14 Vdout1_14ck5 = 0.9 time = 30
.meas tran vdout1_14ck5 FIND v(dout1_14) AT=30.025n

* CHECK dout1_15 Vdout1_15ck5 = 0 time = 30
.meas tran vdout1_15ck5 FIND v(dout1_15) AT=30.025n

* CHECK dout1_16 Vdout1_16ck5 = 0 time = 30
.meas tran vdout1_16ck5 FIND v(dout1_16) AT=30.025n

* CHECK dout1_17 Vdout1_17ck5 = 0 time = 30
.meas tran vdout1_17ck5 FIND v(dout1_17) AT=30.025n

* CHECK dout1_18 Vdout1_18ck5 = 0.9 time = 30
.meas tran vdout1_18ck5 FIND v(dout1_18) AT=30.025n

* CHECK dout1_19 Vdout1_19ck5 = 0.9 time = 30
.meas tran vdout1_19ck5 FIND v(dout1_19) AT=30.025n

* CHECK dout1_20 Vdout1_20ck5 = 0 time = 30
.meas tran vdout1_20ck5 FIND v(dout1_20) AT=30.025n

* CHECK dout1_21 Vdout1_21ck5 = 0 time = 30
.meas tran vdout1_21ck5 FIND v(dout1_21) AT=30.025n

* CHECK dout1_22 Vdout1_22ck5 = 0.9 time = 30
.meas tran vdout1_22ck5 FIND v(dout1_22) AT=30.025n

* CHECK dout1_23 Vdout1_23ck5 = 0 time = 30
.meas tran vdout1_23ck5 FIND v(dout1_23) AT=30.025n

* CHECK dout1_24 Vdout1_24ck5 = 0 time = 30
.meas tran vdout1_24ck5 FIND v(dout1_24) AT=30.025n

* CHECK dout1_25 Vdout1_25ck5 = 0.9 time = 30
.meas tran vdout1_25ck5 FIND v(dout1_25) AT=30.025n

* CHECK dout1_26 Vdout1_26ck5 = 0 time = 30
.meas tran vdout1_26ck5 FIND v(dout1_26) AT=30.025n

* CHECK dout1_27 Vdout1_27ck5 = 0.9 time = 30
.meas tran vdout1_27ck5 FIND v(dout1_27) AT=30.025n

* CHECK dout1_28 Vdout1_28ck5 = 0 time = 30
.meas tran vdout1_28ck5 FIND v(dout1_28) AT=30.025n

* CHECK dout1_29 Vdout1_29ck5 = 0.9 time = 30
.meas tran vdout1_29ck5 FIND v(dout1_29) AT=30.025n

* CHECK dout1_30 Vdout1_30ck5 = 0.9 time = 30
.meas tran vdout1_30ck5 FIND v(dout1_30) AT=30.025n

* CHECK dout1_31 Vdout1_31ck5 = 0 time = 30
.meas tran vdout1_31ck5 FIND v(dout1_31) AT=30.025n

* CHECK dout1_32 Vdout1_32ck5 = 0.9 time = 30
.meas tran vdout1_32ck5 FIND v(dout1_32) AT=30.025n

* CHECK dout1_33 Vdout1_33ck5 = 0 time = 30
.meas tran vdout1_33ck5 FIND v(dout1_33) AT=30.025n

* CHECK dout1_34 Vdout1_34ck5 = 0 time = 30
.meas tran vdout1_34ck5 FIND v(dout1_34) AT=30.025n

* CHECK dout1_35 Vdout1_35ck5 = 0 time = 30
.meas tran vdout1_35ck5 FIND v(dout1_35) AT=30.025n

* CHECK dout1_36 Vdout1_36ck5 = 0.9 time = 30
.meas tran vdout1_36ck5 FIND v(dout1_36) AT=30.025n

* CHECK dout1_37 Vdout1_37ck5 = 0.9 time = 30
.meas tran vdout1_37ck5 FIND v(dout1_37) AT=30.025n

* CHECK dout1_38 Vdout1_38ck5 = 0 time = 30
.meas tran vdout1_38ck5 FIND v(dout1_38) AT=30.025n

* CHECK dout1_39 Vdout1_39ck5 = 0 time = 30
.meas tran vdout1_39ck5 FIND v(dout1_39) AT=30.025n

* CHECK dout1_40 Vdout1_40ck5 = 0 time = 30
.meas tran vdout1_40ck5 FIND v(dout1_40) AT=30.025n

* CHECK dout1_41 Vdout1_41ck5 = 0.9 time = 30
.meas tran vdout1_41ck5 FIND v(dout1_41) AT=30.025n

* CHECK dout1_42 Vdout1_42ck5 = 0 time = 30
.meas tran vdout1_42ck5 FIND v(dout1_42) AT=30.025n

* CHECK dout1_43 Vdout1_43ck5 = 0.9 time = 30
.meas tran vdout1_43ck5 FIND v(dout1_43) AT=30.025n

* CHECK dout1_44 Vdout1_44ck5 = 0.9 time = 30
.meas tran vdout1_44ck5 FIND v(dout1_44) AT=30.025n

* CHECK dout1_45 Vdout1_45ck5 = 0 time = 30
.meas tran vdout1_45ck5 FIND v(dout1_45) AT=30.025n

* CHECK dout1_46 Vdout1_46ck5 = 0 time = 30
.meas tran vdout1_46ck5 FIND v(dout1_46) AT=30.025n

* CHECK dout1_47 Vdout1_47ck5 = 0.9 time = 30
.meas tran vdout1_47ck5 FIND v(dout1_47) AT=30.025n

* CHECK dout1_48 Vdout1_48ck5 = 0 time = 30
.meas tran vdout1_48ck5 FIND v(dout1_48) AT=30.025n

* CHECK dout1_49 Vdout1_49ck5 = 0 time = 30
.meas tran vdout1_49ck5 FIND v(dout1_49) AT=30.025n

* CHECK dout1_50 Vdout1_50ck5 = 0.9 time = 30
.meas tran vdout1_50ck5 FIND v(dout1_50) AT=30.025n

* CHECK dout1_51 Vdout1_51ck5 = 0.9 time = 30
.meas tran vdout1_51ck5 FIND v(dout1_51) AT=30.025n

* CHECK dout1_52 Vdout1_52ck5 = 0 time = 30
.meas tran vdout1_52ck5 FIND v(dout1_52) AT=30.025n

* CHECK dout1_53 Vdout1_53ck5 = 0 time = 30
.meas tran vdout1_53ck5 FIND v(dout1_53) AT=30.025n

* CHECK dout1_54 Vdout1_54ck5 = 0 time = 30
.meas tran vdout1_54ck5 FIND v(dout1_54) AT=30.025n

* CHECK dout1_55 Vdout1_55ck5 = 0 time = 30
.meas tran vdout1_55ck5 FIND v(dout1_55) AT=30.025n

* CHECK dout1_56 Vdout1_56ck5 = 0 time = 30
.meas tran vdout1_56ck5 FIND v(dout1_56) AT=30.025n

* CHECK dout1_57 Vdout1_57ck5 = 0 time = 30
.meas tran vdout1_57ck5 FIND v(dout1_57) AT=30.025n

* CHECK dout1_58 Vdout1_58ck5 = 0.9 time = 30
.meas tran vdout1_58ck5 FIND v(dout1_58) AT=30.025n

* CHECK dout1_59 Vdout1_59ck5 = 0 time = 30
.meas tran vdout1_59ck5 FIND v(dout1_59) AT=30.025n

* CHECK dout1_60 Vdout1_60ck5 = 0 time = 30
.meas tran vdout1_60ck5 FIND v(dout1_60) AT=30.025n

* CHECK dout1_61 Vdout1_61ck5 = 0 time = 30
.meas tran vdout1_61ck5 FIND v(dout1_61) AT=30.025n

* CHECK dout1_62 Vdout1_62ck5 = 0 time = 30
.meas tran vdout1_62ck5 FIND v(dout1_62) AT=30.025n

* CHECK dout1_63 Vdout1_63ck5 = 0.9 time = 30
.meas tran vdout1_63ck5 FIND v(dout1_63) AT=30.025n

* CHECK dout1_64 Vdout1_64ck5 = 0 time = 30
.meas tran vdout1_64ck5 FIND v(dout1_64) AT=30.025n

* CHECK dout1_65 Vdout1_65ck5 = 0 time = 30
.meas tran vdout1_65ck5 FIND v(dout1_65) AT=30.025n

* CHECK dout1_66 Vdout1_66ck5 = 0.9 time = 30
.meas tran vdout1_66ck5 FIND v(dout1_66) AT=30.025n

* CHECK dout1_67 Vdout1_67ck5 = 0.9 time = 30
.meas tran vdout1_67ck5 FIND v(dout1_67) AT=30.025n

* CHECK dout1_68 Vdout1_68ck5 = 0.9 time = 30
.meas tran vdout1_68ck5 FIND v(dout1_68) AT=30.025n

* CHECK dout1_69 Vdout1_69ck5 = 0.9 time = 30
.meas tran vdout1_69ck5 FIND v(dout1_69) AT=30.025n

* CHECK dout1_70 Vdout1_70ck5 = 0 time = 30
.meas tran vdout1_70ck5 FIND v(dout1_70) AT=30.025n

* CHECK dout1_71 Vdout1_71ck5 = 0.9 time = 30
.meas tran vdout1_71ck5 FIND v(dout1_71) AT=30.025n

* CHECK dout1_72 Vdout1_72ck5 = 0 time = 30
.meas tran vdout1_72ck5 FIND v(dout1_72) AT=30.025n

* CHECK dout1_73 Vdout1_73ck5 = 0 time = 30
.meas tran vdout1_73ck5 FIND v(dout1_73) AT=30.025n

* CHECK dout1_74 Vdout1_74ck5 = 0 time = 30
.meas tran vdout1_74ck5 FIND v(dout1_74) AT=30.025n

* CHECK dout1_75 Vdout1_75ck5 = 0.9 time = 30
.meas tran vdout1_75ck5 FIND v(dout1_75) AT=30.025n

* CHECK dout1_76 Vdout1_76ck5 = 0 time = 30
.meas tran vdout1_76ck5 FIND v(dout1_76) AT=30.025n

* CHECK dout1_77 Vdout1_77ck5 = 0.9 time = 30
.meas tran vdout1_77ck5 FIND v(dout1_77) AT=30.025n

* CHECK dout1_78 Vdout1_78ck5 = 0.9 time = 30
.meas tran vdout1_78ck5 FIND v(dout1_78) AT=30.025n

* CHECK dout1_79 Vdout1_79ck5 = 0 time = 30
.meas tran vdout1_79ck5 FIND v(dout1_79) AT=30.025n

* CHECK dout1_80 Vdout1_80ck5 = 0.9 time = 30
.meas tran vdout1_80ck5 FIND v(dout1_80) AT=30.025n

* CHECK dout1_81 Vdout1_81ck5 = 0.9 time = 30
.meas tran vdout1_81ck5 FIND v(dout1_81) AT=30.025n

* CHECK dout1_82 Vdout1_82ck5 = 0.9 time = 30
.meas tran vdout1_82ck5 FIND v(dout1_82) AT=30.025n

* CHECK dout1_83 Vdout1_83ck5 = 0.9 time = 30
.meas tran vdout1_83ck5 FIND v(dout1_83) AT=30.025n

* CHECK dout1_84 Vdout1_84ck5 = 0 time = 30
.meas tran vdout1_84ck5 FIND v(dout1_84) AT=30.025n

* CHECK dout1_85 Vdout1_85ck5 = 0 time = 30
.meas tran vdout1_85ck5 FIND v(dout1_85) AT=30.025n

* CHECK dout1_86 Vdout1_86ck5 = 0 time = 30
.meas tran vdout1_86ck5 FIND v(dout1_86) AT=30.025n

* CHECK dout1_87 Vdout1_87ck5 = 0 time = 30
.meas tran vdout1_87ck5 FIND v(dout1_87) AT=30.025n

* CHECK dout1_88 Vdout1_88ck5 = 0 time = 30
.meas tran vdout1_88ck5 FIND v(dout1_88) AT=30.025n

* CHECK dout1_89 Vdout1_89ck5 = 0.9 time = 30
.meas tran vdout1_89ck5 FIND v(dout1_89) AT=30.025n

* CHECK dout1_90 Vdout1_90ck5 = 0 time = 30
.meas tran vdout1_90ck5 FIND v(dout1_90) AT=30.025n

* CHECK dout1_91 Vdout1_91ck5 = 0 time = 30
.meas tran vdout1_91ck5 FIND v(dout1_91) AT=30.025n

* CHECK dout1_92 Vdout1_92ck5 = 0 time = 30
.meas tran vdout1_92ck5 FIND v(dout1_92) AT=30.025n

* CHECK dout1_93 Vdout1_93ck5 = 0 time = 30
.meas tran vdout1_93ck5 FIND v(dout1_93) AT=30.025n

* CHECK dout1_94 Vdout1_94ck5 = 0.9 time = 30
.meas tran vdout1_94ck5 FIND v(dout1_94) AT=30.025n

* CHECK dout1_95 Vdout1_95ck5 = 0.9 time = 30
.meas tran vdout1_95ck5 FIND v(dout1_95) AT=30.025n

* CHECK dout1_0 Vdout1_0ck11 = 0 time = 60
.meas tran vdout1_0ck11 FIND v(dout1_0) AT=60.025n

* CHECK dout1_1 Vdout1_1ck11 = 0.9 time = 60
.meas tran vdout1_1ck11 FIND v(dout1_1) AT=60.025n

* CHECK dout1_2 Vdout1_2ck11 = 0 time = 60
.meas tran vdout1_2ck11 FIND v(dout1_2) AT=60.025n

* CHECK dout1_3 Vdout1_3ck11 = 0 time = 60
.meas tran vdout1_3ck11 FIND v(dout1_3) AT=60.025n

* CHECK dout1_4 Vdout1_4ck11 = 0.9 time = 60
.meas tran vdout1_4ck11 FIND v(dout1_4) AT=60.025n

* CHECK dout1_5 Vdout1_5ck11 = 0.9 time = 60
.meas tran vdout1_5ck11 FIND v(dout1_5) AT=60.025n

* CHECK dout1_6 Vdout1_6ck11 = 0.9 time = 60
.meas tran vdout1_6ck11 FIND v(dout1_6) AT=60.025n

* CHECK dout1_7 Vdout1_7ck11 = 0 time = 60
.meas tran vdout1_7ck11 FIND v(dout1_7) AT=60.025n

* CHECK dout1_8 Vdout1_8ck11 = 0 time = 60
.meas tran vdout1_8ck11 FIND v(dout1_8) AT=60.025n

* CHECK dout1_9 Vdout1_9ck11 = 0 time = 60
.meas tran vdout1_9ck11 FIND v(dout1_9) AT=60.025n

* CHECK dout1_10 Vdout1_10ck11 = 0.9 time = 60
.meas tran vdout1_10ck11 FIND v(dout1_10) AT=60.025n

* CHECK dout1_11 Vdout1_11ck11 = 0 time = 60
.meas tran vdout1_11ck11 FIND v(dout1_11) AT=60.025n

* CHECK dout1_12 Vdout1_12ck11 = 0.9 time = 60
.meas tran vdout1_12ck11 FIND v(dout1_12) AT=60.025n

* CHECK dout1_13 Vdout1_13ck11 = 0 time = 60
.meas tran vdout1_13ck11 FIND v(dout1_13) AT=60.025n

* CHECK dout1_14 Vdout1_14ck11 = 0.9 time = 60
.meas tran vdout1_14ck11 FIND v(dout1_14) AT=60.025n

* CHECK dout1_15 Vdout1_15ck11 = 0 time = 60
.meas tran vdout1_15ck11 FIND v(dout1_15) AT=60.025n

* CHECK dout1_16 Vdout1_16ck11 = 0.9 time = 60
.meas tran vdout1_16ck11 FIND v(dout1_16) AT=60.025n

* CHECK dout1_17 Vdout1_17ck11 = 0 time = 60
.meas tran vdout1_17ck11 FIND v(dout1_17) AT=60.025n

* CHECK dout1_18 Vdout1_18ck11 = 0 time = 60
.meas tran vdout1_18ck11 FIND v(dout1_18) AT=60.025n

* CHECK dout1_19 Vdout1_19ck11 = 0 time = 60
.meas tran vdout1_19ck11 FIND v(dout1_19) AT=60.025n

* CHECK dout1_20 Vdout1_20ck11 = 0.9 time = 60
.meas tran vdout1_20ck11 FIND v(dout1_20) AT=60.025n

* CHECK dout1_21 Vdout1_21ck11 = 0 time = 60
.meas tran vdout1_21ck11 FIND v(dout1_21) AT=60.025n

* CHECK dout1_22 Vdout1_22ck11 = 0.9 time = 60
.meas tran vdout1_22ck11 FIND v(dout1_22) AT=60.025n

* CHECK dout1_23 Vdout1_23ck11 = 0.9 time = 60
.meas tran vdout1_23ck11 FIND v(dout1_23) AT=60.025n

* CHECK dout1_24 Vdout1_24ck11 = 0.9 time = 60
.meas tran vdout1_24ck11 FIND v(dout1_24) AT=60.025n

* CHECK dout1_25 Vdout1_25ck11 = 0.9 time = 60
.meas tran vdout1_25ck11 FIND v(dout1_25) AT=60.025n

* CHECK dout1_26 Vdout1_26ck11 = 0 time = 60
.meas tran vdout1_26ck11 FIND v(dout1_26) AT=60.025n

* CHECK dout1_27 Vdout1_27ck11 = 0 time = 60
.meas tran vdout1_27ck11 FIND v(dout1_27) AT=60.025n

* CHECK dout1_28 Vdout1_28ck11 = 0 time = 60
.meas tran vdout1_28ck11 FIND v(dout1_28) AT=60.025n

* CHECK dout1_29 Vdout1_29ck11 = 0 time = 60
.meas tran vdout1_29ck11 FIND v(dout1_29) AT=60.025n

* CHECK dout1_30 Vdout1_30ck11 = 0 time = 60
.meas tran vdout1_30ck11 FIND v(dout1_30) AT=60.025n

* CHECK dout1_31 Vdout1_31ck11 = 0.9 time = 60
.meas tran vdout1_31ck11 FIND v(dout1_31) AT=60.025n

* CHECK dout1_32 Vdout1_32ck11 = 0.9 time = 60
.meas tran vdout1_32ck11 FIND v(dout1_32) AT=60.025n

* CHECK dout1_33 Vdout1_33ck11 = 0 time = 60
.meas tran vdout1_33ck11 FIND v(dout1_33) AT=60.025n

* CHECK dout1_34 Vdout1_34ck11 = 0 time = 60
.meas tran vdout1_34ck11 FIND v(dout1_34) AT=60.025n

* CHECK dout1_35 Vdout1_35ck11 = 0.9 time = 60
.meas tran vdout1_35ck11 FIND v(dout1_35) AT=60.025n

* CHECK dout1_36 Vdout1_36ck11 = 0.9 time = 60
.meas tran vdout1_36ck11 FIND v(dout1_36) AT=60.025n

* CHECK dout1_37 Vdout1_37ck11 = 0.9 time = 60
.meas tran vdout1_37ck11 FIND v(dout1_37) AT=60.025n

* CHECK dout1_38 Vdout1_38ck11 = 0 time = 60
.meas tran vdout1_38ck11 FIND v(dout1_38) AT=60.025n

* CHECK dout1_39 Vdout1_39ck11 = 0.9 time = 60
.meas tran vdout1_39ck11 FIND v(dout1_39) AT=60.025n

* CHECK dout1_40 Vdout1_40ck11 = 0.9 time = 60
.meas tran vdout1_40ck11 FIND v(dout1_40) AT=60.025n

* CHECK dout1_41 Vdout1_41ck11 = 0 time = 60
.meas tran vdout1_41ck11 FIND v(dout1_41) AT=60.025n

* CHECK dout1_42 Vdout1_42ck11 = 0.9 time = 60
.meas tran vdout1_42ck11 FIND v(dout1_42) AT=60.025n

* CHECK dout1_43 Vdout1_43ck11 = 0 time = 60
.meas tran vdout1_43ck11 FIND v(dout1_43) AT=60.025n

* CHECK dout1_44 Vdout1_44ck11 = 0.9 time = 60
.meas tran vdout1_44ck11 FIND v(dout1_44) AT=60.025n

* CHECK dout1_45 Vdout1_45ck11 = 0.9 time = 60
.meas tran vdout1_45ck11 FIND v(dout1_45) AT=60.025n

* CHECK dout1_46 Vdout1_46ck11 = 0.9 time = 60
.meas tran vdout1_46ck11 FIND v(dout1_46) AT=60.025n

* CHECK dout1_47 Vdout1_47ck11 = 0 time = 60
.meas tran vdout1_47ck11 FIND v(dout1_47) AT=60.025n

* CHECK dout1_48 Vdout1_48ck11 = 0 time = 60
.meas tran vdout1_48ck11 FIND v(dout1_48) AT=60.025n

* CHECK dout1_49 Vdout1_49ck11 = 0 time = 60
.meas tran vdout1_49ck11 FIND v(dout1_49) AT=60.025n

* CHECK dout1_50 Vdout1_50ck11 = 0 time = 60
.meas tran vdout1_50ck11 FIND v(dout1_50) AT=60.025n

* CHECK dout1_51 Vdout1_51ck11 = 0 time = 60
.meas tran vdout1_51ck11 FIND v(dout1_51) AT=60.025n

* CHECK dout1_52 Vdout1_52ck11 = 0.9 time = 60
.meas tran vdout1_52ck11 FIND v(dout1_52) AT=60.025n

* CHECK dout1_53 Vdout1_53ck11 = 0.9 time = 60
.meas tran vdout1_53ck11 FIND v(dout1_53) AT=60.025n

* CHECK dout1_54 Vdout1_54ck11 = 0 time = 60
.meas tran vdout1_54ck11 FIND v(dout1_54) AT=60.025n

* CHECK dout1_55 Vdout1_55ck11 = 0 time = 60
.meas tran vdout1_55ck11 FIND v(dout1_55) AT=60.025n

* CHECK dout1_56 Vdout1_56ck11 = 0 time = 60
.meas tran vdout1_56ck11 FIND v(dout1_56) AT=60.025n

* CHECK dout1_57 Vdout1_57ck11 = 0 time = 60
.meas tran vdout1_57ck11 FIND v(dout1_57) AT=60.025n

* CHECK dout1_58 Vdout1_58ck11 = 0 time = 60
.meas tran vdout1_58ck11 FIND v(dout1_58) AT=60.025n

* CHECK dout1_59 Vdout1_59ck11 = 0 time = 60
.meas tran vdout1_59ck11 FIND v(dout1_59) AT=60.025n

* CHECK dout1_60 Vdout1_60ck11 = 0 time = 60
.meas tran vdout1_60ck11 FIND v(dout1_60) AT=60.025n

* CHECK dout1_61 Vdout1_61ck11 = 0.9 time = 60
.meas tran vdout1_61ck11 FIND v(dout1_61) AT=60.025n

* CHECK dout1_62 Vdout1_62ck11 = 0 time = 60
.meas tran vdout1_62ck11 FIND v(dout1_62) AT=60.025n

* CHECK dout1_63 Vdout1_63ck11 = 0 time = 60
.meas tran vdout1_63ck11 FIND v(dout1_63) AT=60.025n

* CHECK dout1_64 Vdout1_64ck11 = 0 time = 60
.meas tran vdout1_64ck11 FIND v(dout1_64) AT=60.025n

* CHECK dout1_65 Vdout1_65ck11 = 0 time = 60
.meas tran vdout1_65ck11 FIND v(dout1_65) AT=60.025n

* CHECK dout1_66 Vdout1_66ck11 = 0 time = 60
.meas tran vdout1_66ck11 FIND v(dout1_66) AT=60.025n

* CHECK dout1_67 Vdout1_67ck11 = 0 time = 60
.meas tran vdout1_67ck11 FIND v(dout1_67) AT=60.025n

* CHECK dout1_68 Vdout1_68ck11 = 0.9 time = 60
.meas tran vdout1_68ck11 FIND v(dout1_68) AT=60.025n

* CHECK dout1_69 Vdout1_69ck11 = 0 time = 60
.meas tran vdout1_69ck11 FIND v(dout1_69) AT=60.025n

* CHECK dout1_70 Vdout1_70ck11 = 0 time = 60
.meas tran vdout1_70ck11 FIND v(dout1_70) AT=60.025n

* CHECK dout1_71 Vdout1_71ck11 = 0.9 time = 60
.meas tran vdout1_71ck11 FIND v(dout1_71) AT=60.025n

* CHECK dout1_72 Vdout1_72ck11 = 0.9 time = 60
.meas tran vdout1_72ck11 FIND v(dout1_72) AT=60.025n

* CHECK dout1_73 Vdout1_73ck11 = 0 time = 60
.meas tran vdout1_73ck11 FIND v(dout1_73) AT=60.025n

* CHECK dout1_74 Vdout1_74ck11 = 0 time = 60
.meas tran vdout1_74ck11 FIND v(dout1_74) AT=60.025n

* CHECK dout1_75 Vdout1_75ck11 = 0.9 time = 60
.meas tran vdout1_75ck11 FIND v(dout1_75) AT=60.025n

* CHECK dout1_76 Vdout1_76ck11 = 0 time = 60
.meas tran vdout1_76ck11 FIND v(dout1_76) AT=60.025n

* CHECK dout1_77 Vdout1_77ck11 = 0.9 time = 60
.meas tran vdout1_77ck11 FIND v(dout1_77) AT=60.025n

* CHECK dout1_78 Vdout1_78ck11 = 0 time = 60
.meas tran vdout1_78ck11 FIND v(dout1_78) AT=60.025n

* CHECK dout1_79 Vdout1_79ck11 = 0 time = 60
.meas tran vdout1_79ck11 FIND v(dout1_79) AT=60.025n

* CHECK dout1_80 Vdout1_80ck11 = 0.9 time = 60
.meas tran vdout1_80ck11 FIND v(dout1_80) AT=60.025n

* CHECK dout1_81 Vdout1_81ck11 = 0.9 time = 60
.meas tran vdout1_81ck11 FIND v(dout1_81) AT=60.025n

* CHECK dout1_82 Vdout1_82ck11 = 0.9 time = 60
.meas tran vdout1_82ck11 FIND v(dout1_82) AT=60.025n

* CHECK dout1_83 Vdout1_83ck11 = 0 time = 60
.meas tran vdout1_83ck11 FIND v(dout1_83) AT=60.025n

* CHECK dout1_84 Vdout1_84ck11 = 0 time = 60
.meas tran vdout1_84ck11 FIND v(dout1_84) AT=60.025n

* CHECK dout1_85 Vdout1_85ck11 = 0.9 time = 60
.meas tran vdout1_85ck11 FIND v(dout1_85) AT=60.025n

* CHECK dout1_86 Vdout1_86ck11 = 0 time = 60
.meas tran vdout1_86ck11 FIND v(dout1_86) AT=60.025n

* CHECK dout1_87 Vdout1_87ck11 = 0 time = 60
.meas tran vdout1_87ck11 FIND v(dout1_87) AT=60.025n

* CHECK dout1_88 Vdout1_88ck11 = 0.9 time = 60
.meas tran vdout1_88ck11 FIND v(dout1_88) AT=60.025n

* CHECK dout1_89 Vdout1_89ck11 = 0 time = 60
.meas tran vdout1_89ck11 FIND v(dout1_89) AT=60.025n

* CHECK dout1_90 Vdout1_90ck11 = 0 time = 60
.meas tran vdout1_90ck11 FIND v(dout1_90) AT=60.025n

* CHECK dout1_91 Vdout1_91ck11 = 0 time = 60
.meas tran vdout1_91ck11 FIND v(dout1_91) AT=60.025n

* CHECK dout1_92 Vdout1_92ck11 = 0 time = 60
.meas tran vdout1_92ck11 FIND v(dout1_92) AT=60.025n

* CHECK dout1_93 Vdout1_93ck11 = 0.9 time = 60
.meas tran vdout1_93ck11 FIND v(dout1_93) AT=60.025n

* CHECK dout1_94 Vdout1_94ck11 = 0 time = 60
.meas tran vdout1_94ck11 FIND v(dout1_94) AT=60.025n

* CHECK dout1_95 Vdout1_95ck11 = 0 time = 60
.meas tran vdout1_95ck11 FIND v(dout1_95) AT=60.025n

* CHECK dout1_0 Vdout1_0ck19 = 0 time = 100
.meas tran vdout1_0ck19 FIND v(dout1_0) AT=100.025n

* CHECK dout1_1 Vdout1_1ck19 = 0 time = 100
.meas tran vdout1_1ck19 FIND v(dout1_1) AT=100.025n

* CHECK dout1_2 Vdout1_2ck19 = 0 time = 100
.meas tran vdout1_2ck19 FIND v(dout1_2) AT=100.025n

* CHECK dout1_3 Vdout1_3ck19 = 0.9 time = 100
.meas tran vdout1_3ck19 FIND v(dout1_3) AT=100.025n

* CHECK dout1_4 Vdout1_4ck19 = 0.9 time = 100
.meas tran vdout1_4ck19 FIND v(dout1_4) AT=100.025n

* CHECK dout1_5 Vdout1_5ck19 = 0 time = 100
.meas tran vdout1_5ck19 FIND v(dout1_5) AT=100.025n

* CHECK dout1_6 Vdout1_6ck19 = 0.9 time = 100
.meas tran vdout1_6ck19 FIND v(dout1_6) AT=100.025n

* CHECK dout1_7 Vdout1_7ck19 = 0 time = 100
.meas tran vdout1_7ck19 FIND v(dout1_7) AT=100.025n

* CHECK dout1_8 Vdout1_8ck19 = 0.9 time = 100
.meas tran vdout1_8ck19 FIND v(dout1_8) AT=100.025n

* CHECK dout1_9 Vdout1_9ck19 = 0.9 time = 100
.meas tran vdout1_9ck19 FIND v(dout1_9) AT=100.025n

* CHECK dout1_10 Vdout1_10ck19 = 0 time = 100
.meas tran vdout1_10ck19 FIND v(dout1_10) AT=100.025n

* CHECK dout1_11 Vdout1_11ck19 = 0.9 time = 100
.meas tran vdout1_11ck19 FIND v(dout1_11) AT=100.025n

* CHECK dout1_12 Vdout1_12ck19 = 0 time = 100
.meas tran vdout1_12ck19 FIND v(dout1_12) AT=100.025n

* CHECK dout1_13 Vdout1_13ck19 = 0 time = 100
.meas tran vdout1_13ck19 FIND v(dout1_13) AT=100.025n

* CHECK dout1_14 Vdout1_14ck19 = 0 time = 100
.meas tran vdout1_14ck19 FIND v(dout1_14) AT=100.025n

* CHECK dout1_15 Vdout1_15ck19 = 0.9 time = 100
.meas tran vdout1_15ck19 FIND v(dout1_15) AT=100.025n

* CHECK dout1_16 Vdout1_16ck19 = 0.9 time = 100
.meas tran vdout1_16ck19 FIND v(dout1_16) AT=100.025n

* CHECK dout1_17 Vdout1_17ck19 = 0 time = 100
.meas tran vdout1_17ck19 FIND v(dout1_17) AT=100.025n

* CHECK dout1_18 Vdout1_18ck19 = 0.9 time = 100
.meas tran vdout1_18ck19 FIND v(dout1_18) AT=100.025n

* CHECK dout1_19 Vdout1_19ck19 = 0.9 time = 100
.meas tran vdout1_19ck19 FIND v(dout1_19) AT=100.025n

* CHECK dout1_20 Vdout1_20ck19 = 0 time = 100
.meas tran vdout1_20ck19 FIND v(dout1_20) AT=100.025n

* CHECK dout1_21 Vdout1_21ck19 = 0.9 time = 100
.meas tran vdout1_21ck19 FIND v(dout1_21) AT=100.025n

* CHECK dout1_22 Vdout1_22ck19 = 0.9 time = 100
.meas tran vdout1_22ck19 FIND v(dout1_22) AT=100.025n

* CHECK dout1_23 Vdout1_23ck19 = 0.9 time = 100
.meas tran vdout1_23ck19 FIND v(dout1_23) AT=100.025n

* CHECK dout1_24 Vdout1_24ck19 = 0.9 time = 100
.meas tran vdout1_24ck19 FIND v(dout1_24) AT=100.025n

* CHECK dout1_25 Vdout1_25ck19 = 0 time = 100
.meas tran vdout1_25ck19 FIND v(dout1_25) AT=100.025n

* CHECK dout1_26 Vdout1_26ck19 = 0 time = 100
.meas tran vdout1_26ck19 FIND v(dout1_26) AT=100.025n

* CHECK dout1_27 Vdout1_27ck19 = 0.9 time = 100
.meas tran vdout1_27ck19 FIND v(dout1_27) AT=100.025n

* CHECK dout1_28 Vdout1_28ck19 = 0 time = 100
.meas tran vdout1_28ck19 FIND v(dout1_28) AT=100.025n

* CHECK dout1_29 Vdout1_29ck19 = 0.9 time = 100
.meas tran vdout1_29ck19 FIND v(dout1_29) AT=100.025n

* CHECK dout1_30 Vdout1_30ck19 = 0 time = 100
.meas tran vdout1_30ck19 FIND v(dout1_30) AT=100.025n

* CHECK dout1_31 Vdout1_31ck19 = 0 time = 100
.meas tran vdout1_31ck19 FIND v(dout1_31) AT=100.025n

* CHECK dout1_32 Vdout1_32ck19 = 0.9 time = 100
.meas tran vdout1_32ck19 FIND v(dout1_32) AT=100.025n

* CHECK dout1_33 Vdout1_33ck19 = 0.9 time = 100
.meas tran vdout1_33ck19 FIND v(dout1_33) AT=100.025n

* CHECK dout1_34 Vdout1_34ck19 = 0.9 time = 100
.meas tran vdout1_34ck19 FIND v(dout1_34) AT=100.025n

* CHECK dout1_35 Vdout1_35ck19 = 0 time = 100
.meas tran vdout1_35ck19 FIND v(dout1_35) AT=100.025n

* CHECK dout1_36 Vdout1_36ck19 = 0.9 time = 100
.meas tran vdout1_36ck19 FIND v(dout1_36) AT=100.025n

* CHECK dout1_37 Vdout1_37ck19 = 0 time = 100
.meas tran vdout1_37ck19 FIND v(dout1_37) AT=100.025n

* CHECK dout1_38 Vdout1_38ck19 = 0 time = 100
.meas tran vdout1_38ck19 FIND v(dout1_38) AT=100.025n

* CHECK dout1_39 Vdout1_39ck19 = 0 time = 100
.meas tran vdout1_39ck19 FIND v(dout1_39) AT=100.025n

* CHECK dout1_40 Vdout1_40ck19 = 0.9 time = 100
.meas tran vdout1_40ck19 FIND v(dout1_40) AT=100.025n

* CHECK dout1_41 Vdout1_41ck19 = 0.9 time = 100
.meas tran vdout1_41ck19 FIND v(dout1_41) AT=100.025n

* CHECK dout1_42 Vdout1_42ck19 = 0 time = 100
.meas tran vdout1_42ck19 FIND v(dout1_42) AT=100.025n

* CHECK dout1_43 Vdout1_43ck19 = 0 time = 100
.meas tran vdout1_43ck19 FIND v(dout1_43) AT=100.025n

* CHECK dout1_44 Vdout1_44ck19 = 0 time = 100
.meas tran vdout1_44ck19 FIND v(dout1_44) AT=100.025n

* CHECK dout1_45 Vdout1_45ck19 = 0 time = 100
.meas tran vdout1_45ck19 FIND v(dout1_45) AT=100.025n

* CHECK dout1_46 Vdout1_46ck19 = 0.9 time = 100
.meas tran vdout1_46ck19 FIND v(dout1_46) AT=100.025n

* CHECK dout1_47 Vdout1_47ck19 = 0 time = 100
.meas tran vdout1_47ck19 FIND v(dout1_47) AT=100.025n

* CHECK dout1_48 Vdout1_48ck19 = 0.9 time = 100
.meas tran vdout1_48ck19 FIND v(dout1_48) AT=100.025n

* CHECK dout1_49 Vdout1_49ck19 = 0 time = 100
.meas tran vdout1_49ck19 FIND v(dout1_49) AT=100.025n

* CHECK dout1_50 Vdout1_50ck19 = 0.9 time = 100
.meas tran vdout1_50ck19 FIND v(dout1_50) AT=100.025n

* CHECK dout1_51 Vdout1_51ck19 = 0.9 time = 100
.meas tran vdout1_51ck19 FIND v(dout1_51) AT=100.025n

* CHECK dout1_52 Vdout1_52ck19 = 0.9 time = 100
.meas tran vdout1_52ck19 FIND v(dout1_52) AT=100.025n

* CHECK dout1_53 Vdout1_53ck19 = 0 time = 100
.meas tran vdout1_53ck19 FIND v(dout1_53) AT=100.025n

* CHECK dout1_54 Vdout1_54ck19 = 0.9 time = 100
.meas tran vdout1_54ck19 FIND v(dout1_54) AT=100.025n

* CHECK dout1_55 Vdout1_55ck19 = 0.9 time = 100
.meas tran vdout1_55ck19 FIND v(dout1_55) AT=100.025n

* CHECK dout1_56 Vdout1_56ck19 = 0.9 time = 100
.meas tran vdout1_56ck19 FIND v(dout1_56) AT=100.025n

* CHECK dout1_57 Vdout1_57ck19 = 0 time = 100
.meas tran vdout1_57ck19 FIND v(dout1_57) AT=100.025n

* CHECK dout1_58 Vdout1_58ck19 = 0.9 time = 100
.meas tran vdout1_58ck19 FIND v(dout1_58) AT=100.025n

* CHECK dout1_59 Vdout1_59ck19 = 0 time = 100
.meas tran vdout1_59ck19 FIND v(dout1_59) AT=100.025n

* CHECK dout1_60 Vdout1_60ck19 = 0.9 time = 100
.meas tran vdout1_60ck19 FIND v(dout1_60) AT=100.025n

* CHECK dout1_61 Vdout1_61ck19 = 0 time = 100
.meas tran vdout1_61ck19 FIND v(dout1_61) AT=100.025n

* CHECK dout1_62 Vdout1_62ck19 = 0 time = 100
.meas tran vdout1_62ck19 FIND v(dout1_62) AT=100.025n

* CHECK dout1_63 Vdout1_63ck19 = 0 time = 100
.meas tran vdout1_63ck19 FIND v(dout1_63) AT=100.025n

* CHECK dout1_64 Vdout1_64ck19 = 0 time = 100
.meas tran vdout1_64ck19 FIND v(dout1_64) AT=100.025n

* CHECK dout1_65 Vdout1_65ck19 = 0.9 time = 100
.meas tran vdout1_65ck19 FIND v(dout1_65) AT=100.025n

* CHECK dout1_66 Vdout1_66ck19 = 0 time = 100
.meas tran vdout1_66ck19 FIND v(dout1_66) AT=100.025n

* CHECK dout1_67 Vdout1_67ck19 = 0 time = 100
.meas tran vdout1_67ck19 FIND v(dout1_67) AT=100.025n

* CHECK dout1_68 Vdout1_68ck19 = 0 time = 100
.meas tran vdout1_68ck19 FIND v(dout1_68) AT=100.025n

* CHECK dout1_69 Vdout1_69ck19 = 0.9 time = 100
.meas tran vdout1_69ck19 FIND v(dout1_69) AT=100.025n

* CHECK dout1_70 Vdout1_70ck19 = 0 time = 100
.meas tran vdout1_70ck19 FIND v(dout1_70) AT=100.025n

* CHECK dout1_71 Vdout1_71ck19 = 0.9 time = 100
.meas tran vdout1_71ck19 FIND v(dout1_71) AT=100.025n

* CHECK dout1_72 Vdout1_72ck19 = 0 time = 100
.meas tran vdout1_72ck19 FIND v(dout1_72) AT=100.025n

* CHECK dout1_73 Vdout1_73ck19 = 0.9 time = 100
.meas tran vdout1_73ck19 FIND v(dout1_73) AT=100.025n

* CHECK dout1_74 Vdout1_74ck19 = 0.9 time = 100
.meas tran vdout1_74ck19 FIND v(dout1_74) AT=100.025n

* CHECK dout1_75 Vdout1_75ck19 = 0.9 time = 100
.meas tran vdout1_75ck19 FIND v(dout1_75) AT=100.025n

* CHECK dout1_76 Vdout1_76ck19 = 0 time = 100
.meas tran vdout1_76ck19 FIND v(dout1_76) AT=100.025n

* CHECK dout1_77 Vdout1_77ck19 = 0 time = 100
.meas tran vdout1_77ck19 FIND v(dout1_77) AT=100.025n

* CHECK dout1_78 Vdout1_78ck19 = 0 time = 100
.meas tran vdout1_78ck19 FIND v(dout1_78) AT=100.025n

* CHECK dout1_79 Vdout1_79ck19 = 0.9 time = 100
.meas tran vdout1_79ck19 FIND v(dout1_79) AT=100.025n

* CHECK dout1_80 Vdout1_80ck19 = 0 time = 100
.meas tran vdout1_80ck19 FIND v(dout1_80) AT=100.025n

* CHECK dout1_81 Vdout1_81ck19 = 0 time = 100
.meas tran vdout1_81ck19 FIND v(dout1_81) AT=100.025n

* CHECK dout1_82 Vdout1_82ck19 = 0 time = 100
.meas tran vdout1_82ck19 FIND v(dout1_82) AT=100.025n

* CHECK dout1_83 Vdout1_83ck19 = 0 time = 100
.meas tran vdout1_83ck19 FIND v(dout1_83) AT=100.025n

* CHECK dout1_84 Vdout1_84ck19 = 0 time = 100
.meas tran vdout1_84ck19 FIND v(dout1_84) AT=100.025n

* CHECK dout1_85 Vdout1_85ck19 = 0.9 time = 100
.meas tran vdout1_85ck19 FIND v(dout1_85) AT=100.025n

* CHECK dout1_86 Vdout1_86ck19 = 0.9 time = 100
.meas tran vdout1_86ck19 FIND v(dout1_86) AT=100.025n

* CHECK dout1_87 Vdout1_87ck19 = 0.9 time = 100
.meas tran vdout1_87ck19 FIND v(dout1_87) AT=100.025n

* CHECK dout1_88 Vdout1_88ck19 = 0.9 time = 100
.meas tran vdout1_88ck19 FIND v(dout1_88) AT=100.025n

* CHECK dout1_89 Vdout1_89ck19 = 0.9 time = 100
.meas tran vdout1_89ck19 FIND v(dout1_89) AT=100.025n

* CHECK dout1_90 Vdout1_90ck19 = 0 time = 100
.meas tran vdout1_90ck19 FIND v(dout1_90) AT=100.025n

* CHECK dout1_91 Vdout1_91ck19 = 0.9 time = 100
.meas tran vdout1_91ck19 FIND v(dout1_91) AT=100.025n

* CHECK dout1_92 Vdout1_92ck19 = 0.9 time = 100
.meas tran vdout1_92ck19 FIND v(dout1_92) AT=100.025n

* CHECK dout1_93 Vdout1_93ck19 = 0 time = 100
.meas tran vdout1_93ck19 FIND v(dout1_93) AT=100.025n

* CHECK dout1_94 Vdout1_94ck19 = 0 time = 100
.meas tran vdout1_94ck19 FIND v(dout1_94) AT=100.025n

* CHECK dout1_95 Vdout1_95ck19 = 0 time = 100
.meas tran vdout1_95ck19 FIND v(dout1_95) AT=100.025n

* CHECK dout1_0 Vdout1_0ck25 = 0 time = 130
.meas tran vdout1_0ck25 FIND v(dout1_0) AT=130.025n

* CHECK dout1_1 Vdout1_1ck25 = 0 time = 130
.meas tran vdout1_1ck25 FIND v(dout1_1) AT=130.025n

* CHECK dout1_2 Vdout1_2ck25 = 0.9 time = 130
.meas tran vdout1_2ck25 FIND v(dout1_2) AT=130.025n

* CHECK dout1_3 Vdout1_3ck25 = 0 time = 130
.meas tran vdout1_3ck25 FIND v(dout1_3) AT=130.025n

* CHECK dout1_4 Vdout1_4ck25 = 0.9 time = 130
.meas tran vdout1_4ck25 FIND v(dout1_4) AT=130.025n

* CHECK dout1_5 Vdout1_5ck25 = 0 time = 130
.meas tran vdout1_5ck25 FIND v(dout1_5) AT=130.025n

* CHECK dout1_6 Vdout1_6ck25 = 0 time = 130
.meas tran vdout1_6ck25 FIND v(dout1_6) AT=130.025n

* CHECK dout1_7 Vdout1_7ck25 = 0 time = 130
.meas tran vdout1_7ck25 FIND v(dout1_7) AT=130.025n

* CHECK dout1_8 Vdout1_8ck25 = 0.9 time = 130
.meas tran vdout1_8ck25 FIND v(dout1_8) AT=130.025n

* CHECK dout1_9 Vdout1_9ck25 = 0 time = 130
.meas tran vdout1_9ck25 FIND v(dout1_9) AT=130.025n

* CHECK dout1_10 Vdout1_10ck25 = 0 time = 130
.meas tran vdout1_10ck25 FIND v(dout1_10) AT=130.025n

* CHECK dout1_11 Vdout1_11ck25 = 0.9 time = 130
.meas tran vdout1_11ck25 FIND v(dout1_11) AT=130.025n

* CHECK dout1_12 Vdout1_12ck25 = 0 time = 130
.meas tran vdout1_12ck25 FIND v(dout1_12) AT=130.025n

* CHECK dout1_13 Vdout1_13ck25 = 0 time = 130
.meas tran vdout1_13ck25 FIND v(dout1_13) AT=130.025n

* CHECK dout1_14 Vdout1_14ck25 = 0.9 time = 130
.meas tran vdout1_14ck25 FIND v(dout1_14) AT=130.025n

* CHECK dout1_15 Vdout1_15ck25 = 0.9 time = 130
.meas tran vdout1_15ck25 FIND v(dout1_15) AT=130.025n

* CHECK dout1_16 Vdout1_16ck25 = 0 time = 130
.meas tran vdout1_16ck25 FIND v(dout1_16) AT=130.025n

* CHECK dout1_17 Vdout1_17ck25 = 0.9 time = 130
.meas tran vdout1_17ck25 FIND v(dout1_17) AT=130.025n

* CHECK dout1_18 Vdout1_18ck25 = 0.9 time = 130
.meas tran vdout1_18ck25 FIND v(dout1_18) AT=130.025n

* CHECK dout1_19 Vdout1_19ck25 = 0 time = 130
.meas tran vdout1_19ck25 FIND v(dout1_19) AT=130.025n

* CHECK dout1_20 Vdout1_20ck25 = 0 time = 130
.meas tran vdout1_20ck25 FIND v(dout1_20) AT=130.025n

* CHECK dout1_21 Vdout1_21ck25 = 0 time = 130
.meas tran vdout1_21ck25 FIND v(dout1_21) AT=130.025n

* CHECK dout1_22 Vdout1_22ck25 = 0.9 time = 130
.meas tran vdout1_22ck25 FIND v(dout1_22) AT=130.025n

* CHECK dout1_23 Vdout1_23ck25 = 0.9 time = 130
.meas tran vdout1_23ck25 FIND v(dout1_23) AT=130.025n

* CHECK dout1_24 Vdout1_24ck25 = 0.9 time = 130
.meas tran vdout1_24ck25 FIND v(dout1_24) AT=130.025n

* CHECK dout1_25 Vdout1_25ck25 = 0.9 time = 130
.meas tran vdout1_25ck25 FIND v(dout1_25) AT=130.025n

* CHECK dout1_26 Vdout1_26ck25 = 0.9 time = 130
.meas tran vdout1_26ck25 FIND v(dout1_26) AT=130.025n

* CHECK dout1_27 Vdout1_27ck25 = 0 time = 130
.meas tran vdout1_27ck25 FIND v(dout1_27) AT=130.025n

* CHECK dout1_28 Vdout1_28ck25 = 0.9 time = 130
.meas tran vdout1_28ck25 FIND v(dout1_28) AT=130.025n

* CHECK dout1_29 Vdout1_29ck25 = 0.9 time = 130
.meas tran vdout1_29ck25 FIND v(dout1_29) AT=130.025n

* CHECK dout1_30 Vdout1_30ck25 = 0 time = 130
.meas tran vdout1_30ck25 FIND v(dout1_30) AT=130.025n

* CHECK dout1_31 Vdout1_31ck25 = 0.9 time = 130
.meas tran vdout1_31ck25 FIND v(dout1_31) AT=130.025n

* CHECK dout1_32 Vdout1_32ck25 = 0.9 time = 130
.meas tran vdout1_32ck25 FIND v(dout1_32) AT=130.025n

* CHECK dout1_33 Vdout1_33ck25 = 0.9 time = 130
.meas tran vdout1_33ck25 FIND v(dout1_33) AT=130.025n

* CHECK dout1_34 Vdout1_34ck25 = 0.9 time = 130
.meas tran vdout1_34ck25 FIND v(dout1_34) AT=130.025n

* CHECK dout1_35 Vdout1_35ck25 = 0 time = 130
.meas tran vdout1_35ck25 FIND v(dout1_35) AT=130.025n

* CHECK dout1_36 Vdout1_36ck25 = 0.9 time = 130
.meas tran vdout1_36ck25 FIND v(dout1_36) AT=130.025n

* CHECK dout1_37 Vdout1_37ck25 = 0 time = 130
.meas tran vdout1_37ck25 FIND v(dout1_37) AT=130.025n

* CHECK dout1_38 Vdout1_38ck25 = 0 time = 130
.meas tran vdout1_38ck25 FIND v(dout1_38) AT=130.025n

* CHECK dout1_39 Vdout1_39ck25 = 0 time = 130
.meas tran vdout1_39ck25 FIND v(dout1_39) AT=130.025n

* CHECK dout1_40 Vdout1_40ck25 = 0.9 time = 130
.meas tran vdout1_40ck25 FIND v(dout1_40) AT=130.025n

* CHECK dout1_41 Vdout1_41ck25 = 0.9 time = 130
.meas tran vdout1_41ck25 FIND v(dout1_41) AT=130.025n

* CHECK dout1_42 Vdout1_42ck25 = 0 time = 130
.meas tran vdout1_42ck25 FIND v(dout1_42) AT=130.025n

* CHECK dout1_43 Vdout1_43ck25 = 0 time = 130
.meas tran vdout1_43ck25 FIND v(dout1_43) AT=130.025n

* CHECK dout1_44 Vdout1_44ck25 = 0 time = 130
.meas tran vdout1_44ck25 FIND v(dout1_44) AT=130.025n

* CHECK dout1_45 Vdout1_45ck25 = 0 time = 130
.meas tran vdout1_45ck25 FIND v(dout1_45) AT=130.025n

* CHECK dout1_46 Vdout1_46ck25 = 0.9 time = 130
.meas tran vdout1_46ck25 FIND v(dout1_46) AT=130.025n

* CHECK dout1_47 Vdout1_47ck25 = 0 time = 130
.meas tran vdout1_47ck25 FIND v(dout1_47) AT=130.025n

* CHECK dout1_48 Vdout1_48ck25 = 0.9 time = 130
.meas tran vdout1_48ck25 FIND v(dout1_48) AT=130.025n

* CHECK dout1_49 Vdout1_49ck25 = 0 time = 130
.meas tran vdout1_49ck25 FIND v(dout1_49) AT=130.025n

* CHECK dout1_50 Vdout1_50ck25 = 0.9 time = 130
.meas tran vdout1_50ck25 FIND v(dout1_50) AT=130.025n

* CHECK dout1_51 Vdout1_51ck25 = 0.9 time = 130
.meas tran vdout1_51ck25 FIND v(dout1_51) AT=130.025n

* CHECK dout1_52 Vdout1_52ck25 = 0.9 time = 130
.meas tran vdout1_52ck25 FIND v(dout1_52) AT=130.025n

* CHECK dout1_53 Vdout1_53ck25 = 0 time = 130
.meas tran vdout1_53ck25 FIND v(dout1_53) AT=130.025n

* CHECK dout1_54 Vdout1_54ck25 = 0.9 time = 130
.meas tran vdout1_54ck25 FIND v(dout1_54) AT=130.025n

* CHECK dout1_55 Vdout1_55ck25 = 0.9 time = 130
.meas tran vdout1_55ck25 FIND v(dout1_55) AT=130.025n

* CHECK dout1_56 Vdout1_56ck25 = 0.9 time = 130
.meas tran vdout1_56ck25 FIND v(dout1_56) AT=130.025n

* CHECK dout1_57 Vdout1_57ck25 = 0 time = 130
.meas tran vdout1_57ck25 FIND v(dout1_57) AT=130.025n

* CHECK dout1_58 Vdout1_58ck25 = 0.9 time = 130
.meas tran vdout1_58ck25 FIND v(dout1_58) AT=130.025n

* CHECK dout1_59 Vdout1_59ck25 = 0 time = 130
.meas tran vdout1_59ck25 FIND v(dout1_59) AT=130.025n

* CHECK dout1_60 Vdout1_60ck25 = 0.9 time = 130
.meas tran vdout1_60ck25 FIND v(dout1_60) AT=130.025n

* CHECK dout1_61 Vdout1_61ck25 = 0 time = 130
.meas tran vdout1_61ck25 FIND v(dout1_61) AT=130.025n

* CHECK dout1_62 Vdout1_62ck25 = 0 time = 130
.meas tran vdout1_62ck25 FIND v(dout1_62) AT=130.025n

* CHECK dout1_63 Vdout1_63ck25 = 0 time = 130
.meas tran vdout1_63ck25 FIND v(dout1_63) AT=130.025n

* CHECK dout1_64 Vdout1_64ck25 = 0 time = 130
.meas tran vdout1_64ck25 FIND v(dout1_64) AT=130.025n

* CHECK dout1_65 Vdout1_65ck25 = 0.9 time = 130
.meas tran vdout1_65ck25 FIND v(dout1_65) AT=130.025n

* CHECK dout1_66 Vdout1_66ck25 = 0 time = 130
.meas tran vdout1_66ck25 FIND v(dout1_66) AT=130.025n

* CHECK dout1_67 Vdout1_67ck25 = 0 time = 130
.meas tran vdout1_67ck25 FIND v(dout1_67) AT=130.025n

* CHECK dout1_68 Vdout1_68ck25 = 0 time = 130
.meas tran vdout1_68ck25 FIND v(dout1_68) AT=130.025n

* CHECK dout1_69 Vdout1_69ck25 = 0.9 time = 130
.meas tran vdout1_69ck25 FIND v(dout1_69) AT=130.025n

* CHECK dout1_70 Vdout1_70ck25 = 0 time = 130
.meas tran vdout1_70ck25 FIND v(dout1_70) AT=130.025n

* CHECK dout1_71 Vdout1_71ck25 = 0.9 time = 130
.meas tran vdout1_71ck25 FIND v(dout1_71) AT=130.025n

* CHECK dout1_72 Vdout1_72ck25 = 0 time = 130
.meas tran vdout1_72ck25 FIND v(dout1_72) AT=130.025n

* CHECK dout1_73 Vdout1_73ck25 = 0.9 time = 130
.meas tran vdout1_73ck25 FIND v(dout1_73) AT=130.025n

* CHECK dout1_74 Vdout1_74ck25 = 0.9 time = 130
.meas tran vdout1_74ck25 FIND v(dout1_74) AT=130.025n

* CHECK dout1_75 Vdout1_75ck25 = 0.9 time = 130
.meas tran vdout1_75ck25 FIND v(dout1_75) AT=130.025n

* CHECK dout1_76 Vdout1_76ck25 = 0 time = 130
.meas tran vdout1_76ck25 FIND v(dout1_76) AT=130.025n

* CHECK dout1_77 Vdout1_77ck25 = 0 time = 130
.meas tran vdout1_77ck25 FIND v(dout1_77) AT=130.025n

* CHECK dout1_78 Vdout1_78ck25 = 0 time = 130
.meas tran vdout1_78ck25 FIND v(dout1_78) AT=130.025n

* CHECK dout1_79 Vdout1_79ck25 = 0.9 time = 130
.meas tran vdout1_79ck25 FIND v(dout1_79) AT=130.025n

* CHECK dout1_80 Vdout1_80ck25 = 0 time = 130
.meas tran vdout1_80ck25 FIND v(dout1_80) AT=130.025n

* CHECK dout1_81 Vdout1_81ck25 = 0 time = 130
.meas tran vdout1_81ck25 FIND v(dout1_81) AT=130.025n

* CHECK dout1_82 Vdout1_82ck25 = 0 time = 130
.meas tran vdout1_82ck25 FIND v(dout1_82) AT=130.025n

* CHECK dout1_83 Vdout1_83ck25 = 0 time = 130
.meas tran vdout1_83ck25 FIND v(dout1_83) AT=130.025n

* CHECK dout1_84 Vdout1_84ck25 = 0 time = 130
.meas tran vdout1_84ck25 FIND v(dout1_84) AT=130.025n

* CHECK dout1_85 Vdout1_85ck25 = 0.9 time = 130
.meas tran vdout1_85ck25 FIND v(dout1_85) AT=130.025n

* CHECK dout1_86 Vdout1_86ck25 = 0.9 time = 130
.meas tran vdout1_86ck25 FIND v(dout1_86) AT=130.025n

* CHECK dout1_87 Vdout1_87ck25 = 0.9 time = 130
.meas tran vdout1_87ck25 FIND v(dout1_87) AT=130.025n

* CHECK dout1_88 Vdout1_88ck25 = 0.9 time = 130
.meas tran vdout1_88ck25 FIND v(dout1_88) AT=130.025n

* CHECK dout1_89 Vdout1_89ck25 = 0.9 time = 130
.meas tran vdout1_89ck25 FIND v(dout1_89) AT=130.025n

* CHECK dout1_90 Vdout1_90ck25 = 0 time = 130
.meas tran vdout1_90ck25 FIND v(dout1_90) AT=130.025n

* CHECK dout1_91 Vdout1_91ck25 = 0.9 time = 130
.meas tran vdout1_91ck25 FIND v(dout1_91) AT=130.025n

* CHECK dout1_92 Vdout1_92ck25 = 0.9 time = 130
.meas tran vdout1_92ck25 FIND v(dout1_92) AT=130.025n

* CHECK dout1_93 Vdout1_93ck25 = 0 time = 130
.meas tran vdout1_93ck25 FIND v(dout1_93) AT=130.025n

* CHECK dout1_94 Vdout1_94ck25 = 0 time = 130
.meas tran vdout1_94ck25 FIND v(dout1_94) AT=130.025n

* CHECK dout1_95 Vdout1_95ck25 = 0 time = 130
.meas tran vdout1_95ck25 FIND v(dout1_95) AT=130.025n

* CHECK dout1_0 Vdout1_0ck29 = 0 time = 150
.meas tran vdout1_0ck29 FIND v(dout1_0) AT=150.025n

* CHECK dout1_1 Vdout1_1ck29 = 0 time = 150
.meas tran vdout1_1ck29 FIND v(dout1_1) AT=150.025n

* CHECK dout1_2 Vdout1_2ck29 = 0.9 time = 150
.meas tran vdout1_2ck29 FIND v(dout1_2) AT=150.025n

* CHECK dout1_3 Vdout1_3ck29 = 0 time = 150
.meas tran vdout1_3ck29 FIND v(dout1_3) AT=150.025n

* CHECK dout1_4 Vdout1_4ck29 = 0.9 time = 150
.meas tran vdout1_4ck29 FIND v(dout1_4) AT=150.025n

* CHECK dout1_5 Vdout1_5ck29 = 0 time = 150
.meas tran vdout1_5ck29 FIND v(dout1_5) AT=150.025n

* CHECK dout1_6 Vdout1_6ck29 = 0 time = 150
.meas tran vdout1_6ck29 FIND v(dout1_6) AT=150.025n

* CHECK dout1_7 Vdout1_7ck29 = 0 time = 150
.meas tran vdout1_7ck29 FIND v(dout1_7) AT=150.025n

* CHECK dout1_8 Vdout1_8ck29 = 0.9 time = 150
.meas tran vdout1_8ck29 FIND v(dout1_8) AT=150.025n

* CHECK dout1_9 Vdout1_9ck29 = 0 time = 150
.meas tran vdout1_9ck29 FIND v(dout1_9) AT=150.025n

* CHECK dout1_10 Vdout1_10ck29 = 0 time = 150
.meas tran vdout1_10ck29 FIND v(dout1_10) AT=150.025n

* CHECK dout1_11 Vdout1_11ck29 = 0.9 time = 150
.meas tran vdout1_11ck29 FIND v(dout1_11) AT=150.025n

* CHECK dout1_12 Vdout1_12ck29 = 0 time = 150
.meas tran vdout1_12ck29 FIND v(dout1_12) AT=150.025n

* CHECK dout1_13 Vdout1_13ck29 = 0 time = 150
.meas tran vdout1_13ck29 FIND v(dout1_13) AT=150.025n

* CHECK dout1_14 Vdout1_14ck29 = 0.9 time = 150
.meas tran vdout1_14ck29 FIND v(dout1_14) AT=150.025n

* CHECK dout1_15 Vdout1_15ck29 = 0.9 time = 150
.meas tran vdout1_15ck29 FIND v(dout1_15) AT=150.025n

* CHECK dout1_16 Vdout1_16ck29 = 0 time = 150
.meas tran vdout1_16ck29 FIND v(dout1_16) AT=150.025n

* CHECK dout1_17 Vdout1_17ck29 = 0.9 time = 150
.meas tran vdout1_17ck29 FIND v(dout1_17) AT=150.025n

* CHECK dout1_18 Vdout1_18ck29 = 0.9 time = 150
.meas tran vdout1_18ck29 FIND v(dout1_18) AT=150.025n

* CHECK dout1_19 Vdout1_19ck29 = 0 time = 150
.meas tran vdout1_19ck29 FIND v(dout1_19) AT=150.025n

* CHECK dout1_20 Vdout1_20ck29 = 0 time = 150
.meas tran vdout1_20ck29 FIND v(dout1_20) AT=150.025n

* CHECK dout1_21 Vdout1_21ck29 = 0 time = 150
.meas tran vdout1_21ck29 FIND v(dout1_21) AT=150.025n

* CHECK dout1_22 Vdout1_22ck29 = 0.9 time = 150
.meas tran vdout1_22ck29 FIND v(dout1_22) AT=150.025n

* CHECK dout1_23 Vdout1_23ck29 = 0.9 time = 150
.meas tran vdout1_23ck29 FIND v(dout1_23) AT=150.025n

* CHECK dout1_24 Vdout1_24ck29 = 0.9 time = 150
.meas tran vdout1_24ck29 FIND v(dout1_24) AT=150.025n

* CHECK dout1_25 Vdout1_25ck29 = 0.9 time = 150
.meas tran vdout1_25ck29 FIND v(dout1_25) AT=150.025n

* CHECK dout1_26 Vdout1_26ck29 = 0.9 time = 150
.meas tran vdout1_26ck29 FIND v(dout1_26) AT=150.025n

* CHECK dout1_27 Vdout1_27ck29 = 0 time = 150
.meas tran vdout1_27ck29 FIND v(dout1_27) AT=150.025n

* CHECK dout1_28 Vdout1_28ck29 = 0.9 time = 150
.meas tran vdout1_28ck29 FIND v(dout1_28) AT=150.025n

* CHECK dout1_29 Vdout1_29ck29 = 0.9 time = 150
.meas tran vdout1_29ck29 FIND v(dout1_29) AT=150.025n

* CHECK dout1_30 Vdout1_30ck29 = 0 time = 150
.meas tran vdout1_30ck29 FIND v(dout1_30) AT=150.025n

* CHECK dout1_31 Vdout1_31ck29 = 0.9 time = 150
.meas tran vdout1_31ck29 FIND v(dout1_31) AT=150.025n

* CHECK dout1_32 Vdout1_32ck29 = 0.9 time = 150
.meas tran vdout1_32ck29 FIND v(dout1_32) AT=150.025n

* CHECK dout1_33 Vdout1_33ck29 = 0.9 time = 150
.meas tran vdout1_33ck29 FIND v(dout1_33) AT=150.025n

* CHECK dout1_34 Vdout1_34ck29 = 0.9 time = 150
.meas tran vdout1_34ck29 FIND v(dout1_34) AT=150.025n

* CHECK dout1_35 Vdout1_35ck29 = 0 time = 150
.meas tran vdout1_35ck29 FIND v(dout1_35) AT=150.025n

* CHECK dout1_36 Vdout1_36ck29 = 0.9 time = 150
.meas tran vdout1_36ck29 FIND v(dout1_36) AT=150.025n

* CHECK dout1_37 Vdout1_37ck29 = 0 time = 150
.meas tran vdout1_37ck29 FIND v(dout1_37) AT=150.025n

* CHECK dout1_38 Vdout1_38ck29 = 0 time = 150
.meas tran vdout1_38ck29 FIND v(dout1_38) AT=150.025n

* CHECK dout1_39 Vdout1_39ck29 = 0 time = 150
.meas tran vdout1_39ck29 FIND v(dout1_39) AT=150.025n

* CHECK dout1_40 Vdout1_40ck29 = 0.9 time = 150
.meas tran vdout1_40ck29 FIND v(dout1_40) AT=150.025n

* CHECK dout1_41 Vdout1_41ck29 = 0.9 time = 150
.meas tran vdout1_41ck29 FIND v(dout1_41) AT=150.025n

* CHECK dout1_42 Vdout1_42ck29 = 0 time = 150
.meas tran vdout1_42ck29 FIND v(dout1_42) AT=150.025n

* CHECK dout1_43 Vdout1_43ck29 = 0 time = 150
.meas tran vdout1_43ck29 FIND v(dout1_43) AT=150.025n

* CHECK dout1_44 Vdout1_44ck29 = 0 time = 150
.meas tran vdout1_44ck29 FIND v(dout1_44) AT=150.025n

* CHECK dout1_45 Vdout1_45ck29 = 0 time = 150
.meas tran vdout1_45ck29 FIND v(dout1_45) AT=150.025n

* CHECK dout1_46 Vdout1_46ck29 = 0.9 time = 150
.meas tran vdout1_46ck29 FIND v(dout1_46) AT=150.025n

* CHECK dout1_47 Vdout1_47ck29 = 0 time = 150
.meas tran vdout1_47ck29 FIND v(dout1_47) AT=150.025n

* CHECK dout1_48 Vdout1_48ck29 = 0.9 time = 150
.meas tran vdout1_48ck29 FIND v(dout1_48) AT=150.025n

* CHECK dout1_49 Vdout1_49ck29 = 0 time = 150
.meas tran vdout1_49ck29 FIND v(dout1_49) AT=150.025n

* CHECK dout1_50 Vdout1_50ck29 = 0.9 time = 150
.meas tran vdout1_50ck29 FIND v(dout1_50) AT=150.025n

* CHECK dout1_51 Vdout1_51ck29 = 0.9 time = 150
.meas tran vdout1_51ck29 FIND v(dout1_51) AT=150.025n

* CHECK dout1_52 Vdout1_52ck29 = 0.9 time = 150
.meas tran vdout1_52ck29 FIND v(dout1_52) AT=150.025n

* CHECK dout1_53 Vdout1_53ck29 = 0 time = 150
.meas tran vdout1_53ck29 FIND v(dout1_53) AT=150.025n

* CHECK dout1_54 Vdout1_54ck29 = 0.9 time = 150
.meas tran vdout1_54ck29 FIND v(dout1_54) AT=150.025n

* CHECK dout1_55 Vdout1_55ck29 = 0.9 time = 150
.meas tran vdout1_55ck29 FIND v(dout1_55) AT=150.025n

* CHECK dout1_56 Vdout1_56ck29 = 0.9 time = 150
.meas tran vdout1_56ck29 FIND v(dout1_56) AT=150.025n

* CHECK dout1_57 Vdout1_57ck29 = 0 time = 150
.meas tran vdout1_57ck29 FIND v(dout1_57) AT=150.025n

* CHECK dout1_58 Vdout1_58ck29 = 0.9 time = 150
.meas tran vdout1_58ck29 FIND v(dout1_58) AT=150.025n

* CHECK dout1_59 Vdout1_59ck29 = 0 time = 150
.meas tran vdout1_59ck29 FIND v(dout1_59) AT=150.025n

* CHECK dout1_60 Vdout1_60ck29 = 0.9 time = 150
.meas tran vdout1_60ck29 FIND v(dout1_60) AT=150.025n

* CHECK dout1_61 Vdout1_61ck29 = 0 time = 150
.meas tran vdout1_61ck29 FIND v(dout1_61) AT=150.025n

* CHECK dout1_62 Vdout1_62ck29 = 0 time = 150
.meas tran vdout1_62ck29 FIND v(dout1_62) AT=150.025n

* CHECK dout1_63 Vdout1_63ck29 = 0 time = 150
.meas tran vdout1_63ck29 FIND v(dout1_63) AT=150.025n

* CHECK dout1_64 Vdout1_64ck29 = 0 time = 150
.meas tran vdout1_64ck29 FIND v(dout1_64) AT=150.025n

* CHECK dout1_65 Vdout1_65ck29 = 0.9 time = 150
.meas tran vdout1_65ck29 FIND v(dout1_65) AT=150.025n

* CHECK dout1_66 Vdout1_66ck29 = 0 time = 150
.meas tran vdout1_66ck29 FIND v(dout1_66) AT=150.025n

* CHECK dout1_67 Vdout1_67ck29 = 0 time = 150
.meas tran vdout1_67ck29 FIND v(dout1_67) AT=150.025n

* CHECK dout1_68 Vdout1_68ck29 = 0 time = 150
.meas tran vdout1_68ck29 FIND v(dout1_68) AT=150.025n

* CHECK dout1_69 Vdout1_69ck29 = 0.9 time = 150
.meas tran vdout1_69ck29 FIND v(dout1_69) AT=150.025n

* CHECK dout1_70 Vdout1_70ck29 = 0 time = 150
.meas tran vdout1_70ck29 FIND v(dout1_70) AT=150.025n

* CHECK dout1_71 Vdout1_71ck29 = 0.9 time = 150
.meas tran vdout1_71ck29 FIND v(dout1_71) AT=150.025n

* CHECK dout1_72 Vdout1_72ck29 = 0 time = 150
.meas tran vdout1_72ck29 FIND v(dout1_72) AT=150.025n

* CHECK dout1_73 Vdout1_73ck29 = 0.9 time = 150
.meas tran vdout1_73ck29 FIND v(dout1_73) AT=150.025n

* CHECK dout1_74 Vdout1_74ck29 = 0.9 time = 150
.meas tran vdout1_74ck29 FIND v(dout1_74) AT=150.025n

* CHECK dout1_75 Vdout1_75ck29 = 0.9 time = 150
.meas tran vdout1_75ck29 FIND v(dout1_75) AT=150.025n

* CHECK dout1_76 Vdout1_76ck29 = 0 time = 150
.meas tran vdout1_76ck29 FIND v(dout1_76) AT=150.025n

* CHECK dout1_77 Vdout1_77ck29 = 0 time = 150
.meas tran vdout1_77ck29 FIND v(dout1_77) AT=150.025n

* CHECK dout1_78 Vdout1_78ck29 = 0 time = 150
.meas tran vdout1_78ck29 FIND v(dout1_78) AT=150.025n

* CHECK dout1_79 Vdout1_79ck29 = 0.9 time = 150
.meas tran vdout1_79ck29 FIND v(dout1_79) AT=150.025n

* CHECK dout1_80 Vdout1_80ck29 = 0 time = 150
.meas tran vdout1_80ck29 FIND v(dout1_80) AT=150.025n

* CHECK dout1_81 Vdout1_81ck29 = 0 time = 150
.meas tran vdout1_81ck29 FIND v(dout1_81) AT=150.025n

* CHECK dout1_82 Vdout1_82ck29 = 0 time = 150
.meas tran vdout1_82ck29 FIND v(dout1_82) AT=150.025n

* CHECK dout1_83 Vdout1_83ck29 = 0 time = 150
.meas tran vdout1_83ck29 FIND v(dout1_83) AT=150.025n

* CHECK dout1_84 Vdout1_84ck29 = 0 time = 150
.meas tran vdout1_84ck29 FIND v(dout1_84) AT=150.025n

* CHECK dout1_85 Vdout1_85ck29 = 0.9 time = 150
.meas tran vdout1_85ck29 FIND v(dout1_85) AT=150.025n

* CHECK dout1_86 Vdout1_86ck29 = 0.9 time = 150
.meas tran vdout1_86ck29 FIND v(dout1_86) AT=150.025n

* CHECK dout1_87 Vdout1_87ck29 = 0.9 time = 150
.meas tran vdout1_87ck29 FIND v(dout1_87) AT=150.025n

* CHECK dout1_88 Vdout1_88ck29 = 0.9 time = 150
.meas tran vdout1_88ck29 FIND v(dout1_88) AT=150.025n

* CHECK dout1_89 Vdout1_89ck29 = 0.9 time = 150
.meas tran vdout1_89ck29 FIND v(dout1_89) AT=150.025n

* CHECK dout1_90 Vdout1_90ck29 = 0 time = 150
.meas tran vdout1_90ck29 FIND v(dout1_90) AT=150.025n

* CHECK dout1_91 Vdout1_91ck29 = 0.9 time = 150
.meas tran vdout1_91ck29 FIND v(dout1_91) AT=150.025n

* CHECK dout1_92 Vdout1_92ck29 = 0.9 time = 150
.meas tran vdout1_92ck29 FIND v(dout1_92) AT=150.025n

* CHECK dout1_93 Vdout1_93ck29 = 0 time = 150
.meas tran vdout1_93ck29 FIND v(dout1_93) AT=150.025n

* CHECK dout1_94 Vdout1_94ck29 = 0 time = 150
.meas tran vdout1_94ck29 FIND v(dout1_94) AT=150.025n

* CHECK dout1_95 Vdout1_95ck29 = 0 time = 150
.meas tran vdout1_95ck29 FIND v(dout1_95) AT=150.025n

* CHECK dout1_0 Vdout1_0ck30 = 0 time = 155
.meas tran vdout1_0ck30 FIND v(dout1_0) AT=155.025n

* CHECK dout1_1 Vdout1_1ck30 = 0 time = 155
.meas tran vdout1_1ck30 FIND v(dout1_1) AT=155.025n

* CHECK dout1_2 Vdout1_2ck30 = 0.9 time = 155
.meas tran vdout1_2ck30 FIND v(dout1_2) AT=155.025n

* CHECK dout1_3 Vdout1_3ck30 = 0 time = 155
.meas tran vdout1_3ck30 FIND v(dout1_3) AT=155.025n

* CHECK dout1_4 Vdout1_4ck30 = 0.9 time = 155
.meas tran vdout1_4ck30 FIND v(dout1_4) AT=155.025n

* CHECK dout1_5 Vdout1_5ck30 = 0 time = 155
.meas tran vdout1_5ck30 FIND v(dout1_5) AT=155.025n

* CHECK dout1_6 Vdout1_6ck30 = 0 time = 155
.meas tran vdout1_6ck30 FIND v(dout1_6) AT=155.025n

* CHECK dout1_7 Vdout1_7ck30 = 0 time = 155
.meas tran vdout1_7ck30 FIND v(dout1_7) AT=155.025n

* CHECK dout1_8 Vdout1_8ck30 = 0.9 time = 155
.meas tran vdout1_8ck30 FIND v(dout1_8) AT=155.025n

* CHECK dout1_9 Vdout1_9ck30 = 0 time = 155
.meas tran vdout1_9ck30 FIND v(dout1_9) AT=155.025n

* CHECK dout1_10 Vdout1_10ck30 = 0 time = 155
.meas tran vdout1_10ck30 FIND v(dout1_10) AT=155.025n

* CHECK dout1_11 Vdout1_11ck30 = 0.9 time = 155
.meas tran vdout1_11ck30 FIND v(dout1_11) AT=155.025n

* CHECK dout1_12 Vdout1_12ck30 = 0 time = 155
.meas tran vdout1_12ck30 FIND v(dout1_12) AT=155.025n

* CHECK dout1_13 Vdout1_13ck30 = 0 time = 155
.meas tran vdout1_13ck30 FIND v(dout1_13) AT=155.025n

* CHECK dout1_14 Vdout1_14ck30 = 0.9 time = 155
.meas tran vdout1_14ck30 FIND v(dout1_14) AT=155.025n

* CHECK dout1_15 Vdout1_15ck30 = 0.9 time = 155
.meas tran vdout1_15ck30 FIND v(dout1_15) AT=155.025n

* CHECK dout1_16 Vdout1_16ck30 = 0 time = 155
.meas tran vdout1_16ck30 FIND v(dout1_16) AT=155.025n

* CHECK dout1_17 Vdout1_17ck30 = 0.9 time = 155
.meas tran vdout1_17ck30 FIND v(dout1_17) AT=155.025n

* CHECK dout1_18 Vdout1_18ck30 = 0.9 time = 155
.meas tran vdout1_18ck30 FIND v(dout1_18) AT=155.025n

* CHECK dout1_19 Vdout1_19ck30 = 0 time = 155
.meas tran vdout1_19ck30 FIND v(dout1_19) AT=155.025n

* CHECK dout1_20 Vdout1_20ck30 = 0 time = 155
.meas tran vdout1_20ck30 FIND v(dout1_20) AT=155.025n

* CHECK dout1_21 Vdout1_21ck30 = 0 time = 155
.meas tran vdout1_21ck30 FIND v(dout1_21) AT=155.025n

* CHECK dout1_22 Vdout1_22ck30 = 0.9 time = 155
.meas tran vdout1_22ck30 FIND v(dout1_22) AT=155.025n

* CHECK dout1_23 Vdout1_23ck30 = 0.9 time = 155
.meas tran vdout1_23ck30 FIND v(dout1_23) AT=155.025n

* CHECK dout1_24 Vdout1_24ck30 = 0.9 time = 155
.meas tran vdout1_24ck30 FIND v(dout1_24) AT=155.025n

* CHECK dout1_25 Vdout1_25ck30 = 0.9 time = 155
.meas tran vdout1_25ck30 FIND v(dout1_25) AT=155.025n

* CHECK dout1_26 Vdout1_26ck30 = 0.9 time = 155
.meas tran vdout1_26ck30 FIND v(dout1_26) AT=155.025n

* CHECK dout1_27 Vdout1_27ck30 = 0 time = 155
.meas tran vdout1_27ck30 FIND v(dout1_27) AT=155.025n

* CHECK dout1_28 Vdout1_28ck30 = 0.9 time = 155
.meas tran vdout1_28ck30 FIND v(dout1_28) AT=155.025n

* CHECK dout1_29 Vdout1_29ck30 = 0.9 time = 155
.meas tran vdout1_29ck30 FIND v(dout1_29) AT=155.025n

* CHECK dout1_30 Vdout1_30ck30 = 0 time = 155
.meas tran vdout1_30ck30 FIND v(dout1_30) AT=155.025n

* CHECK dout1_31 Vdout1_31ck30 = 0.9 time = 155
.meas tran vdout1_31ck30 FIND v(dout1_31) AT=155.025n

* CHECK dout1_32 Vdout1_32ck30 = 0.9 time = 155
.meas tran vdout1_32ck30 FIND v(dout1_32) AT=155.025n

* CHECK dout1_33 Vdout1_33ck30 = 0.9 time = 155
.meas tran vdout1_33ck30 FIND v(dout1_33) AT=155.025n

* CHECK dout1_34 Vdout1_34ck30 = 0.9 time = 155
.meas tran vdout1_34ck30 FIND v(dout1_34) AT=155.025n

* CHECK dout1_35 Vdout1_35ck30 = 0 time = 155
.meas tran vdout1_35ck30 FIND v(dout1_35) AT=155.025n

* CHECK dout1_36 Vdout1_36ck30 = 0.9 time = 155
.meas tran vdout1_36ck30 FIND v(dout1_36) AT=155.025n

* CHECK dout1_37 Vdout1_37ck30 = 0 time = 155
.meas tran vdout1_37ck30 FIND v(dout1_37) AT=155.025n

* CHECK dout1_38 Vdout1_38ck30 = 0 time = 155
.meas tran vdout1_38ck30 FIND v(dout1_38) AT=155.025n

* CHECK dout1_39 Vdout1_39ck30 = 0 time = 155
.meas tran vdout1_39ck30 FIND v(dout1_39) AT=155.025n

* CHECK dout1_40 Vdout1_40ck30 = 0.9 time = 155
.meas tran vdout1_40ck30 FIND v(dout1_40) AT=155.025n

* CHECK dout1_41 Vdout1_41ck30 = 0.9 time = 155
.meas tran vdout1_41ck30 FIND v(dout1_41) AT=155.025n

* CHECK dout1_42 Vdout1_42ck30 = 0 time = 155
.meas tran vdout1_42ck30 FIND v(dout1_42) AT=155.025n

* CHECK dout1_43 Vdout1_43ck30 = 0 time = 155
.meas tran vdout1_43ck30 FIND v(dout1_43) AT=155.025n

* CHECK dout1_44 Vdout1_44ck30 = 0 time = 155
.meas tran vdout1_44ck30 FIND v(dout1_44) AT=155.025n

* CHECK dout1_45 Vdout1_45ck30 = 0 time = 155
.meas tran vdout1_45ck30 FIND v(dout1_45) AT=155.025n

* CHECK dout1_46 Vdout1_46ck30 = 0.9 time = 155
.meas tran vdout1_46ck30 FIND v(dout1_46) AT=155.025n

* CHECK dout1_47 Vdout1_47ck30 = 0 time = 155
.meas tran vdout1_47ck30 FIND v(dout1_47) AT=155.025n

* CHECK dout1_48 Vdout1_48ck30 = 0.9 time = 155
.meas tran vdout1_48ck30 FIND v(dout1_48) AT=155.025n

* CHECK dout1_49 Vdout1_49ck30 = 0 time = 155
.meas tran vdout1_49ck30 FIND v(dout1_49) AT=155.025n

* CHECK dout1_50 Vdout1_50ck30 = 0.9 time = 155
.meas tran vdout1_50ck30 FIND v(dout1_50) AT=155.025n

* CHECK dout1_51 Vdout1_51ck30 = 0.9 time = 155
.meas tran vdout1_51ck30 FIND v(dout1_51) AT=155.025n

* CHECK dout1_52 Vdout1_52ck30 = 0.9 time = 155
.meas tran vdout1_52ck30 FIND v(dout1_52) AT=155.025n

* CHECK dout1_53 Vdout1_53ck30 = 0 time = 155
.meas tran vdout1_53ck30 FIND v(dout1_53) AT=155.025n

* CHECK dout1_54 Vdout1_54ck30 = 0.9 time = 155
.meas tran vdout1_54ck30 FIND v(dout1_54) AT=155.025n

* CHECK dout1_55 Vdout1_55ck30 = 0.9 time = 155
.meas tran vdout1_55ck30 FIND v(dout1_55) AT=155.025n

* CHECK dout1_56 Vdout1_56ck30 = 0.9 time = 155
.meas tran vdout1_56ck30 FIND v(dout1_56) AT=155.025n

* CHECK dout1_57 Vdout1_57ck30 = 0 time = 155
.meas tran vdout1_57ck30 FIND v(dout1_57) AT=155.025n

* CHECK dout1_58 Vdout1_58ck30 = 0.9 time = 155
.meas tran vdout1_58ck30 FIND v(dout1_58) AT=155.025n

* CHECK dout1_59 Vdout1_59ck30 = 0 time = 155
.meas tran vdout1_59ck30 FIND v(dout1_59) AT=155.025n

* CHECK dout1_60 Vdout1_60ck30 = 0.9 time = 155
.meas tran vdout1_60ck30 FIND v(dout1_60) AT=155.025n

* CHECK dout1_61 Vdout1_61ck30 = 0 time = 155
.meas tran vdout1_61ck30 FIND v(dout1_61) AT=155.025n

* CHECK dout1_62 Vdout1_62ck30 = 0 time = 155
.meas tran vdout1_62ck30 FIND v(dout1_62) AT=155.025n

* CHECK dout1_63 Vdout1_63ck30 = 0 time = 155
.meas tran vdout1_63ck30 FIND v(dout1_63) AT=155.025n

* CHECK dout1_64 Vdout1_64ck30 = 0 time = 155
.meas tran vdout1_64ck30 FIND v(dout1_64) AT=155.025n

* CHECK dout1_65 Vdout1_65ck30 = 0.9 time = 155
.meas tran vdout1_65ck30 FIND v(dout1_65) AT=155.025n

* CHECK dout1_66 Vdout1_66ck30 = 0 time = 155
.meas tran vdout1_66ck30 FIND v(dout1_66) AT=155.025n

* CHECK dout1_67 Vdout1_67ck30 = 0 time = 155
.meas tran vdout1_67ck30 FIND v(dout1_67) AT=155.025n

* CHECK dout1_68 Vdout1_68ck30 = 0 time = 155
.meas tran vdout1_68ck30 FIND v(dout1_68) AT=155.025n

* CHECK dout1_69 Vdout1_69ck30 = 0.9 time = 155
.meas tran vdout1_69ck30 FIND v(dout1_69) AT=155.025n

* CHECK dout1_70 Vdout1_70ck30 = 0 time = 155
.meas tran vdout1_70ck30 FIND v(dout1_70) AT=155.025n

* CHECK dout1_71 Vdout1_71ck30 = 0.9 time = 155
.meas tran vdout1_71ck30 FIND v(dout1_71) AT=155.025n

* CHECK dout1_72 Vdout1_72ck30 = 0 time = 155
.meas tran vdout1_72ck30 FIND v(dout1_72) AT=155.025n

* CHECK dout1_73 Vdout1_73ck30 = 0.9 time = 155
.meas tran vdout1_73ck30 FIND v(dout1_73) AT=155.025n

* CHECK dout1_74 Vdout1_74ck30 = 0.9 time = 155
.meas tran vdout1_74ck30 FIND v(dout1_74) AT=155.025n

* CHECK dout1_75 Vdout1_75ck30 = 0.9 time = 155
.meas tran vdout1_75ck30 FIND v(dout1_75) AT=155.025n

* CHECK dout1_76 Vdout1_76ck30 = 0 time = 155
.meas tran vdout1_76ck30 FIND v(dout1_76) AT=155.025n

* CHECK dout1_77 Vdout1_77ck30 = 0 time = 155
.meas tran vdout1_77ck30 FIND v(dout1_77) AT=155.025n

* CHECK dout1_78 Vdout1_78ck30 = 0 time = 155
.meas tran vdout1_78ck30 FIND v(dout1_78) AT=155.025n

* CHECK dout1_79 Vdout1_79ck30 = 0.9 time = 155
.meas tran vdout1_79ck30 FIND v(dout1_79) AT=155.025n

* CHECK dout1_80 Vdout1_80ck30 = 0 time = 155
.meas tran vdout1_80ck30 FIND v(dout1_80) AT=155.025n

* CHECK dout1_81 Vdout1_81ck30 = 0 time = 155
.meas tran vdout1_81ck30 FIND v(dout1_81) AT=155.025n

* CHECK dout1_82 Vdout1_82ck30 = 0 time = 155
.meas tran vdout1_82ck30 FIND v(dout1_82) AT=155.025n

* CHECK dout1_83 Vdout1_83ck30 = 0 time = 155
.meas tran vdout1_83ck30 FIND v(dout1_83) AT=155.025n

* CHECK dout1_84 Vdout1_84ck30 = 0 time = 155
.meas tran vdout1_84ck30 FIND v(dout1_84) AT=155.025n

* CHECK dout1_85 Vdout1_85ck30 = 0.9 time = 155
.meas tran vdout1_85ck30 FIND v(dout1_85) AT=155.025n

* CHECK dout1_86 Vdout1_86ck30 = 0.9 time = 155
.meas tran vdout1_86ck30 FIND v(dout1_86) AT=155.025n

* CHECK dout1_87 Vdout1_87ck30 = 0.9 time = 155
.meas tran vdout1_87ck30 FIND v(dout1_87) AT=155.025n

* CHECK dout1_88 Vdout1_88ck30 = 0.9 time = 155
.meas tran vdout1_88ck30 FIND v(dout1_88) AT=155.025n

* CHECK dout1_89 Vdout1_89ck30 = 0.9 time = 155
.meas tran vdout1_89ck30 FIND v(dout1_89) AT=155.025n

* CHECK dout1_90 Vdout1_90ck30 = 0 time = 155
.meas tran vdout1_90ck30 FIND v(dout1_90) AT=155.025n

* CHECK dout1_91 Vdout1_91ck30 = 0.9 time = 155
.meas tran vdout1_91ck30 FIND v(dout1_91) AT=155.025n

* CHECK dout1_92 Vdout1_92ck30 = 0.9 time = 155
.meas tran vdout1_92ck30 FIND v(dout1_92) AT=155.025n

* CHECK dout1_93 Vdout1_93ck30 = 0 time = 155
.meas tran vdout1_93ck30 FIND v(dout1_93) AT=155.025n

* CHECK dout1_94 Vdout1_94ck30 = 0 time = 155
.meas tran vdout1_94ck30 FIND v(dout1_94) AT=155.025n

* CHECK dout1_95 Vdout1_95ck30 = 0 time = 155
.meas tran vdout1_95ck30 FIND v(dout1_95) AT=155.025n

* CHECK dout1_0 Vdout1_0ck32 = 0 time = 165
.meas tran vdout1_0ck32 FIND v(dout1_0) AT=165.025n

* CHECK dout1_1 Vdout1_1ck32 = 0 time = 165
.meas tran vdout1_1ck32 FIND v(dout1_1) AT=165.025n

* CHECK dout1_2 Vdout1_2ck32 = 0.9 time = 165
.meas tran vdout1_2ck32 FIND v(dout1_2) AT=165.025n

* CHECK dout1_3 Vdout1_3ck32 = 0 time = 165
.meas tran vdout1_3ck32 FIND v(dout1_3) AT=165.025n

* CHECK dout1_4 Vdout1_4ck32 = 0.9 time = 165
.meas tran vdout1_4ck32 FIND v(dout1_4) AT=165.025n

* CHECK dout1_5 Vdout1_5ck32 = 0 time = 165
.meas tran vdout1_5ck32 FIND v(dout1_5) AT=165.025n

* CHECK dout1_6 Vdout1_6ck32 = 0 time = 165
.meas tran vdout1_6ck32 FIND v(dout1_6) AT=165.025n

* CHECK dout1_7 Vdout1_7ck32 = 0 time = 165
.meas tran vdout1_7ck32 FIND v(dout1_7) AT=165.025n

* CHECK dout1_8 Vdout1_8ck32 = 0.9 time = 165
.meas tran vdout1_8ck32 FIND v(dout1_8) AT=165.025n

* CHECK dout1_9 Vdout1_9ck32 = 0 time = 165
.meas tran vdout1_9ck32 FIND v(dout1_9) AT=165.025n

* CHECK dout1_10 Vdout1_10ck32 = 0 time = 165
.meas tran vdout1_10ck32 FIND v(dout1_10) AT=165.025n

* CHECK dout1_11 Vdout1_11ck32 = 0.9 time = 165
.meas tran vdout1_11ck32 FIND v(dout1_11) AT=165.025n

* CHECK dout1_12 Vdout1_12ck32 = 0 time = 165
.meas tran vdout1_12ck32 FIND v(dout1_12) AT=165.025n

* CHECK dout1_13 Vdout1_13ck32 = 0 time = 165
.meas tran vdout1_13ck32 FIND v(dout1_13) AT=165.025n

* CHECK dout1_14 Vdout1_14ck32 = 0.9 time = 165
.meas tran vdout1_14ck32 FIND v(dout1_14) AT=165.025n

* CHECK dout1_15 Vdout1_15ck32 = 0.9 time = 165
.meas tran vdout1_15ck32 FIND v(dout1_15) AT=165.025n

* CHECK dout1_16 Vdout1_16ck32 = 0 time = 165
.meas tran vdout1_16ck32 FIND v(dout1_16) AT=165.025n

* CHECK dout1_17 Vdout1_17ck32 = 0.9 time = 165
.meas tran vdout1_17ck32 FIND v(dout1_17) AT=165.025n

* CHECK dout1_18 Vdout1_18ck32 = 0.9 time = 165
.meas tran vdout1_18ck32 FIND v(dout1_18) AT=165.025n

* CHECK dout1_19 Vdout1_19ck32 = 0 time = 165
.meas tran vdout1_19ck32 FIND v(dout1_19) AT=165.025n

* CHECK dout1_20 Vdout1_20ck32 = 0 time = 165
.meas tran vdout1_20ck32 FIND v(dout1_20) AT=165.025n

* CHECK dout1_21 Vdout1_21ck32 = 0 time = 165
.meas tran vdout1_21ck32 FIND v(dout1_21) AT=165.025n

* CHECK dout1_22 Vdout1_22ck32 = 0.9 time = 165
.meas tran vdout1_22ck32 FIND v(dout1_22) AT=165.025n

* CHECK dout1_23 Vdout1_23ck32 = 0.9 time = 165
.meas tran vdout1_23ck32 FIND v(dout1_23) AT=165.025n

* CHECK dout1_24 Vdout1_24ck32 = 0.9 time = 165
.meas tran vdout1_24ck32 FIND v(dout1_24) AT=165.025n

* CHECK dout1_25 Vdout1_25ck32 = 0.9 time = 165
.meas tran vdout1_25ck32 FIND v(dout1_25) AT=165.025n

* CHECK dout1_26 Vdout1_26ck32 = 0.9 time = 165
.meas tran vdout1_26ck32 FIND v(dout1_26) AT=165.025n

* CHECK dout1_27 Vdout1_27ck32 = 0 time = 165
.meas tran vdout1_27ck32 FIND v(dout1_27) AT=165.025n

* CHECK dout1_28 Vdout1_28ck32 = 0.9 time = 165
.meas tran vdout1_28ck32 FIND v(dout1_28) AT=165.025n

* CHECK dout1_29 Vdout1_29ck32 = 0.9 time = 165
.meas tran vdout1_29ck32 FIND v(dout1_29) AT=165.025n

* CHECK dout1_30 Vdout1_30ck32 = 0 time = 165
.meas tran vdout1_30ck32 FIND v(dout1_30) AT=165.025n

* CHECK dout1_31 Vdout1_31ck32 = 0.9 time = 165
.meas tran vdout1_31ck32 FIND v(dout1_31) AT=165.025n

* CHECK dout1_32 Vdout1_32ck32 = 0.9 time = 165
.meas tran vdout1_32ck32 FIND v(dout1_32) AT=165.025n

* CHECK dout1_33 Vdout1_33ck32 = 0.9 time = 165
.meas tran vdout1_33ck32 FIND v(dout1_33) AT=165.025n

* CHECK dout1_34 Vdout1_34ck32 = 0.9 time = 165
.meas tran vdout1_34ck32 FIND v(dout1_34) AT=165.025n

* CHECK dout1_35 Vdout1_35ck32 = 0 time = 165
.meas tran vdout1_35ck32 FIND v(dout1_35) AT=165.025n

* CHECK dout1_36 Vdout1_36ck32 = 0.9 time = 165
.meas tran vdout1_36ck32 FIND v(dout1_36) AT=165.025n

* CHECK dout1_37 Vdout1_37ck32 = 0 time = 165
.meas tran vdout1_37ck32 FIND v(dout1_37) AT=165.025n

* CHECK dout1_38 Vdout1_38ck32 = 0 time = 165
.meas tran vdout1_38ck32 FIND v(dout1_38) AT=165.025n

* CHECK dout1_39 Vdout1_39ck32 = 0 time = 165
.meas tran vdout1_39ck32 FIND v(dout1_39) AT=165.025n

* CHECK dout1_40 Vdout1_40ck32 = 0.9 time = 165
.meas tran vdout1_40ck32 FIND v(dout1_40) AT=165.025n

* CHECK dout1_41 Vdout1_41ck32 = 0.9 time = 165
.meas tran vdout1_41ck32 FIND v(dout1_41) AT=165.025n

* CHECK dout1_42 Vdout1_42ck32 = 0 time = 165
.meas tran vdout1_42ck32 FIND v(dout1_42) AT=165.025n

* CHECK dout1_43 Vdout1_43ck32 = 0 time = 165
.meas tran vdout1_43ck32 FIND v(dout1_43) AT=165.025n

* CHECK dout1_44 Vdout1_44ck32 = 0 time = 165
.meas tran vdout1_44ck32 FIND v(dout1_44) AT=165.025n

* CHECK dout1_45 Vdout1_45ck32 = 0 time = 165
.meas tran vdout1_45ck32 FIND v(dout1_45) AT=165.025n

* CHECK dout1_46 Vdout1_46ck32 = 0.9 time = 165
.meas tran vdout1_46ck32 FIND v(dout1_46) AT=165.025n

* CHECK dout1_47 Vdout1_47ck32 = 0 time = 165
.meas tran vdout1_47ck32 FIND v(dout1_47) AT=165.025n

* CHECK dout1_48 Vdout1_48ck32 = 0.9 time = 165
.meas tran vdout1_48ck32 FIND v(dout1_48) AT=165.025n

* CHECK dout1_49 Vdout1_49ck32 = 0 time = 165
.meas tran vdout1_49ck32 FIND v(dout1_49) AT=165.025n

* CHECK dout1_50 Vdout1_50ck32 = 0.9 time = 165
.meas tran vdout1_50ck32 FIND v(dout1_50) AT=165.025n

* CHECK dout1_51 Vdout1_51ck32 = 0.9 time = 165
.meas tran vdout1_51ck32 FIND v(dout1_51) AT=165.025n

* CHECK dout1_52 Vdout1_52ck32 = 0.9 time = 165
.meas tran vdout1_52ck32 FIND v(dout1_52) AT=165.025n

* CHECK dout1_53 Vdout1_53ck32 = 0 time = 165
.meas tran vdout1_53ck32 FIND v(dout1_53) AT=165.025n

* CHECK dout1_54 Vdout1_54ck32 = 0.9 time = 165
.meas tran vdout1_54ck32 FIND v(dout1_54) AT=165.025n

* CHECK dout1_55 Vdout1_55ck32 = 0.9 time = 165
.meas tran vdout1_55ck32 FIND v(dout1_55) AT=165.025n

* CHECK dout1_56 Vdout1_56ck32 = 0.9 time = 165
.meas tran vdout1_56ck32 FIND v(dout1_56) AT=165.025n

* CHECK dout1_57 Vdout1_57ck32 = 0 time = 165
.meas tran vdout1_57ck32 FIND v(dout1_57) AT=165.025n

* CHECK dout1_58 Vdout1_58ck32 = 0.9 time = 165
.meas tran vdout1_58ck32 FIND v(dout1_58) AT=165.025n

* CHECK dout1_59 Vdout1_59ck32 = 0 time = 165
.meas tran vdout1_59ck32 FIND v(dout1_59) AT=165.025n

* CHECK dout1_60 Vdout1_60ck32 = 0.9 time = 165
.meas tran vdout1_60ck32 FIND v(dout1_60) AT=165.025n

* CHECK dout1_61 Vdout1_61ck32 = 0 time = 165
.meas tran vdout1_61ck32 FIND v(dout1_61) AT=165.025n

* CHECK dout1_62 Vdout1_62ck32 = 0 time = 165
.meas tran vdout1_62ck32 FIND v(dout1_62) AT=165.025n

* CHECK dout1_63 Vdout1_63ck32 = 0 time = 165
.meas tran vdout1_63ck32 FIND v(dout1_63) AT=165.025n

* CHECK dout1_64 Vdout1_64ck32 = 0 time = 165
.meas tran vdout1_64ck32 FIND v(dout1_64) AT=165.025n

* CHECK dout1_65 Vdout1_65ck32 = 0.9 time = 165
.meas tran vdout1_65ck32 FIND v(dout1_65) AT=165.025n

* CHECK dout1_66 Vdout1_66ck32 = 0 time = 165
.meas tran vdout1_66ck32 FIND v(dout1_66) AT=165.025n

* CHECK dout1_67 Vdout1_67ck32 = 0 time = 165
.meas tran vdout1_67ck32 FIND v(dout1_67) AT=165.025n

* CHECK dout1_68 Vdout1_68ck32 = 0 time = 165
.meas tran vdout1_68ck32 FIND v(dout1_68) AT=165.025n

* CHECK dout1_69 Vdout1_69ck32 = 0.9 time = 165
.meas tran vdout1_69ck32 FIND v(dout1_69) AT=165.025n

* CHECK dout1_70 Vdout1_70ck32 = 0 time = 165
.meas tran vdout1_70ck32 FIND v(dout1_70) AT=165.025n

* CHECK dout1_71 Vdout1_71ck32 = 0.9 time = 165
.meas tran vdout1_71ck32 FIND v(dout1_71) AT=165.025n

* CHECK dout1_72 Vdout1_72ck32 = 0 time = 165
.meas tran vdout1_72ck32 FIND v(dout1_72) AT=165.025n

* CHECK dout1_73 Vdout1_73ck32 = 0.9 time = 165
.meas tran vdout1_73ck32 FIND v(dout1_73) AT=165.025n

* CHECK dout1_74 Vdout1_74ck32 = 0.9 time = 165
.meas tran vdout1_74ck32 FIND v(dout1_74) AT=165.025n

* CHECK dout1_75 Vdout1_75ck32 = 0.9 time = 165
.meas tran vdout1_75ck32 FIND v(dout1_75) AT=165.025n

* CHECK dout1_76 Vdout1_76ck32 = 0 time = 165
.meas tran vdout1_76ck32 FIND v(dout1_76) AT=165.025n

* CHECK dout1_77 Vdout1_77ck32 = 0 time = 165
.meas tran vdout1_77ck32 FIND v(dout1_77) AT=165.025n

* CHECK dout1_78 Vdout1_78ck32 = 0 time = 165
.meas tran vdout1_78ck32 FIND v(dout1_78) AT=165.025n

* CHECK dout1_79 Vdout1_79ck32 = 0.9 time = 165
.meas tran vdout1_79ck32 FIND v(dout1_79) AT=165.025n

* CHECK dout1_80 Vdout1_80ck32 = 0 time = 165
.meas tran vdout1_80ck32 FIND v(dout1_80) AT=165.025n

* CHECK dout1_81 Vdout1_81ck32 = 0 time = 165
.meas tran vdout1_81ck32 FIND v(dout1_81) AT=165.025n

* CHECK dout1_82 Vdout1_82ck32 = 0 time = 165
.meas tran vdout1_82ck32 FIND v(dout1_82) AT=165.025n

* CHECK dout1_83 Vdout1_83ck32 = 0 time = 165
.meas tran vdout1_83ck32 FIND v(dout1_83) AT=165.025n

* CHECK dout1_84 Vdout1_84ck32 = 0 time = 165
.meas tran vdout1_84ck32 FIND v(dout1_84) AT=165.025n

* CHECK dout1_85 Vdout1_85ck32 = 0.9 time = 165
.meas tran vdout1_85ck32 FIND v(dout1_85) AT=165.025n

* CHECK dout1_86 Vdout1_86ck32 = 0.9 time = 165
.meas tran vdout1_86ck32 FIND v(dout1_86) AT=165.025n

* CHECK dout1_87 Vdout1_87ck32 = 0.9 time = 165
.meas tran vdout1_87ck32 FIND v(dout1_87) AT=165.025n

* CHECK dout1_88 Vdout1_88ck32 = 0.9 time = 165
.meas tran vdout1_88ck32 FIND v(dout1_88) AT=165.025n

* CHECK dout1_89 Vdout1_89ck32 = 0.9 time = 165
.meas tran vdout1_89ck32 FIND v(dout1_89) AT=165.025n

* CHECK dout1_90 Vdout1_90ck32 = 0 time = 165
.meas tran vdout1_90ck32 FIND v(dout1_90) AT=165.025n

* CHECK dout1_91 Vdout1_91ck32 = 0.9 time = 165
.meas tran vdout1_91ck32 FIND v(dout1_91) AT=165.025n

* CHECK dout1_92 Vdout1_92ck32 = 0.9 time = 165
.meas tran vdout1_92ck32 FIND v(dout1_92) AT=165.025n

* CHECK dout1_93 Vdout1_93ck32 = 0 time = 165
.meas tran vdout1_93ck32 FIND v(dout1_93) AT=165.025n

* CHECK dout1_94 Vdout1_94ck32 = 0 time = 165
.meas tran vdout1_94ck32 FIND v(dout1_94) AT=165.025n

* CHECK dout1_95 Vdout1_95ck32 = 0 time = 165
.meas tran vdout1_95ck32 FIND v(dout1_95) AT=165.025n

* CHECK dout1_0 Vdout1_0ck33 = 0 time = 170
.meas tran vdout1_0ck33 FIND v(dout1_0) AT=170.025n

* CHECK dout1_1 Vdout1_1ck33 = 0 time = 170
.meas tran vdout1_1ck33 FIND v(dout1_1) AT=170.025n

* CHECK dout1_2 Vdout1_2ck33 = 0.9 time = 170
.meas tran vdout1_2ck33 FIND v(dout1_2) AT=170.025n

* CHECK dout1_3 Vdout1_3ck33 = 0 time = 170
.meas tran vdout1_3ck33 FIND v(dout1_3) AT=170.025n

* CHECK dout1_4 Vdout1_4ck33 = 0.9 time = 170
.meas tran vdout1_4ck33 FIND v(dout1_4) AT=170.025n

* CHECK dout1_5 Vdout1_5ck33 = 0 time = 170
.meas tran vdout1_5ck33 FIND v(dout1_5) AT=170.025n

* CHECK dout1_6 Vdout1_6ck33 = 0 time = 170
.meas tran vdout1_6ck33 FIND v(dout1_6) AT=170.025n

* CHECK dout1_7 Vdout1_7ck33 = 0 time = 170
.meas tran vdout1_7ck33 FIND v(dout1_7) AT=170.025n

* CHECK dout1_8 Vdout1_8ck33 = 0.9 time = 170
.meas tran vdout1_8ck33 FIND v(dout1_8) AT=170.025n

* CHECK dout1_9 Vdout1_9ck33 = 0 time = 170
.meas tran vdout1_9ck33 FIND v(dout1_9) AT=170.025n

* CHECK dout1_10 Vdout1_10ck33 = 0 time = 170
.meas tran vdout1_10ck33 FIND v(dout1_10) AT=170.025n

* CHECK dout1_11 Vdout1_11ck33 = 0.9 time = 170
.meas tran vdout1_11ck33 FIND v(dout1_11) AT=170.025n

* CHECK dout1_12 Vdout1_12ck33 = 0 time = 170
.meas tran vdout1_12ck33 FIND v(dout1_12) AT=170.025n

* CHECK dout1_13 Vdout1_13ck33 = 0 time = 170
.meas tran vdout1_13ck33 FIND v(dout1_13) AT=170.025n

* CHECK dout1_14 Vdout1_14ck33 = 0.9 time = 170
.meas tran vdout1_14ck33 FIND v(dout1_14) AT=170.025n

* CHECK dout1_15 Vdout1_15ck33 = 0.9 time = 170
.meas tran vdout1_15ck33 FIND v(dout1_15) AT=170.025n

* CHECK dout1_16 Vdout1_16ck33 = 0 time = 170
.meas tran vdout1_16ck33 FIND v(dout1_16) AT=170.025n

* CHECK dout1_17 Vdout1_17ck33 = 0.9 time = 170
.meas tran vdout1_17ck33 FIND v(dout1_17) AT=170.025n

* CHECK dout1_18 Vdout1_18ck33 = 0.9 time = 170
.meas tran vdout1_18ck33 FIND v(dout1_18) AT=170.025n

* CHECK dout1_19 Vdout1_19ck33 = 0 time = 170
.meas tran vdout1_19ck33 FIND v(dout1_19) AT=170.025n

* CHECK dout1_20 Vdout1_20ck33 = 0 time = 170
.meas tran vdout1_20ck33 FIND v(dout1_20) AT=170.025n

* CHECK dout1_21 Vdout1_21ck33 = 0 time = 170
.meas tran vdout1_21ck33 FIND v(dout1_21) AT=170.025n

* CHECK dout1_22 Vdout1_22ck33 = 0.9 time = 170
.meas tran vdout1_22ck33 FIND v(dout1_22) AT=170.025n

* CHECK dout1_23 Vdout1_23ck33 = 0.9 time = 170
.meas tran vdout1_23ck33 FIND v(dout1_23) AT=170.025n

* CHECK dout1_24 Vdout1_24ck33 = 0.9 time = 170
.meas tran vdout1_24ck33 FIND v(dout1_24) AT=170.025n

* CHECK dout1_25 Vdout1_25ck33 = 0.9 time = 170
.meas tran vdout1_25ck33 FIND v(dout1_25) AT=170.025n

* CHECK dout1_26 Vdout1_26ck33 = 0.9 time = 170
.meas tran vdout1_26ck33 FIND v(dout1_26) AT=170.025n

* CHECK dout1_27 Vdout1_27ck33 = 0 time = 170
.meas tran vdout1_27ck33 FIND v(dout1_27) AT=170.025n

* CHECK dout1_28 Vdout1_28ck33 = 0.9 time = 170
.meas tran vdout1_28ck33 FIND v(dout1_28) AT=170.025n

* CHECK dout1_29 Vdout1_29ck33 = 0.9 time = 170
.meas tran vdout1_29ck33 FIND v(dout1_29) AT=170.025n

* CHECK dout1_30 Vdout1_30ck33 = 0 time = 170
.meas tran vdout1_30ck33 FIND v(dout1_30) AT=170.025n

* CHECK dout1_31 Vdout1_31ck33 = 0.9 time = 170
.meas tran vdout1_31ck33 FIND v(dout1_31) AT=170.025n

* CHECK dout1_32 Vdout1_32ck33 = 0.9 time = 170
.meas tran vdout1_32ck33 FIND v(dout1_32) AT=170.025n

* CHECK dout1_33 Vdout1_33ck33 = 0.9 time = 170
.meas tran vdout1_33ck33 FIND v(dout1_33) AT=170.025n

* CHECK dout1_34 Vdout1_34ck33 = 0.9 time = 170
.meas tran vdout1_34ck33 FIND v(dout1_34) AT=170.025n

* CHECK dout1_35 Vdout1_35ck33 = 0 time = 170
.meas tran vdout1_35ck33 FIND v(dout1_35) AT=170.025n

* CHECK dout1_36 Vdout1_36ck33 = 0.9 time = 170
.meas tran vdout1_36ck33 FIND v(dout1_36) AT=170.025n

* CHECK dout1_37 Vdout1_37ck33 = 0 time = 170
.meas tran vdout1_37ck33 FIND v(dout1_37) AT=170.025n

* CHECK dout1_38 Vdout1_38ck33 = 0 time = 170
.meas tran vdout1_38ck33 FIND v(dout1_38) AT=170.025n

* CHECK dout1_39 Vdout1_39ck33 = 0 time = 170
.meas tran vdout1_39ck33 FIND v(dout1_39) AT=170.025n

* CHECK dout1_40 Vdout1_40ck33 = 0.9 time = 170
.meas tran vdout1_40ck33 FIND v(dout1_40) AT=170.025n

* CHECK dout1_41 Vdout1_41ck33 = 0.9 time = 170
.meas tran vdout1_41ck33 FIND v(dout1_41) AT=170.025n

* CHECK dout1_42 Vdout1_42ck33 = 0 time = 170
.meas tran vdout1_42ck33 FIND v(dout1_42) AT=170.025n

* CHECK dout1_43 Vdout1_43ck33 = 0 time = 170
.meas tran vdout1_43ck33 FIND v(dout1_43) AT=170.025n

* CHECK dout1_44 Vdout1_44ck33 = 0 time = 170
.meas tran vdout1_44ck33 FIND v(dout1_44) AT=170.025n

* CHECK dout1_45 Vdout1_45ck33 = 0 time = 170
.meas tran vdout1_45ck33 FIND v(dout1_45) AT=170.025n

* CHECK dout1_46 Vdout1_46ck33 = 0.9 time = 170
.meas tran vdout1_46ck33 FIND v(dout1_46) AT=170.025n

* CHECK dout1_47 Vdout1_47ck33 = 0 time = 170
.meas tran vdout1_47ck33 FIND v(dout1_47) AT=170.025n

* CHECK dout1_48 Vdout1_48ck33 = 0.9 time = 170
.meas tran vdout1_48ck33 FIND v(dout1_48) AT=170.025n

* CHECK dout1_49 Vdout1_49ck33 = 0 time = 170
.meas tran vdout1_49ck33 FIND v(dout1_49) AT=170.025n

* CHECK dout1_50 Vdout1_50ck33 = 0.9 time = 170
.meas tran vdout1_50ck33 FIND v(dout1_50) AT=170.025n

* CHECK dout1_51 Vdout1_51ck33 = 0.9 time = 170
.meas tran vdout1_51ck33 FIND v(dout1_51) AT=170.025n

* CHECK dout1_52 Vdout1_52ck33 = 0.9 time = 170
.meas tran vdout1_52ck33 FIND v(dout1_52) AT=170.025n

* CHECK dout1_53 Vdout1_53ck33 = 0 time = 170
.meas tran vdout1_53ck33 FIND v(dout1_53) AT=170.025n

* CHECK dout1_54 Vdout1_54ck33 = 0.9 time = 170
.meas tran vdout1_54ck33 FIND v(dout1_54) AT=170.025n

* CHECK dout1_55 Vdout1_55ck33 = 0.9 time = 170
.meas tran vdout1_55ck33 FIND v(dout1_55) AT=170.025n

* CHECK dout1_56 Vdout1_56ck33 = 0.9 time = 170
.meas tran vdout1_56ck33 FIND v(dout1_56) AT=170.025n

* CHECK dout1_57 Vdout1_57ck33 = 0 time = 170
.meas tran vdout1_57ck33 FIND v(dout1_57) AT=170.025n

* CHECK dout1_58 Vdout1_58ck33 = 0.9 time = 170
.meas tran vdout1_58ck33 FIND v(dout1_58) AT=170.025n

* CHECK dout1_59 Vdout1_59ck33 = 0 time = 170
.meas tran vdout1_59ck33 FIND v(dout1_59) AT=170.025n

* CHECK dout1_60 Vdout1_60ck33 = 0.9 time = 170
.meas tran vdout1_60ck33 FIND v(dout1_60) AT=170.025n

* CHECK dout1_61 Vdout1_61ck33 = 0 time = 170
.meas tran vdout1_61ck33 FIND v(dout1_61) AT=170.025n

* CHECK dout1_62 Vdout1_62ck33 = 0 time = 170
.meas tran vdout1_62ck33 FIND v(dout1_62) AT=170.025n

* CHECK dout1_63 Vdout1_63ck33 = 0 time = 170
.meas tran vdout1_63ck33 FIND v(dout1_63) AT=170.025n

* CHECK dout1_64 Vdout1_64ck33 = 0 time = 170
.meas tran vdout1_64ck33 FIND v(dout1_64) AT=170.025n

* CHECK dout1_65 Vdout1_65ck33 = 0.9 time = 170
.meas tran vdout1_65ck33 FIND v(dout1_65) AT=170.025n

* CHECK dout1_66 Vdout1_66ck33 = 0 time = 170
.meas tran vdout1_66ck33 FIND v(dout1_66) AT=170.025n

* CHECK dout1_67 Vdout1_67ck33 = 0 time = 170
.meas tran vdout1_67ck33 FIND v(dout1_67) AT=170.025n

* CHECK dout1_68 Vdout1_68ck33 = 0 time = 170
.meas tran vdout1_68ck33 FIND v(dout1_68) AT=170.025n

* CHECK dout1_69 Vdout1_69ck33 = 0.9 time = 170
.meas tran vdout1_69ck33 FIND v(dout1_69) AT=170.025n

* CHECK dout1_70 Vdout1_70ck33 = 0 time = 170
.meas tran vdout1_70ck33 FIND v(dout1_70) AT=170.025n

* CHECK dout1_71 Vdout1_71ck33 = 0.9 time = 170
.meas tran vdout1_71ck33 FIND v(dout1_71) AT=170.025n

* CHECK dout1_72 Vdout1_72ck33 = 0 time = 170
.meas tran vdout1_72ck33 FIND v(dout1_72) AT=170.025n

* CHECK dout1_73 Vdout1_73ck33 = 0.9 time = 170
.meas tran vdout1_73ck33 FIND v(dout1_73) AT=170.025n

* CHECK dout1_74 Vdout1_74ck33 = 0.9 time = 170
.meas tran vdout1_74ck33 FIND v(dout1_74) AT=170.025n

* CHECK dout1_75 Vdout1_75ck33 = 0.9 time = 170
.meas tran vdout1_75ck33 FIND v(dout1_75) AT=170.025n

* CHECK dout1_76 Vdout1_76ck33 = 0 time = 170
.meas tran vdout1_76ck33 FIND v(dout1_76) AT=170.025n

* CHECK dout1_77 Vdout1_77ck33 = 0 time = 170
.meas tran vdout1_77ck33 FIND v(dout1_77) AT=170.025n

* CHECK dout1_78 Vdout1_78ck33 = 0 time = 170
.meas tran vdout1_78ck33 FIND v(dout1_78) AT=170.025n

* CHECK dout1_79 Vdout1_79ck33 = 0.9 time = 170
.meas tran vdout1_79ck33 FIND v(dout1_79) AT=170.025n

* CHECK dout1_80 Vdout1_80ck33 = 0 time = 170
.meas tran vdout1_80ck33 FIND v(dout1_80) AT=170.025n

* CHECK dout1_81 Vdout1_81ck33 = 0 time = 170
.meas tran vdout1_81ck33 FIND v(dout1_81) AT=170.025n

* CHECK dout1_82 Vdout1_82ck33 = 0 time = 170
.meas tran vdout1_82ck33 FIND v(dout1_82) AT=170.025n

* CHECK dout1_83 Vdout1_83ck33 = 0 time = 170
.meas tran vdout1_83ck33 FIND v(dout1_83) AT=170.025n

* CHECK dout1_84 Vdout1_84ck33 = 0 time = 170
.meas tran vdout1_84ck33 FIND v(dout1_84) AT=170.025n

* CHECK dout1_85 Vdout1_85ck33 = 0.9 time = 170
.meas tran vdout1_85ck33 FIND v(dout1_85) AT=170.025n

* CHECK dout1_86 Vdout1_86ck33 = 0.9 time = 170
.meas tran vdout1_86ck33 FIND v(dout1_86) AT=170.025n

* CHECK dout1_87 Vdout1_87ck33 = 0.9 time = 170
.meas tran vdout1_87ck33 FIND v(dout1_87) AT=170.025n

* CHECK dout1_88 Vdout1_88ck33 = 0.9 time = 170
.meas tran vdout1_88ck33 FIND v(dout1_88) AT=170.025n

* CHECK dout1_89 Vdout1_89ck33 = 0.9 time = 170
.meas tran vdout1_89ck33 FIND v(dout1_89) AT=170.025n

* CHECK dout1_90 Vdout1_90ck33 = 0 time = 170
.meas tran vdout1_90ck33 FIND v(dout1_90) AT=170.025n

* CHECK dout1_91 Vdout1_91ck33 = 0.9 time = 170
.meas tran vdout1_91ck33 FIND v(dout1_91) AT=170.025n

* CHECK dout1_92 Vdout1_92ck33 = 0.9 time = 170
.meas tran vdout1_92ck33 FIND v(dout1_92) AT=170.025n

* CHECK dout1_93 Vdout1_93ck33 = 0 time = 170
.meas tran vdout1_93ck33 FIND v(dout1_93) AT=170.025n

* CHECK dout1_94 Vdout1_94ck33 = 0 time = 170
.meas tran vdout1_94ck33 FIND v(dout1_94) AT=170.025n

* CHECK dout1_95 Vdout1_95ck33 = 0 time = 170
.meas tran vdout1_95ck33 FIND v(dout1_95) AT=170.025n

* CHECK dout1_0 Vdout1_0ck36 = 0.9 time = 185
.meas tran vdout1_0ck36 FIND v(dout1_0) AT=185.025n

* CHECK dout1_1 Vdout1_1ck36 = 0.9 time = 185
.meas tran vdout1_1ck36 FIND v(dout1_1) AT=185.025n

* CHECK dout1_2 Vdout1_2ck36 = 0.9 time = 185
.meas tran vdout1_2ck36 FIND v(dout1_2) AT=185.025n

* CHECK dout1_3 Vdout1_3ck36 = 0 time = 185
.meas tran vdout1_3ck36 FIND v(dout1_3) AT=185.025n

* CHECK dout1_4 Vdout1_4ck36 = 0.9 time = 185
.meas tran vdout1_4ck36 FIND v(dout1_4) AT=185.025n

* CHECK dout1_5 Vdout1_5ck36 = 0.9 time = 185
.meas tran vdout1_5ck36 FIND v(dout1_5) AT=185.025n

* CHECK dout1_6 Vdout1_6ck36 = 0.9 time = 185
.meas tran vdout1_6ck36 FIND v(dout1_6) AT=185.025n

* CHECK dout1_7 Vdout1_7ck36 = 0.9 time = 185
.meas tran vdout1_7ck36 FIND v(dout1_7) AT=185.025n

* CHECK dout1_8 Vdout1_8ck36 = 0 time = 185
.meas tran vdout1_8ck36 FIND v(dout1_8) AT=185.025n

* CHECK dout1_9 Vdout1_9ck36 = 0 time = 185
.meas tran vdout1_9ck36 FIND v(dout1_9) AT=185.025n

* CHECK dout1_10 Vdout1_10ck36 = 0 time = 185
.meas tran vdout1_10ck36 FIND v(dout1_10) AT=185.025n

* CHECK dout1_11 Vdout1_11ck36 = 0.9 time = 185
.meas tran vdout1_11ck36 FIND v(dout1_11) AT=185.025n

* CHECK dout1_12 Vdout1_12ck36 = 0 time = 185
.meas tran vdout1_12ck36 FIND v(dout1_12) AT=185.025n

* CHECK dout1_13 Vdout1_13ck36 = 0 time = 185
.meas tran vdout1_13ck36 FIND v(dout1_13) AT=185.025n

* CHECK dout1_14 Vdout1_14ck36 = 0 time = 185
.meas tran vdout1_14ck36 FIND v(dout1_14) AT=185.025n

* CHECK dout1_15 Vdout1_15ck36 = 0 time = 185
.meas tran vdout1_15ck36 FIND v(dout1_15) AT=185.025n

* CHECK dout1_16 Vdout1_16ck36 = 0 time = 185
.meas tran vdout1_16ck36 FIND v(dout1_16) AT=185.025n

* CHECK dout1_17 Vdout1_17ck36 = 0 time = 185
.meas tran vdout1_17ck36 FIND v(dout1_17) AT=185.025n

* CHECK dout1_18 Vdout1_18ck36 = 0 time = 185
.meas tran vdout1_18ck36 FIND v(dout1_18) AT=185.025n

* CHECK dout1_19 Vdout1_19ck36 = 0 time = 185
.meas tran vdout1_19ck36 FIND v(dout1_19) AT=185.025n

* CHECK dout1_20 Vdout1_20ck36 = 0.9 time = 185
.meas tran vdout1_20ck36 FIND v(dout1_20) AT=185.025n

* CHECK dout1_21 Vdout1_21ck36 = 0 time = 185
.meas tran vdout1_21ck36 FIND v(dout1_21) AT=185.025n

* CHECK dout1_22 Vdout1_22ck36 = 0.9 time = 185
.meas tran vdout1_22ck36 FIND v(dout1_22) AT=185.025n

* CHECK dout1_23 Vdout1_23ck36 = 0 time = 185
.meas tran vdout1_23ck36 FIND v(dout1_23) AT=185.025n

* CHECK dout1_24 Vdout1_24ck36 = 0 time = 185
.meas tran vdout1_24ck36 FIND v(dout1_24) AT=185.025n

* CHECK dout1_25 Vdout1_25ck36 = 0 time = 185
.meas tran vdout1_25ck36 FIND v(dout1_25) AT=185.025n

* CHECK dout1_26 Vdout1_26ck36 = 0.9 time = 185
.meas tran vdout1_26ck36 FIND v(dout1_26) AT=185.025n

* CHECK dout1_27 Vdout1_27ck36 = 0.9 time = 185
.meas tran vdout1_27ck36 FIND v(dout1_27) AT=185.025n

* CHECK dout1_28 Vdout1_28ck36 = 0 time = 185
.meas tran vdout1_28ck36 FIND v(dout1_28) AT=185.025n

* CHECK dout1_29 Vdout1_29ck36 = 0 time = 185
.meas tran vdout1_29ck36 FIND v(dout1_29) AT=185.025n

* CHECK dout1_30 Vdout1_30ck36 = 0.9 time = 185
.meas tran vdout1_30ck36 FIND v(dout1_30) AT=185.025n

* CHECK dout1_31 Vdout1_31ck36 = 0.9 time = 185
.meas tran vdout1_31ck36 FIND v(dout1_31) AT=185.025n

* CHECK dout1_32 Vdout1_32ck36 = 0.9 time = 185
.meas tran vdout1_32ck36 FIND v(dout1_32) AT=185.025n

* CHECK dout1_33 Vdout1_33ck36 = 0 time = 185
.meas tran vdout1_33ck36 FIND v(dout1_33) AT=185.025n

* CHECK dout1_34 Vdout1_34ck36 = 0.9 time = 185
.meas tran vdout1_34ck36 FIND v(dout1_34) AT=185.025n

* CHECK dout1_35 Vdout1_35ck36 = 0.9 time = 185
.meas tran vdout1_35ck36 FIND v(dout1_35) AT=185.025n

* CHECK dout1_36 Vdout1_36ck36 = 0 time = 185
.meas tran vdout1_36ck36 FIND v(dout1_36) AT=185.025n

* CHECK dout1_37 Vdout1_37ck36 = 0 time = 185
.meas tran vdout1_37ck36 FIND v(dout1_37) AT=185.025n

* CHECK dout1_38 Vdout1_38ck36 = 0.9 time = 185
.meas tran vdout1_38ck36 FIND v(dout1_38) AT=185.025n

* CHECK dout1_39 Vdout1_39ck36 = 0.9 time = 185
.meas tran vdout1_39ck36 FIND v(dout1_39) AT=185.025n

* CHECK dout1_40 Vdout1_40ck36 = 0.9 time = 185
.meas tran vdout1_40ck36 FIND v(dout1_40) AT=185.025n

* CHECK dout1_41 Vdout1_41ck36 = 0.9 time = 185
.meas tran vdout1_41ck36 FIND v(dout1_41) AT=185.025n

* CHECK dout1_42 Vdout1_42ck36 = 0 time = 185
.meas tran vdout1_42ck36 FIND v(dout1_42) AT=185.025n

* CHECK dout1_43 Vdout1_43ck36 = 0 time = 185
.meas tran vdout1_43ck36 FIND v(dout1_43) AT=185.025n

* CHECK dout1_44 Vdout1_44ck36 = 0 time = 185
.meas tran vdout1_44ck36 FIND v(dout1_44) AT=185.025n

* CHECK dout1_45 Vdout1_45ck36 = 0.9 time = 185
.meas tran vdout1_45ck36 FIND v(dout1_45) AT=185.025n

* CHECK dout1_46 Vdout1_46ck36 = 0 time = 185
.meas tran vdout1_46ck36 FIND v(dout1_46) AT=185.025n

* CHECK dout1_47 Vdout1_47ck36 = 0 time = 185
.meas tran vdout1_47ck36 FIND v(dout1_47) AT=185.025n

* CHECK dout1_48 Vdout1_48ck36 = 0 time = 185
.meas tran vdout1_48ck36 FIND v(dout1_48) AT=185.025n

* CHECK dout1_49 Vdout1_49ck36 = 0 time = 185
.meas tran vdout1_49ck36 FIND v(dout1_49) AT=185.025n

* CHECK dout1_50 Vdout1_50ck36 = 0.9 time = 185
.meas tran vdout1_50ck36 FIND v(dout1_50) AT=185.025n

* CHECK dout1_51 Vdout1_51ck36 = 0 time = 185
.meas tran vdout1_51ck36 FIND v(dout1_51) AT=185.025n

* CHECK dout1_52 Vdout1_52ck36 = 0 time = 185
.meas tran vdout1_52ck36 FIND v(dout1_52) AT=185.025n

* CHECK dout1_53 Vdout1_53ck36 = 0 time = 185
.meas tran vdout1_53ck36 FIND v(dout1_53) AT=185.025n

* CHECK dout1_54 Vdout1_54ck36 = 0.9 time = 185
.meas tran vdout1_54ck36 FIND v(dout1_54) AT=185.025n

* CHECK dout1_55 Vdout1_55ck36 = 0 time = 185
.meas tran vdout1_55ck36 FIND v(dout1_55) AT=185.025n

* CHECK dout1_56 Vdout1_56ck36 = 0.9 time = 185
.meas tran vdout1_56ck36 FIND v(dout1_56) AT=185.025n

* CHECK dout1_57 Vdout1_57ck36 = 0 time = 185
.meas tran vdout1_57ck36 FIND v(dout1_57) AT=185.025n

* CHECK dout1_58 Vdout1_58ck36 = 0.9 time = 185
.meas tran vdout1_58ck36 FIND v(dout1_58) AT=185.025n

* CHECK dout1_59 Vdout1_59ck36 = 0.9 time = 185
.meas tran vdout1_59ck36 FIND v(dout1_59) AT=185.025n

* CHECK dout1_60 Vdout1_60ck36 = 0 time = 185
.meas tran vdout1_60ck36 FIND v(dout1_60) AT=185.025n

* CHECK dout1_61 Vdout1_61ck36 = 0.9 time = 185
.meas tran vdout1_61ck36 FIND v(dout1_61) AT=185.025n

* CHECK dout1_62 Vdout1_62ck36 = 0.9 time = 185
.meas tran vdout1_62ck36 FIND v(dout1_62) AT=185.025n

* CHECK dout1_63 Vdout1_63ck36 = 0.9 time = 185
.meas tran vdout1_63ck36 FIND v(dout1_63) AT=185.025n

* CHECK dout1_64 Vdout1_64ck36 = 0 time = 185
.meas tran vdout1_64ck36 FIND v(dout1_64) AT=185.025n

* CHECK dout1_65 Vdout1_65ck36 = 0 time = 185
.meas tran vdout1_65ck36 FIND v(dout1_65) AT=185.025n

* CHECK dout1_66 Vdout1_66ck36 = 0.9 time = 185
.meas tran vdout1_66ck36 FIND v(dout1_66) AT=185.025n

* CHECK dout1_67 Vdout1_67ck36 = 0.9 time = 185
.meas tran vdout1_67ck36 FIND v(dout1_67) AT=185.025n

* CHECK dout1_68 Vdout1_68ck36 = 0 time = 185
.meas tran vdout1_68ck36 FIND v(dout1_68) AT=185.025n

* CHECK dout1_69 Vdout1_69ck36 = 0 time = 185
.meas tran vdout1_69ck36 FIND v(dout1_69) AT=185.025n

* CHECK dout1_70 Vdout1_70ck36 = 0.9 time = 185
.meas tran vdout1_70ck36 FIND v(dout1_70) AT=185.025n

* CHECK dout1_71 Vdout1_71ck36 = 0.9 time = 185
.meas tran vdout1_71ck36 FIND v(dout1_71) AT=185.025n

* CHECK dout1_72 Vdout1_72ck36 = 0 time = 185
.meas tran vdout1_72ck36 FIND v(dout1_72) AT=185.025n

* CHECK dout1_73 Vdout1_73ck36 = 0 time = 185
.meas tran vdout1_73ck36 FIND v(dout1_73) AT=185.025n

* CHECK dout1_74 Vdout1_74ck36 = 0.9 time = 185
.meas tran vdout1_74ck36 FIND v(dout1_74) AT=185.025n

* CHECK dout1_75 Vdout1_75ck36 = 0 time = 185
.meas tran vdout1_75ck36 FIND v(dout1_75) AT=185.025n

* CHECK dout1_76 Vdout1_76ck36 = 0.9 time = 185
.meas tran vdout1_76ck36 FIND v(dout1_76) AT=185.025n

* CHECK dout1_77 Vdout1_77ck36 = 0.9 time = 185
.meas tran vdout1_77ck36 FIND v(dout1_77) AT=185.025n

* CHECK dout1_78 Vdout1_78ck36 = 0 time = 185
.meas tran vdout1_78ck36 FIND v(dout1_78) AT=185.025n

* CHECK dout1_79 Vdout1_79ck36 = 0.9 time = 185
.meas tran vdout1_79ck36 FIND v(dout1_79) AT=185.025n

* CHECK dout1_80 Vdout1_80ck36 = 0 time = 185
.meas tran vdout1_80ck36 FIND v(dout1_80) AT=185.025n

* CHECK dout1_81 Vdout1_81ck36 = 0 time = 185
.meas tran vdout1_81ck36 FIND v(dout1_81) AT=185.025n

* CHECK dout1_82 Vdout1_82ck36 = 0.9 time = 185
.meas tran vdout1_82ck36 FIND v(dout1_82) AT=185.025n

* CHECK dout1_83 Vdout1_83ck36 = 0 time = 185
.meas tran vdout1_83ck36 FIND v(dout1_83) AT=185.025n

* CHECK dout1_84 Vdout1_84ck36 = 0 time = 185
.meas tran vdout1_84ck36 FIND v(dout1_84) AT=185.025n

* CHECK dout1_85 Vdout1_85ck36 = 0 time = 185
.meas tran vdout1_85ck36 FIND v(dout1_85) AT=185.025n

* CHECK dout1_86 Vdout1_86ck36 = 0.9 time = 185
.meas tran vdout1_86ck36 FIND v(dout1_86) AT=185.025n

* CHECK dout1_87 Vdout1_87ck36 = 0 time = 185
.meas tran vdout1_87ck36 FIND v(dout1_87) AT=185.025n

* CHECK dout1_88 Vdout1_88ck36 = 0.9 time = 185
.meas tran vdout1_88ck36 FIND v(dout1_88) AT=185.025n

* CHECK dout1_89 Vdout1_89ck36 = 0 time = 185
.meas tran vdout1_89ck36 FIND v(dout1_89) AT=185.025n

* CHECK dout1_90 Vdout1_90ck36 = 0 time = 185
.meas tran vdout1_90ck36 FIND v(dout1_90) AT=185.025n

* CHECK dout1_91 Vdout1_91ck36 = 0.9 time = 185
.meas tran vdout1_91ck36 FIND v(dout1_91) AT=185.025n

* CHECK dout1_92 Vdout1_92ck36 = 0.9 time = 185
.meas tran vdout1_92ck36 FIND v(dout1_92) AT=185.025n

* CHECK dout1_93 Vdout1_93ck36 = 0.9 time = 185
.meas tran vdout1_93ck36 FIND v(dout1_93) AT=185.025n

* CHECK dout1_94 Vdout1_94ck36 = 0 time = 185
.meas tran vdout1_94ck36 FIND v(dout1_94) AT=185.025n

* CHECK dout1_95 Vdout1_95ck36 = 0.9 time = 185
.meas tran vdout1_95ck36 FIND v(dout1_95) AT=185.025n

* CHECK dout1_0 Vdout1_0ck45 = 0 time = 230
.meas tran vdout1_0ck45 FIND v(dout1_0) AT=230.025n

* CHECK dout1_1 Vdout1_1ck45 = 0.9 time = 230
.meas tran vdout1_1ck45 FIND v(dout1_1) AT=230.025n

* CHECK dout1_2 Vdout1_2ck45 = 0 time = 230
.meas tran vdout1_2ck45 FIND v(dout1_2) AT=230.025n

* CHECK dout1_3 Vdout1_3ck45 = 0 time = 230
.meas tran vdout1_3ck45 FIND v(dout1_3) AT=230.025n

* CHECK dout1_4 Vdout1_4ck45 = 0.9 time = 230
.meas tran vdout1_4ck45 FIND v(dout1_4) AT=230.025n

* CHECK dout1_5 Vdout1_5ck45 = 0.9 time = 230
.meas tran vdout1_5ck45 FIND v(dout1_5) AT=230.025n

* CHECK dout1_6 Vdout1_6ck45 = 0 time = 230
.meas tran vdout1_6ck45 FIND v(dout1_6) AT=230.025n

* CHECK dout1_7 Vdout1_7ck45 = 0 time = 230
.meas tran vdout1_7ck45 FIND v(dout1_7) AT=230.025n

* CHECK dout1_8 Vdout1_8ck45 = 0 time = 230
.meas tran vdout1_8ck45 FIND v(dout1_8) AT=230.025n

* CHECK dout1_9 Vdout1_9ck45 = 0.9 time = 230
.meas tran vdout1_9ck45 FIND v(dout1_9) AT=230.025n

* CHECK dout1_10 Vdout1_10ck45 = 0.9 time = 230
.meas tran vdout1_10ck45 FIND v(dout1_10) AT=230.025n

* CHECK dout1_11 Vdout1_11ck45 = 0 time = 230
.meas tran vdout1_11ck45 FIND v(dout1_11) AT=230.025n

* CHECK dout1_12 Vdout1_12ck45 = 0.9 time = 230
.meas tran vdout1_12ck45 FIND v(dout1_12) AT=230.025n

* CHECK dout1_13 Vdout1_13ck45 = 0.9 time = 230
.meas tran vdout1_13ck45 FIND v(dout1_13) AT=230.025n

* CHECK dout1_14 Vdout1_14ck45 = 0.9 time = 230
.meas tran vdout1_14ck45 FIND v(dout1_14) AT=230.025n

* CHECK dout1_15 Vdout1_15ck45 = 0 time = 230
.meas tran vdout1_15ck45 FIND v(dout1_15) AT=230.025n

* CHECK dout1_16 Vdout1_16ck45 = 0 time = 230
.meas tran vdout1_16ck45 FIND v(dout1_16) AT=230.025n

* CHECK dout1_17 Vdout1_17ck45 = 0 time = 230
.meas tran vdout1_17ck45 FIND v(dout1_17) AT=230.025n

* CHECK dout1_18 Vdout1_18ck45 = 0 time = 230
.meas tran vdout1_18ck45 FIND v(dout1_18) AT=230.025n

* CHECK dout1_19 Vdout1_19ck45 = 0 time = 230
.meas tran vdout1_19ck45 FIND v(dout1_19) AT=230.025n

* CHECK dout1_20 Vdout1_20ck45 = 0 time = 230
.meas tran vdout1_20ck45 FIND v(dout1_20) AT=230.025n

* CHECK dout1_21 Vdout1_21ck45 = 0.9 time = 230
.meas tran vdout1_21ck45 FIND v(dout1_21) AT=230.025n

* CHECK dout1_22 Vdout1_22ck45 = 0.9 time = 230
.meas tran vdout1_22ck45 FIND v(dout1_22) AT=230.025n

* CHECK dout1_23 Vdout1_23ck45 = 0.9 time = 230
.meas tran vdout1_23ck45 FIND v(dout1_23) AT=230.025n

* CHECK dout1_24 Vdout1_24ck45 = 0.9 time = 230
.meas tran vdout1_24ck45 FIND v(dout1_24) AT=230.025n

* CHECK dout1_25 Vdout1_25ck45 = 0 time = 230
.meas tran vdout1_25ck45 FIND v(dout1_25) AT=230.025n

* CHECK dout1_26 Vdout1_26ck45 = 0 time = 230
.meas tran vdout1_26ck45 FIND v(dout1_26) AT=230.025n

* CHECK dout1_27 Vdout1_27ck45 = 0.9 time = 230
.meas tran vdout1_27ck45 FIND v(dout1_27) AT=230.025n

* CHECK dout1_28 Vdout1_28ck45 = 0.9 time = 230
.meas tran vdout1_28ck45 FIND v(dout1_28) AT=230.025n

* CHECK dout1_29 Vdout1_29ck45 = 0 time = 230
.meas tran vdout1_29ck45 FIND v(dout1_29) AT=230.025n

* CHECK dout1_30 Vdout1_30ck45 = 0 time = 230
.meas tran vdout1_30ck45 FIND v(dout1_30) AT=230.025n

* CHECK dout1_31 Vdout1_31ck45 = 0.9 time = 230
.meas tran vdout1_31ck45 FIND v(dout1_31) AT=230.025n

* CHECK dout1_32 Vdout1_32ck45 = 0.9 time = 230
.meas tran vdout1_32ck45 FIND v(dout1_32) AT=230.025n

* CHECK dout1_33 Vdout1_33ck45 = 0.9 time = 230
.meas tran vdout1_33ck45 FIND v(dout1_33) AT=230.025n

* CHECK dout1_34 Vdout1_34ck45 = 0.9 time = 230
.meas tran vdout1_34ck45 FIND v(dout1_34) AT=230.025n

* CHECK dout1_35 Vdout1_35ck45 = 0 time = 230
.meas tran vdout1_35ck45 FIND v(dout1_35) AT=230.025n

* CHECK dout1_36 Vdout1_36ck45 = 0.9 time = 230
.meas tran vdout1_36ck45 FIND v(dout1_36) AT=230.025n

* CHECK dout1_37 Vdout1_37ck45 = 0.9 time = 230
.meas tran vdout1_37ck45 FIND v(dout1_37) AT=230.025n

* CHECK dout1_38 Vdout1_38ck45 = 0.9 time = 230
.meas tran vdout1_38ck45 FIND v(dout1_38) AT=230.025n

* CHECK dout1_39 Vdout1_39ck45 = 0.9 time = 230
.meas tran vdout1_39ck45 FIND v(dout1_39) AT=230.025n

* CHECK dout1_40 Vdout1_40ck45 = 0 time = 230
.meas tran vdout1_40ck45 FIND v(dout1_40) AT=230.025n

* CHECK dout1_41 Vdout1_41ck45 = 0.9 time = 230
.meas tran vdout1_41ck45 FIND v(dout1_41) AT=230.025n

* CHECK dout1_42 Vdout1_42ck45 = 0.9 time = 230
.meas tran vdout1_42ck45 FIND v(dout1_42) AT=230.025n

* CHECK dout1_43 Vdout1_43ck45 = 0 time = 230
.meas tran vdout1_43ck45 FIND v(dout1_43) AT=230.025n

* CHECK dout1_44 Vdout1_44ck45 = 0 time = 230
.meas tran vdout1_44ck45 FIND v(dout1_44) AT=230.025n

* CHECK dout1_45 Vdout1_45ck45 = 0 time = 230
.meas tran vdout1_45ck45 FIND v(dout1_45) AT=230.025n

* CHECK dout1_46 Vdout1_46ck45 = 0 time = 230
.meas tran vdout1_46ck45 FIND v(dout1_46) AT=230.025n

* CHECK dout1_47 Vdout1_47ck45 = 0.9 time = 230
.meas tran vdout1_47ck45 FIND v(dout1_47) AT=230.025n

* CHECK dout1_48 Vdout1_48ck45 = 0.9 time = 230
.meas tran vdout1_48ck45 FIND v(dout1_48) AT=230.025n

* CHECK dout1_49 Vdout1_49ck45 = 0 time = 230
.meas tran vdout1_49ck45 FIND v(dout1_49) AT=230.025n

* CHECK dout1_50 Vdout1_50ck45 = 0 time = 230
.meas tran vdout1_50ck45 FIND v(dout1_50) AT=230.025n

* CHECK dout1_51 Vdout1_51ck45 = 0.9 time = 230
.meas tran vdout1_51ck45 FIND v(dout1_51) AT=230.025n

* CHECK dout1_52 Vdout1_52ck45 = 0.9 time = 230
.meas tran vdout1_52ck45 FIND v(dout1_52) AT=230.025n

* CHECK dout1_53 Vdout1_53ck45 = 0.9 time = 230
.meas tran vdout1_53ck45 FIND v(dout1_53) AT=230.025n

* CHECK dout1_54 Vdout1_54ck45 = 0 time = 230
.meas tran vdout1_54ck45 FIND v(dout1_54) AT=230.025n

* CHECK dout1_55 Vdout1_55ck45 = 0.9 time = 230
.meas tran vdout1_55ck45 FIND v(dout1_55) AT=230.025n

* CHECK dout1_56 Vdout1_56ck45 = 0 time = 230
.meas tran vdout1_56ck45 FIND v(dout1_56) AT=230.025n

* CHECK dout1_57 Vdout1_57ck45 = 0 time = 230
.meas tran vdout1_57ck45 FIND v(dout1_57) AT=230.025n

* CHECK dout1_58 Vdout1_58ck45 = 0.9 time = 230
.meas tran vdout1_58ck45 FIND v(dout1_58) AT=230.025n

* CHECK dout1_59 Vdout1_59ck45 = 0 time = 230
.meas tran vdout1_59ck45 FIND v(dout1_59) AT=230.025n

* CHECK dout1_60 Vdout1_60ck45 = 0 time = 230
.meas tran vdout1_60ck45 FIND v(dout1_60) AT=230.025n

* CHECK dout1_61 Vdout1_61ck45 = 0 time = 230
.meas tran vdout1_61ck45 FIND v(dout1_61) AT=230.025n

* CHECK dout1_62 Vdout1_62ck45 = 0 time = 230
.meas tran vdout1_62ck45 FIND v(dout1_62) AT=230.025n

* CHECK dout1_63 Vdout1_63ck45 = 0 time = 230
.meas tran vdout1_63ck45 FIND v(dout1_63) AT=230.025n

* CHECK dout1_64 Vdout1_64ck45 = 0 time = 230
.meas tran vdout1_64ck45 FIND v(dout1_64) AT=230.025n

* CHECK dout1_65 Vdout1_65ck45 = 0 time = 230
.meas tran vdout1_65ck45 FIND v(dout1_65) AT=230.025n

* CHECK dout1_66 Vdout1_66ck45 = 0 time = 230
.meas tran vdout1_66ck45 FIND v(dout1_66) AT=230.025n

* CHECK dout1_67 Vdout1_67ck45 = 0 time = 230
.meas tran vdout1_67ck45 FIND v(dout1_67) AT=230.025n

* CHECK dout1_68 Vdout1_68ck45 = 0 time = 230
.meas tran vdout1_68ck45 FIND v(dout1_68) AT=230.025n

* CHECK dout1_69 Vdout1_69ck45 = 0 time = 230
.meas tran vdout1_69ck45 FIND v(dout1_69) AT=230.025n

* CHECK dout1_70 Vdout1_70ck45 = 0.9 time = 230
.meas tran vdout1_70ck45 FIND v(dout1_70) AT=230.025n

* CHECK dout1_71 Vdout1_71ck45 = 0 time = 230
.meas tran vdout1_71ck45 FIND v(dout1_71) AT=230.025n

* CHECK dout1_72 Vdout1_72ck45 = 0.9 time = 230
.meas tran vdout1_72ck45 FIND v(dout1_72) AT=230.025n

* CHECK dout1_73 Vdout1_73ck45 = 0.9 time = 230
.meas tran vdout1_73ck45 FIND v(dout1_73) AT=230.025n

* CHECK dout1_74 Vdout1_74ck45 = 0 time = 230
.meas tran vdout1_74ck45 FIND v(dout1_74) AT=230.025n

* CHECK dout1_75 Vdout1_75ck45 = 0 time = 230
.meas tran vdout1_75ck45 FIND v(dout1_75) AT=230.025n

* CHECK dout1_76 Vdout1_76ck45 = 0.9 time = 230
.meas tran vdout1_76ck45 FIND v(dout1_76) AT=230.025n

* CHECK dout1_77 Vdout1_77ck45 = 0 time = 230
.meas tran vdout1_77ck45 FIND v(dout1_77) AT=230.025n

* CHECK dout1_78 Vdout1_78ck45 = 0.9 time = 230
.meas tran vdout1_78ck45 FIND v(dout1_78) AT=230.025n

* CHECK dout1_79 Vdout1_79ck45 = 0.9 time = 230
.meas tran vdout1_79ck45 FIND v(dout1_79) AT=230.025n

* CHECK dout1_80 Vdout1_80ck45 = 0.9 time = 230
.meas tran vdout1_80ck45 FIND v(dout1_80) AT=230.025n

* CHECK dout1_81 Vdout1_81ck45 = 0.9 time = 230
.meas tran vdout1_81ck45 FIND v(dout1_81) AT=230.025n

* CHECK dout1_82 Vdout1_82ck45 = 0.9 time = 230
.meas tran vdout1_82ck45 FIND v(dout1_82) AT=230.025n

* CHECK dout1_83 Vdout1_83ck45 = 0.9 time = 230
.meas tran vdout1_83ck45 FIND v(dout1_83) AT=230.025n

* CHECK dout1_84 Vdout1_84ck45 = 0.9 time = 230
.meas tran vdout1_84ck45 FIND v(dout1_84) AT=230.025n

* CHECK dout1_85 Vdout1_85ck45 = 0.9 time = 230
.meas tran vdout1_85ck45 FIND v(dout1_85) AT=230.025n

* CHECK dout1_86 Vdout1_86ck45 = 0.9 time = 230
.meas tran vdout1_86ck45 FIND v(dout1_86) AT=230.025n

* CHECK dout1_87 Vdout1_87ck45 = 0.9 time = 230
.meas tran vdout1_87ck45 FIND v(dout1_87) AT=230.025n

* CHECK dout1_88 Vdout1_88ck45 = 0.9 time = 230
.meas tran vdout1_88ck45 FIND v(dout1_88) AT=230.025n

* CHECK dout1_89 Vdout1_89ck45 = 0 time = 230
.meas tran vdout1_89ck45 FIND v(dout1_89) AT=230.025n

* CHECK dout1_90 Vdout1_90ck45 = 0.9 time = 230
.meas tran vdout1_90ck45 FIND v(dout1_90) AT=230.025n

* CHECK dout1_91 Vdout1_91ck45 = 0.9 time = 230
.meas tran vdout1_91ck45 FIND v(dout1_91) AT=230.025n

* CHECK dout1_92 Vdout1_92ck45 = 0 time = 230
.meas tran vdout1_92ck45 FIND v(dout1_92) AT=230.025n

* CHECK dout1_93 Vdout1_93ck45 = 0 time = 230
.meas tran vdout1_93ck45 FIND v(dout1_93) AT=230.025n

* CHECK dout1_94 Vdout1_94ck45 = 0.9 time = 230
.meas tran vdout1_94ck45 FIND v(dout1_94) AT=230.025n

* CHECK dout1_95 Vdout1_95ck45 = 0 time = 230
.meas tran vdout1_95ck45 FIND v(dout1_95) AT=230.025n

* CHECK dout1_0 Vdout1_0ck50 = 0.9 time = 255
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=255.025n

* CHECK dout1_1 Vdout1_1ck50 = 0 time = 255
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=255.025n

* CHECK dout1_2 Vdout1_2ck50 = 0 time = 255
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=255.025n

* CHECK dout1_3 Vdout1_3ck50 = 0 time = 255
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=255.025n

* CHECK dout1_4 Vdout1_4ck50 = 0.9 time = 255
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=255.025n

* CHECK dout1_5 Vdout1_5ck50 = 0 time = 255
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=255.025n

* CHECK dout1_6 Vdout1_6ck50 = 0 time = 255
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=255.025n

* CHECK dout1_7 Vdout1_7ck50 = 0.9 time = 255
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=255.025n

* CHECK dout1_8 Vdout1_8ck50 = 0 time = 255
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=255.025n

* CHECK dout1_9 Vdout1_9ck50 = 0 time = 255
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=255.025n

* CHECK dout1_10 Vdout1_10ck50 = 0.9 time = 255
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=255.025n

* CHECK dout1_11 Vdout1_11ck50 = 0.9 time = 255
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=255.025n

* CHECK dout1_12 Vdout1_12ck50 = 0 time = 255
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=255.025n

* CHECK dout1_13 Vdout1_13ck50 = 0 time = 255
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=255.025n

* CHECK dout1_14 Vdout1_14ck50 = 0 time = 255
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=255.025n

* CHECK dout1_15 Vdout1_15ck50 = 0.9 time = 255
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=255.025n

* CHECK dout1_16 Vdout1_16ck50 = 0.9 time = 255
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=255.025n

* CHECK dout1_17 Vdout1_17ck50 = 0.9 time = 255
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=255.025n

* CHECK dout1_18 Vdout1_18ck50 = 0.9 time = 255
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=255.025n

* CHECK dout1_19 Vdout1_19ck50 = 0.9 time = 255
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=255.025n

* CHECK dout1_20 Vdout1_20ck50 = 0.9 time = 255
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=255.025n

* CHECK dout1_21 Vdout1_21ck50 = 0.9 time = 255
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=255.025n

* CHECK dout1_22 Vdout1_22ck50 = 0 time = 255
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=255.025n

* CHECK dout1_23 Vdout1_23ck50 = 0 time = 255
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=255.025n

* CHECK dout1_24 Vdout1_24ck50 = 0 time = 255
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=255.025n

* CHECK dout1_25 Vdout1_25ck50 = 0.9 time = 255
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=255.025n

* CHECK dout1_26 Vdout1_26ck50 = 0 time = 255
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=255.025n

* CHECK dout1_27 Vdout1_27ck50 = 0.9 time = 255
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=255.025n

* CHECK dout1_28 Vdout1_28ck50 = 0.9 time = 255
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=255.025n

* CHECK dout1_29 Vdout1_29ck50 = 0.9 time = 255
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=255.025n

* CHECK dout1_30 Vdout1_30ck50 = 0 time = 255
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=255.025n

* CHECK dout1_31 Vdout1_31ck50 = 0 time = 255
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=255.025n

* CHECK dout1_32 Vdout1_32ck50 = 0.9 time = 255
.meas tran vdout1_32ck50 FIND v(dout1_32) AT=255.025n

* CHECK dout1_33 Vdout1_33ck50 = 0.9 time = 255
.meas tran vdout1_33ck50 FIND v(dout1_33) AT=255.025n

* CHECK dout1_34 Vdout1_34ck50 = 0.9 time = 255
.meas tran vdout1_34ck50 FIND v(dout1_34) AT=255.025n

* CHECK dout1_35 Vdout1_35ck50 = 0.9 time = 255
.meas tran vdout1_35ck50 FIND v(dout1_35) AT=255.025n

* CHECK dout1_36 Vdout1_36ck50 = 0.9 time = 255
.meas tran vdout1_36ck50 FIND v(dout1_36) AT=255.025n

* CHECK dout1_37 Vdout1_37ck50 = 0.9 time = 255
.meas tran vdout1_37ck50 FIND v(dout1_37) AT=255.025n

* CHECK dout1_38 Vdout1_38ck50 = 0 time = 255
.meas tran vdout1_38ck50 FIND v(dout1_38) AT=255.025n

* CHECK dout1_39 Vdout1_39ck50 = 0.9 time = 255
.meas tran vdout1_39ck50 FIND v(dout1_39) AT=255.025n

* CHECK dout1_40 Vdout1_40ck50 = 0.9 time = 255
.meas tran vdout1_40ck50 FIND v(dout1_40) AT=255.025n

* CHECK dout1_41 Vdout1_41ck50 = 0 time = 255
.meas tran vdout1_41ck50 FIND v(dout1_41) AT=255.025n

* CHECK dout1_42 Vdout1_42ck50 = 0.9 time = 255
.meas tran vdout1_42ck50 FIND v(dout1_42) AT=255.025n

* CHECK dout1_43 Vdout1_43ck50 = 0.9 time = 255
.meas tran vdout1_43ck50 FIND v(dout1_43) AT=255.025n

* CHECK dout1_44 Vdout1_44ck50 = 0.9 time = 255
.meas tran vdout1_44ck50 FIND v(dout1_44) AT=255.025n

* CHECK dout1_45 Vdout1_45ck50 = 0.9 time = 255
.meas tran vdout1_45ck50 FIND v(dout1_45) AT=255.025n

* CHECK dout1_46 Vdout1_46ck50 = 0.9 time = 255
.meas tran vdout1_46ck50 FIND v(dout1_46) AT=255.025n

* CHECK dout1_47 Vdout1_47ck50 = 0 time = 255
.meas tran vdout1_47ck50 FIND v(dout1_47) AT=255.025n

* CHECK dout1_48 Vdout1_48ck50 = 0.9 time = 255
.meas tran vdout1_48ck50 FIND v(dout1_48) AT=255.025n

* CHECK dout1_49 Vdout1_49ck50 = 0.9 time = 255
.meas tran vdout1_49ck50 FIND v(dout1_49) AT=255.025n

* CHECK dout1_50 Vdout1_50ck50 = 0.9 time = 255
.meas tran vdout1_50ck50 FIND v(dout1_50) AT=255.025n

* CHECK dout1_51 Vdout1_51ck50 = 0 time = 255
.meas tran vdout1_51ck50 FIND v(dout1_51) AT=255.025n

* CHECK dout1_52 Vdout1_52ck50 = 0.9 time = 255
.meas tran vdout1_52ck50 FIND v(dout1_52) AT=255.025n

* CHECK dout1_53 Vdout1_53ck50 = 0.9 time = 255
.meas tran vdout1_53ck50 FIND v(dout1_53) AT=255.025n

* CHECK dout1_54 Vdout1_54ck50 = 0.9 time = 255
.meas tran vdout1_54ck50 FIND v(dout1_54) AT=255.025n

* CHECK dout1_55 Vdout1_55ck50 = 0 time = 255
.meas tran vdout1_55ck50 FIND v(dout1_55) AT=255.025n

* CHECK dout1_56 Vdout1_56ck50 = 0 time = 255
.meas tran vdout1_56ck50 FIND v(dout1_56) AT=255.025n

* CHECK dout1_57 Vdout1_57ck50 = 0.9 time = 255
.meas tran vdout1_57ck50 FIND v(dout1_57) AT=255.025n

* CHECK dout1_58 Vdout1_58ck50 = 0.9 time = 255
.meas tran vdout1_58ck50 FIND v(dout1_58) AT=255.025n

* CHECK dout1_59 Vdout1_59ck50 = 0 time = 255
.meas tran vdout1_59ck50 FIND v(dout1_59) AT=255.025n

* CHECK dout1_60 Vdout1_60ck50 = 0.9 time = 255
.meas tran vdout1_60ck50 FIND v(dout1_60) AT=255.025n

* CHECK dout1_61 Vdout1_61ck50 = 0 time = 255
.meas tran vdout1_61ck50 FIND v(dout1_61) AT=255.025n

* CHECK dout1_62 Vdout1_62ck50 = 0.9 time = 255
.meas tran vdout1_62ck50 FIND v(dout1_62) AT=255.025n

* CHECK dout1_63 Vdout1_63ck50 = 0 time = 255
.meas tran vdout1_63ck50 FIND v(dout1_63) AT=255.025n

* CHECK dout1_64 Vdout1_64ck50 = 0.9 time = 255
.meas tran vdout1_64ck50 FIND v(dout1_64) AT=255.025n

* CHECK dout1_65 Vdout1_65ck50 = 0.9 time = 255
.meas tran vdout1_65ck50 FIND v(dout1_65) AT=255.025n

* CHECK dout1_66 Vdout1_66ck50 = 0 time = 255
.meas tran vdout1_66ck50 FIND v(dout1_66) AT=255.025n

* CHECK dout1_67 Vdout1_67ck50 = 0.9 time = 255
.meas tran vdout1_67ck50 FIND v(dout1_67) AT=255.025n

* CHECK dout1_68 Vdout1_68ck50 = 0.9 time = 255
.meas tran vdout1_68ck50 FIND v(dout1_68) AT=255.025n

* CHECK dout1_69 Vdout1_69ck50 = 0 time = 255
.meas tran vdout1_69ck50 FIND v(dout1_69) AT=255.025n

* CHECK dout1_70 Vdout1_70ck50 = 0.9 time = 255
.meas tran vdout1_70ck50 FIND v(dout1_70) AT=255.025n

* CHECK dout1_71 Vdout1_71ck50 = 0 time = 255
.meas tran vdout1_71ck50 FIND v(dout1_71) AT=255.025n

* CHECK dout1_72 Vdout1_72ck50 = 0 time = 255
.meas tran vdout1_72ck50 FIND v(dout1_72) AT=255.025n

* CHECK dout1_73 Vdout1_73ck50 = 0.9 time = 255
.meas tran vdout1_73ck50 FIND v(dout1_73) AT=255.025n

* CHECK dout1_74 Vdout1_74ck50 = 0 time = 255
.meas tran vdout1_74ck50 FIND v(dout1_74) AT=255.025n

* CHECK dout1_75 Vdout1_75ck50 = 0 time = 255
.meas tran vdout1_75ck50 FIND v(dout1_75) AT=255.025n

* CHECK dout1_76 Vdout1_76ck50 = 0 time = 255
.meas tran vdout1_76ck50 FIND v(dout1_76) AT=255.025n

* CHECK dout1_77 Vdout1_77ck50 = 0 time = 255
.meas tran vdout1_77ck50 FIND v(dout1_77) AT=255.025n

* CHECK dout1_78 Vdout1_78ck50 = 0.9 time = 255
.meas tran vdout1_78ck50 FIND v(dout1_78) AT=255.025n

* CHECK dout1_79 Vdout1_79ck50 = 0.9 time = 255
.meas tran vdout1_79ck50 FIND v(dout1_79) AT=255.025n

* CHECK dout1_80 Vdout1_80ck50 = 0 time = 255
.meas tran vdout1_80ck50 FIND v(dout1_80) AT=255.025n

* CHECK dout1_81 Vdout1_81ck50 = 0.9 time = 255
.meas tran vdout1_81ck50 FIND v(dout1_81) AT=255.025n

* CHECK dout1_82 Vdout1_82ck50 = 0 time = 255
.meas tran vdout1_82ck50 FIND v(dout1_82) AT=255.025n

* CHECK dout1_83 Vdout1_83ck50 = 0 time = 255
.meas tran vdout1_83ck50 FIND v(dout1_83) AT=255.025n

* CHECK dout1_84 Vdout1_84ck50 = 0 time = 255
.meas tran vdout1_84ck50 FIND v(dout1_84) AT=255.025n

* CHECK dout1_85 Vdout1_85ck50 = 0 time = 255
.meas tran vdout1_85ck50 FIND v(dout1_85) AT=255.025n

* CHECK dout1_86 Vdout1_86ck50 = 0.9 time = 255
.meas tran vdout1_86ck50 FIND v(dout1_86) AT=255.025n

* CHECK dout1_87 Vdout1_87ck50 = 0.9 time = 255
.meas tran vdout1_87ck50 FIND v(dout1_87) AT=255.025n

* CHECK dout1_88 Vdout1_88ck50 = 0 time = 255
.meas tran vdout1_88ck50 FIND v(dout1_88) AT=255.025n

* CHECK dout1_89 Vdout1_89ck50 = 0 time = 255
.meas tran vdout1_89ck50 FIND v(dout1_89) AT=255.025n

* CHECK dout1_90 Vdout1_90ck50 = 0.9 time = 255
.meas tran vdout1_90ck50 FIND v(dout1_90) AT=255.025n

* CHECK dout1_91 Vdout1_91ck50 = 0.9 time = 255
.meas tran vdout1_91ck50 FIND v(dout1_91) AT=255.025n

* CHECK dout1_92 Vdout1_92ck50 = 0.9 time = 255
.meas tran vdout1_92ck50 FIND v(dout1_92) AT=255.025n

* CHECK dout1_93 Vdout1_93ck50 = 0.9 time = 255
.meas tran vdout1_93ck50 FIND v(dout1_93) AT=255.025n

* CHECK dout1_94 Vdout1_94ck50 = 0 time = 255
.meas tran vdout1_94ck50 FIND v(dout1_94) AT=255.025n

* CHECK dout1_95 Vdout1_95ck50 = 0.9 time = 255
.meas tran vdout1_95ck50 FIND v(dout1_95) AT=255.025n

* CHECK dout1_0 Vdout1_0ck55 = 0.9 time = 280
.meas tran vdout1_0ck55 FIND v(dout1_0) AT=280.025n

* CHECK dout1_1 Vdout1_1ck55 = 0 time = 280
.meas tran vdout1_1ck55 FIND v(dout1_1) AT=280.025n

* CHECK dout1_2 Vdout1_2ck55 = 0 time = 280
.meas tran vdout1_2ck55 FIND v(dout1_2) AT=280.025n

* CHECK dout1_3 Vdout1_3ck55 = 0 time = 280
.meas tran vdout1_3ck55 FIND v(dout1_3) AT=280.025n

* CHECK dout1_4 Vdout1_4ck55 = 0.9 time = 280
.meas tran vdout1_4ck55 FIND v(dout1_4) AT=280.025n

* CHECK dout1_5 Vdout1_5ck55 = 0 time = 280
.meas tran vdout1_5ck55 FIND v(dout1_5) AT=280.025n

* CHECK dout1_6 Vdout1_6ck55 = 0 time = 280
.meas tran vdout1_6ck55 FIND v(dout1_6) AT=280.025n

* CHECK dout1_7 Vdout1_7ck55 = 0.9 time = 280
.meas tran vdout1_7ck55 FIND v(dout1_7) AT=280.025n

* CHECK dout1_8 Vdout1_8ck55 = 0 time = 280
.meas tran vdout1_8ck55 FIND v(dout1_8) AT=280.025n

* CHECK dout1_9 Vdout1_9ck55 = 0 time = 280
.meas tran vdout1_9ck55 FIND v(dout1_9) AT=280.025n

* CHECK dout1_10 Vdout1_10ck55 = 0.9 time = 280
.meas tran vdout1_10ck55 FIND v(dout1_10) AT=280.025n

* CHECK dout1_11 Vdout1_11ck55 = 0.9 time = 280
.meas tran vdout1_11ck55 FIND v(dout1_11) AT=280.025n

* CHECK dout1_12 Vdout1_12ck55 = 0 time = 280
.meas tran vdout1_12ck55 FIND v(dout1_12) AT=280.025n

* CHECK dout1_13 Vdout1_13ck55 = 0 time = 280
.meas tran vdout1_13ck55 FIND v(dout1_13) AT=280.025n

* CHECK dout1_14 Vdout1_14ck55 = 0 time = 280
.meas tran vdout1_14ck55 FIND v(dout1_14) AT=280.025n

* CHECK dout1_15 Vdout1_15ck55 = 0.9 time = 280
.meas tran vdout1_15ck55 FIND v(dout1_15) AT=280.025n

* CHECK dout1_16 Vdout1_16ck55 = 0.9 time = 280
.meas tran vdout1_16ck55 FIND v(dout1_16) AT=280.025n

* CHECK dout1_17 Vdout1_17ck55 = 0.9 time = 280
.meas tran vdout1_17ck55 FIND v(dout1_17) AT=280.025n

* CHECK dout1_18 Vdout1_18ck55 = 0.9 time = 280
.meas tran vdout1_18ck55 FIND v(dout1_18) AT=280.025n

* CHECK dout1_19 Vdout1_19ck55 = 0.9 time = 280
.meas tran vdout1_19ck55 FIND v(dout1_19) AT=280.025n

* CHECK dout1_20 Vdout1_20ck55 = 0.9 time = 280
.meas tran vdout1_20ck55 FIND v(dout1_20) AT=280.025n

* CHECK dout1_21 Vdout1_21ck55 = 0.9 time = 280
.meas tran vdout1_21ck55 FIND v(dout1_21) AT=280.025n

* CHECK dout1_22 Vdout1_22ck55 = 0 time = 280
.meas tran vdout1_22ck55 FIND v(dout1_22) AT=280.025n

* CHECK dout1_23 Vdout1_23ck55 = 0 time = 280
.meas tran vdout1_23ck55 FIND v(dout1_23) AT=280.025n

* CHECK dout1_24 Vdout1_24ck55 = 0 time = 280
.meas tran vdout1_24ck55 FIND v(dout1_24) AT=280.025n

* CHECK dout1_25 Vdout1_25ck55 = 0.9 time = 280
.meas tran vdout1_25ck55 FIND v(dout1_25) AT=280.025n

* CHECK dout1_26 Vdout1_26ck55 = 0 time = 280
.meas tran vdout1_26ck55 FIND v(dout1_26) AT=280.025n

* CHECK dout1_27 Vdout1_27ck55 = 0.9 time = 280
.meas tran vdout1_27ck55 FIND v(dout1_27) AT=280.025n

* CHECK dout1_28 Vdout1_28ck55 = 0.9 time = 280
.meas tran vdout1_28ck55 FIND v(dout1_28) AT=280.025n

* CHECK dout1_29 Vdout1_29ck55 = 0.9 time = 280
.meas tran vdout1_29ck55 FIND v(dout1_29) AT=280.025n

* CHECK dout1_30 Vdout1_30ck55 = 0 time = 280
.meas tran vdout1_30ck55 FIND v(dout1_30) AT=280.025n

* CHECK dout1_31 Vdout1_31ck55 = 0 time = 280
.meas tran vdout1_31ck55 FIND v(dout1_31) AT=280.025n

* CHECK dout1_32 Vdout1_32ck55 = 0.9 time = 280
.meas tran vdout1_32ck55 FIND v(dout1_32) AT=280.025n

* CHECK dout1_33 Vdout1_33ck55 = 0.9 time = 280
.meas tran vdout1_33ck55 FIND v(dout1_33) AT=280.025n

* CHECK dout1_34 Vdout1_34ck55 = 0.9 time = 280
.meas tran vdout1_34ck55 FIND v(dout1_34) AT=280.025n

* CHECK dout1_35 Vdout1_35ck55 = 0.9 time = 280
.meas tran vdout1_35ck55 FIND v(dout1_35) AT=280.025n

* CHECK dout1_36 Vdout1_36ck55 = 0.9 time = 280
.meas tran vdout1_36ck55 FIND v(dout1_36) AT=280.025n

* CHECK dout1_37 Vdout1_37ck55 = 0.9 time = 280
.meas tran vdout1_37ck55 FIND v(dout1_37) AT=280.025n

* CHECK dout1_38 Vdout1_38ck55 = 0 time = 280
.meas tran vdout1_38ck55 FIND v(dout1_38) AT=280.025n

* CHECK dout1_39 Vdout1_39ck55 = 0.9 time = 280
.meas tran vdout1_39ck55 FIND v(dout1_39) AT=280.025n

* CHECK dout1_40 Vdout1_40ck55 = 0.9 time = 280
.meas tran vdout1_40ck55 FIND v(dout1_40) AT=280.025n

* CHECK dout1_41 Vdout1_41ck55 = 0 time = 280
.meas tran vdout1_41ck55 FIND v(dout1_41) AT=280.025n

* CHECK dout1_42 Vdout1_42ck55 = 0.9 time = 280
.meas tran vdout1_42ck55 FIND v(dout1_42) AT=280.025n

* CHECK dout1_43 Vdout1_43ck55 = 0.9 time = 280
.meas tran vdout1_43ck55 FIND v(dout1_43) AT=280.025n

* CHECK dout1_44 Vdout1_44ck55 = 0.9 time = 280
.meas tran vdout1_44ck55 FIND v(dout1_44) AT=280.025n

* CHECK dout1_45 Vdout1_45ck55 = 0.9 time = 280
.meas tran vdout1_45ck55 FIND v(dout1_45) AT=280.025n

* CHECK dout1_46 Vdout1_46ck55 = 0.9 time = 280
.meas tran vdout1_46ck55 FIND v(dout1_46) AT=280.025n

* CHECK dout1_47 Vdout1_47ck55 = 0 time = 280
.meas tran vdout1_47ck55 FIND v(dout1_47) AT=280.025n

* CHECK dout1_48 Vdout1_48ck55 = 0.9 time = 280
.meas tran vdout1_48ck55 FIND v(dout1_48) AT=280.025n

* CHECK dout1_49 Vdout1_49ck55 = 0.9 time = 280
.meas tran vdout1_49ck55 FIND v(dout1_49) AT=280.025n

* CHECK dout1_50 Vdout1_50ck55 = 0.9 time = 280
.meas tran vdout1_50ck55 FIND v(dout1_50) AT=280.025n

* CHECK dout1_51 Vdout1_51ck55 = 0 time = 280
.meas tran vdout1_51ck55 FIND v(dout1_51) AT=280.025n

* CHECK dout1_52 Vdout1_52ck55 = 0.9 time = 280
.meas tran vdout1_52ck55 FIND v(dout1_52) AT=280.025n

* CHECK dout1_53 Vdout1_53ck55 = 0.9 time = 280
.meas tran vdout1_53ck55 FIND v(dout1_53) AT=280.025n

* CHECK dout1_54 Vdout1_54ck55 = 0.9 time = 280
.meas tran vdout1_54ck55 FIND v(dout1_54) AT=280.025n

* CHECK dout1_55 Vdout1_55ck55 = 0 time = 280
.meas tran vdout1_55ck55 FIND v(dout1_55) AT=280.025n

* CHECK dout1_56 Vdout1_56ck55 = 0 time = 280
.meas tran vdout1_56ck55 FIND v(dout1_56) AT=280.025n

* CHECK dout1_57 Vdout1_57ck55 = 0.9 time = 280
.meas tran vdout1_57ck55 FIND v(dout1_57) AT=280.025n

* CHECK dout1_58 Vdout1_58ck55 = 0.9 time = 280
.meas tran vdout1_58ck55 FIND v(dout1_58) AT=280.025n

* CHECK dout1_59 Vdout1_59ck55 = 0 time = 280
.meas tran vdout1_59ck55 FIND v(dout1_59) AT=280.025n

* CHECK dout1_60 Vdout1_60ck55 = 0.9 time = 280
.meas tran vdout1_60ck55 FIND v(dout1_60) AT=280.025n

* CHECK dout1_61 Vdout1_61ck55 = 0 time = 280
.meas tran vdout1_61ck55 FIND v(dout1_61) AT=280.025n

* CHECK dout1_62 Vdout1_62ck55 = 0.9 time = 280
.meas tran vdout1_62ck55 FIND v(dout1_62) AT=280.025n

* CHECK dout1_63 Vdout1_63ck55 = 0 time = 280
.meas tran vdout1_63ck55 FIND v(dout1_63) AT=280.025n

* CHECK dout1_64 Vdout1_64ck55 = 0.9 time = 280
.meas tran vdout1_64ck55 FIND v(dout1_64) AT=280.025n

* CHECK dout1_65 Vdout1_65ck55 = 0.9 time = 280
.meas tran vdout1_65ck55 FIND v(dout1_65) AT=280.025n

* CHECK dout1_66 Vdout1_66ck55 = 0 time = 280
.meas tran vdout1_66ck55 FIND v(dout1_66) AT=280.025n

* CHECK dout1_67 Vdout1_67ck55 = 0.9 time = 280
.meas tran vdout1_67ck55 FIND v(dout1_67) AT=280.025n

* CHECK dout1_68 Vdout1_68ck55 = 0.9 time = 280
.meas tran vdout1_68ck55 FIND v(dout1_68) AT=280.025n

* CHECK dout1_69 Vdout1_69ck55 = 0 time = 280
.meas tran vdout1_69ck55 FIND v(dout1_69) AT=280.025n

* CHECK dout1_70 Vdout1_70ck55 = 0.9 time = 280
.meas tran vdout1_70ck55 FIND v(dout1_70) AT=280.025n

* CHECK dout1_71 Vdout1_71ck55 = 0 time = 280
.meas tran vdout1_71ck55 FIND v(dout1_71) AT=280.025n

* CHECK dout1_72 Vdout1_72ck55 = 0 time = 280
.meas tran vdout1_72ck55 FIND v(dout1_72) AT=280.025n

* CHECK dout1_73 Vdout1_73ck55 = 0.9 time = 280
.meas tran vdout1_73ck55 FIND v(dout1_73) AT=280.025n

* CHECK dout1_74 Vdout1_74ck55 = 0 time = 280
.meas tran vdout1_74ck55 FIND v(dout1_74) AT=280.025n

* CHECK dout1_75 Vdout1_75ck55 = 0 time = 280
.meas tran vdout1_75ck55 FIND v(dout1_75) AT=280.025n

* CHECK dout1_76 Vdout1_76ck55 = 0 time = 280
.meas tran vdout1_76ck55 FIND v(dout1_76) AT=280.025n

* CHECK dout1_77 Vdout1_77ck55 = 0 time = 280
.meas tran vdout1_77ck55 FIND v(dout1_77) AT=280.025n

* CHECK dout1_78 Vdout1_78ck55 = 0.9 time = 280
.meas tran vdout1_78ck55 FIND v(dout1_78) AT=280.025n

* CHECK dout1_79 Vdout1_79ck55 = 0.9 time = 280
.meas tran vdout1_79ck55 FIND v(dout1_79) AT=280.025n

* CHECK dout1_80 Vdout1_80ck55 = 0 time = 280
.meas tran vdout1_80ck55 FIND v(dout1_80) AT=280.025n

* CHECK dout1_81 Vdout1_81ck55 = 0.9 time = 280
.meas tran vdout1_81ck55 FIND v(dout1_81) AT=280.025n

* CHECK dout1_82 Vdout1_82ck55 = 0 time = 280
.meas tran vdout1_82ck55 FIND v(dout1_82) AT=280.025n

* CHECK dout1_83 Vdout1_83ck55 = 0 time = 280
.meas tran vdout1_83ck55 FIND v(dout1_83) AT=280.025n

* CHECK dout1_84 Vdout1_84ck55 = 0 time = 280
.meas tran vdout1_84ck55 FIND v(dout1_84) AT=280.025n

* CHECK dout1_85 Vdout1_85ck55 = 0 time = 280
.meas tran vdout1_85ck55 FIND v(dout1_85) AT=280.025n

* CHECK dout1_86 Vdout1_86ck55 = 0.9 time = 280
.meas tran vdout1_86ck55 FIND v(dout1_86) AT=280.025n

* CHECK dout1_87 Vdout1_87ck55 = 0.9 time = 280
.meas tran vdout1_87ck55 FIND v(dout1_87) AT=280.025n

* CHECK dout1_88 Vdout1_88ck55 = 0 time = 280
.meas tran vdout1_88ck55 FIND v(dout1_88) AT=280.025n

* CHECK dout1_89 Vdout1_89ck55 = 0 time = 280
.meas tran vdout1_89ck55 FIND v(dout1_89) AT=280.025n

* CHECK dout1_90 Vdout1_90ck55 = 0.9 time = 280
.meas tran vdout1_90ck55 FIND v(dout1_90) AT=280.025n

* CHECK dout1_91 Vdout1_91ck55 = 0.9 time = 280
.meas tran vdout1_91ck55 FIND v(dout1_91) AT=280.025n

* CHECK dout1_92 Vdout1_92ck55 = 0.9 time = 280
.meas tran vdout1_92ck55 FIND v(dout1_92) AT=280.025n

* CHECK dout1_93 Vdout1_93ck55 = 0.9 time = 280
.meas tran vdout1_93ck55 FIND v(dout1_93) AT=280.025n

* CHECK dout1_94 Vdout1_94ck55 = 0 time = 280
.meas tran vdout1_94ck55 FIND v(dout1_94) AT=280.025n

* CHECK dout1_95 Vdout1_95ck55 = 0.9 time = 280
.meas tran vdout1_95ck55 FIND v(dout1_95) AT=280.025n

* CHECK dout1_0 Vdout1_0ck56 = 0.9 time = 285
.meas tran vdout1_0ck56 FIND v(dout1_0) AT=285.025n

* CHECK dout1_1 Vdout1_1ck56 = 0.9 time = 285
.meas tran vdout1_1ck56 FIND v(dout1_1) AT=285.025n

* CHECK dout1_2 Vdout1_2ck56 = 0.9 time = 285
.meas tran vdout1_2ck56 FIND v(dout1_2) AT=285.025n

* CHECK dout1_3 Vdout1_3ck56 = 0.9 time = 285
.meas tran vdout1_3ck56 FIND v(dout1_3) AT=285.025n

* CHECK dout1_4 Vdout1_4ck56 = 0 time = 285
.meas tran vdout1_4ck56 FIND v(dout1_4) AT=285.025n

* CHECK dout1_5 Vdout1_5ck56 = 0.9 time = 285
.meas tran vdout1_5ck56 FIND v(dout1_5) AT=285.025n

* CHECK dout1_6 Vdout1_6ck56 = 0.9 time = 285
.meas tran vdout1_6ck56 FIND v(dout1_6) AT=285.025n

* CHECK dout1_7 Vdout1_7ck56 = 0.9 time = 285
.meas tran vdout1_7ck56 FIND v(dout1_7) AT=285.025n

* CHECK dout1_8 Vdout1_8ck56 = 0.9 time = 285
.meas tran vdout1_8ck56 FIND v(dout1_8) AT=285.025n

* CHECK dout1_9 Vdout1_9ck56 = 0 time = 285
.meas tran vdout1_9ck56 FIND v(dout1_9) AT=285.025n

* CHECK dout1_10 Vdout1_10ck56 = 0.9 time = 285
.meas tran vdout1_10ck56 FIND v(dout1_10) AT=285.025n

* CHECK dout1_11 Vdout1_11ck56 = 0.9 time = 285
.meas tran vdout1_11ck56 FIND v(dout1_11) AT=285.025n

* CHECK dout1_12 Vdout1_12ck56 = 0 time = 285
.meas tran vdout1_12ck56 FIND v(dout1_12) AT=285.025n

* CHECK dout1_13 Vdout1_13ck56 = 0.9 time = 285
.meas tran vdout1_13ck56 FIND v(dout1_13) AT=285.025n

* CHECK dout1_14 Vdout1_14ck56 = 0.9 time = 285
.meas tran vdout1_14ck56 FIND v(dout1_14) AT=285.025n

* CHECK dout1_15 Vdout1_15ck56 = 0.9 time = 285
.meas tran vdout1_15ck56 FIND v(dout1_15) AT=285.025n

* CHECK dout1_16 Vdout1_16ck56 = 0.9 time = 285
.meas tran vdout1_16ck56 FIND v(dout1_16) AT=285.025n

* CHECK dout1_17 Vdout1_17ck56 = 0.9 time = 285
.meas tran vdout1_17ck56 FIND v(dout1_17) AT=285.025n

* CHECK dout1_18 Vdout1_18ck56 = 0 time = 285
.meas tran vdout1_18ck56 FIND v(dout1_18) AT=285.025n

* CHECK dout1_19 Vdout1_19ck56 = 0 time = 285
.meas tran vdout1_19ck56 FIND v(dout1_19) AT=285.025n

* CHECK dout1_20 Vdout1_20ck56 = 0.9 time = 285
.meas tran vdout1_20ck56 FIND v(dout1_20) AT=285.025n

* CHECK dout1_21 Vdout1_21ck56 = 0.9 time = 285
.meas tran vdout1_21ck56 FIND v(dout1_21) AT=285.025n

* CHECK dout1_22 Vdout1_22ck56 = 0.9 time = 285
.meas tran vdout1_22ck56 FIND v(dout1_22) AT=285.025n

* CHECK dout1_23 Vdout1_23ck56 = 0 time = 285
.meas tran vdout1_23ck56 FIND v(dout1_23) AT=285.025n

* CHECK dout1_24 Vdout1_24ck56 = 0 time = 285
.meas tran vdout1_24ck56 FIND v(dout1_24) AT=285.025n

* CHECK dout1_25 Vdout1_25ck56 = 0.9 time = 285
.meas tran vdout1_25ck56 FIND v(dout1_25) AT=285.025n

* CHECK dout1_26 Vdout1_26ck56 = 0 time = 285
.meas tran vdout1_26ck56 FIND v(dout1_26) AT=285.025n

* CHECK dout1_27 Vdout1_27ck56 = 0 time = 285
.meas tran vdout1_27ck56 FIND v(dout1_27) AT=285.025n

* CHECK dout1_28 Vdout1_28ck56 = 0.9 time = 285
.meas tran vdout1_28ck56 FIND v(dout1_28) AT=285.025n

* CHECK dout1_29 Vdout1_29ck56 = 0 time = 285
.meas tran vdout1_29ck56 FIND v(dout1_29) AT=285.025n

* CHECK dout1_30 Vdout1_30ck56 = 0.9 time = 285
.meas tran vdout1_30ck56 FIND v(dout1_30) AT=285.025n

* CHECK dout1_31 Vdout1_31ck56 = 0.9 time = 285
.meas tran vdout1_31ck56 FIND v(dout1_31) AT=285.025n

* CHECK dout1_32 Vdout1_32ck56 = 0 time = 285
.meas tran vdout1_32ck56 FIND v(dout1_32) AT=285.025n

* CHECK dout1_33 Vdout1_33ck56 = 0.9 time = 285
.meas tran vdout1_33ck56 FIND v(dout1_33) AT=285.025n

* CHECK dout1_34 Vdout1_34ck56 = 0.9 time = 285
.meas tran vdout1_34ck56 FIND v(dout1_34) AT=285.025n

* CHECK dout1_35 Vdout1_35ck56 = 0.9 time = 285
.meas tran vdout1_35ck56 FIND v(dout1_35) AT=285.025n

* CHECK dout1_36 Vdout1_36ck56 = 0.9 time = 285
.meas tran vdout1_36ck56 FIND v(dout1_36) AT=285.025n

* CHECK dout1_37 Vdout1_37ck56 = 0 time = 285
.meas tran vdout1_37ck56 FIND v(dout1_37) AT=285.025n

* CHECK dout1_38 Vdout1_38ck56 = 0 time = 285
.meas tran vdout1_38ck56 FIND v(dout1_38) AT=285.025n

* CHECK dout1_39 Vdout1_39ck56 = 0 time = 285
.meas tran vdout1_39ck56 FIND v(dout1_39) AT=285.025n

* CHECK dout1_40 Vdout1_40ck56 = 0 time = 285
.meas tran vdout1_40ck56 FIND v(dout1_40) AT=285.025n

* CHECK dout1_41 Vdout1_41ck56 = 0.9 time = 285
.meas tran vdout1_41ck56 FIND v(dout1_41) AT=285.025n

* CHECK dout1_42 Vdout1_42ck56 = 0.9 time = 285
.meas tran vdout1_42ck56 FIND v(dout1_42) AT=285.025n

* CHECK dout1_43 Vdout1_43ck56 = 0 time = 285
.meas tran vdout1_43ck56 FIND v(dout1_43) AT=285.025n

* CHECK dout1_44 Vdout1_44ck56 = 0 time = 285
.meas tran vdout1_44ck56 FIND v(dout1_44) AT=285.025n

* CHECK dout1_45 Vdout1_45ck56 = 0.9 time = 285
.meas tran vdout1_45ck56 FIND v(dout1_45) AT=285.025n

* CHECK dout1_46 Vdout1_46ck56 = 0 time = 285
.meas tran vdout1_46ck56 FIND v(dout1_46) AT=285.025n

* CHECK dout1_47 Vdout1_47ck56 = 0 time = 285
.meas tran vdout1_47ck56 FIND v(dout1_47) AT=285.025n

* CHECK dout1_48 Vdout1_48ck56 = 0.9 time = 285
.meas tran vdout1_48ck56 FIND v(dout1_48) AT=285.025n

* CHECK dout1_49 Vdout1_49ck56 = 0 time = 285
.meas tran vdout1_49ck56 FIND v(dout1_49) AT=285.025n

* CHECK dout1_50 Vdout1_50ck56 = 0 time = 285
.meas tran vdout1_50ck56 FIND v(dout1_50) AT=285.025n

* CHECK dout1_51 Vdout1_51ck56 = 0 time = 285
.meas tran vdout1_51ck56 FIND v(dout1_51) AT=285.025n

* CHECK dout1_52 Vdout1_52ck56 = 0 time = 285
.meas tran vdout1_52ck56 FIND v(dout1_52) AT=285.025n

* CHECK dout1_53 Vdout1_53ck56 = 0 time = 285
.meas tran vdout1_53ck56 FIND v(dout1_53) AT=285.025n

* CHECK dout1_54 Vdout1_54ck56 = 0.9 time = 285
.meas tran vdout1_54ck56 FIND v(dout1_54) AT=285.025n

* CHECK dout1_55 Vdout1_55ck56 = 0.9 time = 285
.meas tran vdout1_55ck56 FIND v(dout1_55) AT=285.025n

* CHECK dout1_56 Vdout1_56ck56 = 0.9 time = 285
.meas tran vdout1_56ck56 FIND v(dout1_56) AT=285.025n

* CHECK dout1_57 Vdout1_57ck56 = 0.9 time = 285
.meas tran vdout1_57ck56 FIND v(dout1_57) AT=285.025n

* CHECK dout1_58 Vdout1_58ck56 = 0 time = 285
.meas tran vdout1_58ck56 FIND v(dout1_58) AT=285.025n

* CHECK dout1_59 Vdout1_59ck56 = 0.9 time = 285
.meas tran vdout1_59ck56 FIND v(dout1_59) AT=285.025n

* CHECK dout1_60 Vdout1_60ck56 = 0 time = 285
.meas tran vdout1_60ck56 FIND v(dout1_60) AT=285.025n

* CHECK dout1_61 Vdout1_61ck56 = 0.9 time = 285
.meas tran vdout1_61ck56 FIND v(dout1_61) AT=285.025n

* CHECK dout1_62 Vdout1_62ck56 = 0.9 time = 285
.meas tran vdout1_62ck56 FIND v(dout1_62) AT=285.025n

* CHECK dout1_63 Vdout1_63ck56 = 0 time = 285
.meas tran vdout1_63ck56 FIND v(dout1_63) AT=285.025n

* CHECK dout1_64 Vdout1_64ck56 = 0 time = 285
.meas tran vdout1_64ck56 FIND v(dout1_64) AT=285.025n

* CHECK dout1_65 Vdout1_65ck56 = 0.9 time = 285
.meas tran vdout1_65ck56 FIND v(dout1_65) AT=285.025n

* CHECK dout1_66 Vdout1_66ck56 = 0 time = 285
.meas tran vdout1_66ck56 FIND v(dout1_66) AT=285.025n

* CHECK dout1_67 Vdout1_67ck56 = 0.9 time = 285
.meas tran vdout1_67ck56 FIND v(dout1_67) AT=285.025n

* CHECK dout1_68 Vdout1_68ck56 = 0.9 time = 285
.meas tran vdout1_68ck56 FIND v(dout1_68) AT=285.025n

* CHECK dout1_69 Vdout1_69ck56 = 0.9 time = 285
.meas tran vdout1_69ck56 FIND v(dout1_69) AT=285.025n

* CHECK dout1_70 Vdout1_70ck56 = 0 time = 285
.meas tran vdout1_70ck56 FIND v(dout1_70) AT=285.025n

* CHECK dout1_71 Vdout1_71ck56 = 0.9 time = 285
.meas tran vdout1_71ck56 FIND v(dout1_71) AT=285.025n

* CHECK dout1_72 Vdout1_72ck56 = 0.9 time = 285
.meas tran vdout1_72ck56 FIND v(dout1_72) AT=285.025n

* CHECK dout1_73 Vdout1_73ck56 = 0 time = 285
.meas tran vdout1_73ck56 FIND v(dout1_73) AT=285.025n

* CHECK dout1_74 Vdout1_74ck56 = 0 time = 285
.meas tran vdout1_74ck56 FIND v(dout1_74) AT=285.025n

* CHECK dout1_75 Vdout1_75ck56 = 0 time = 285
.meas tran vdout1_75ck56 FIND v(dout1_75) AT=285.025n

* CHECK dout1_76 Vdout1_76ck56 = 0.9 time = 285
.meas tran vdout1_76ck56 FIND v(dout1_76) AT=285.025n

* CHECK dout1_77 Vdout1_77ck56 = 0 time = 285
.meas tran vdout1_77ck56 FIND v(dout1_77) AT=285.025n

* CHECK dout1_78 Vdout1_78ck56 = 0.9 time = 285
.meas tran vdout1_78ck56 FIND v(dout1_78) AT=285.025n

* CHECK dout1_79 Vdout1_79ck56 = 0 time = 285
.meas tran vdout1_79ck56 FIND v(dout1_79) AT=285.025n

* CHECK dout1_80 Vdout1_80ck56 = 0 time = 285
.meas tran vdout1_80ck56 FIND v(dout1_80) AT=285.025n

* CHECK dout1_81 Vdout1_81ck56 = 0.9 time = 285
.meas tran vdout1_81ck56 FIND v(dout1_81) AT=285.025n

* CHECK dout1_82 Vdout1_82ck56 = 0.9 time = 285
.meas tran vdout1_82ck56 FIND v(dout1_82) AT=285.025n

* CHECK dout1_83 Vdout1_83ck56 = 0.9 time = 285
.meas tran vdout1_83ck56 FIND v(dout1_83) AT=285.025n

* CHECK dout1_84 Vdout1_84ck56 = 0 time = 285
.meas tran vdout1_84ck56 FIND v(dout1_84) AT=285.025n

* CHECK dout1_85 Vdout1_85ck56 = 0 time = 285
.meas tran vdout1_85ck56 FIND v(dout1_85) AT=285.025n

* CHECK dout1_86 Vdout1_86ck56 = 0 time = 285
.meas tran vdout1_86ck56 FIND v(dout1_86) AT=285.025n

* CHECK dout1_87 Vdout1_87ck56 = 0 time = 285
.meas tran vdout1_87ck56 FIND v(dout1_87) AT=285.025n

* CHECK dout1_88 Vdout1_88ck56 = 0 time = 285
.meas tran vdout1_88ck56 FIND v(dout1_88) AT=285.025n

* CHECK dout1_89 Vdout1_89ck56 = 0.9 time = 285
.meas tran vdout1_89ck56 FIND v(dout1_89) AT=285.025n

* CHECK dout1_90 Vdout1_90ck56 = 0.9 time = 285
.meas tran vdout1_90ck56 FIND v(dout1_90) AT=285.025n

* CHECK dout1_91 Vdout1_91ck56 = 0 time = 285
.meas tran vdout1_91ck56 FIND v(dout1_91) AT=285.025n

* CHECK dout1_92 Vdout1_92ck56 = 0.9 time = 285
.meas tran vdout1_92ck56 FIND v(dout1_92) AT=285.025n

* CHECK dout1_93 Vdout1_93ck56 = 0.9 time = 285
.meas tran vdout1_93ck56 FIND v(dout1_93) AT=285.025n

* CHECK dout1_94 Vdout1_94ck56 = 0.9 time = 285
.meas tran vdout1_94ck56 FIND v(dout1_94) AT=285.025n

* CHECK dout1_95 Vdout1_95ck56 = 0.9 time = 285
.meas tran vdout1_95ck56 FIND v(dout1_95) AT=285.025n

* CHECK dout1_0 Vdout1_0ck61 = 0 time = 310
.meas tran vdout1_0ck61 FIND v(dout1_0) AT=310.025n

* CHECK dout1_1 Vdout1_1ck61 = 0 time = 310
.meas tran vdout1_1ck61 FIND v(dout1_1) AT=310.025n

* CHECK dout1_2 Vdout1_2ck61 = 0 time = 310
.meas tran vdout1_2ck61 FIND v(dout1_2) AT=310.025n

* CHECK dout1_3 Vdout1_3ck61 = 0 time = 310
.meas tran vdout1_3ck61 FIND v(dout1_3) AT=310.025n

* CHECK dout1_4 Vdout1_4ck61 = 0 time = 310
.meas tran vdout1_4ck61 FIND v(dout1_4) AT=310.025n

* CHECK dout1_5 Vdout1_5ck61 = 0 time = 310
.meas tran vdout1_5ck61 FIND v(dout1_5) AT=310.025n

* CHECK dout1_6 Vdout1_6ck61 = 0 time = 310
.meas tran vdout1_6ck61 FIND v(dout1_6) AT=310.025n

* CHECK dout1_7 Vdout1_7ck61 = 0 time = 310
.meas tran vdout1_7ck61 FIND v(dout1_7) AT=310.025n

* CHECK dout1_8 Vdout1_8ck61 = 0 time = 310
.meas tran vdout1_8ck61 FIND v(dout1_8) AT=310.025n

* CHECK dout1_9 Vdout1_9ck61 = 0.9 time = 310
.meas tran vdout1_9ck61 FIND v(dout1_9) AT=310.025n

* CHECK dout1_10 Vdout1_10ck61 = 0 time = 310
.meas tran vdout1_10ck61 FIND v(dout1_10) AT=310.025n

* CHECK dout1_11 Vdout1_11ck61 = 0.9 time = 310
.meas tran vdout1_11ck61 FIND v(dout1_11) AT=310.025n

* CHECK dout1_12 Vdout1_12ck61 = 0.9 time = 310
.meas tran vdout1_12ck61 FIND v(dout1_12) AT=310.025n

* CHECK dout1_13 Vdout1_13ck61 = 0 time = 310
.meas tran vdout1_13ck61 FIND v(dout1_13) AT=310.025n

* CHECK dout1_14 Vdout1_14ck61 = 0.9 time = 310
.meas tran vdout1_14ck61 FIND v(dout1_14) AT=310.025n

* CHECK dout1_15 Vdout1_15ck61 = 0.9 time = 310
.meas tran vdout1_15ck61 FIND v(dout1_15) AT=310.025n

* CHECK dout1_16 Vdout1_16ck61 = 0.9 time = 310
.meas tran vdout1_16ck61 FIND v(dout1_16) AT=310.025n

* CHECK dout1_17 Vdout1_17ck61 = 0 time = 310
.meas tran vdout1_17ck61 FIND v(dout1_17) AT=310.025n

* CHECK dout1_18 Vdout1_18ck61 = 0 time = 310
.meas tran vdout1_18ck61 FIND v(dout1_18) AT=310.025n

* CHECK dout1_19 Vdout1_19ck61 = 0 time = 310
.meas tran vdout1_19ck61 FIND v(dout1_19) AT=310.025n

* CHECK dout1_20 Vdout1_20ck61 = 0 time = 310
.meas tran vdout1_20ck61 FIND v(dout1_20) AT=310.025n

* CHECK dout1_21 Vdout1_21ck61 = 0 time = 310
.meas tran vdout1_21ck61 FIND v(dout1_21) AT=310.025n

* CHECK dout1_22 Vdout1_22ck61 = 0 time = 310
.meas tran vdout1_22ck61 FIND v(dout1_22) AT=310.025n

* CHECK dout1_23 Vdout1_23ck61 = 0 time = 310
.meas tran vdout1_23ck61 FIND v(dout1_23) AT=310.025n

* CHECK dout1_24 Vdout1_24ck61 = 0.9 time = 310
.meas tran vdout1_24ck61 FIND v(dout1_24) AT=310.025n

* CHECK dout1_25 Vdout1_25ck61 = 0.9 time = 310
.meas tran vdout1_25ck61 FIND v(dout1_25) AT=310.025n

* CHECK dout1_26 Vdout1_26ck61 = 0 time = 310
.meas tran vdout1_26ck61 FIND v(dout1_26) AT=310.025n

* CHECK dout1_27 Vdout1_27ck61 = 0 time = 310
.meas tran vdout1_27ck61 FIND v(dout1_27) AT=310.025n

* CHECK dout1_28 Vdout1_28ck61 = 0.9 time = 310
.meas tran vdout1_28ck61 FIND v(dout1_28) AT=310.025n

* CHECK dout1_29 Vdout1_29ck61 = 0.9 time = 310
.meas tran vdout1_29ck61 FIND v(dout1_29) AT=310.025n

* CHECK dout1_30 Vdout1_30ck61 = 0.9 time = 310
.meas tran vdout1_30ck61 FIND v(dout1_30) AT=310.025n

* CHECK dout1_31 Vdout1_31ck61 = 0.9 time = 310
.meas tran vdout1_31ck61 FIND v(dout1_31) AT=310.025n

* CHECK dout1_32 Vdout1_32ck61 = 0 time = 310
.meas tran vdout1_32ck61 FIND v(dout1_32) AT=310.025n

* CHECK dout1_33 Vdout1_33ck61 = 0 time = 310
.meas tran vdout1_33ck61 FIND v(dout1_33) AT=310.025n

* CHECK dout1_34 Vdout1_34ck61 = 0.9 time = 310
.meas tran vdout1_34ck61 FIND v(dout1_34) AT=310.025n

* CHECK dout1_35 Vdout1_35ck61 = 0 time = 310
.meas tran vdout1_35ck61 FIND v(dout1_35) AT=310.025n

* CHECK dout1_36 Vdout1_36ck61 = 0.9 time = 310
.meas tran vdout1_36ck61 FIND v(dout1_36) AT=310.025n

* CHECK dout1_37 Vdout1_37ck61 = 0 time = 310
.meas tran vdout1_37ck61 FIND v(dout1_37) AT=310.025n

* CHECK dout1_38 Vdout1_38ck61 = 0.9 time = 310
.meas tran vdout1_38ck61 FIND v(dout1_38) AT=310.025n

* CHECK dout1_39 Vdout1_39ck61 = 0.9 time = 310
.meas tran vdout1_39ck61 FIND v(dout1_39) AT=310.025n

* CHECK dout1_40 Vdout1_40ck61 = 0 time = 310
.meas tran vdout1_40ck61 FIND v(dout1_40) AT=310.025n

* CHECK dout1_41 Vdout1_41ck61 = 0 time = 310
.meas tran vdout1_41ck61 FIND v(dout1_41) AT=310.025n

* CHECK dout1_42 Vdout1_42ck61 = 0.9 time = 310
.meas tran vdout1_42ck61 FIND v(dout1_42) AT=310.025n

* CHECK dout1_43 Vdout1_43ck61 = 0.9 time = 310
.meas tran vdout1_43ck61 FIND v(dout1_43) AT=310.025n

* CHECK dout1_44 Vdout1_44ck61 = 0.9 time = 310
.meas tran vdout1_44ck61 FIND v(dout1_44) AT=310.025n

* CHECK dout1_45 Vdout1_45ck61 = 0.9 time = 310
.meas tran vdout1_45ck61 FIND v(dout1_45) AT=310.025n

* CHECK dout1_46 Vdout1_46ck61 = 0.9 time = 310
.meas tran vdout1_46ck61 FIND v(dout1_46) AT=310.025n

* CHECK dout1_47 Vdout1_47ck61 = 0.9 time = 310
.meas tran vdout1_47ck61 FIND v(dout1_47) AT=310.025n

* CHECK dout1_48 Vdout1_48ck61 = 0 time = 310
.meas tran vdout1_48ck61 FIND v(dout1_48) AT=310.025n

* CHECK dout1_49 Vdout1_49ck61 = 0 time = 310
.meas tran vdout1_49ck61 FIND v(dout1_49) AT=310.025n

* CHECK dout1_50 Vdout1_50ck61 = 0 time = 310
.meas tran vdout1_50ck61 FIND v(dout1_50) AT=310.025n

* CHECK dout1_51 Vdout1_51ck61 = 0.9 time = 310
.meas tran vdout1_51ck61 FIND v(dout1_51) AT=310.025n

* CHECK dout1_52 Vdout1_52ck61 = 0 time = 310
.meas tran vdout1_52ck61 FIND v(dout1_52) AT=310.025n

* CHECK dout1_53 Vdout1_53ck61 = 0.9 time = 310
.meas tran vdout1_53ck61 FIND v(dout1_53) AT=310.025n

* CHECK dout1_54 Vdout1_54ck61 = 0 time = 310
.meas tran vdout1_54ck61 FIND v(dout1_54) AT=310.025n

* CHECK dout1_55 Vdout1_55ck61 = 0.9 time = 310
.meas tran vdout1_55ck61 FIND v(dout1_55) AT=310.025n

* CHECK dout1_56 Vdout1_56ck61 = 0.9 time = 310
.meas tran vdout1_56ck61 FIND v(dout1_56) AT=310.025n

* CHECK dout1_57 Vdout1_57ck61 = 0.9 time = 310
.meas tran vdout1_57ck61 FIND v(dout1_57) AT=310.025n

* CHECK dout1_58 Vdout1_58ck61 = 0.9 time = 310
.meas tran vdout1_58ck61 FIND v(dout1_58) AT=310.025n

* CHECK dout1_59 Vdout1_59ck61 = 0.9 time = 310
.meas tran vdout1_59ck61 FIND v(dout1_59) AT=310.025n

* CHECK dout1_60 Vdout1_60ck61 = 0.9 time = 310
.meas tran vdout1_60ck61 FIND v(dout1_60) AT=310.025n

* CHECK dout1_61 Vdout1_61ck61 = 0.9 time = 310
.meas tran vdout1_61ck61 FIND v(dout1_61) AT=310.025n

* CHECK dout1_62 Vdout1_62ck61 = 0.9 time = 310
.meas tran vdout1_62ck61 FIND v(dout1_62) AT=310.025n

* CHECK dout1_63 Vdout1_63ck61 = 0 time = 310
.meas tran vdout1_63ck61 FIND v(dout1_63) AT=310.025n

* CHECK dout1_64 Vdout1_64ck61 = 0 time = 310
.meas tran vdout1_64ck61 FIND v(dout1_64) AT=310.025n

* CHECK dout1_65 Vdout1_65ck61 = 0 time = 310
.meas tran vdout1_65ck61 FIND v(dout1_65) AT=310.025n

* CHECK dout1_66 Vdout1_66ck61 = 0.9 time = 310
.meas tran vdout1_66ck61 FIND v(dout1_66) AT=310.025n

* CHECK dout1_67 Vdout1_67ck61 = 0 time = 310
.meas tran vdout1_67ck61 FIND v(dout1_67) AT=310.025n

* CHECK dout1_68 Vdout1_68ck61 = 0 time = 310
.meas tran vdout1_68ck61 FIND v(dout1_68) AT=310.025n

* CHECK dout1_69 Vdout1_69ck61 = 0.9 time = 310
.meas tran vdout1_69ck61 FIND v(dout1_69) AT=310.025n

* CHECK dout1_70 Vdout1_70ck61 = 0.9 time = 310
.meas tran vdout1_70ck61 FIND v(dout1_70) AT=310.025n

* CHECK dout1_71 Vdout1_71ck61 = 0.9 time = 310
.meas tran vdout1_71ck61 FIND v(dout1_71) AT=310.025n

* CHECK dout1_72 Vdout1_72ck61 = 0.9 time = 310
.meas tran vdout1_72ck61 FIND v(dout1_72) AT=310.025n

* CHECK dout1_73 Vdout1_73ck61 = 0.9 time = 310
.meas tran vdout1_73ck61 FIND v(dout1_73) AT=310.025n

* CHECK dout1_74 Vdout1_74ck61 = 0 time = 310
.meas tran vdout1_74ck61 FIND v(dout1_74) AT=310.025n

* CHECK dout1_75 Vdout1_75ck61 = 0 time = 310
.meas tran vdout1_75ck61 FIND v(dout1_75) AT=310.025n

* CHECK dout1_76 Vdout1_76ck61 = 0.9 time = 310
.meas tran vdout1_76ck61 FIND v(dout1_76) AT=310.025n

* CHECK dout1_77 Vdout1_77ck61 = 0.9 time = 310
.meas tran vdout1_77ck61 FIND v(dout1_77) AT=310.025n

* CHECK dout1_78 Vdout1_78ck61 = 0.9 time = 310
.meas tran vdout1_78ck61 FIND v(dout1_78) AT=310.025n

* CHECK dout1_79 Vdout1_79ck61 = 0 time = 310
.meas tran vdout1_79ck61 FIND v(dout1_79) AT=310.025n

* CHECK dout1_80 Vdout1_80ck61 = 0 time = 310
.meas tran vdout1_80ck61 FIND v(dout1_80) AT=310.025n

* CHECK dout1_81 Vdout1_81ck61 = 0.9 time = 310
.meas tran vdout1_81ck61 FIND v(dout1_81) AT=310.025n

* CHECK dout1_82 Vdout1_82ck61 = 0 time = 310
.meas tran vdout1_82ck61 FIND v(dout1_82) AT=310.025n

* CHECK dout1_83 Vdout1_83ck61 = 0.9 time = 310
.meas tran vdout1_83ck61 FIND v(dout1_83) AT=310.025n

* CHECK dout1_84 Vdout1_84ck61 = 0.9 time = 310
.meas tran vdout1_84ck61 FIND v(dout1_84) AT=310.025n

* CHECK dout1_85 Vdout1_85ck61 = 0.9 time = 310
.meas tran vdout1_85ck61 FIND v(dout1_85) AT=310.025n

* CHECK dout1_86 Vdout1_86ck61 = 0 time = 310
.meas tran vdout1_86ck61 FIND v(dout1_86) AT=310.025n

* CHECK dout1_87 Vdout1_87ck61 = 0 time = 310
.meas tran vdout1_87ck61 FIND v(dout1_87) AT=310.025n

* CHECK dout1_88 Vdout1_88ck61 = 0 time = 310
.meas tran vdout1_88ck61 FIND v(dout1_88) AT=310.025n

* CHECK dout1_89 Vdout1_89ck61 = 0 time = 310
.meas tran vdout1_89ck61 FIND v(dout1_89) AT=310.025n

* CHECK dout1_90 Vdout1_90ck61 = 0.9 time = 310
.meas tran vdout1_90ck61 FIND v(dout1_90) AT=310.025n

* CHECK dout1_91 Vdout1_91ck61 = 0 time = 310
.meas tran vdout1_91ck61 FIND v(dout1_91) AT=310.025n

* CHECK dout1_92 Vdout1_92ck61 = 0 time = 310
.meas tran vdout1_92ck61 FIND v(dout1_92) AT=310.025n

* CHECK dout1_93 Vdout1_93ck61 = 0.9 time = 310
.meas tran vdout1_93ck61 FIND v(dout1_93) AT=310.025n

* CHECK dout1_94 Vdout1_94ck61 = 0 time = 310
.meas tran vdout1_94ck61 FIND v(dout1_94) AT=310.025n

* CHECK dout1_95 Vdout1_95ck61 = 0.9 time = 310
.meas tran vdout1_95ck61 FIND v(dout1_95) AT=310.025n

* CHECK dout1_0 Vdout1_0ck66 = 0 time = 335
.meas tran vdout1_0ck66 FIND v(dout1_0) AT=335.025n

* CHECK dout1_1 Vdout1_1ck66 = 0 time = 335
.meas tran vdout1_1ck66 FIND v(dout1_1) AT=335.025n

* CHECK dout1_2 Vdout1_2ck66 = 0 time = 335
.meas tran vdout1_2ck66 FIND v(dout1_2) AT=335.025n

* CHECK dout1_3 Vdout1_3ck66 = 0 time = 335
.meas tran vdout1_3ck66 FIND v(dout1_3) AT=335.025n

* CHECK dout1_4 Vdout1_4ck66 = 0 time = 335
.meas tran vdout1_4ck66 FIND v(dout1_4) AT=335.025n

* CHECK dout1_5 Vdout1_5ck66 = 0 time = 335
.meas tran vdout1_5ck66 FIND v(dout1_5) AT=335.025n

* CHECK dout1_6 Vdout1_6ck66 = 0 time = 335
.meas tran vdout1_6ck66 FIND v(dout1_6) AT=335.025n

* CHECK dout1_7 Vdout1_7ck66 = 0 time = 335
.meas tran vdout1_7ck66 FIND v(dout1_7) AT=335.025n

* CHECK dout1_8 Vdout1_8ck66 = 0 time = 335
.meas tran vdout1_8ck66 FIND v(dout1_8) AT=335.025n

* CHECK dout1_9 Vdout1_9ck66 = 0.9 time = 335
.meas tran vdout1_9ck66 FIND v(dout1_9) AT=335.025n

* CHECK dout1_10 Vdout1_10ck66 = 0 time = 335
.meas tran vdout1_10ck66 FIND v(dout1_10) AT=335.025n

* CHECK dout1_11 Vdout1_11ck66 = 0.9 time = 335
.meas tran vdout1_11ck66 FIND v(dout1_11) AT=335.025n

* CHECK dout1_12 Vdout1_12ck66 = 0.9 time = 335
.meas tran vdout1_12ck66 FIND v(dout1_12) AT=335.025n

* CHECK dout1_13 Vdout1_13ck66 = 0 time = 335
.meas tran vdout1_13ck66 FIND v(dout1_13) AT=335.025n

* CHECK dout1_14 Vdout1_14ck66 = 0.9 time = 335
.meas tran vdout1_14ck66 FIND v(dout1_14) AT=335.025n

* CHECK dout1_15 Vdout1_15ck66 = 0.9 time = 335
.meas tran vdout1_15ck66 FIND v(dout1_15) AT=335.025n

* CHECK dout1_16 Vdout1_16ck66 = 0.9 time = 335
.meas tran vdout1_16ck66 FIND v(dout1_16) AT=335.025n

* CHECK dout1_17 Vdout1_17ck66 = 0 time = 335
.meas tran vdout1_17ck66 FIND v(dout1_17) AT=335.025n

* CHECK dout1_18 Vdout1_18ck66 = 0 time = 335
.meas tran vdout1_18ck66 FIND v(dout1_18) AT=335.025n

* CHECK dout1_19 Vdout1_19ck66 = 0 time = 335
.meas tran vdout1_19ck66 FIND v(dout1_19) AT=335.025n

* CHECK dout1_20 Vdout1_20ck66 = 0 time = 335
.meas tran vdout1_20ck66 FIND v(dout1_20) AT=335.025n

* CHECK dout1_21 Vdout1_21ck66 = 0 time = 335
.meas tran vdout1_21ck66 FIND v(dout1_21) AT=335.025n

* CHECK dout1_22 Vdout1_22ck66 = 0 time = 335
.meas tran vdout1_22ck66 FIND v(dout1_22) AT=335.025n

* CHECK dout1_23 Vdout1_23ck66 = 0 time = 335
.meas tran vdout1_23ck66 FIND v(dout1_23) AT=335.025n

* CHECK dout1_24 Vdout1_24ck66 = 0.9 time = 335
.meas tran vdout1_24ck66 FIND v(dout1_24) AT=335.025n

* CHECK dout1_25 Vdout1_25ck66 = 0.9 time = 335
.meas tran vdout1_25ck66 FIND v(dout1_25) AT=335.025n

* CHECK dout1_26 Vdout1_26ck66 = 0 time = 335
.meas tran vdout1_26ck66 FIND v(dout1_26) AT=335.025n

* CHECK dout1_27 Vdout1_27ck66 = 0 time = 335
.meas tran vdout1_27ck66 FIND v(dout1_27) AT=335.025n

* CHECK dout1_28 Vdout1_28ck66 = 0.9 time = 335
.meas tran vdout1_28ck66 FIND v(dout1_28) AT=335.025n

* CHECK dout1_29 Vdout1_29ck66 = 0.9 time = 335
.meas tran vdout1_29ck66 FIND v(dout1_29) AT=335.025n

* CHECK dout1_30 Vdout1_30ck66 = 0.9 time = 335
.meas tran vdout1_30ck66 FIND v(dout1_30) AT=335.025n

* CHECK dout1_31 Vdout1_31ck66 = 0.9 time = 335
.meas tran vdout1_31ck66 FIND v(dout1_31) AT=335.025n

* CHECK dout1_32 Vdout1_32ck66 = 0.9 time = 335
.meas tran vdout1_32ck66 FIND v(dout1_32) AT=335.025n

* CHECK dout1_33 Vdout1_33ck66 = 0.9 time = 335
.meas tran vdout1_33ck66 FIND v(dout1_33) AT=335.025n

* CHECK dout1_34 Vdout1_34ck66 = 0.9 time = 335
.meas tran vdout1_34ck66 FIND v(dout1_34) AT=335.025n

* CHECK dout1_35 Vdout1_35ck66 = 0.9 time = 335
.meas tran vdout1_35ck66 FIND v(dout1_35) AT=335.025n

* CHECK dout1_36 Vdout1_36ck66 = 0 time = 335
.meas tran vdout1_36ck66 FIND v(dout1_36) AT=335.025n

* CHECK dout1_37 Vdout1_37ck66 = 0.9 time = 335
.meas tran vdout1_37ck66 FIND v(dout1_37) AT=335.025n

* CHECK dout1_38 Vdout1_38ck66 = 0.9 time = 335
.meas tran vdout1_38ck66 FIND v(dout1_38) AT=335.025n

* CHECK dout1_39 Vdout1_39ck66 = 0 time = 335
.meas tran vdout1_39ck66 FIND v(dout1_39) AT=335.025n

* CHECK dout1_40 Vdout1_40ck66 = 0.9 time = 335
.meas tran vdout1_40ck66 FIND v(dout1_40) AT=335.025n

* CHECK dout1_41 Vdout1_41ck66 = 0 time = 335
.meas tran vdout1_41ck66 FIND v(dout1_41) AT=335.025n

* CHECK dout1_42 Vdout1_42ck66 = 0 time = 335
.meas tran vdout1_42ck66 FIND v(dout1_42) AT=335.025n

* CHECK dout1_43 Vdout1_43ck66 = 0 time = 335
.meas tran vdout1_43ck66 FIND v(dout1_43) AT=335.025n

* CHECK dout1_44 Vdout1_44ck66 = 0.9 time = 335
.meas tran vdout1_44ck66 FIND v(dout1_44) AT=335.025n

* CHECK dout1_45 Vdout1_45ck66 = 0.9 time = 335
.meas tran vdout1_45ck66 FIND v(dout1_45) AT=335.025n

* CHECK dout1_46 Vdout1_46ck66 = 0 time = 335
.meas tran vdout1_46ck66 FIND v(dout1_46) AT=335.025n

* CHECK dout1_47 Vdout1_47ck66 = 0 time = 335
.meas tran vdout1_47ck66 FIND v(dout1_47) AT=335.025n

* CHECK dout1_48 Vdout1_48ck66 = 0 time = 335
.meas tran vdout1_48ck66 FIND v(dout1_48) AT=335.025n

* CHECK dout1_49 Vdout1_49ck66 = 0 time = 335
.meas tran vdout1_49ck66 FIND v(dout1_49) AT=335.025n

* CHECK dout1_50 Vdout1_50ck66 = 0 time = 335
.meas tran vdout1_50ck66 FIND v(dout1_50) AT=335.025n

* CHECK dout1_51 Vdout1_51ck66 = 0.9 time = 335
.meas tran vdout1_51ck66 FIND v(dout1_51) AT=335.025n

* CHECK dout1_52 Vdout1_52ck66 = 0 time = 335
.meas tran vdout1_52ck66 FIND v(dout1_52) AT=335.025n

* CHECK dout1_53 Vdout1_53ck66 = 0 time = 335
.meas tran vdout1_53ck66 FIND v(dout1_53) AT=335.025n

* CHECK dout1_54 Vdout1_54ck66 = 0.9 time = 335
.meas tran vdout1_54ck66 FIND v(dout1_54) AT=335.025n

* CHECK dout1_55 Vdout1_55ck66 = 0.9 time = 335
.meas tran vdout1_55ck66 FIND v(dout1_55) AT=335.025n

* CHECK dout1_56 Vdout1_56ck66 = 0 time = 335
.meas tran vdout1_56ck66 FIND v(dout1_56) AT=335.025n

* CHECK dout1_57 Vdout1_57ck66 = 0 time = 335
.meas tran vdout1_57ck66 FIND v(dout1_57) AT=335.025n

* CHECK dout1_58 Vdout1_58ck66 = 0.9 time = 335
.meas tran vdout1_58ck66 FIND v(dout1_58) AT=335.025n

* CHECK dout1_59 Vdout1_59ck66 = 0.9 time = 335
.meas tran vdout1_59ck66 FIND v(dout1_59) AT=335.025n

* CHECK dout1_60 Vdout1_60ck66 = 0.9 time = 335
.meas tran vdout1_60ck66 FIND v(dout1_60) AT=335.025n

* CHECK dout1_61 Vdout1_61ck66 = 0.9 time = 335
.meas tran vdout1_61ck66 FIND v(dout1_61) AT=335.025n

* CHECK dout1_62 Vdout1_62ck66 = 0 time = 335
.meas tran vdout1_62ck66 FIND v(dout1_62) AT=335.025n

* CHECK dout1_63 Vdout1_63ck66 = 0 time = 335
.meas tran vdout1_63ck66 FIND v(dout1_63) AT=335.025n

* CHECK dout1_64 Vdout1_64ck66 = 0 time = 335
.meas tran vdout1_64ck66 FIND v(dout1_64) AT=335.025n

* CHECK dout1_65 Vdout1_65ck66 = 0 time = 335
.meas tran vdout1_65ck66 FIND v(dout1_65) AT=335.025n

* CHECK dout1_66 Vdout1_66ck66 = 0.9 time = 335
.meas tran vdout1_66ck66 FIND v(dout1_66) AT=335.025n

* CHECK dout1_67 Vdout1_67ck66 = 0 time = 335
.meas tran vdout1_67ck66 FIND v(dout1_67) AT=335.025n

* CHECK dout1_68 Vdout1_68ck66 = 0 time = 335
.meas tran vdout1_68ck66 FIND v(dout1_68) AT=335.025n

* CHECK dout1_69 Vdout1_69ck66 = 0.9 time = 335
.meas tran vdout1_69ck66 FIND v(dout1_69) AT=335.025n

* CHECK dout1_70 Vdout1_70ck66 = 0.9 time = 335
.meas tran vdout1_70ck66 FIND v(dout1_70) AT=335.025n

* CHECK dout1_71 Vdout1_71ck66 = 0.9 time = 335
.meas tran vdout1_71ck66 FIND v(dout1_71) AT=335.025n

* CHECK dout1_72 Vdout1_72ck66 = 0.9 time = 335
.meas tran vdout1_72ck66 FIND v(dout1_72) AT=335.025n

* CHECK dout1_73 Vdout1_73ck66 = 0.9 time = 335
.meas tran vdout1_73ck66 FIND v(dout1_73) AT=335.025n

* CHECK dout1_74 Vdout1_74ck66 = 0 time = 335
.meas tran vdout1_74ck66 FIND v(dout1_74) AT=335.025n

* CHECK dout1_75 Vdout1_75ck66 = 0 time = 335
.meas tran vdout1_75ck66 FIND v(dout1_75) AT=335.025n

* CHECK dout1_76 Vdout1_76ck66 = 0.9 time = 335
.meas tran vdout1_76ck66 FIND v(dout1_76) AT=335.025n

* CHECK dout1_77 Vdout1_77ck66 = 0.9 time = 335
.meas tran vdout1_77ck66 FIND v(dout1_77) AT=335.025n

* CHECK dout1_78 Vdout1_78ck66 = 0.9 time = 335
.meas tran vdout1_78ck66 FIND v(dout1_78) AT=335.025n

* CHECK dout1_79 Vdout1_79ck66 = 0 time = 335
.meas tran vdout1_79ck66 FIND v(dout1_79) AT=335.025n

* CHECK dout1_80 Vdout1_80ck66 = 0 time = 335
.meas tran vdout1_80ck66 FIND v(dout1_80) AT=335.025n

* CHECK dout1_81 Vdout1_81ck66 = 0.9 time = 335
.meas tran vdout1_81ck66 FIND v(dout1_81) AT=335.025n

* CHECK dout1_82 Vdout1_82ck66 = 0 time = 335
.meas tran vdout1_82ck66 FIND v(dout1_82) AT=335.025n

* CHECK dout1_83 Vdout1_83ck66 = 0.9 time = 335
.meas tran vdout1_83ck66 FIND v(dout1_83) AT=335.025n

* CHECK dout1_84 Vdout1_84ck66 = 0.9 time = 335
.meas tran vdout1_84ck66 FIND v(dout1_84) AT=335.025n

* CHECK dout1_85 Vdout1_85ck66 = 0.9 time = 335
.meas tran vdout1_85ck66 FIND v(dout1_85) AT=335.025n

* CHECK dout1_86 Vdout1_86ck66 = 0 time = 335
.meas tran vdout1_86ck66 FIND v(dout1_86) AT=335.025n

* CHECK dout1_87 Vdout1_87ck66 = 0 time = 335
.meas tran vdout1_87ck66 FIND v(dout1_87) AT=335.025n

* CHECK dout1_88 Vdout1_88ck66 = 0 time = 335
.meas tran vdout1_88ck66 FIND v(dout1_88) AT=335.025n

* CHECK dout1_89 Vdout1_89ck66 = 0 time = 335
.meas tran vdout1_89ck66 FIND v(dout1_89) AT=335.025n

* CHECK dout1_90 Vdout1_90ck66 = 0.9 time = 335
.meas tran vdout1_90ck66 FIND v(dout1_90) AT=335.025n

* CHECK dout1_91 Vdout1_91ck66 = 0 time = 335
.meas tran vdout1_91ck66 FIND v(dout1_91) AT=335.025n

* CHECK dout1_92 Vdout1_92ck66 = 0 time = 335
.meas tran vdout1_92ck66 FIND v(dout1_92) AT=335.025n

* CHECK dout1_93 Vdout1_93ck66 = 0.9 time = 335
.meas tran vdout1_93ck66 FIND v(dout1_93) AT=335.025n

* CHECK dout1_94 Vdout1_94ck66 = 0 time = 335
.meas tran vdout1_94ck66 FIND v(dout1_94) AT=335.025n

* CHECK dout1_95 Vdout1_95ck66 = 0.9 time = 335
.meas tran vdout1_95ck66 FIND v(dout1_95) AT=335.025n

* CHECK dout1_0 Vdout1_0ck67 = 0.9 time = 340
.meas tran vdout1_0ck67 FIND v(dout1_0) AT=340.025n

* CHECK dout1_1 Vdout1_1ck67 = 0.9 time = 340
.meas tran vdout1_1ck67 FIND v(dout1_1) AT=340.025n

* CHECK dout1_2 Vdout1_2ck67 = 0 time = 340
.meas tran vdout1_2ck67 FIND v(dout1_2) AT=340.025n

* CHECK dout1_3 Vdout1_3ck67 = 0.9 time = 340
.meas tran vdout1_3ck67 FIND v(dout1_3) AT=340.025n

* CHECK dout1_4 Vdout1_4ck67 = 0 time = 340
.meas tran vdout1_4ck67 FIND v(dout1_4) AT=340.025n

* CHECK dout1_5 Vdout1_5ck67 = 0.9 time = 340
.meas tran vdout1_5ck67 FIND v(dout1_5) AT=340.025n

* CHECK dout1_6 Vdout1_6ck67 = 0 time = 340
.meas tran vdout1_6ck67 FIND v(dout1_6) AT=340.025n

* CHECK dout1_7 Vdout1_7ck67 = 0 time = 340
.meas tran vdout1_7ck67 FIND v(dout1_7) AT=340.025n

* CHECK dout1_8 Vdout1_8ck67 = 0.9 time = 340
.meas tran vdout1_8ck67 FIND v(dout1_8) AT=340.025n

* CHECK dout1_9 Vdout1_9ck67 = 0 time = 340
.meas tran vdout1_9ck67 FIND v(dout1_9) AT=340.025n

* CHECK dout1_10 Vdout1_10ck67 = 0.9 time = 340
.meas tran vdout1_10ck67 FIND v(dout1_10) AT=340.025n

* CHECK dout1_11 Vdout1_11ck67 = 0 time = 340
.meas tran vdout1_11ck67 FIND v(dout1_11) AT=340.025n

* CHECK dout1_12 Vdout1_12ck67 = 0 time = 340
.meas tran vdout1_12ck67 FIND v(dout1_12) AT=340.025n

* CHECK dout1_13 Vdout1_13ck67 = 0.9 time = 340
.meas tran vdout1_13ck67 FIND v(dout1_13) AT=340.025n

* CHECK dout1_14 Vdout1_14ck67 = 0.9 time = 340
.meas tran vdout1_14ck67 FIND v(dout1_14) AT=340.025n

* CHECK dout1_15 Vdout1_15ck67 = 0.9 time = 340
.meas tran vdout1_15ck67 FIND v(dout1_15) AT=340.025n

* CHECK dout1_16 Vdout1_16ck67 = 0.9 time = 340
.meas tran vdout1_16ck67 FIND v(dout1_16) AT=340.025n

* CHECK dout1_17 Vdout1_17ck67 = 0 time = 340
.meas tran vdout1_17ck67 FIND v(dout1_17) AT=340.025n

* CHECK dout1_18 Vdout1_18ck67 = 0 time = 340
.meas tran vdout1_18ck67 FIND v(dout1_18) AT=340.025n

* CHECK dout1_19 Vdout1_19ck67 = 0 time = 340
.meas tran vdout1_19ck67 FIND v(dout1_19) AT=340.025n

* CHECK dout1_20 Vdout1_20ck67 = 0.9 time = 340
.meas tran vdout1_20ck67 FIND v(dout1_20) AT=340.025n

* CHECK dout1_21 Vdout1_21ck67 = 0.9 time = 340
.meas tran vdout1_21ck67 FIND v(dout1_21) AT=340.025n

* CHECK dout1_22 Vdout1_22ck67 = 0 time = 340
.meas tran vdout1_22ck67 FIND v(dout1_22) AT=340.025n

* CHECK dout1_23 Vdout1_23ck67 = 0.9 time = 340
.meas tran vdout1_23ck67 FIND v(dout1_23) AT=340.025n

* CHECK dout1_24 Vdout1_24ck67 = 0.9 time = 340
.meas tran vdout1_24ck67 FIND v(dout1_24) AT=340.025n

* CHECK dout1_25 Vdout1_25ck67 = 0 time = 340
.meas tran vdout1_25ck67 FIND v(dout1_25) AT=340.025n

* CHECK dout1_26 Vdout1_26ck67 = 0.9 time = 340
.meas tran vdout1_26ck67 FIND v(dout1_26) AT=340.025n

* CHECK dout1_27 Vdout1_27ck67 = 0.9 time = 340
.meas tran vdout1_27ck67 FIND v(dout1_27) AT=340.025n

* CHECK dout1_28 Vdout1_28ck67 = 0.9 time = 340
.meas tran vdout1_28ck67 FIND v(dout1_28) AT=340.025n

* CHECK dout1_29 Vdout1_29ck67 = 0.9 time = 340
.meas tran vdout1_29ck67 FIND v(dout1_29) AT=340.025n

* CHECK dout1_30 Vdout1_30ck67 = 0 time = 340
.meas tran vdout1_30ck67 FIND v(dout1_30) AT=340.025n

* CHECK dout1_31 Vdout1_31ck67 = 0 time = 340
.meas tran vdout1_31ck67 FIND v(dout1_31) AT=340.025n

* CHECK dout1_32 Vdout1_32ck67 = 0.9 time = 340
.meas tran vdout1_32ck67 FIND v(dout1_32) AT=340.025n

* CHECK dout1_33 Vdout1_33ck67 = 0.9 time = 340
.meas tran vdout1_33ck67 FIND v(dout1_33) AT=340.025n

* CHECK dout1_34 Vdout1_34ck67 = 0 time = 340
.meas tran vdout1_34ck67 FIND v(dout1_34) AT=340.025n

* CHECK dout1_35 Vdout1_35ck67 = 0 time = 340
.meas tran vdout1_35ck67 FIND v(dout1_35) AT=340.025n

* CHECK dout1_36 Vdout1_36ck67 = 0 time = 340
.meas tran vdout1_36ck67 FIND v(dout1_36) AT=340.025n

* CHECK dout1_37 Vdout1_37ck67 = 0.9 time = 340
.meas tran vdout1_37ck67 FIND v(dout1_37) AT=340.025n

* CHECK dout1_38 Vdout1_38ck67 = 0.9 time = 340
.meas tran vdout1_38ck67 FIND v(dout1_38) AT=340.025n

* CHECK dout1_39 Vdout1_39ck67 = 0.9 time = 340
.meas tran vdout1_39ck67 FIND v(dout1_39) AT=340.025n

* CHECK dout1_40 Vdout1_40ck67 = 0 time = 340
.meas tran vdout1_40ck67 FIND v(dout1_40) AT=340.025n

* CHECK dout1_41 Vdout1_41ck67 = 0.9 time = 340
.meas tran vdout1_41ck67 FIND v(dout1_41) AT=340.025n

* CHECK dout1_42 Vdout1_42ck67 = 0 time = 340
.meas tran vdout1_42ck67 FIND v(dout1_42) AT=340.025n

* CHECK dout1_43 Vdout1_43ck67 = 0.9 time = 340
.meas tran vdout1_43ck67 FIND v(dout1_43) AT=340.025n

* CHECK dout1_44 Vdout1_44ck67 = 0 time = 340
.meas tran vdout1_44ck67 FIND v(dout1_44) AT=340.025n

* CHECK dout1_45 Vdout1_45ck67 = 0 time = 340
.meas tran vdout1_45ck67 FIND v(dout1_45) AT=340.025n

* CHECK dout1_46 Vdout1_46ck67 = 0 time = 340
.meas tran vdout1_46ck67 FIND v(dout1_46) AT=340.025n

* CHECK dout1_47 Vdout1_47ck67 = 0.9 time = 340
.meas tran vdout1_47ck67 FIND v(dout1_47) AT=340.025n

* CHECK dout1_48 Vdout1_48ck67 = 0.9 time = 340
.meas tran vdout1_48ck67 FIND v(dout1_48) AT=340.025n

* CHECK dout1_49 Vdout1_49ck67 = 0.9 time = 340
.meas tran vdout1_49ck67 FIND v(dout1_49) AT=340.025n

* CHECK dout1_50 Vdout1_50ck67 = 0.9 time = 340
.meas tran vdout1_50ck67 FIND v(dout1_50) AT=340.025n

* CHECK dout1_51 Vdout1_51ck67 = 0 time = 340
.meas tran vdout1_51ck67 FIND v(dout1_51) AT=340.025n

* CHECK dout1_52 Vdout1_52ck67 = 0 time = 340
.meas tran vdout1_52ck67 FIND v(dout1_52) AT=340.025n

* CHECK dout1_53 Vdout1_53ck67 = 0 time = 340
.meas tran vdout1_53ck67 FIND v(dout1_53) AT=340.025n

* CHECK dout1_54 Vdout1_54ck67 = 0.9 time = 340
.meas tran vdout1_54ck67 FIND v(dout1_54) AT=340.025n

* CHECK dout1_55 Vdout1_55ck67 = 0.9 time = 340
.meas tran vdout1_55ck67 FIND v(dout1_55) AT=340.025n

* CHECK dout1_56 Vdout1_56ck67 = 0.9 time = 340
.meas tran vdout1_56ck67 FIND v(dout1_56) AT=340.025n

* CHECK dout1_57 Vdout1_57ck67 = 0.9 time = 340
.meas tran vdout1_57ck67 FIND v(dout1_57) AT=340.025n

* CHECK dout1_58 Vdout1_58ck67 = 0 time = 340
.meas tran vdout1_58ck67 FIND v(dout1_58) AT=340.025n

* CHECK dout1_59 Vdout1_59ck67 = 0.9 time = 340
.meas tran vdout1_59ck67 FIND v(dout1_59) AT=340.025n

* CHECK dout1_60 Vdout1_60ck67 = 0 time = 340
.meas tran vdout1_60ck67 FIND v(dout1_60) AT=340.025n

* CHECK dout1_61 Vdout1_61ck67 = 0.9 time = 340
.meas tran vdout1_61ck67 FIND v(dout1_61) AT=340.025n

* CHECK dout1_62 Vdout1_62ck67 = 0 time = 340
.meas tran vdout1_62ck67 FIND v(dout1_62) AT=340.025n

* CHECK dout1_63 Vdout1_63ck67 = 0 time = 340
.meas tran vdout1_63ck67 FIND v(dout1_63) AT=340.025n

* CHECK dout1_64 Vdout1_64ck67 = 0 time = 340
.meas tran vdout1_64ck67 FIND v(dout1_64) AT=340.025n

* CHECK dout1_65 Vdout1_65ck67 = 0.9 time = 340
.meas tran vdout1_65ck67 FIND v(dout1_65) AT=340.025n

* CHECK dout1_66 Vdout1_66ck67 = 0.9 time = 340
.meas tran vdout1_66ck67 FIND v(dout1_66) AT=340.025n

* CHECK dout1_67 Vdout1_67ck67 = 0.9 time = 340
.meas tran vdout1_67ck67 FIND v(dout1_67) AT=340.025n

* CHECK dout1_68 Vdout1_68ck67 = 0.9 time = 340
.meas tran vdout1_68ck67 FIND v(dout1_68) AT=340.025n

* CHECK dout1_69 Vdout1_69ck67 = 0.9 time = 340
.meas tran vdout1_69ck67 FIND v(dout1_69) AT=340.025n

* CHECK dout1_70 Vdout1_70ck67 = 0 time = 340
.meas tran vdout1_70ck67 FIND v(dout1_70) AT=340.025n

* CHECK dout1_71 Vdout1_71ck67 = 0.9 time = 340
.meas tran vdout1_71ck67 FIND v(dout1_71) AT=340.025n

* CHECK dout1_72 Vdout1_72ck67 = 0.9 time = 340
.meas tran vdout1_72ck67 FIND v(dout1_72) AT=340.025n

* CHECK dout1_73 Vdout1_73ck67 = 0.9 time = 340
.meas tran vdout1_73ck67 FIND v(dout1_73) AT=340.025n

* CHECK dout1_74 Vdout1_74ck67 = 0.9 time = 340
.meas tran vdout1_74ck67 FIND v(dout1_74) AT=340.025n

* CHECK dout1_75 Vdout1_75ck67 = 0 time = 340
.meas tran vdout1_75ck67 FIND v(dout1_75) AT=340.025n

* CHECK dout1_76 Vdout1_76ck67 = 0.9 time = 340
.meas tran vdout1_76ck67 FIND v(dout1_76) AT=340.025n

* CHECK dout1_77 Vdout1_77ck67 = 0 time = 340
.meas tran vdout1_77ck67 FIND v(dout1_77) AT=340.025n

* CHECK dout1_78 Vdout1_78ck67 = 0.9 time = 340
.meas tran vdout1_78ck67 FIND v(dout1_78) AT=340.025n

* CHECK dout1_79 Vdout1_79ck67 = 0.9 time = 340
.meas tran vdout1_79ck67 FIND v(dout1_79) AT=340.025n

* CHECK dout1_80 Vdout1_80ck67 = 0.9 time = 340
.meas tran vdout1_80ck67 FIND v(dout1_80) AT=340.025n

* CHECK dout1_81 Vdout1_81ck67 = 0 time = 340
.meas tran vdout1_81ck67 FIND v(dout1_81) AT=340.025n

* CHECK dout1_82 Vdout1_82ck67 = 0.9 time = 340
.meas tran vdout1_82ck67 FIND v(dout1_82) AT=340.025n

* CHECK dout1_83 Vdout1_83ck67 = 0.9 time = 340
.meas tran vdout1_83ck67 FIND v(dout1_83) AT=340.025n

* CHECK dout1_84 Vdout1_84ck67 = 0.9 time = 340
.meas tran vdout1_84ck67 FIND v(dout1_84) AT=340.025n

* CHECK dout1_85 Vdout1_85ck67 = 0.9 time = 340
.meas tran vdout1_85ck67 FIND v(dout1_85) AT=340.025n

* CHECK dout1_86 Vdout1_86ck67 = 0.9 time = 340
.meas tran vdout1_86ck67 FIND v(dout1_86) AT=340.025n

* CHECK dout1_87 Vdout1_87ck67 = 0 time = 340
.meas tran vdout1_87ck67 FIND v(dout1_87) AT=340.025n

* CHECK dout1_88 Vdout1_88ck67 = 0.9 time = 340
.meas tran vdout1_88ck67 FIND v(dout1_88) AT=340.025n

* CHECK dout1_89 Vdout1_89ck67 = 0.9 time = 340
.meas tran vdout1_89ck67 FIND v(dout1_89) AT=340.025n

* CHECK dout1_90 Vdout1_90ck67 = 0.9 time = 340
.meas tran vdout1_90ck67 FIND v(dout1_90) AT=340.025n

* CHECK dout1_91 Vdout1_91ck67 = 0 time = 340
.meas tran vdout1_91ck67 FIND v(dout1_91) AT=340.025n

* CHECK dout1_92 Vdout1_92ck67 = 0 time = 340
.meas tran vdout1_92ck67 FIND v(dout1_92) AT=340.025n

* CHECK dout1_93 Vdout1_93ck67 = 0 time = 340
.meas tran vdout1_93ck67 FIND v(dout1_93) AT=340.025n

* CHECK dout1_94 Vdout1_94ck67 = 0 time = 340
.meas tran vdout1_94ck67 FIND v(dout1_94) AT=340.025n

* CHECK dout1_95 Vdout1_95ck67 = 0 time = 340
.meas tran vdout1_95ck67 FIND v(dout1_95) AT=340.025n

* CHECK dout1_0 Vdout1_0ck68 = 0.9 time = 345
.meas tran vdout1_0ck68 FIND v(dout1_0) AT=345.025n

* CHECK dout1_1 Vdout1_1ck68 = 0.9 time = 345
.meas tran vdout1_1ck68 FIND v(dout1_1) AT=345.025n

* CHECK dout1_2 Vdout1_2ck68 = 0 time = 345
.meas tran vdout1_2ck68 FIND v(dout1_2) AT=345.025n

* CHECK dout1_3 Vdout1_3ck68 = 0.9 time = 345
.meas tran vdout1_3ck68 FIND v(dout1_3) AT=345.025n

* CHECK dout1_4 Vdout1_4ck68 = 0 time = 345
.meas tran vdout1_4ck68 FIND v(dout1_4) AT=345.025n

* CHECK dout1_5 Vdout1_5ck68 = 0.9 time = 345
.meas tran vdout1_5ck68 FIND v(dout1_5) AT=345.025n

* CHECK dout1_6 Vdout1_6ck68 = 0 time = 345
.meas tran vdout1_6ck68 FIND v(dout1_6) AT=345.025n

* CHECK dout1_7 Vdout1_7ck68 = 0 time = 345
.meas tran vdout1_7ck68 FIND v(dout1_7) AT=345.025n

* CHECK dout1_8 Vdout1_8ck68 = 0.9 time = 345
.meas tran vdout1_8ck68 FIND v(dout1_8) AT=345.025n

* CHECK dout1_9 Vdout1_9ck68 = 0 time = 345
.meas tran vdout1_9ck68 FIND v(dout1_9) AT=345.025n

* CHECK dout1_10 Vdout1_10ck68 = 0.9 time = 345
.meas tran vdout1_10ck68 FIND v(dout1_10) AT=345.025n

* CHECK dout1_11 Vdout1_11ck68 = 0 time = 345
.meas tran vdout1_11ck68 FIND v(dout1_11) AT=345.025n

* CHECK dout1_12 Vdout1_12ck68 = 0 time = 345
.meas tran vdout1_12ck68 FIND v(dout1_12) AT=345.025n

* CHECK dout1_13 Vdout1_13ck68 = 0.9 time = 345
.meas tran vdout1_13ck68 FIND v(dout1_13) AT=345.025n

* CHECK dout1_14 Vdout1_14ck68 = 0.9 time = 345
.meas tran vdout1_14ck68 FIND v(dout1_14) AT=345.025n

* CHECK dout1_15 Vdout1_15ck68 = 0.9 time = 345
.meas tran vdout1_15ck68 FIND v(dout1_15) AT=345.025n

* CHECK dout1_16 Vdout1_16ck68 = 0.9 time = 345
.meas tran vdout1_16ck68 FIND v(dout1_16) AT=345.025n

* CHECK dout1_17 Vdout1_17ck68 = 0 time = 345
.meas tran vdout1_17ck68 FIND v(dout1_17) AT=345.025n

* CHECK dout1_18 Vdout1_18ck68 = 0 time = 345
.meas tran vdout1_18ck68 FIND v(dout1_18) AT=345.025n

* CHECK dout1_19 Vdout1_19ck68 = 0 time = 345
.meas tran vdout1_19ck68 FIND v(dout1_19) AT=345.025n

* CHECK dout1_20 Vdout1_20ck68 = 0.9 time = 345
.meas tran vdout1_20ck68 FIND v(dout1_20) AT=345.025n

* CHECK dout1_21 Vdout1_21ck68 = 0.9 time = 345
.meas tran vdout1_21ck68 FIND v(dout1_21) AT=345.025n

* CHECK dout1_22 Vdout1_22ck68 = 0 time = 345
.meas tran vdout1_22ck68 FIND v(dout1_22) AT=345.025n

* CHECK dout1_23 Vdout1_23ck68 = 0.9 time = 345
.meas tran vdout1_23ck68 FIND v(dout1_23) AT=345.025n

* CHECK dout1_24 Vdout1_24ck68 = 0.9 time = 345
.meas tran vdout1_24ck68 FIND v(dout1_24) AT=345.025n

* CHECK dout1_25 Vdout1_25ck68 = 0 time = 345
.meas tran vdout1_25ck68 FIND v(dout1_25) AT=345.025n

* CHECK dout1_26 Vdout1_26ck68 = 0.9 time = 345
.meas tran vdout1_26ck68 FIND v(dout1_26) AT=345.025n

* CHECK dout1_27 Vdout1_27ck68 = 0.9 time = 345
.meas tran vdout1_27ck68 FIND v(dout1_27) AT=345.025n

* CHECK dout1_28 Vdout1_28ck68 = 0.9 time = 345
.meas tran vdout1_28ck68 FIND v(dout1_28) AT=345.025n

* CHECK dout1_29 Vdout1_29ck68 = 0.9 time = 345
.meas tran vdout1_29ck68 FIND v(dout1_29) AT=345.025n

* CHECK dout1_30 Vdout1_30ck68 = 0 time = 345
.meas tran vdout1_30ck68 FIND v(dout1_30) AT=345.025n

* CHECK dout1_31 Vdout1_31ck68 = 0 time = 345
.meas tran vdout1_31ck68 FIND v(dout1_31) AT=345.025n

* CHECK dout1_32 Vdout1_32ck68 = 0.9 time = 345
.meas tran vdout1_32ck68 FIND v(dout1_32) AT=345.025n

* CHECK dout1_33 Vdout1_33ck68 = 0.9 time = 345
.meas tran vdout1_33ck68 FIND v(dout1_33) AT=345.025n

* CHECK dout1_34 Vdout1_34ck68 = 0 time = 345
.meas tran vdout1_34ck68 FIND v(dout1_34) AT=345.025n

* CHECK dout1_35 Vdout1_35ck68 = 0 time = 345
.meas tran vdout1_35ck68 FIND v(dout1_35) AT=345.025n

* CHECK dout1_36 Vdout1_36ck68 = 0 time = 345
.meas tran vdout1_36ck68 FIND v(dout1_36) AT=345.025n

* CHECK dout1_37 Vdout1_37ck68 = 0.9 time = 345
.meas tran vdout1_37ck68 FIND v(dout1_37) AT=345.025n

* CHECK dout1_38 Vdout1_38ck68 = 0.9 time = 345
.meas tran vdout1_38ck68 FIND v(dout1_38) AT=345.025n

* CHECK dout1_39 Vdout1_39ck68 = 0.9 time = 345
.meas tran vdout1_39ck68 FIND v(dout1_39) AT=345.025n

* CHECK dout1_40 Vdout1_40ck68 = 0 time = 345
.meas tran vdout1_40ck68 FIND v(dout1_40) AT=345.025n

* CHECK dout1_41 Vdout1_41ck68 = 0.9 time = 345
.meas tran vdout1_41ck68 FIND v(dout1_41) AT=345.025n

* CHECK dout1_42 Vdout1_42ck68 = 0 time = 345
.meas tran vdout1_42ck68 FIND v(dout1_42) AT=345.025n

* CHECK dout1_43 Vdout1_43ck68 = 0.9 time = 345
.meas tran vdout1_43ck68 FIND v(dout1_43) AT=345.025n

* CHECK dout1_44 Vdout1_44ck68 = 0 time = 345
.meas tran vdout1_44ck68 FIND v(dout1_44) AT=345.025n

* CHECK dout1_45 Vdout1_45ck68 = 0 time = 345
.meas tran vdout1_45ck68 FIND v(dout1_45) AT=345.025n

* CHECK dout1_46 Vdout1_46ck68 = 0 time = 345
.meas tran vdout1_46ck68 FIND v(dout1_46) AT=345.025n

* CHECK dout1_47 Vdout1_47ck68 = 0.9 time = 345
.meas tran vdout1_47ck68 FIND v(dout1_47) AT=345.025n

* CHECK dout1_48 Vdout1_48ck68 = 0.9 time = 345
.meas tran vdout1_48ck68 FIND v(dout1_48) AT=345.025n

* CHECK dout1_49 Vdout1_49ck68 = 0.9 time = 345
.meas tran vdout1_49ck68 FIND v(dout1_49) AT=345.025n

* CHECK dout1_50 Vdout1_50ck68 = 0.9 time = 345
.meas tran vdout1_50ck68 FIND v(dout1_50) AT=345.025n

* CHECK dout1_51 Vdout1_51ck68 = 0 time = 345
.meas tran vdout1_51ck68 FIND v(dout1_51) AT=345.025n

* CHECK dout1_52 Vdout1_52ck68 = 0 time = 345
.meas tran vdout1_52ck68 FIND v(dout1_52) AT=345.025n

* CHECK dout1_53 Vdout1_53ck68 = 0 time = 345
.meas tran vdout1_53ck68 FIND v(dout1_53) AT=345.025n

* CHECK dout1_54 Vdout1_54ck68 = 0.9 time = 345
.meas tran vdout1_54ck68 FIND v(dout1_54) AT=345.025n

* CHECK dout1_55 Vdout1_55ck68 = 0.9 time = 345
.meas tran vdout1_55ck68 FIND v(dout1_55) AT=345.025n

* CHECK dout1_56 Vdout1_56ck68 = 0.9 time = 345
.meas tran vdout1_56ck68 FIND v(dout1_56) AT=345.025n

* CHECK dout1_57 Vdout1_57ck68 = 0.9 time = 345
.meas tran vdout1_57ck68 FIND v(dout1_57) AT=345.025n

* CHECK dout1_58 Vdout1_58ck68 = 0 time = 345
.meas tran vdout1_58ck68 FIND v(dout1_58) AT=345.025n

* CHECK dout1_59 Vdout1_59ck68 = 0.9 time = 345
.meas tran vdout1_59ck68 FIND v(dout1_59) AT=345.025n

* CHECK dout1_60 Vdout1_60ck68 = 0 time = 345
.meas tran vdout1_60ck68 FIND v(dout1_60) AT=345.025n

* CHECK dout1_61 Vdout1_61ck68 = 0.9 time = 345
.meas tran vdout1_61ck68 FIND v(dout1_61) AT=345.025n

* CHECK dout1_62 Vdout1_62ck68 = 0 time = 345
.meas tran vdout1_62ck68 FIND v(dout1_62) AT=345.025n

* CHECK dout1_63 Vdout1_63ck68 = 0 time = 345
.meas tran vdout1_63ck68 FIND v(dout1_63) AT=345.025n

* CHECK dout1_64 Vdout1_64ck68 = 0 time = 345
.meas tran vdout1_64ck68 FIND v(dout1_64) AT=345.025n

* CHECK dout1_65 Vdout1_65ck68 = 0.9 time = 345
.meas tran vdout1_65ck68 FIND v(dout1_65) AT=345.025n

* CHECK dout1_66 Vdout1_66ck68 = 0.9 time = 345
.meas tran vdout1_66ck68 FIND v(dout1_66) AT=345.025n

* CHECK dout1_67 Vdout1_67ck68 = 0.9 time = 345
.meas tran vdout1_67ck68 FIND v(dout1_67) AT=345.025n

* CHECK dout1_68 Vdout1_68ck68 = 0.9 time = 345
.meas tran vdout1_68ck68 FIND v(dout1_68) AT=345.025n

* CHECK dout1_69 Vdout1_69ck68 = 0.9 time = 345
.meas tran vdout1_69ck68 FIND v(dout1_69) AT=345.025n

* CHECK dout1_70 Vdout1_70ck68 = 0 time = 345
.meas tran vdout1_70ck68 FIND v(dout1_70) AT=345.025n

* CHECK dout1_71 Vdout1_71ck68 = 0.9 time = 345
.meas tran vdout1_71ck68 FIND v(dout1_71) AT=345.025n

* CHECK dout1_72 Vdout1_72ck68 = 0.9 time = 345
.meas tran vdout1_72ck68 FIND v(dout1_72) AT=345.025n

* CHECK dout1_73 Vdout1_73ck68 = 0.9 time = 345
.meas tran vdout1_73ck68 FIND v(dout1_73) AT=345.025n

* CHECK dout1_74 Vdout1_74ck68 = 0.9 time = 345
.meas tran vdout1_74ck68 FIND v(dout1_74) AT=345.025n

* CHECK dout1_75 Vdout1_75ck68 = 0 time = 345
.meas tran vdout1_75ck68 FIND v(dout1_75) AT=345.025n

* CHECK dout1_76 Vdout1_76ck68 = 0.9 time = 345
.meas tran vdout1_76ck68 FIND v(dout1_76) AT=345.025n

* CHECK dout1_77 Vdout1_77ck68 = 0 time = 345
.meas tran vdout1_77ck68 FIND v(dout1_77) AT=345.025n

* CHECK dout1_78 Vdout1_78ck68 = 0.9 time = 345
.meas tran vdout1_78ck68 FIND v(dout1_78) AT=345.025n

* CHECK dout1_79 Vdout1_79ck68 = 0.9 time = 345
.meas tran vdout1_79ck68 FIND v(dout1_79) AT=345.025n

* CHECK dout1_80 Vdout1_80ck68 = 0.9 time = 345
.meas tran vdout1_80ck68 FIND v(dout1_80) AT=345.025n

* CHECK dout1_81 Vdout1_81ck68 = 0 time = 345
.meas tran vdout1_81ck68 FIND v(dout1_81) AT=345.025n

* CHECK dout1_82 Vdout1_82ck68 = 0.9 time = 345
.meas tran vdout1_82ck68 FIND v(dout1_82) AT=345.025n

* CHECK dout1_83 Vdout1_83ck68 = 0.9 time = 345
.meas tran vdout1_83ck68 FIND v(dout1_83) AT=345.025n

* CHECK dout1_84 Vdout1_84ck68 = 0.9 time = 345
.meas tran vdout1_84ck68 FIND v(dout1_84) AT=345.025n

* CHECK dout1_85 Vdout1_85ck68 = 0.9 time = 345
.meas tran vdout1_85ck68 FIND v(dout1_85) AT=345.025n

* CHECK dout1_86 Vdout1_86ck68 = 0.9 time = 345
.meas tran vdout1_86ck68 FIND v(dout1_86) AT=345.025n

* CHECK dout1_87 Vdout1_87ck68 = 0 time = 345
.meas tran vdout1_87ck68 FIND v(dout1_87) AT=345.025n

* CHECK dout1_88 Vdout1_88ck68 = 0.9 time = 345
.meas tran vdout1_88ck68 FIND v(dout1_88) AT=345.025n

* CHECK dout1_89 Vdout1_89ck68 = 0.9 time = 345
.meas tran vdout1_89ck68 FIND v(dout1_89) AT=345.025n

* CHECK dout1_90 Vdout1_90ck68 = 0.9 time = 345
.meas tran vdout1_90ck68 FIND v(dout1_90) AT=345.025n

* CHECK dout1_91 Vdout1_91ck68 = 0 time = 345
.meas tran vdout1_91ck68 FIND v(dout1_91) AT=345.025n

* CHECK dout1_92 Vdout1_92ck68 = 0 time = 345
.meas tran vdout1_92ck68 FIND v(dout1_92) AT=345.025n

* CHECK dout1_93 Vdout1_93ck68 = 0 time = 345
.meas tran vdout1_93ck68 FIND v(dout1_93) AT=345.025n

* CHECK dout1_94 Vdout1_94ck68 = 0 time = 345
.meas tran vdout1_94ck68 FIND v(dout1_94) AT=345.025n

* CHECK dout1_95 Vdout1_95ck68 = 0 time = 345
.meas tran vdout1_95ck68 FIND v(dout1_95) AT=345.025n

* CHECK dout1_0 Vdout1_0ck71 = 0.9 time = 360
.meas tran vdout1_0ck71 FIND v(dout1_0) AT=360.025n

* CHECK dout1_1 Vdout1_1ck71 = 0 time = 360
.meas tran vdout1_1ck71 FIND v(dout1_1) AT=360.025n

* CHECK dout1_2 Vdout1_2ck71 = 0.9 time = 360
.meas tran vdout1_2ck71 FIND v(dout1_2) AT=360.025n

* CHECK dout1_3 Vdout1_3ck71 = 0.9 time = 360
.meas tran vdout1_3ck71 FIND v(dout1_3) AT=360.025n

* CHECK dout1_4 Vdout1_4ck71 = 0 time = 360
.meas tran vdout1_4ck71 FIND v(dout1_4) AT=360.025n

* CHECK dout1_5 Vdout1_5ck71 = 0.9 time = 360
.meas tran vdout1_5ck71 FIND v(dout1_5) AT=360.025n

* CHECK dout1_6 Vdout1_6ck71 = 0.9 time = 360
.meas tran vdout1_6ck71 FIND v(dout1_6) AT=360.025n

* CHECK dout1_7 Vdout1_7ck71 = 0.9 time = 360
.meas tran vdout1_7ck71 FIND v(dout1_7) AT=360.025n

* CHECK dout1_8 Vdout1_8ck71 = 0.9 time = 360
.meas tran vdout1_8ck71 FIND v(dout1_8) AT=360.025n

* CHECK dout1_9 Vdout1_9ck71 = 0 time = 360
.meas tran vdout1_9ck71 FIND v(dout1_9) AT=360.025n

* CHECK dout1_10 Vdout1_10ck71 = 0.9 time = 360
.meas tran vdout1_10ck71 FIND v(dout1_10) AT=360.025n

* CHECK dout1_11 Vdout1_11ck71 = 0 time = 360
.meas tran vdout1_11ck71 FIND v(dout1_11) AT=360.025n

* CHECK dout1_12 Vdout1_12ck71 = 0 time = 360
.meas tran vdout1_12ck71 FIND v(dout1_12) AT=360.025n

* CHECK dout1_13 Vdout1_13ck71 = 0.9 time = 360
.meas tran vdout1_13ck71 FIND v(dout1_13) AT=360.025n

* CHECK dout1_14 Vdout1_14ck71 = 0.9 time = 360
.meas tran vdout1_14ck71 FIND v(dout1_14) AT=360.025n

* CHECK dout1_15 Vdout1_15ck71 = 0 time = 360
.meas tran vdout1_15ck71 FIND v(dout1_15) AT=360.025n

* CHECK dout1_16 Vdout1_16ck71 = 0 time = 360
.meas tran vdout1_16ck71 FIND v(dout1_16) AT=360.025n

* CHECK dout1_17 Vdout1_17ck71 = 0.9 time = 360
.meas tran vdout1_17ck71 FIND v(dout1_17) AT=360.025n

* CHECK dout1_18 Vdout1_18ck71 = 0.9 time = 360
.meas tran vdout1_18ck71 FIND v(dout1_18) AT=360.025n

* CHECK dout1_19 Vdout1_19ck71 = 0 time = 360
.meas tran vdout1_19ck71 FIND v(dout1_19) AT=360.025n

* CHECK dout1_20 Vdout1_20ck71 = 0 time = 360
.meas tran vdout1_20ck71 FIND v(dout1_20) AT=360.025n

* CHECK dout1_21 Vdout1_21ck71 = 0 time = 360
.meas tran vdout1_21ck71 FIND v(dout1_21) AT=360.025n

* CHECK dout1_22 Vdout1_22ck71 = 0 time = 360
.meas tran vdout1_22ck71 FIND v(dout1_22) AT=360.025n

* CHECK dout1_23 Vdout1_23ck71 = 0 time = 360
.meas tran vdout1_23ck71 FIND v(dout1_23) AT=360.025n

* CHECK dout1_24 Vdout1_24ck71 = 0.9 time = 360
.meas tran vdout1_24ck71 FIND v(dout1_24) AT=360.025n

* CHECK dout1_25 Vdout1_25ck71 = 0.9 time = 360
.meas tran vdout1_25ck71 FIND v(dout1_25) AT=360.025n

* CHECK dout1_26 Vdout1_26ck71 = 0 time = 360
.meas tran vdout1_26ck71 FIND v(dout1_26) AT=360.025n

* CHECK dout1_27 Vdout1_27ck71 = 0 time = 360
.meas tran vdout1_27ck71 FIND v(dout1_27) AT=360.025n

* CHECK dout1_28 Vdout1_28ck71 = 0.9 time = 360
.meas tran vdout1_28ck71 FIND v(dout1_28) AT=360.025n

* CHECK dout1_29 Vdout1_29ck71 = 0 time = 360
.meas tran vdout1_29ck71 FIND v(dout1_29) AT=360.025n

* CHECK dout1_30 Vdout1_30ck71 = 0.9 time = 360
.meas tran vdout1_30ck71 FIND v(dout1_30) AT=360.025n

* CHECK dout1_31 Vdout1_31ck71 = 0 time = 360
.meas tran vdout1_31ck71 FIND v(dout1_31) AT=360.025n

* CHECK dout1_32 Vdout1_32ck71 = 0.9 time = 360
.meas tran vdout1_32ck71 FIND v(dout1_32) AT=360.025n

* CHECK dout1_33 Vdout1_33ck71 = 0 time = 360
.meas tran vdout1_33ck71 FIND v(dout1_33) AT=360.025n

* CHECK dout1_34 Vdout1_34ck71 = 0 time = 360
.meas tran vdout1_34ck71 FIND v(dout1_34) AT=360.025n

* CHECK dout1_35 Vdout1_35ck71 = 0 time = 360
.meas tran vdout1_35ck71 FIND v(dout1_35) AT=360.025n

* CHECK dout1_36 Vdout1_36ck71 = 0 time = 360
.meas tran vdout1_36ck71 FIND v(dout1_36) AT=360.025n

* CHECK dout1_37 Vdout1_37ck71 = 0 time = 360
.meas tran vdout1_37ck71 FIND v(dout1_37) AT=360.025n

* CHECK dout1_38 Vdout1_38ck71 = 0.9 time = 360
.meas tran vdout1_38ck71 FIND v(dout1_38) AT=360.025n

* CHECK dout1_39 Vdout1_39ck71 = 0.9 time = 360
.meas tran vdout1_39ck71 FIND v(dout1_39) AT=360.025n

* CHECK dout1_40 Vdout1_40ck71 = 0.9 time = 360
.meas tran vdout1_40ck71 FIND v(dout1_40) AT=360.025n

* CHECK dout1_41 Vdout1_41ck71 = 0 time = 360
.meas tran vdout1_41ck71 FIND v(dout1_41) AT=360.025n

* CHECK dout1_42 Vdout1_42ck71 = 0 time = 360
.meas tran vdout1_42ck71 FIND v(dout1_42) AT=360.025n

* CHECK dout1_43 Vdout1_43ck71 = 0.9 time = 360
.meas tran vdout1_43ck71 FIND v(dout1_43) AT=360.025n

* CHECK dout1_44 Vdout1_44ck71 = 0 time = 360
.meas tran vdout1_44ck71 FIND v(dout1_44) AT=360.025n

* CHECK dout1_45 Vdout1_45ck71 = 0.9 time = 360
.meas tran vdout1_45ck71 FIND v(dout1_45) AT=360.025n

* CHECK dout1_46 Vdout1_46ck71 = 0 time = 360
.meas tran vdout1_46ck71 FIND v(dout1_46) AT=360.025n

* CHECK dout1_47 Vdout1_47ck71 = 0 time = 360
.meas tran vdout1_47ck71 FIND v(dout1_47) AT=360.025n

* CHECK dout1_48 Vdout1_48ck71 = 0 time = 360
.meas tran vdout1_48ck71 FIND v(dout1_48) AT=360.025n

* CHECK dout1_49 Vdout1_49ck71 = 0.9 time = 360
.meas tran vdout1_49ck71 FIND v(dout1_49) AT=360.025n

* CHECK dout1_50 Vdout1_50ck71 = 0.9 time = 360
.meas tran vdout1_50ck71 FIND v(dout1_50) AT=360.025n

* CHECK dout1_51 Vdout1_51ck71 = 0 time = 360
.meas tran vdout1_51ck71 FIND v(dout1_51) AT=360.025n

* CHECK dout1_52 Vdout1_52ck71 = 0.9 time = 360
.meas tran vdout1_52ck71 FIND v(dout1_52) AT=360.025n

* CHECK dout1_53 Vdout1_53ck71 = 0 time = 360
.meas tran vdout1_53ck71 FIND v(dout1_53) AT=360.025n

* CHECK dout1_54 Vdout1_54ck71 = 0.9 time = 360
.meas tran vdout1_54ck71 FIND v(dout1_54) AT=360.025n

* CHECK dout1_55 Vdout1_55ck71 = 0.9 time = 360
.meas tran vdout1_55ck71 FIND v(dout1_55) AT=360.025n

* CHECK dout1_56 Vdout1_56ck71 = 0.9 time = 360
.meas tran vdout1_56ck71 FIND v(dout1_56) AT=360.025n

* CHECK dout1_57 Vdout1_57ck71 = 0.9 time = 360
.meas tran vdout1_57ck71 FIND v(dout1_57) AT=360.025n

* CHECK dout1_58 Vdout1_58ck71 = 0 time = 360
.meas tran vdout1_58ck71 FIND v(dout1_58) AT=360.025n

* CHECK dout1_59 Vdout1_59ck71 = 0.9 time = 360
.meas tran vdout1_59ck71 FIND v(dout1_59) AT=360.025n

* CHECK dout1_60 Vdout1_60ck71 = 0.9 time = 360
.meas tran vdout1_60ck71 FIND v(dout1_60) AT=360.025n

* CHECK dout1_61 Vdout1_61ck71 = 0.9 time = 360
.meas tran vdout1_61ck71 FIND v(dout1_61) AT=360.025n

* CHECK dout1_62 Vdout1_62ck71 = 0.9 time = 360
.meas tran vdout1_62ck71 FIND v(dout1_62) AT=360.025n

* CHECK dout1_63 Vdout1_63ck71 = 0.9 time = 360
.meas tran vdout1_63ck71 FIND v(dout1_63) AT=360.025n

* CHECK dout1_64 Vdout1_64ck71 = 0.9 time = 360
.meas tran vdout1_64ck71 FIND v(dout1_64) AT=360.025n

* CHECK dout1_65 Vdout1_65ck71 = 0.9 time = 360
.meas tran vdout1_65ck71 FIND v(dout1_65) AT=360.025n

* CHECK dout1_66 Vdout1_66ck71 = 0.9 time = 360
.meas tran vdout1_66ck71 FIND v(dout1_66) AT=360.025n

* CHECK dout1_67 Vdout1_67ck71 = 0 time = 360
.meas tran vdout1_67ck71 FIND v(dout1_67) AT=360.025n

* CHECK dout1_68 Vdout1_68ck71 = 0 time = 360
.meas tran vdout1_68ck71 FIND v(dout1_68) AT=360.025n

* CHECK dout1_69 Vdout1_69ck71 = 0 time = 360
.meas tran vdout1_69ck71 FIND v(dout1_69) AT=360.025n

* CHECK dout1_70 Vdout1_70ck71 = 0.9 time = 360
.meas tran vdout1_70ck71 FIND v(dout1_70) AT=360.025n

* CHECK dout1_71 Vdout1_71ck71 = 0 time = 360
.meas tran vdout1_71ck71 FIND v(dout1_71) AT=360.025n

* CHECK dout1_72 Vdout1_72ck71 = 0 time = 360
.meas tran vdout1_72ck71 FIND v(dout1_72) AT=360.025n

* CHECK dout1_73 Vdout1_73ck71 = 0 time = 360
.meas tran vdout1_73ck71 FIND v(dout1_73) AT=360.025n

* CHECK dout1_74 Vdout1_74ck71 = 0 time = 360
.meas tran vdout1_74ck71 FIND v(dout1_74) AT=360.025n

* CHECK dout1_75 Vdout1_75ck71 = 0.9 time = 360
.meas tran vdout1_75ck71 FIND v(dout1_75) AT=360.025n

* CHECK dout1_76 Vdout1_76ck71 = 0 time = 360
.meas tran vdout1_76ck71 FIND v(dout1_76) AT=360.025n

* CHECK dout1_77 Vdout1_77ck71 = 0 time = 360
.meas tran vdout1_77ck71 FIND v(dout1_77) AT=360.025n

* CHECK dout1_78 Vdout1_78ck71 = 0 time = 360
.meas tran vdout1_78ck71 FIND v(dout1_78) AT=360.025n

* CHECK dout1_79 Vdout1_79ck71 = 0.9 time = 360
.meas tran vdout1_79ck71 FIND v(dout1_79) AT=360.025n

* CHECK dout1_80 Vdout1_80ck71 = 0.9 time = 360
.meas tran vdout1_80ck71 FIND v(dout1_80) AT=360.025n

* CHECK dout1_81 Vdout1_81ck71 = 0.9 time = 360
.meas tran vdout1_81ck71 FIND v(dout1_81) AT=360.025n

* CHECK dout1_82 Vdout1_82ck71 = 0.9 time = 360
.meas tran vdout1_82ck71 FIND v(dout1_82) AT=360.025n

* CHECK dout1_83 Vdout1_83ck71 = 0.9 time = 360
.meas tran vdout1_83ck71 FIND v(dout1_83) AT=360.025n

* CHECK dout1_84 Vdout1_84ck71 = 0.9 time = 360
.meas tran vdout1_84ck71 FIND v(dout1_84) AT=360.025n

* CHECK dout1_85 Vdout1_85ck71 = 0 time = 360
.meas tran vdout1_85ck71 FIND v(dout1_85) AT=360.025n

* CHECK dout1_86 Vdout1_86ck71 = 0.9 time = 360
.meas tran vdout1_86ck71 FIND v(dout1_86) AT=360.025n

* CHECK dout1_87 Vdout1_87ck71 = 0 time = 360
.meas tran vdout1_87ck71 FIND v(dout1_87) AT=360.025n

* CHECK dout1_88 Vdout1_88ck71 = 0 time = 360
.meas tran vdout1_88ck71 FIND v(dout1_88) AT=360.025n

* CHECK dout1_89 Vdout1_89ck71 = 0.9 time = 360
.meas tran vdout1_89ck71 FIND v(dout1_89) AT=360.025n

* CHECK dout1_90 Vdout1_90ck71 = 0 time = 360
.meas tran vdout1_90ck71 FIND v(dout1_90) AT=360.025n

* CHECK dout1_91 Vdout1_91ck71 = 0 time = 360
.meas tran vdout1_91ck71 FIND v(dout1_91) AT=360.025n

* CHECK dout1_92 Vdout1_92ck71 = 0 time = 360
.meas tran vdout1_92ck71 FIND v(dout1_92) AT=360.025n

* CHECK dout1_93 Vdout1_93ck71 = 0 time = 360
.meas tran vdout1_93ck71 FIND v(dout1_93) AT=360.025n

* CHECK dout1_94 Vdout1_94ck71 = 0.9 time = 360
.meas tran vdout1_94ck71 FIND v(dout1_94) AT=360.025n

* CHECK dout1_95 Vdout1_95ck71 = 0 time = 360
.meas tran vdout1_95ck71 FIND v(dout1_95) AT=360.025n

* CHECK dout1_0 Vdout1_0ck72 = 0 time = 365
.meas tran vdout1_0ck72 FIND v(dout1_0) AT=365.025n

* CHECK dout1_1 Vdout1_1ck72 = 0 time = 365
.meas tran vdout1_1ck72 FIND v(dout1_1) AT=365.025n

* CHECK dout1_2 Vdout1_2ck72 = 0.9 time = 365
.meas tran vdout1_2ck72 FIND v(dout1_2) AT=365.025n

* CHECK dout1_3 Vdout1_3ck72 = 0.9 time = 365
.meas tran vdout1_3ck72 FIND v(dout1_3) AT=365.025n

* CHECK dout1_4 Vdout1_4ck72 = 0 time = 365
.meas tran vdout1_4ck72 FIND v(dout1_4) AT=365.025n

* CHECK dout1_5 Vdout1_5ck72 = 0.9 time = 365
.meas tran vdout1_5ck72 FIND v(dout1_5) AT=365.025n

* CHECK dout1_6 Vdout1_6ck72 = 0 time = 365
.meas tran vdout1_6ck72 FIND v(dout1_6) AT=365.025n

* CHECK dout1_7 Vdout1_7ck72 = 0 time = 365
.meas tran vdout1_7ck72 FIND v(dout1_7) AT=365.025n

* CHECK dout1_8 Vdout1_8ck72 = 0.9 time = 365
.meas tran vdout1_8ck72 FIND v(dout1_8) AT=365.025n

* CHECK dout1_9 Vdout1_9ck72 = 0 time = 365
.meas tran vdout1_9ck72 FIND v(dout1_9) AT=365.025n

* CHECK dout1_10 Vdout1_10ck72 = 0 time = 365
.meas tran vdout1_10ck72 FIND v(dout1_10) AT=365.025n

* CHECK dout1_11 Vdout1_11ck72 = 0.9 time = 365
.meas tran vdout1_11ck72 FIND v(dout1_11) AT=365.025n

* CHECK dout1_12 Vdout1_12ck72 = 0.9 time = 365
.meas tran vdout1_12ck72 FIND v(dout1_12) AT=365.025n

* CHECK dout1_13 Vdout1_13ck72 = 0.9 time = 365
.meas tran vdout1_13ck72 FIND v(dout1_13) AT=365.025n

* CHECK dout1_14 Vdout1_14ck72 = 0.9 time = 365
.meas tran vdout1_14ck72 FIND v(dout1_14) AT=365.025n

* CHECK dout1_15 Vdout1_15ck72 = 0.9 time = 365
.meas tran vdout1_15ck72 FIND v(dout1_15) AT=365.025n

* CHECK dout1_16 Vdout1_16ck72 = 0 time = 365
.meas tran vdout1_16ck72 FIND v(dout1_16) AT=365.025n

* CHECK dout1_17 Vdout1_17ck72 = 0 time = 365
.meas tran vdout1_17ck72 FIND v(dout1_17) AT=365.025n

* CHECK dout1_18 Vdout1_18ck72 = 0.9 time = 365
.meas tran vdout1_18ck72 FIND v(dout1_18) AT=365.025n

* CHECK dout1_19 Vdout1_19ck72 = 0.9 time = 365
.meas tran vdout1_19ck72 FIND v(dout1_19) AT=365.025n

* CHECK dout1_20 Vdout1_20ck72 = 0.9 time = 365
.meas tran vdout1_20ck72 FIND v(dout1_20) AT=365.025n

* CHECK dout1_21 Vdout1_21ck72 = 0 time = 365
.meas tran vdout1_21ck72 FIND v(dout1_21) AT=365.025n

* CHECK dout1_22 Vdout1_22ck72 = 0 time = 365
.meas tran vdout1_22ck72 FIND v(dout1_22) AT=365.025n

* CHECK dout1_23 Vdout1_23ck72 = 0 time = 365
.meas tran vdout1_23ck72 FIND v(dout1_23) AT=365.025n

* CHECK dout1_24 Vdout1_24ck72 = 0 time = 365
.meas tran vdout1_24ck72 FIND v(dout1_24) AT=365.025n

* CHECK dout1_25 Vdout1_25ck72 = 0.9 time = 365
.meas tran vdout1_25ck72 FIND v(dout1_25) AT=365.025n

* CHECK dout1_26 Vdout1_26ck72 = 0.9 time = 365
.meas tran vdout1_26ck72 FIND v(dout1_26) AT=365.025n

* CHECK dout1_27 Vdout1_27ck72 = 0 time = 365
.meas tran vdout1_27ck72 FIND v(dout1_27) AT=365.025n

* CHECK dout1_28 Vdout1_28ck72 = 0 time = 365
.meas tran vdout1_28ck72 FIND v(dout1_28) AT=365.025n

* CHECK dout1_29 Vdout1_29ck72 = 0 time = 365
.meas tran vdout1_29ck72 FIND v(dout1_29) AT=365.025n

* CHECK dout1_30 Vdout1_30ck72 = 0 time = 365
.meas tran vdout1_30ck72 FIND v(dout1_30) AT=365.025n

* CHECK dout1_31 Vdout1_31ck72 = 0.9 time = 365
.meas tran vdout1_31ck72 FIND v(dout1_31) AT=365.025n

* CHECK dout1_32 Vdout1_32ck72 = 0.9 time = 365
.meas tran vdout1_32ck72 FIND v(dout1_32) AT=365.025n

* CHECK dout1_33 Vdout1_33ck72 = 0.9 time = 365
.meas tran vdout1_33ck72 FIND v(dout1_33) AT=365.025n

* CHECK dout1_34 Vdout1_34ck72 = 0 time = 365
.meas tran vdout1_34ck72 FIND v(dout1_34) AT=365.025n

* CHECK dout1_35 Vdout1_35ck72 = 0 time = 365
.meas tran vdout1_35ck72 FIND v(dout1_35) AT=365.025n

* CHECK dout1_36 Vdout1_36ck72 = 0 time = 365
.meas tran vdout1_36ck72 FIND v(dout1_36) AT=365.025n

* CHECK dout1_37 Vdout1_37ck72 = 0.9 time = 365
.meas tran vdout1_37ck72 FIND v(dout1_37) AT=365.025n

* CHECK dout1_38 Vdout1_38ck72 = 0.9 time = 365
.meas tran vdout1_38ck72 FIND v(dout1_38) AT=365.025n

* CHECK dout1_39 Vdout1_39ck72 = 0.9 time = 365
.meas tran vdout1_39ck72 FIND v(dout1_39) AT=365.025n

* CHECK dout1_40 Vdout1_40ck72 = 0 time = 365
.meas tran vdout1_40ck72 FIND v(dout1_40) AT=365.025n

* CHECK dout1_41 Vdout1_41ck72 = 0.9 time = 365
.meas tran vdout1_41ck72 FIND v(dout1_41) AT=365.025n

* CHECK dout1_42 Vdout1_42ck72 = 0 time = 365
.meas tran vdout1_42ck72 FIND v(dout1_42) AT=365.025n

* CHECK dout1_43 Vdout1_43ck72 = 0.9 time = 365
.meas tran vdout1_43ck72 FIND v(dout1_43) AT=365.025n

* CHECK dout1_44 Vdout1_44ck72 = 0 time = 365
.meas tran vdout1_44ck72 FIND v(dout1_44) AT=365.025n

* CHECK dout1_45 Vdout1_45ck72 = 0 time = 365
.meas tran vdout1_45ck72 FIND v(dout1_45) AT=365.025n

* CHECK dout1_46 Vdout1_46ck72 = 0 time = 365
.meas tran vdout1_46ck72 FIND v(dout1_46) AT=365.025n

* CHECK dout1_47 Vdout1_47ck72 = 0.9 time = 365
.meas tran vdout1_47ck72 FIND v(dout1_47) AT=365.025n

* CHECK dout1_48 Vdout1_48ck72 = 0.9 time = 365
.meas tran vdout1_48ck72 FIND v(dout1_48) AT=365.025n

* CHECK dout1_49 Vdout1_49ck72 = 0.9 time = 365
.meas tran vdout1_49ck72 FIND v(dout1_49) AT=365.025n

* CHECK dout1_50 Vdout1_50ck72 = 0.9 time = 365
.meas tran vdout1_50ck72 FIND v(dout1_50) AT=365.025n

* CHECK dout1_51 Vdout1_51ck72 = 0 time = 365
.meas tran vdout1_51ck72 FIND v(dout1_51) AT=365.025n

* CHECK dout1_52 Vdout1_52ck72 = 0 time = 365
.meas tran vdout1_52ck72 FIND v(dout1_52) AT=365.025n

* CHECK dout1_53 Vdout1_53ck72 = 0 time = 365
.meas tran vdout1_53ck72 FIND v(dout1_53) AT=365.025n

* CHECK dout1_54 Vdout1_54ck72 = 0.9 time = 365
.meas tran vdout1_54ck72 FIND v(dout1_54) AT=365.025n

* CHECK dout1_55 Vdout1_55ck72 = 0.9 time = 365
.meas tran vdout1_55ck72 FIND v(dout1_55) AT=365.025n

* CHECK dout1_56 Vdout1_56ck72 = 0.9 time = 365
.meas tran vdout1_56ck72 FIND v(dout1_56) AT=365.025n

* CHECK dout1_57 Vdout1_57ck72 = 0.9 time = 365
.meas tran vdout1_57ck72 FIND v(dout1_57) AT=365.025n

* CHECK dout1_58 Vdout1_58ck72 = 0 time = 365
.meas tran vdout1_58ck72 FIND v(dout1_58) AT=365.025n

* CHECK dout1_59 Vdout1_59ck72 = 0.9 time = 365
.meas tran vdout1_59ck72 FIND v(dout1_59) AT=365.025n

* CHECK dout1_60 Vdout1_60ck72 = 0 time = 365
.meas tran vdout1_60ck72 FIND v(dout1_60) AT=365.025n

* CHECK dout1_61 Vdout1_61ck72 = 0.9 time = 365
.meas tran vdout1_61ck72 FIND v(dout1_61) AT=365.025n

* CHECK dout1_62 Vdout1_62ck72 = 0 time = 365
.meas tran vdout1_62ck72 FIND v(dout1_62) AT=365.025n

* CHECK dout1_63 Vdout1_63ck72 = 0 time = 365
.meas tran vdout1_63ck72 FIND v(dout1_63) AT=365.025n

* CHECK dout1_64 Vdout1_64ck72 = 0 time = 365
.meas tran vdout1_64ck72 FIND v(dout1_64) AT=365.025n

* CHECK dout1_65 Vdout1_65ck72 = 0 time = 365
.meas tran vdout1_65ck72 FIND v(dout1_65) AT=365.025n

* CHECK dout1_66 Vdout1_66ck72 = 0 time = 365
.meas tran vdout1_66ck72 FIND v(dout1_66) AT=365.025n

* CHECK dout1_67 Vdout1_67ck72 = 0 time = 365
.meas tran vdout1_67ck72 FIND v(dout1_67) AT=365.025n

* CHECK dout1_68 Vdout1_68ck72 = 0.9 time = 365
.meas tran vdout1_68ck72 FIND v(dout1_68) AT=365.025n

* CHECK dout1_69 Vdout1_69ck72 = 0 time = 365
.meas tran vdout1_69ck72 FIND v(dout1_69) AT=365.025n

* CHECK dout1_70 Vdout1_70ck72 = 0.9 time = 365
.meas tran vdout1_70ck72 FIND v(dout1_70) AT=365.025n

* CHECK dout1_71 Vdout1_71ck72 = 0 time = 365
.meas tran vdout1_71ck72 FIND v(dout1_71) AT=365.025n

* CHECK dout1_72 Vdout1_72ck72 = 0 time = 365
.meas tran vdout1_72ck72 FIND v(dout1_72) AT=365.025n

* CHECK dout1_73 Vdout1_73ck72 = 0.9 time = 365
.meas tran vdout1_73ck72 FIND v(dout1_73) AT=365.025n

* CHECK dout1_74 Vdout1_74ck72 = 0 time = 365
.meas tran vdout1_74ck72 FIND v(dout1_74) AT=365.025n

* CHECK dout1_75 Vdout1_75ck72 = 0.9 time = 365
.meas tran vdout1_75ck72 FIND v(dout1_75) AT=365.025n

* CHECK dout1_76 Vdout1_76ck72 = 0 time = 365
.meas tran vdout1_76ck72 FIND v(dout1_76) AT=365.025n

* CHECK dout1_77 Vdout1_77ck72 = 0.9 time = 365
.meas tran vdout1_77ck72 FIND v(dout1_77) AT=365.025n

* CHECK dout1_78 Vdout1_78ck72 = 0 time = 365
.meas tran vdout1_78ck72 FIND v(dout1_78) AT=365.025n

* CHECK dout1_79 Vdout1_79ck72 = 0 time = 365
.meas tran vdout1_79ck72 FIND v(dout1_79) AT=365.025n

* CHECK dout1_80 Vdout1_80ck72 = 0 time = 365
.meas tran vdout1_80ck72 FIND v(dout1_80) AT=365.025n

* CHECK dout1_81 Vdout1_81ck72 = 0 time = 365
.meas tran vdout1_81ck72 FIND v(dout1_81) AT=365.025n

* CHECK dout1_82 Vdout1_82ck72 = 0 time = 365
.meas tran vdout1_82ck72 FIND v(dout1_82) AT=365.025n

* CHECK dout1_83 Vdout1_83ck72 = 0.9 time = 365
.meas tran vdout1_83ck72 FIND v(dout1_83) AT=365.025n

* CHECK dout1_84 Vdout1_84ck72 = 0 time = 365
.meas tran vdout1_84ck72 FIND v(dout1_84) AT=365.025n

* CHECK dout1_85 Vdout1_85ck72 = 0.9 time = 365
.meas tran vdout1_85ck72 FIND v(dout1_85) AT=365.025n

* CHECK dout1_86 Vdout1_86ck72 = 0 time = 365
.meas tran vdout1_86ck72 FIND v(dout1_86) AT=365.025n

* CHECK dout1_87 Vdout1_87ck72 = 0.9 time = 365
.meas tran vdout1_87ck72 FIND v(dout1_87) AT=365.025n

* CHECK dout1_88 Vdout1_88ck72 = 0.9 time = 365
.meas tran vdout1_88ck72 FIND v(dout1_88) AT=365.025n

* CHECK dout1_89 Vdout1_89ck72 = 0 time = 365
.meas tran vdout1_89ck72 FIND v(dout1_89) AT=365.025n

* CHECK dout1_90 Vdout1_90ck72 = 0 time = 365
.meas tran vdout1_90ck72 FIND v(dout1_90) AT=365.025n

* CHECK dout1_91 Vdout1_91ck72 = 0 time = 365
.meas tran vdout1_91ck72 FIND v(dout1_91) AT=365.025n

* CHECK dout1_92 Vdout1_92ck72 = 0 time = 365
.meas tran vdout1_92ck72 FIND v(dout1_92) AT=365.025n

* CHECK dout1_93 Vdout1_93ck72 = 0 time = 365
.meas tran vdout1_93ck72 FIND v(dout1_93) AT=365.025n

* CHECK dout1_94 Vdout1_94ck72 = 0 time = 365
.meas tran vdout1_94ck72 FIND v(dout1_94) AT=365.025n

* CHECK dout1_95 Vdout1_95ck72 = 0 time = 365
.meas tran vdout1_95ck72 FIND v(dout1_95) AT=365.025n

* CHECK dout1_0 Vdout1_0ck74 = 0 time = 375
.meas tran vdout1_0ck74 FIND v(dout1_0) AT=375.025n

* CHECK dout1_1 Vdout1_1ck74 = 0 time = 375
.meas tran vdout1_1ck74 FIND v(dout1_1) AT=375.025n

* CHECK dout1_2 Vdout1_2ck74 = 0.9 time = 375
.meas tran vdout1_2ck74 FIND v(dout1_2) AT=375.025n

* CHECK dout1_3 Vdout1_3ck74 = 0.9 time = 375
.meas tran vdout1_3ck74 FIND v(dout1_3) AT=375.025n

* CHECK dout1_4 Vdout1_4ck74 = 0 time = 375
.meas tran vdout1_4ck74 FIND v(dout1_4) AT=375.025n

* CHECK dout1_5 Vdout1_5ck74 = 0.9 time = 375
.meas tran vdout1_5ck74 FIND v(dout1_5) AT=375.025n

* CHECK dout1_6 Vdout1_6ck74 = 0 time = 375
.meas tran vdout1_6ck74 FIND v(dout1_6) AT=375.025n

* CHECK dout1_7 Vdout1_7ck74 = 0 time = 375
.meas tran vdout1_7ck74 FIND v(dout1_7) AT=375.025n

* CHECK dout1_8 Vdout1_8ck74 = 0.9 time = 375
.meas tran vdout1_8ck74 FIND v(dout1_8) AT=375.025n

* CHECK dout1_9 Vdout1_9ck74 = 0 time = 375
.meas tran vdout1_9ck74 FIND v(dout1_9) AT=375.025n

* CHECK dout1_10 Vdout1_10ck74 = 0 time = 375
.meas tran vdout1_10ck74 FIND v(dout1_10) AT=375.025n

* CHECK dout1_11 Vdout1_11ck74 = 0.9 time = 375
.meas tran vdout1_11ck74 FIND v(dout1_11) AT=375.025n

* CHECK dout1_12 Vdout1_12ck74 = 0.9 time = 375
.meas tran vdout1_12ck74 FIND v(dout1_12) AT=375.025n

* CHECK dout1_13 Vdout1_13ck74 = 0.9 time = 375
.meas tran vdout1_13ck74 FIND v(dout1_13) AT=375.025n

* CHECK dout1_14 Vdout1_14ck74 = 0.9 time = 375
.meas tran vdout1_14ck74 FIND v(dout1_14) AT=375.025n

* CHECK dout1_15 Vdout1_15ck74 = 0.9 time = 375
.meas tran vdout1_15ck74 FIND v(dout1_15) AT=375.025n

* CHECK dout1_16 Vdout1_16ck74 = 0 time = 375
.meas tran vdout1_16ck74 FIND v(dout1_16) AT=375.025n

* CHECK dout1_17 Vdout1_17ck74 = 0 time = 375
.meas tran vdout1_17ck74 FIND v(dout1_17) AT=375.025n

* CHECK dout1_18 Vdout1_18ck74 = 0.9 time = 375
.meas tran vdout1_18ck74 FIND v(dout1_18) AT=375.025n

* CHECK dout1_19 Vdout1_19ck74 = 0.9 time = 375
.meas tran vdout1_19ck74 FIND v(dout1_19) AT=375.025n

* CHECK dout1_20 Vdout1_20ck74 = 0.9 time = 375
.meas tran vdout1_20ck74 FIND v(dout1_20) AT=375.025n

* CHECK dout1_21 Vdout1_21ck74 = 0 time = 375
.meas tran vdout1_21ck74 FIND v(dout1_21) AT=375.025n

* CHECK dout1_22 Vdout1_22ck74 = 0 time = 375
.meas tran vdout1_22ck74 FIND v(dout1_22) AT=375.025n

* CHECK dout1_23 Vdout1_23ck74 = 0 time = 375
.meas tran vdout1_23ck74 FIND v(dout1_23) AT=375.025n

* CHECK dout1_24 Vdout1_24ck74 = 0 time = 375
.meas tran vdout1_24ck74 FIND v(dout1_24) AT=375.025n

* CHECK dout1_25 Vdout1_25ck74 = 0.9 time = 375
.meas tran vdout1_25ck74 FIND v(dout1_25) AT=375.025n

* CHECK dout1_26 Vdout1_26ck74 = 0.9 time = 375
.meas tran vdout1_26ck74 FIND v(dout1_26) AT=375.025n

* CHECK dout1_27 Vdout1_27ck74 = 0 time = 375
.meas tran vdout1_27ck74 FIND v(dout1_27) AT=375.025n

* CHECK dout1_28 Vdout1_28ck74 = 0 time = 375
.meas tran vdout1_28ck74 FIND v(dout1_28) AT=375.025n

* CHECK dout1_29 Vdout1_29ck74 = 0 time = 375
.meas tran vdout1_29ck74 FIND v(dout1_29) AT=375.025n

* CHECK dout1_30 Vdout1_30ck74 = 0 time = 375
.meas tran vdout1_30ck74 FIND v(dout1_30) AT=375.025n

* CHECK dout1_31 Vdout1_31ck74 = 0.9 time = 375
.meas tran vdout1_31ck74 FIND v(dout1_31) AT=375.025n

* CHECK dout1_32 Vdout1_32ck74 = 0.9 time = 375
.meas tran vdout1_32ck74 FIND v(dout1_32) AT=375.025n

* CHECK dout1_33 Vdout1_33ck74 = 0.9 time = 375
.meas tran vdout1_33ck74 FIND v(dout1_33) AT=375.025n

* CHECK dout1_34 Vdout1_34ck74 = 0 time = 375
.meas tran vdout1_34ck74 FIND v(dout1_34) AT=375.025n

* CHECK dout1_35 Vdout1_35ck74 = 0 time = 375
.meas tran vdout1_35ck74 FIND v(dout1_35) AT=375.025n

* CHECK dout1_36 Vdout1_36ck74 = 0 time = 375
.meas tran vdout1_36ck74 FIND v(dout1_36) AT=375.025n

* CHECK dout1_37 Vdout1_37ck74 = 0.9 time = 375
.meas tran vdout1_37ck74 FIND v(dout1_37) AT=375.025n

* CHECK dout1_38 Vdout1_38ck74 = 0.9 time = 375
.meas tran vdout1_38ck74 FIND v(dout1_38) AT=375.025n

* CHECK dout1_39 Vdout1_39ck74 = 0.9 time = 375
.meas tran vdout1_39ck74 FIND v(dout1_39) AT=375.025n

* CHECK dout1_40 Vdout1_40ck74 = 0 time = 375
.meas tran vdout1_40ck74 FIND v(dout1_40) AT=375.025n

* CHECK dout1_41 Vdout1_41ck74 = 0.9 time = 375
.meas tran vdout1_41ck74 FIND v(dout1_41) AT=375.025n

* CHECK dout1_42 Vdout1_42ck74 = 0 time = 375
.meas tran vdout1_42ck74 FIND v(dout1_42) AT=375.025n

* CHECK dout1_43 Vdout1_43ck74 = 0.9 time = 375
.meas tran vdout1_43ck74 FIND v(dout1_43) AT=375.025n

* CHECK dout1_44 Vdout1_44ck74 = 0 time = 375
.meas tran vdout1_44ck74 FIND v(dout1_44) AT=375.025n

* CHECK dout1_45 Vdout1_45ck74 = 0 time = 375
.meas tran vdout1_45ck74 FIND v(dout1_45) AT=375.025n

* CHECK dout1_46 Vdout1_46ck74 = 0 time = 375
.meas tran vdout1_46ck74 FIND v(dout1_46) AT=375.025n

* CHECK dout1_47 Vdout1_47ck74 = 0.9 time = 375
.meas tran vdout1_47ck74 FIND v(dout1_47) AT=375.025n

* CHECK dout1_48 Vdout1_48ck74 = 0.9 time = 375
.meas tran vdout1_48ck74 FIND v(dout1_48) AT=375.025n

* CHECK dout1_49 Vdout1_49ck74 = 0.9 time = 375
.meas tran vdout1_49ck74 FIND v(dout1_49) AT=375.025n

* CHECK dout1_50 Vdout1_50ck74 = 0.9 time = 375
.meas tran vdout1_50ck74 FIND v(dout1_50) AT=375.025n

* CHECK dout1_51 Vdout1_51ck74 = 0 time = 375
.meas tran vdout1_51ck74 FIND v(dout1_51) AT=375.025n

* CHECK dout1_52 Vdout1_52ck74 = 0 time = 375
.meas tran vdout1_52ck74 FIND v(dout1_52) AT=375.025n

* CHECK dout1_53 Vdout1_53ck74 = 0 time = 375
.meas tran vdout1_53ck74 FIND v(dout1_53) AT=375.025n

* CHECK dout1_54 Vdout1_54ck74 = 0.9 time = 375
.meas tran vdout1_54ck74 FIND v(dout1_54) AT=375.025n

* CHECK dout1_55 Vdout1_55ck74 = 0.9 time = 375
.meas tran vdout1_55ck74 FIND v(dout1_55) AT=375.025n

* CHECK dout1_56 Vdout1_56ck74 = 0.9 time = 375
.meas tran vdout1_56ck74 FIND v(dout1_56) AT=375.025n

* CHECK dout1_57 Vdout1_57ck74 = 0.9 time = 375
.meas tran vdout1_57ck74 FIND v(dout1_57) AT=375.025n

* CHECK dout1_58 Vdout1_58ck74 = 0 time = 375
.meas tran vdout1_58ck74 FIND v(dout1_58) AT=375.025n

* CHECK dout1_59 Vdout1_59ck74 = 0.9 time = 375
.meas tran vdout1_59ck74 FIND v(dout1_59) AT=375.025n

* CHECK dout1_60 Vdout1_60ck74 = 0 time = 375
.meas tran vdout1_60ck74 FIND v(dout1_60) AT=375.025n

* CHECK dout1_61 Vdout1_61ck74 = 0.9 time = 375
.meas tran vdout1_61ck74 FIND v(dout1_61) AT=375.025n

* CHECK dout1_62 Vdout1_62ck74 = 0 time = 375
.meas tran vdout1_62ck74 FIND v(dout1_62) AT=375.025n

* CHECK dout1_63 Vdout1_63ck74 = 0 time = 375
.meas tran vdout1_63ck74 FIND v(dout1_63) AT=375.025n

* CHECK dout1_64 Vdout1_64ck74 = 0 time = 375
.meas tran vdout1_64ck74 FIND v(dout1_64) AT=375.025n

* CHECK dout1_65 Vdout1_65ck74 = 0 time = 375
.meas tran vdout1_65ck74 FIND v(dout1_65) AT=375.025n

* CHECK dout1_66 Vdout1_66ck74 = 0 time = 375
.meas tran vdout1_66ck74 FIND v(dout1_66) AT=375.025n

* CHECK dout1_67 Vdout1_67ck74 = 0 time = 375
.meas tran vdout1_67ck74 FIND v(dout1_67) AT=375.025n

* CHECK dout1_68 Vdout1_68ck74 = 0.9 time = 375
.meas tran vdout1_68ck74 FIND v(dout1_68) AT=375.025n

* CHECK dout1_69 Vdout1_69ck74 = 0 time = 375
.meas tran vdout1_69ck74 FIND v(dout1_69) AT=375.025n

* CHECK dout1_70 Vdout1_70ck74 = 0.9 time = 375
.meas tran vdout1_70ck74 FIND v(dout1_70) AT=375.025n

* CHECK dout1_71 Vdout1_71ck74 = 0 time = 375
.meas tran vdout1_71ck74 FIND v(dout1_71) AT=375.025n

* CHECK dout1_72 Vdout1_72ck74 = 0 time = 375
.meas tran vdout1_72ck74 FIND v(dout1_72) AT=375.025n

* CHECK dout1_73 Vdout1_73ck74 = 0.9 time = 375
.meas tran vdout1_73ck74 FIND v(dout1_73) AT=375.025n

* CHECK dout1_74 Vdout1_74ck74 = 0 time = 375
.meas tran vdout1_74ck74 FIND v(dout1_74) AT=375.025n

* CHECK dout1_75 Vdout1_75ck74 = 0.9 time = 375
.meas tran vdout1_75ck74 FIND v(dout1_75) AT=375.025n

* CHECK dout1_76 Vdout1_76ck74 = 0 time = 375
.meas tran vdout1_76ck74 FIND v(dout1_76) AT=375.025n

* CHECK dout1_77 Vdout1_77ck74 = 0.9 time = 375
.meas tran vdout1_77ck74 FIND v(dout1_77) AT=375.025n

* CHECK dout1_78 Vdout1_78ck74 = 0 time = 375
.meas tran vdout1_78ck74 FIND v(dout1_78) AT=375.025n

* CHECK dout1_79 Vdout1_79ck74 = 0 time = 375
.meas tran vdout1_79ck74 FIND v(dout1_79) AT=375.025n

* CHECK dout1_80 Vdout1_80ck74 = 0 time = 375
.meas tran vdout1_80ck74 FIND v(dout1_80) AT=375.025n

* CHECK dout1_81 Vdout1_81ck74 = 0 time = 375
.meas tran vdout1_81ck74 FIND v(dout1_81) AT=375.025n

* CHECK dout1_82 Vdout1_82ck74 = 0 time = 375
.meas tran vdout1_82ck74 FIND v(dout1_82) AT=375.025n

* CHECK dout1_83 Vdout1_83ck74 = 0.9 time = 375
.meas tran vdout1_83ck74 FIND v(dout1_83) AT=375.025n

* CHECK dout1_84 Vdout1_84ck74 = 0 time = 375
.meas tran vdout1_84ck74 FIND v(dout1_84) AT=375.025n

* CHECK dout1_85 Vdout1_85ck74 = 0.9 time = 375
.meas tran vdout1_85ck74 FIND v(dout1_85) AT=375.025n

* CHECK dout1_86 Vdout1_86ck74 = 0 time = 375
.meas tran vdout1_86ck74 FIND v(dout1_86) AT=375.025n

* CHECK dout1_87 Vdout1_87ck74 = 0.9 time = 375
.meas tran vdout1_87ck74 FIND v(dout1_87) AT=375.025n

* CHECK dout1_88 Vdout1_88ck74 = 0.9 time = 375
.meas tran vdout1_88ck74 FIND v(dout1_88) AT=375.025n

* CHECK dout1_89 Vdout1_89ck74 = 0 time = 375
.meas tran vdout1_89ck74 FIND v(dout1_89) AT=375.025n

* CHECK dout1_90 Vdout1_90ck74 = 0 time = 375
.meas tran vdout1_90ck74 FIND v(dout1_90) AT=375.025n

* CHECK dout1_91 Vdout1_91ck74 = 0 time = 375
.meas tran vdout1_91ck74 FIND v(dout1_91) AT=375.025n

* CHECK dout1_92 Vdout1_92ck74 = 0 time = 375
.meas tran vdout1_92ck74 FIND v(dout1_92) AT=375.025n

* CHECK dout1_93 Vdout1_93ck74 = 0 time = 375
.meas tran vdout1_93ck74 FIND v(dout1_93) AT=375.025n

* CHECK dout1_94 Vdout1_94ck74 = 0 time = 375
.meas tran vdout1_94ck74 FIND v(dout1_94) AT=375.025n

* CHECK dout1_95 Vdout1_95ck74 = 0 time = 375
.meas tran vdout1_95ck74 FIND v(dout1_95) AT=375.025n

* CHECK dout1_0 Vdout1_0ck79 = 0 time = 400
.meas tran vdout1_0ck79 FIND v(dout1_0) AT=400.025n

* CHECK dout1_1 Vdout1_1ck79 = 0 time = 400
.meas tran vdout1_1ck79 FIND v(dout1_1) AT=400.025n

* CHECK dout1_2 Vdout1_2ck79 = 0.9 time = 400
.meas tran vdout1_2ck79 FIND v(dout1_2) AT=400.025n

* CHECK dout1_3 Vdout1_3ck79 = 0.9 time = 400
.meas tran vdout1_3ck79 FIND v(dout1_3) AT=400.025n

* CHECK dout1_4 Vdout1_4ck79 = 0 time = 400
.meas tran vdout1_4ck79 FIND v(dout1_4) AT=400.025n

* CHECK dout1_5 Vdout1_5ck79 = 0.9 time = 400
.meas tran vdout1_5ck79 FIND v(dout1_5) AT=400.025n

* CHECK dout1_6 Vdout1_6ck79 = 0 time = 400
.meas tran vdout1_6ck79 FIND v(dout1_6) AT=400.025n

* CHECK dout1_7 Vdout1_7ck79 = 0 time = 400
.meas tran vdout1_7ck79 FIND v(dout1_7) AT=400.025n

* CHECK dout1_8 Vdout1_8ck79 = 0.9 time = 400
.meas tran vdout1_8ck79 FIND v(dout1_8) AT=400.025n

* CHECK dout1_9 Vdout1_9ck79 = 0 time = 400
.meas tran vdout1_9ck79 FIND v(dout1_9) AT=400.025n

* CHECK dout1_10 Vdout1_10ck79 = 0 time = 400
.meas tran vdout1_10ck79 FIND v(dout1_10) AT=400.025n

* CHECK dout1_11 Vdout1_11ck79 = 0.9 time = 400
.meas tran vdout1_11ck79 FIND v(dout1_11) AT=400.025n

* CHECK dout1_12 Vdout1_12ck79 = 0.9 time = 400
.meas tran vdout1_12ck79 FIND v(dout1_12) AT=400.025n

* CHECK dout1_13 Vdout1_13ck79 = 0.9 time = 400
.meas tran vdout1_13ck79 FIND v(dout1_13) AT=400.025n

* CHECK dout1_14 Vdout1_14ck79 = 0.9 time = 400
.meas tran vdout1_14ck79 FIND v(dout1_14) AT=400.025n

* CHECK dout1_15 Vdout1_15ck79 = 0.9 time = 400
.meas tran vdout1_15ck79 FIND v(dout1_15) AT=400.025n

* CHECK dout1_16 Vdout1_16ck79 = 0 time = 400
.meas tran vdout1_16ck79 FIND v(dout1_16) AT=400.025n

* CHECK dout1_17 Vdout1_17ck79 = 0 time = 400
.meas tran vdout1_17ck79 FIND v(dout1_17) AT=400.025n

* CHECK dout1_18 Vdout1_18ck79 = 0.9 time = 400
.meas tran vdout1_18ck79 FIND v(dout1_18) AT=400.025n

* CHECK dout1_19 Vdout1_19ck79 = 0.9 time = 400
.meas tran vdout1_19ck79 FIND v(dout1_19) AT=400.025n

* CHECK dout1_20 Vdout1_20ck79 = 0.9 time = 400
.meas tran vdout1_20ck79 FIND v(dout1_20) AT=400.025n

* CHECK dout1_21 Vdout1_21ck79 = 0 time = 400
.meas tran vdout1_21ck79 FIND v(dout1_21) AT=400.025n

* CHECK dout1_22 Vdout1_22ck79 = 0 time = 400
.meas tran vdout1_22ck79 FIND v(dout1_22) AT=400.025n

* CHECK dout1_23 Vdout1_23ck79 = 0 time = 400
.meas tran vdout1_23ck79 FIND v(dout1_23) AT=400.025n

* CHECK dout1_24 Vdout1_24ck79 = 0 time = 400
.meas tran vdout1_24ck79 FIND v(dout1_24) AT=400.025n

* CHECK dout1_25 Vdout1_25ck79 = 0.9 time = 400
.meas tran vdout1_25ck79 FIND v(dout1_25) AT=400.025n

* CHECK dout1_26 Vdout1_26ck79 = 0.9 time = 400
.meas tran vdout1_26ck79 FIND v(dout1_26) AT=400.025n

* CHECK dout1_27 Vdout1_27ck79 = 0 time = 400
.meas tran vdout1_27ck79 FIND v(dout1_27) AT=400.025n

* CHECK dout1_28 Vdout1_28ck79 = 0 time = 400
.meas tran vdout1_28ck79 FIND v(dout1_28) AT=400.025n

* CHECK dout1_29 Vdout1_29ck79 = 0 time = 400
.meas tran vdout1_29ck79 FIND v(dout1_29) AT=400.025n

* CHECK dout1_30 Vdout1_30ck79 = 0 time = 400
.meas tran vdout1_30ck79 FIND v(dout1_30) AT=400.025n

* CHECK dout1_31 Vdout1_31ck79 = 0.9 time = 400
.meas tran vdout1_31ck79 FIND v(dout1_31) AT=400.025n

* CHECK dout1_32 Vdout1_32ck79 = 0.9 time = 400
.meas tran vdout1_32ck79 FIND v(dout1_32) AT=400.025n

* CHECK dout1_33 Vdout1_33ck79 = 0.9 time = 400
.meas tran vdout1_33ck79 FIND v(dout1_33) AT=400.025n

* CHECK dout1_34 Vdout1_34ck79 = 0 time = 400
.meas tran vdout1_34ck79 FIND v(dout1_34) AT=400.025n

* CHECK dout1_35 Vdout1_35ck79 = 0 time = 400
.meas tran vdout1_35ck79 FIND v(dout1_35) AT=400.025n

* CHECK dout1_36 Vdout1_36ck79 = 0 time = 400
.meas tran vdout1_36ck79 FIND v(dout1_36) AT=400.025n

* CHECK dout1_37 Vdout1_37ck79 = 0.9 time = 400
.meas tran vdout1_37ck79 FIND v(dout1_37) AT=400.025n

* CHECK dout1_38 Vdout1_38ck79 = 0.9 time = 400
.meas tran vdout1_38ck79 FIND v(dout1_38) AT=400.025n

* CHECK dout1_39 Vdout1_39ck79 = 0.9 time = 400
.meas tran vdout1_39ck79 FIND v(dout1_39) AT=400.025n

* CHECK dout1_40 Vdout1_40ck79 = 0 time = 400
.meas tran vdout1_40ck79 FIND v(dout1_40) AT=400.025n

* CHECK dout1_41 Vdout1_41ck79 = 0.9 time = 400
.meas tran vdout1_41ck79 FIND v(dout1_41) AT=400.025n

* CHECK dout1_42 Vdout1_42ck79 = 0 time = 400
.meas tran vdout1_42ck79 FIND v(dout1_42) AT=400.025n

* CHECK dout1_43 Vdout1_43ck79 = 0.9 time = 400
.meas tran vdout1_43ck79 FIND v(dout1_43) AT=400.025n

* CHECK dout1_44 Vdout1_44ck79 = 0 time = 400
.meas tran vdout1_44ck79 FIND v(dout1_44) AT=400.025n

* CHECK dout1_45 Vdout1_45ck79 = 0 time = 400
.meas tran vdout1_45ck79 FIND v(dout1_45) AT=400.025n

* CHECK dout1_46 Vdout1_46ck79 = 0 time = 400
.meas tran vdout1_46ck79 FIND v(dout1_46) AT=400.025n

* CHECK dout1_47 Vdout1_47ck79 = 0.9 time = 400
.meas tran vdout1_47ck79 FIND v(dout1_47) AT=400.025n

* CHECK dout1_48 Vdout1_48ck79 = 0.9 time = 400
.meas tran vdout1_48ck79 FIND v(dout1_48) AT=400.025n

* CHECK dout1_49 Vdout1_49ck79 = 0.9 time = 400
.meas tran vdout1_49ck79 FIND v(dout1_49) AT=400.025n

* CHECK dout1_50 Vdout1_50ck79 = 0.9 time = 400
.meas tran vdout1_50ck79 FIND v(dout1_50) AT=400.025n

* CHECK dout1_51 Vdout1_51ck79 = 0 time = 400
.meas tran vdout1_51ck79 FIND v(dout1_51) AT=400.025n

* CHECK dout1_52 Vdout1_52ck79 = 0 time = 400
.meas tran vdout1_52ck79 FIND v(dout1_52) AT=400.025n

* CHECK dout1_53 Vdout1_53ck79 = 0 time = 400
.meas tran vdout1_53ck79 FIND v(dout1_53) AT=400.025n

* CHECK dout1_54 Vdout1_54ck79 = 0.9 time = 400
.meas tran vdout1_54ck79 FIND v(dout1_54) AT=400.025n

* CHECK dout1_55 Vdout1_55ck79 = 0.9 time = 400
.meas tran vdout1_55ck79 FIND v(dout1_55) AT=400.025n

* CHECK dout1_56 Vdout1_56ck79 = 0.9 time = 400
.meas tran vdout1_56ck79 FIND v(dout1_56) AT=400.025n

* CHECK dout1_57 Vdout1_57ck79 = 0.9 time = 400
.meas tran vdout1_57ck79 FIND v(dout1_57) AT=400.025n

* CHECK dout1_58 Vdout1_58ck79 = 0 time = 400
.meas tran vdout1_58ck79 FIND v(dout1_58) AT=400.025n

* CHECK dout1_59 Vdout1_59ck79 = 0.9 time = 400
.meas tran vdout1_59ck79 FIND v(dout1_59) AT=400.025n

* CHECK dout1_60 Vdout1_60ck79 = 0 time = 400
.meas tran vdout1_60ck79 FIND v(dout1_60) AT=400.025n

* CHECK dout1_61 Vdout1_61ck79 = 0.9 time = 400
.meas tran vdout1_61ck79 FIND v(dout1_61) AT=400.025n

* CHECK dout1_62 Vdout1_62ck79 = 0 time = 400
.meas tran vdout1_62ck79 FIND v(dout1_62) AT=400.025n

* CHECK dout1_63 Vdout1_63ck79 = 0 time = 400
.meas tran vdout1_63ck79 FIND v(dout1_63) AT=400.025n

* CHECK dout1_64 Vdout1_64ck79 = 0 time = 400
.meas tran vdout1_64ck79 FIND v(dout1_64) AT=400.025n

* CHECK dout1_65 Vdout1_65ck79 = 0 time = 400
.meas tran vdout1_65ck79 FIND v(dout1_65) AT=400.025n

* CHECK dout1_66 Vdout1_66ck79 = 0 time = 400
.meas tran vdout1_66ck79 FIND v(dout1_66) AT=400.025n

* CHECK dout1_67 Vdout1_67ck79 = 0 time = 400
.meas tran vdout1_67ck79 FIND v(dout1_67) AT=400.025n

* CHECK dout1_68 Vdout1_68ck79 = 0.9 time = 400
.meas tran vdout1_68ck79 FIND v(dout1_68) AT=400.025n

* CHECK dout1_69 Vdout1_69ck79 = 0 time = 400
.meas tran vdout1_69ck79 FIND v(dout1_69) AT=400.025n

* CHECK dout1_70 Vdout1_70ck79 = 0.9 time = 400
.meas tran vdout1_70ck79 FIND v(dout1_70) AT=400.025n

* CHECK dout1_71 Vdout1_71ck79 = 0 time = 400
.meas tran vdout1_71ck79 FIND v(dout1_71) AT=400.025n

* CHECK dout1_72 Vdout1_72ck79 = 0 time = 400
.meas tran vdout1_72ck79 FIND v(dout1_72) AT=400.025n

* CHECK dout1_73 Vdout1_73ck79 = 0.9 time = 400
.meas tran vdout1_73ck79 FIND v(dout1_73) AT=400.025n

* CHECK dout1_74 Vdout1_74ck79 = 0 time = 400
.meas tran vdout1_74ck79 FIND v(dout1_74) AT=400.025n

* CHECK dout1_75 Vdout1_75ck79 = 0.9 time = 400
.meas tran vdout1_75ck79 FIND v(dout1_75) AT=400.025n

* CHECK dout1_76 Vdout1_76ck79 = 0 time = 400
.meas tran vdout1_76ck79 FIND v(dout1_76) AT=400.025n

* CHECK dout1_77 Vdout1_77ck79 = 0.9 time = 400
.meas tran vdout1_77ck79 FIND v(dout1_77) AT=400.025n

* CHECK dout1_78 Vdout1_78ck79 = 0 time = 400
.meas tran vdout1_78ck79 FIND v(dout1_78) AT=400.025n

* CHECK dout1_79 Vdout1_79ck79 = 0 time = 400
.meas tran vdout1_79ck79 FIND v(dout1_79) AT=400.025n

* CHECK dout1_80 Vdout1_80ck79 = 0 time = 400
.meas tran vdout1_80ck79 FIND v(dout1_80) AT=400.025n

* CHECK dout1_81 Vdout1_81ck79 = 0 time = 400
.meas tran vdout1_81ck79 FIND v(dout1_81) AT=400.025n

* CHECK dout1_82 Vdout1_82ck79 = 0 time = 400
.meas tran vdout1_82ck79 FIND v(dout1_82) AT=400.025n

* CHECK dout1_83 Vdout1_83ck79 = 0.9 time = 400
.meas tran vdout1_83ck79 FIND v(dout1_83) AT=400.025n

* CHECK dout1_84 Vdout1_84ck79 = 0 time = 400
.meas tran vdout1_84ck79 FIND v(dout1_84) AT=400.025n

* CHECK dout1_85 Vdout1_85ck79 = 0.9 time = 400
.meas tran vdout1_85ck79 FIND v(dout1_85) AT=400.025n

* CHECK dout1_86 Vdout1_86ck79 = 0 time = 400
.meas tran vdout1_86ck79 FIND v(dout1_86) AT=400.025n

* CHECK dout1_87 Vdout1_87ck79 = 0.9 time = 400
.meas tran vdout1_87ck79 FIND v(dout1_87) AT=400.025n

* CHECK dout1_88 Vdout1_88ck79 = 0.9 time = 400
.meas tran vdout1_88ck79 FIND v(dout1_88) AT=400.025n

* CHECK dout1_89 Vdout1_89ck79 = 0 time = 400
.meas tran vdout1_89ck79 FIND v(dout1_89) AT=400.025n

* CHECK dout1_90 Vdout1_90ck79 = 0 time = 400
.meas tran vdout1_90ck79 FIND v(dout1_90) AT=400.025n

* CHECK dout1_91 Vdout1_91ck79 = 0 time = 400
.meas tran vdout1_91ck79 FIND v(dout1_91) AT=400.025n

* CHECK dout1_92 Vdout1_92ck79 = 0 time = 400
.meas tran vdout1_92ck79 FIND v(dout1_92) AT=400.025n

* CHECK dout1_93 Vdout1_93ck79 = 0 time = 400
.meas tran vdout1_93ck79 FIND v(dout1_93) AT=400.025n

* CHECK dout1_94 Vdout1_94ck79 = 0 time = 400
.meas tran vdout1_94ck79 FIND v(dout1_94) AT=400.025n

* CHECK dout1_95 Vdout1_95ck79 = 0 time = 400
.meas tran vdout1_95ck79 FIND v(dout1_95) AT=400.025n

* CHECK dout1_0 Vdout1_0ck81 = 0.9 time = 410
.meas tran vdout1_0ck81 FIND v(dout1_0) AT=410.025n

* CHECK dout1_1 Vdout1_1ck81 = 0 time = 410
.meas tran vdout1_1ck81 FIND v(dout1_1) AT=410.025n

* CHECK dout1_2 Vdout1_2ck81 = 0.9 time = 410
.meas tran vdout1_2ck81 FIND v(dout1_2) AT=410.025n

* CHECK dout1_3 Vdout1_3ck81 = 0.9 time = 410
.meas tran vdout1_3ck81 FIND v(dout1_3) AT=410.025n

* CHECK dout1_4 Vdout1_4ck81 = 0.9 time = 410
.meas tran vdout1_4ck81 FIND v(dout1_4) AT=410.025n

* CHECK dout1_5 Vdout1_5ck81 = 0 time = 410
.meas tran vdout1_5ck81 FIND v(dout1_5) AT=410.025n

* CHECK dout1_6 Vdout1_6ck81 = 0.9 time = 410
.meas tran vdout1_6ck81 FIND v(dout1_6) AT=410.025n

* CHECK dout1_7 Vdout1_7ck81 = 0 time = 410
.meas tran vdout1_7ck81 FIND v(dout1_7) AT=410.025n

* CHECK dout1_8 Vdout1_8ck81 = 0.9 time = 410
.meas tran vdout1_8ck81 FIND v(dout1_8) AT=410.025n

* CHECK dout1_9 Vdout1_9ck81 = 0.9 time = 410
.meas tran vdout1_9ck81 FIND v(dout1_9) AT=410.025n

* CHECK dout1_10 Vdout1_10ck81 = 0.9 time = 410
.meas tran vdout1_10ck81 FIND v(dout1_10) AT=410.025n

* CHECK dout1_11 Vdout1_11ck81 = 0 time = 410
.meas tran vdout1_11ck81 FIND v(dout1_11) AT=410.025n

* CHECK dout1_12 Vdout1_12ck81 = 0.9 time = 410
.meas tran vdout1_12ck81 FIND v(dout1_12) AT=410.025n

* CHECK dout1_13 Vdout1_13ck81 = 0 time = 410
.meas tran vdout1_13ck81 FIND v(dout1_13) AT=410.025n

* CHECK dout1_14 Vdout1_14ck81 = 0.9 time = 410
.meas tran vdout1_14ck81 FIND v(dout1_14) AT=410.025n

* CHECK dout1_15 Vdout1_15ck81 = 0.9 time = 410
.meas tran vdout1_15ck81 FIND v(dout1_15) AT=410.025n

* CHECK dout1_16 Vdout1_16ck81 = 0.9 time = 410
.meas tran vdout1_16ck81 FIND v(dout1_16) AT=410.025n

* CHECK dout1_17 Vdout1_17ck81 = 0.9 time = 410
.meas tran vdout1_17ck81 FIND v(dout1_17) AT=410.025n

* CHECK dout1_18 Vdout1_18ck81 = 0.9 time = 410
.meas tran vdout1_18ck81 FIND v(dout1_18) AT=410.025n

* CHECK dout1_19 Vdout1_19ck81 = 0 time = 410
.meas tran vdout1_19ck81 FIND v(dout1_19) AT=410.025n

* CHECK dout1_20 Vdout1_20ck81 = 0 time = 410
.meas tran vdout1_20ck81 FIND v(dout1_20) AT=410.025n

* CHECK dout1_21 Vdout1_21ck81 = 0.9 time = 410
.meas tran vdout1_21ck81 FIND v(dout1_21) AT=410.025n

* CHECK dout1_22 Vdout1_22ck81 = 0 time = 410
.meas tran vdout1_22ck81 FIND v(dout1_22) AT=410.025n

* CHECK dout1_23 Vdout1_23ck81 = 0.9 time = 410
.meas tran vdout1_23ck81 FIND v(dout1_23) AT=410.025n

* CHECK dout1_24 Vdout1_24ck81 = 0.9 time = 410
.meas tran vdout1_24ck81 FIND v(dout1_24) AT=410.025n

* CHECK dout1_25 Vdout1_25ck81 = 0 time = 410
.meas tran vdout1_25ck81 FIND v(dout1_25) AT=410.025n

* CHECK dout1_26 Vdout1_26ck81 = 0.9 time = 410
.meas tran vdout1_26ck81 FIND v(dout1_26) AT=410.025n

* CHECK dout1_27 Vdout1_27ck81 = 0.9 time = 410
.meas tran vdout1_27ck81 FIND v(dout1_27) AT=410.025n

* CHECK dout1_28 Vdout1_28ck81 = 0 time = 410
.meas tran vdout1_28ck81 FIND v(dout1_28) AT=410.025n

* CHECK dout1_29 Vdout1_29ck81 = 0 time = 410
.meas tran vdout1_29ck81 FIND v(dout1_29) AT=410.025n

* CHECK dout1_30 Vdout1_30ck81 = 0 time = 410
.meas tran vdout1_30ck81 FIND v(dout1_30) AT=410.025n

* CHECK dout1_31 Vdout1_31ck81 = 0 time = 410
.meas tran vdout1_31ck81 FIND v(dout1_31) AT=410.025n

* CHECK dout1_32 Vdout1_32ck81 = 0 time = 410
.meas tran vdout1_32ck81 FIND v(dout1_32) AT=410.025n

* CHECK dout1_33 Vdout1_33ck81 = 0.9 time = 410
.meas tran vdout1_33ck81 FIND v(dout1_33) AT=410.025n

* CHECK dout1_34 Vdout1_34ck81 = 0 time = 410
.meas tran vdout1_34ck81 FIND v(dout1_34) AT=410.025n

* CHECK dout1_35 Vdout1_35ck81 = 0.9 time = 410
.meas tran vdout1_35ck81 FIND v(dout1_35) AT=410.025n

* CHECK dout1_36 Vdout1_36ck81 = 0.9 time = 410
.meas tran vdout1_36ck81 FIND v(dout1_36) AT=410.025n

* CHECK dout1_37 Vdout1_37ck81 = 0 time = 410
.meas tran vdout1_37ck81 FIND v(dout1_37) AT=410.025n

* CHECK dout1_38 Vdout1_38ck81 = 0.9 time = 410
.meas tran vdout1_38ck81 FIND v(dout1_38) AT=410.025n

* CHECK dout1_39 Vdout1_39ck81 = 0 time = 410
.meas tran vdout1_39ck81 FIND v(dout1_39) AT=410.025n

* CHECK dout1_40 Vdout1_40ck81 = 0 time = 410
.meas tran vdout1_40ck81 FIND v(dout1_40) AT=410.025n

* CHECK dout1_41 Vdout1_41ck81 = 0 time = 410
.meas tran vdout1_41ck81 FIND v(dout1_41) AT=410.025n

* CHECK dout1_42 Vdout1_42ck81 = 0.9 time = 410
.meas tran vdout1_42ck81 FIND v(dout1_42) AT=410.025n

* CHECK dout1_43 Vdout1_43ck81 = 0 time = 410
.meas tran vdout1_43ck81 FIND v(dout1_43) AT=410.025n

* CHECK dout1_44 Vdout1_44ck81 = 0.9 time = 410
.meas tran vdout1_44ck81 FIND v(dout1_44) AT=410.025n

* CHECK dout1_45 Vdout1_45ck81 = 0 time = 410
.meas tran vdout1_45ck81 FIND v(dout1_45) AT=410.025n

* CHECK dout1_46 Vdout1_46ck81 = 0 time = 410
.meas tran vdout1_46ck81 FIND v(dout1_46) AT=410.025n

* CHECK dout1_47 Vdout1_47ck81 = 0.9 time = 410
.meas tran vdout1_47ck81 FIND v(dout1_47) AT=410.025n

* CHECK dout1_48 Vdout1_48ck81 = 0.9 time = 410
.meas tran vdout1_48ck81 FIND v(dout1_48) AT=410.025n

* CHECK dout1_49 Vdout1_49ck81 = 0 time = 410
.meas tran vdout1_49ck81 FIND v(dout1_49) AT=410.025n

* CHECK dout1_50 Vdout1_50ck81 = 0 time = 410
.meas tran vdout1_50ck81 FIND v(dout1_50) AT=410.025n

* CHECK dout1_51 Vdout1_51ck81 = 0.9 time = 410
.meas tran vdout1_51ck81 FIND v(dout1_51) AT=410.025n

* CHECK dout1_52 Vdout1_52ck81 = 0.9 time = 410
.meas tran vdout1_52ck81 FIND v(dout1_52) AT=410.025n

* CHECK dout1_53 Vdout1_53ck81 = 0 time = 410
.meas tran vdout1_53ck81 FIND v(dout1_53) AT=410.025n

* CHECK dout1_54 Vdout1_54ck81 = 0 time = 410
.meas tran vdout1_54ck81 FIND v(dout1_54) AT=410.025n

* CHECK dout1_55 Vdout1_55ck81 = 0 time = 410
.meas tran vdout1_55ck81 FIND v(dout1_55) AT=410.025n

* CHECK dout1_56 Vdout1_56ck81 = 0.9 time = 410
.meas tran vdout1_56ck81 FIND v(dout1_56) AT=410.025n

* CHECK dout1_57 Vdout1_57ck81 = 0.9 time = 410
.meas tran vdout1_57ck81 FIND v(dout1_57) AT=410.025n

* CHECK dout1_58 Vdout1_58ck81 = 0.9 time = 410
.meas tran vdout1_58ck81 FIND v(dout1_58) AT=410.025n

* CHECK dout1_59 Vdout1_59ck81 = 0.9 time = 410
.meas tran vdout1_59ck81 FIND v(dout1_59) AT=410.025n

* CHECK dout1_60 Vdout1_60ck81 = 0 time = 410
.meas tran vdout1_60ck81 FIND v(dout1_60) AT=410.025n

* CHECK dout1_61 Vdout1_61ck81 = 0.9 time = 410
.meas tran vdout1_61ck81 FIND v(dout1_61) AT=410.025n

* CHECK dout1_62 Vdout1_62ck81 = 0.9 time = 410
.meas tran vdout1_62ck81 FIND v(dout1_62) AT=410.025n

* CHECK dout1_63 Vdout1_63ck81 = 0 time = 410
.meas tran vdout1_63ck81 FIND v(dout1_63) AT=410.025n

* CHECK dout1_64 Vdout1_64ck81 = 0.9 time = 410
.meas tran vdout1_64ck81 FIND v(dout1_64) AT=410.025n

* CHECK dout1_65 Vdout1_65ck81 = 0.9 time = 410
.meas tran vdout1_65ck81 FIND v(dout1_65) AT=410.025n

* CHECK dout1_66 Vdout1_66ck81 = 0 time = 410
.meas tran vdout1_66ck81 FIND v(dout1_66) AT=410.025n

* CHECK dout1_67 Vdout1_67ck81 = 0 time = 410
.meas tran vdout1_67ck81 FIND v(dout1_67) AT=410.025n

* CHECK dout1_68 Vdout1_68ck81 = 0.9 time = 410
.meas tran vdout1_68ck81 FIND v(dout1_68) AT=410.025n

* CHECK dout1_69 Vdout1_69ck81 = 0 time = 410
.meas tran vdout1_69ck81 FIND v(dout1_69) AT=410.025n

* CHECK dout1_70 Vdout1_70ck81 = 0.9 time = 410
.meas tran vdout1_70ck81 FIND v(dout1_70) AT=410.025n

* CHECK dout1_71 Vdout1_71ck81 = 0 time = 410
.meas tran vdout1_71ck81 FIND v(dout1_71) AT=410.025n

* CHECK dout1_72 Vdout1_72ck81 = 0 time = 410
.meas tran vdout1_72ck81 FIND v(dout1_72) AT=410.025n

* CHECK dout1_73 Vdout1_73ck81 = 0 time = 410
.meas tran vdout1_73ck81 FIND v(dout1_73) AT=410.025n

* CHECK dout1_74 Vdout1_74ck81 = 0 time = 410
.meas tran vdout1_74ck81 FIND v(dout1_74) AT=410.025n

* CHECK dout1_75 Vdout1_75ck81 = 0 time = 410
.meas tran vdout1_75ck81 FIND v(dout1_75) AT=410.025n

* CHECK dout1_76 Vdout1_76ck81 = 0 time = 410
.meas tran vdout1_76ck81 FIND v(dout1_76) AT=410.025n

* CHECK dout1_77 Vdout1_77ck81 = 0.9 time = 410
.meas tran vdout1_77ck81 FIND v(dout1_77) AT=410.025n

* CHECK dout1_78 Vdout1_78ck81 = 0 time = 410
.meas tran vdout1_78ck81 FIND v(dout1_78) AT=410.025n

* CHECK dout1_79 Vdout1_79ck81 = 0.9 time = 410
.meas tran vdout1_79ck81 FIND v(dout1_79) AT=410.025n

* CHECK dout1_80 Vdout1_80ck81 = 0 time = 410
.meas tran vdout1_80ck81 FIND v(dout1_80) AT=410.025n

* CHECK dout1_81 Vdout1_81ck81 = 0 time = 410
.meas tran vdout1_81ck81 FIND v(dout1_81) AT=410.025n

* CHECK dout1_82 Vdout1_82ck81 = 0.9 time = 410
.meas tran vdout1_82ck81 FIND v(dout1_82) AT=410.025n

* CHECK dout1_83 Vdout1_83ck81 = 0 time = 410
.meas tran vdout1_83ck81 FIND v(dout1_83) AT=410.025n

* CHECK dout1_84 Vdout1_84ck81 = 0 time = 410
.meas tran vdout1_84ck81 FIND v(dout1_84) AT=410.025n

* CHECK dout1_85 Vdout1_85ck81 = 0.9 time = 410
.meas tran vdout1_85ck81 FIND v(dout1_85) AT=410.025n

* CHECK dout1_86 Vdout1_86ck81 = 0.9 time = 410
.meas tran vdout1_86ck81 FIND v(dout1_86) AT=410.025n

* CHECK dout1_87 Vdout1_87ck81 = 0 time = 410
.meas tran vdout1_87ck81 FIND v(dout1_87) AT=410.025n

* CHECK dout1_88 Vdout1_88ck81 = 0.9 time = 410
.meas tran vdout1_88ck81 FIND v(dout1_88) AT=410.025n

* CHECK dout1_89 Vdout1_89ck81 = 0.9 time = 410
.meas tran vdout1_89ck81 FIND v(dout1_89) AT=410.025n

* CHECK dout1_90 Vdout1_90ck81 = 0.9 time = 410
.meas tran vdout1_90ck81 FIND v(dout1_90) AT=410.025n

* CHECK dout1_91 Vdout1_91ck81 = 0.9 time = 410
.meas tran vdout1_91ck81 FIND v(dout1_91) AT=410.025n

* CHECK dout1_92 Vdout1_92ck81 = 0.9 time = 410
.meas tran vdout1_92ck81 FIND v(dout1_92) AT=410.025n

* CHECK dout1_93 Vdout1_93ck81 = 0.9 time = 410
.meas tran vdout1_93ck81 FIND v(dout1_93) AT=410.025n

* CHECK dout1_94 Vdout1_94ck81 = 0.9 time = 410
.meas tran vdout1_94ck81 FIND v(dout1_94) AT=410.025n

* CHECK dout1_95 Vdout1_95ck81 = 0 time = 410
.meas tran vdout1_95ck81 FIND v(dout1_95) AT=410.025n

* CHECK dout1_0 Vdout1_0ck84 = 0 time = 425
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=425.025n

* CHECK dout1_1 Vdout1_1ck84 = 0 time = 425
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=425.025n

* CHECK dout1_2 Vdout1_2ck84 = 0.9 time = 425
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=425.025n

* CHECK dout1_3 Vdout1_3ck84 = 0.9 time = 425
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=425.025n

* CHECK dout1_4 Vdout1_4ck84 = 0.9 time = 425
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=425.025n

* CHECK dout1_5 Vdout1_5ck84 = 0.9 time = 425
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=425.025n

* CHECK dout1_6 Vdout1_6ck84 = 0 time = 425
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=425.025n

* CHECK dout1_7 Vdout1_7ck84 = 0 time = 425
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=425.025n

* CHECK dout1_8 Vdout1_8ck84 = 0.9 time = 425
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=425.025n

* CHECK dout1_9 Vdout1_9ck84 = 0 time = 425
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=425.025n

* CHECK dout1_10 Vdout1_10ck84 = 0.9 time = 425
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=425.025n

* CHECK dout1_11 Vdout1_11ck84 = 0 time = 425
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=425.025n

* CHECK dout1_12 Vdout1_12ck84 = 0 time = 425
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=425.025n

* CHECK dout1_13 Vdout1_13ck84 = 0 time = 425
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=425.025n

* CHECK dout1_14 Vdout1_14ck84 = 0.9 time = 425
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=425.025n

* CHECK dout1_15 Vdout1_15ck84 = 0.9 time = 425
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=425.025n

* CHECK dout1_16 Vdout1_16ck84 = 0.9 time = 425
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=425.025n

* CHECK dout1_17 Vdout1_17ck84 = 0.9 time = 425
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=425.025n

* CHECK dout1_18 Vdout1_18ck84 = 0.9 time = 425
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=425.025n

* CHECK dout1_19 Vdout1_19ck84 = 0.9 time = 425
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=425.025n

* CHECK dout1_20 Vdout1_20ck84 = 0 time = 425
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=425.025n

* CHECK dout1_21 Vdout1_21ck84 = 0 time = 425
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=425.025n

* CHECK dout1_22 Vdout1_22ck84 = 0.9 time = 425
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=425.025n

* CHECK dout1_23 Vdout1_23ck84 = 0.9 time = 425
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=425.025n

* CHECK dout1_24 Vdout1_24ck84 = 0 time = 425
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=425.025n

* CHECK dout1_25 Vdout1_25ck84 = 0 time = 425
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=425.025n

* CHECK dout1_26 Vdout1_26ck84 = 0 time = 425
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=425.025n

* CHECK dout1_27 Vdout1_27ck84 = 0 time = 425
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=425.025n

* CHECK dout1_28 Vdout1_28ck84 = 0.9 time = 425
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=425.025n

* CHECK dout1_29 Vdout1_29ck84 = 0.9 time = 425
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=425.025n

* CHECK dout1_30 Vdout1_30ck84 = 0.9 time = 425
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=425.025n

* CHECK dout1_31 Vdout1_31ck84 = 0 time = 425
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=425.025n

* CHECK dout1_32 Vdout1_32ck84 = 0.9 time = 425
.meas tran vdout1_32ck84 FIND v(dout1_32) AT=425.025n

* CHECK dout1_33 Vdout1_33ck84 = 0 time = 425
.meas tran vdout1_33ck84 FIND v(dout1_33) AT=425.025n

* CHECK dout1_34 Vdout1_34ck84 = 0.9 time = 425
.meas tran vdout1_34ck84 FIND v(dout1_34) AT=425.025n

* CHECK dout1_35 Vdout1_35ck84 = 0 time = 425
.meas tran vdout1_35ck84 FIND v(dout1_35) AT=425.025n

* CHECK dout1_36 Vdout1_36ck84 = 0 time = 425
.meas tran vdout1_36ck84 FIND v(dout1_36) AT=425.025n

* CHECK dout1_37 Vdout1_37ck84 = 0.9 time = 425
.meas tran vdout1_37ck84 FIND v(dout1_37) AT=425.025n

* CHECK dout1_38 Vdout1_38ck84 = 0 time = 425
.meas tran vdout1_38ck84 FIND v(dout1_38) AT=425.025n

* CHECK dout1_39 Vdout1_39ck84 = 0.9 time = 425
.meas tran vdout1_39ck84 FIND v(dout1_39) AT=425.025n

* CHECK dout1_40 Vdout1_40ck84 = 0 time = 425
.meas tran vdout1_40ck84 FIND v(dout1_40) AT=425.025n

* CHECK dout1_41 Vdout1_41ck84 = 0 time = 425
.meas tran vdout1_41ck84 FIND v(dout1_41) AT=425.025n

* CHECK dout1_42 Vdout1_42ck84 = 0.9 time = 425
.meas tran vdout1_42ck84 FIND v(dout1_42) AT=425.025n

* CHECK dout1_43 Vdout1_43ck84 = 0 time = 425
.meas tran vdout1_43ck84 FIND v(dout1_43) AT=425.025n

* CHECK dout1_44 Vdout1_44ck84 = 0.9 time = 425
.meas tran vdout1_44ck84 FIND v(dout1_44) AT=425.025n

* CHECK dout1_45 Vdout1_45ck84 = 0.9 time = 425
.meas tran vdout1_45ck84 FIND v(dout1_45) AT=425.025n

* CHECK dout1_46 Vdout1_46ck84 = 0.9 time = 425
.meas tran vdout1_46ck84 FIND v(dout1_46) AT=425.025n

* CHECK dout1_47 Vdout1_47ck84 = 0 time = 425
.meas tran vdout1_47ck84 FIND v(dout1_47) AT=425.025n

* CHECK dout1_48 Vdout1_48ck84 = 0 time = 425
.meas tran vdout1_48ck84 FIND v(dout1_48) AT=425.025n

* CHECK dout1_49 Vdout1_49ck84 = 0.9 time = 425
.meas tran vdout1_49ck84 FIND v(dout1_49) AT=425.025n

* CHECK dout1_50 Vdout1_50ck84 = 0.9 time = 425
.meas tran vdout1_50ck84 FIND v(dout1_50) AT=425.025n

* CHECK dout1_51 Vdout1_51ck84 = 0.9 time = 425
.meas tran vdout1_51ck84 FIND v(dout1_51) AT=425.025n

* CHECK dout1_52 Vdout1_52ck84 = 0.9 time = 425
.meas tran vdout1_52ck84 FIND v(dout1_52) AT=425.025n

* CHECK dout1_53 Vdout1_53ck84 = 0 time = 425
.meas tran vdout1_53ck84 FIND v(dout1_53) AT=425.025n

* CHECK dout1_54 Vdout1_54ck84 = 0 time = 425
.meas tran vdout1_54ck84 FIND v(dout1_54) AT=425.025n

* CHECK dout1_55 Vdout1_55ck84 = 0.9 time = 425
.meas tran vdout1_55ck84 FIND v(dout1_55) AT=425.025n

* CHECK dout1_56 Vdout1_56ck84 = 0.9 time = 425
.meas tran vdout1_56ck84 FIND v(dout1_56) AT=425.025n

* CHECK dout1_57 Vdout1_57ck84 = 0 time = 425
.meas tran vdout1_57ck84 FIND v(dout1_57) AT=425.025n

* CHECK dout1_58 Vdout1_58ck84 = 0.9 time = 425
.meas tran vdout1_58ck84 FIND v(dout1_58) AT=425.025n

* CHECK dout1_59 Vdout1_59ck84 = 0.9 time = 425
.meas tran vdout1_59ck84 FIND v(dout1_59) AT=425.025n

* CHECK dout1_60 Vdout1_60ck84 = 0.9 time = 425
.meas tran vdout1_60ck84 FIND v(dout1_60) AT=425.025n

* CHECK dout1_61 Vdout1_61ck84 = 0.9 time = 425
.meas tran vdout1_61ck84 FIND v(dout1_61) AT=425.025n

* CHECK dout1_62 Vdout1_62ck84 = 0.9 time = 425
.meas tran vdout1_62ck84 FIND v(dout1_62) AT=425.025n

* CHECK dout1_63 Vdout1_63ck84 = 0.9 time = 425
.meas tran vdout1_63ck84 FIND v(dout1_63) AT=425.025n

* CHECK dout1_64 Vdout1_64ck84 = 0 time = 425
.meas tran vdout1_64ck84 FIND v(dout1_64) AT=425.025n

* CHECK dout1_65 Vdout1_65ck84 = 0 time = 425
.meas tran vdout1_65ck84 FIND v(dout1_65) AT=425.025n

* CHECK dout1_66 Vdout1_66ck84 = 0.9 time = 425
.meas tran vdout1_66ck84 FIND v(dout1_66) AT=425.025n

* CHECK dout1_67 Vdout1_67ck84 = 0 time = 425
.meas tran vdout1_67ck84 FIND v(dout1_67) AT=425.025n

* CHECK dout1_68 Vdout1_68ck84 = 0 time = 425
.meas tran vdout1_68ck84 FIND v(dout1_68) AT=425.025n

* CHECK dout1_69 Vdout1_69ck84 = 0.9 time = 425
.meas tran vdout1_69ck84 FIND v(dout1_69) AT=425.025n

* CHECK dout1_70 Vdout1_70ck84 = 0.9 time = 425
.meas tran vdout1_70ck84 FIND v(dout1_70) AT=425.025n

* CHECK dout1_71 Vdout1_71ck84 = 0 time = 425
.meas tran vdout1_71ck84 FIND v(dout1_71) AT=425.025n

* CHECK dout1_72 Vdout1_72ck84 = 0 time = 425
.meas tran vdout1_72ck84 FIND v(dout1_72) AT=425.025n

* CHECK dout1_73 Vdout1_73ck84 = 0.9 time = 425
.meas tran vdout1_73ck84 FIND v(dout1_73) AT=425.025n

* CHECK dout1_74 Vdout1_74ck84 = 0 time = 425
.meas tran vdout1_74ck84 FIND v(dout1_74) AT=425.025n

* CHECK dout1_75 Vdout1_75ck84 = 0.9 time = 425
.meas tran vdout1_75ck84 FIND v(dout1_75) AT=425.025n

* CHECK dout1_76 Vdout1_76ck84 = 0.9 time = 425
.meas tran vdout1_76ck84 FIND v(dout1_76) AT=425.025n

* CHECK dout1_77 Vdout1_77ck84 = 0 time = 425
.meas tran vdout1_77ck84 FIND v(dout1_77) AT=425.025n

* CHECK dout1_78 Vdout1_78ck84 = 0.9 time = 425
.meas tran vdout1_78ck84 FIND v(dout1_78) AT=425.025n

* CHECK dout1_79 Vdout1_79ck84 = 0.9 time = 425
.meas tran vdout1_79ck84 FIND v(dout1_79) AT=425.025n

* CHECK dout1_80 Vdout1_80ck84 = 0 time = 425
.meas tran vdout1_80ck84 FIND v(dout1_80) AT=425.025n

* CHECK dout1_81 Vdout1_81ck84 = 0.9 time = 425
.meas tran vdout1_81ck84 FIND v(dout1_81) AT=425.025n

* CHECK dout1_82 Vdout1_82ck84 = 0 time = 425
.meas tran vdout1_82ck84 FIND v(dout1_82) AT=425.025n

* CHECK dout1_83 Vdout1_83ck84 = 0 time = 425
.meas tran vdout1_83ck84 FIND v(dout1_83) AT=425.025n

* CHECK dout1_84 Vdout1_84ck84 = 0.9 time = 425
.meas tran vdout1_84ck84 FIND v(dout1_84) AT=425.025n

* CHECK dout1_85 Vdout1_85ck84 = 0.9 time = 425
.meas tran vdout1_85ck84 FIND v(dout1_85) AT=425.025n

* CHECK dout1_86 Vdout1_86ck84 = 0.9 time = 425
.meas tran vdout1_86ck84 FIND v(dout1_86) AT=425.025n

* CHECK dout1_87 Vdout1_87ck84 = 0.9 time = 425
.meas tran vdout1_87ck84 FIND v(dout1_87) AT=425.025n

* CHECK dout1_88 Vdout1_88ck84 = 0.9 time = 425
.meas tran vdout1_88ck84 FIND v(dout1_88) AT=425.025n

* CHECK dout1_89 Vdout1_89ck84 = 0 time = 425
.meas tran vdout1_89ck84 FIND v(dout1_89) AT=425.025n

* CHECK dout1_90 Vdout1_90ck84 = 0 time = 425
.meas tran vdout1_90ck84 FIND v(dout1_90) AT=425.025n

* CHECK dout1_91 Vdout1_91ck84 = 0.9 time = 425
.meas tran vdout1_91ck84 FIND v(dout1_91) AT=425.025n

* CHECK dout1_92 Vdout1_92ck84 = 0.9 time = 425
.meas tran vdout1_92ck84 FIND v(dout1_92) AT=425.025n

* CHECK dout1_93 Vdout1_93ck84 = 0 time = 425
.meas tran vdout1_93ck84 FIND v(dout1_93) AT=425.025n

* CHECK dout1_94 Vdout1_94ck84 = 0 time = 425
.meas tran vdout1_94ck84 FIND v(dout1_94) AT=425.025n

* CHECK dout1_95 Vdout1_95ck84 = 0.9 time = 425
.meas tran vdout1_95ck84 FIND v(dout1_95) AT=425.025n

* CHECK dout1_0 Vdout1_0ck85 = 0.9 time = 430
.meas tran vdout1_0ck85 FIND v(dout1_0) AT=430.025n

* CHECK dout1_1 Vdout1_1ck85 = 0 time = 430
.meas tran vdout1_1ck85 FIND v(dout1_1) AT=430.025n

* CHECK dout1_2 Vdout1_2ck85 = 0.9 time = 430
.meas tran vdout1_2ck85 FIND v(dout1_2) AT=430.025n

* CHECK dout1_3 Vdout1_3ck85 = 0.9 time = 430
.meas tran vdout1_3ck85 FIND v(dout1_3) AT=430.025n

* CHECK dout1_4 Vdout1_4ck85 = 0.9 time = 430
.meas tran vdout1_4ck85 FIND v(dout1_4) AT=430.025n

* CHECK dout1_5 Vdout1_5ck85 = 0 time = 430
.meas tran vdout1_5ck85 FIND v(dout1_5) AT=430.025n

* CHECK dout1_6 Vdout1_6ck85 = 0.9 time = 430
.meas tran vdout1_6ck85 FIND v(dout1_6) AT=430.025n

* CHECK dout1_7 Vdout1_7ck85 = 0 time = 430
.meas tran vdout1_7ck85 FIND v(dout1_7) AT=430.025n

* CHECK dout1_8 Vdout1_8ck85 = 0.9 time = 430
.meas tran vdout1_8ck85 FIND v(dout1_8) AT=430.025n

* CHECK dout1_9 Vdout1_9ck85 = 0.9 time = 430
.meas tran vdout1_9ck85 FIND v(dout1_9) AT=430.025n

* CHECK dout1_10 Vdout1_10ck85 = 0.9 time = 430
.meas tran vdout1_10ck85 FIND v(dout1_10) AT=430.025n

* CHECK dout1_11 Vdout1_11ck85 = 0 time = 430
.meas tran vdout1_11ck85 FIND v(dout1_11) AT=430.025n

* CHECK dout1_12 Vdout1_12ck85 = 0.9 time = 430
.meas tran vdout1_12ck85 FIND v(dout1_12) AT=430.025n

* CHECK dout1_13 Vdout1_13ck85 = 0 time = 430
.meas tran vdout1_13ck85 FIND v(dout1_13) AT=430.025n

* CHECK dout1_14 Vdout1_14ck85 = 0.9 time = 430
.meas tran vdout1_14ck85 FIND v(dout1_14) AT=430.025n

* CHECK dout1_15 Vdout1_15ck85 = 0.9 time = 430
.meas tran vdout1_15ck85 FIND v(dout1_15) AT=430.025n

* CHECK dout1_16 Vdout1_16ck85 = 0.9 time = 430
.meas tran vdout1_16ck85 FIND v(dout1_16) AT=430.025n

* CHECK dout1_17 Vdout1_17ck85 = 0.9 time = 430
.meas tran vdout1_17ck85 FIND v(dout1_17) AT=430.025n

* CHECK dout1_18 Vdout1_18ck85 = 0.9 time = 430
.meas tran vdout1_18ck85 FIND v(dout1_18) AT=430.025n

* CHECK dout1_19 Vdout1_19ck85 = 0 time = 430
.meas tran vdout1_19ck85 FIND v(dout1_19) AT=430.025n

* CHECK dout1_20 Vdout1_20ck85 = 0 time = 430
.meas tran vdout1_20ck85 FIND v(dout1_20) AT=430.025n

* CHECK dout1_21 Vdout1_21ck85 = 0.9 time = 430
.meas tran vdout1_21ck85 FIND v(dout1_21) AT=430.025n

* CHECK dout1_22 Vdout1_22ck85 = 0 time = 430
.meas tran vdout1_22ck85 FIND v(dout1_22) AT=430.025n

* CHECK dout1_23 Vdout1_23ck85 = 0.9 time = 430
.meas tran vdout1_23ck85 FIND v(dout1_23) AT=430.025n

* CHECK dout1_24 Vdout1_24ck85 = 0.9 time = 430
.meas tran vdout1_24ck85 FIND v(dout1_24) AT=430.025n

* CHECK dout1_25 Vdout1_25ck85 = 0 time = 430
.meas tran vdout1_25ck85 FIND v(dout1_25) AT=430.025n

* CHECK dout1_26 Vdout1_26ck85 = 0.9 time = 430
.meas tran vdout1_26ck85 FIND v(dout1_26) AT=430.025n

* CHECK dout1_27 Vdout1_27ck85 = 0.9 time = 430
.meas tran vdout1_27ck85 FIND v(dout1_27) AT=430.025n

* CHECK dout1_28 Vdout1_28ck85 = 0 time = 430
.meas tran vdout1_28ck85 FIND v(dout1_28) AT=430.025n

* CHECK dout1_29 Vdout1_29ck85 = 0 time = 430
.meas tran vdout1_29ck85 FIND v(dout1_29) AT=430.025n

* CHECK dout1_30 Vdout1_30ck85 = 0 time = 430
.meas tran vdout1_30ck85 FIND v(dout1_30) AT=430.025n

* CHECK dout1_31 Vdout1_31ck85 = 0 time = 430
.meas tran vdout1_31ck85 FIND v(dout1_31) AT=430.025n

* CHECK dout1_32 Vdout1_32ck85 = 0 time = 430
.meas tran vdout1_32ck85 FIND v(dout1_32) AT=430.025n

* CHECK dout1_33 Vdout1_33ck85 = 0.9 time = 430
.meas tran vdout1_33ck85 FIND v(dout1_33) AT=430.025n

* CHECK dout1_34 Vdout1_34ck85 = 0 time = 430
.meas tran vdout1_34ck85 FIND v(dout1_34) AT=430.025n

* CHECK dout1_35 Vdout1_35ck85 = 0.9 time = 430
.meas tran vdout1_35ck85 FIND v(dout1_35) AT=430.025n

* CHECK dout1_36 Vdout1_36ck85 = 0.9 time = 430
.meas tran vdout1_36ck85 FIND v(dout1_36) AT=430.025n

* CHECK dout1_37 Vdout1_37ck85 = 0 time = 430
.meas tran vdout1_37ck85 FIND v(dout1_37) AT=430.025n

* CHECK dout1_38 Vdout1_38ck85 = 0.9 time = 430
.meas tran vdout1_38ck85 FIND v(dout1_38) AT=430.025n

* CHECK dout1_39 Vdout1_39ck85 = 0 time = 430
.meas tran vdout1_39ck85 FIND v(dout1_39) AT=430.025n

* CHECK dout1_40 Vdout1_40ck85 = 0 time = 430
.meas tran vdout1_40ck85 FIND v(dout1_40) AT=430.025n

* CHECK dout1_41 Vdout1_41ck85 = 0 time = 430
.meas tran vdout1_41ck85 FIND v(dout1_41) AT=430.025n

* CHECK dout1_42 Vdout1_42ck85 = 0.9 time = 430
.meas tran vdout1_42ck85 FIND v(dout1_42) AT=430.025n

* CHECK dout1_43 Vdout1_43ck85 = 0 time = 430
.meas tran vdout1_43ck85 FIND v(dout1_43) AT=430.025n

* CHECK dout1_44 Vdout1_44ck85 = 0.9 time = 430
.meas tran vdout1_44ck85 FIND v(dout1_44) AT=430.025n

* CHECK dout1_45 Vdout1_45ck85 = 0 time = 430
.meas tran vdout1_45ck85 FIND v(dout1_45) AT=430.025n

* CHECK dout1_46 Vdout1_46ck85 = 0 time = 430
.meas tran vdout1_46ck85 FIND v(dout1_46) AT=430.025n

* CHECK dout1_47 Vdout1_47ck85 = 0.9 time = 430
.meas tran vdout1_47ck85 FIND v(dout1_47) AT=430.025n

* CHECK dout1_48 Vdout1_48ck85 = 0.9 time = 430
.meas tran vdout1_48ck85 FIND v(dout1_48) AT=430.025n

* CHECK dout1_49 Vdout1_49ck85 = 0 time = 430
.meas tran vdout1_49ck85 FIND v(dout1_49) AT=430.025n

* CHECK dout1_50 Vdout1_50ck85 = 0 time = 430
.meas tran vdout1_50ck85 FIND v(dout1_50) AT=430.025n

* CHECK dout1_51 Vdout1_51ck85 = 0.9 time = 430
.meas tran vdout1_51ck85 FIND v(dout1_51) AT=430.025n

* CHECK dout1_52 Vdout1_52ck85 = 0.9 time = 430
.meas tran vdout1_52ck85 FIND v(dout1_52) AT=430.025n

* CHECK dout1_53 Vdout1_53ck85 = 0 time = 430
.meas tran vdout1_53ck85 FIND v(dout1_53) AT=430.025n

* CHECK dout1_54 Vdout1_54ck85 = 0 time = 430
.meas tran vdout1_54ck85 FIND v(dout1_54) AT=430.025n

* CHECK dout1_55 Vdout1_55ck85 = 0 time = 430
.meas tran vdout1_55ck85 FIND v(dout1_55) AT=430.025n

* CHECK dout1_56 Vdout1_56ck85 = 0.9 time = 430
.meas tran vdout1_56ck85 FIND v(dout1_56) AT=430.025n

* CHECK dout1_57 Vdout1_57ck85 = 0.9 time = 430
.meas tran vdout1_57ck85 FIND v(dout1_57) AT=430.025n

* CHECK dout1_58 Vdout1_58ck85 = 0.9 time = 430
.meas tran vdout1_58ck85 FIND v(dout1_58) AT=430.025n

* CHECK dout1_59 Vdout1_59ck85 = 0.9 time = 430
.meas tran vdout1_59ck85 FIND v(dout1_59) AT=430.025n

* CHECK dout1_60 Vdout1_60ck85 = 0 time = 430
.meas tran vdout1_60ck85 FIND v(dout1_60) AT=430.025n

* CHECK dout1_61 Vdout1_61ck85 = 0.9 time = 430
.meas tran vdout1_61ck85 FIND v(dout1_61) AT=430.025n

* CHECK dout1_62 Vdout1_62ck85 = 0.9 time = 430
.meas tran vdout1_62ck85 FIND v(dout1_62) AT=430.025n

* CHECK dout1_63 Vdout1_63ck85 = 0 time = 430
.meas tran vdout1_63ck85 FIND v(dout1_63) AT=430.025n

* CHECK dout1_64 Vdout1_64ck85 = 0.9 time = 430
.meas tran vdout1_64ck85 FIND v(dout1_64) AT=430.025n

* CHECK dout1_65 Vdout1_65ck85 = 0.9 time = 430
.meas tran vdout1_65ck85 FIND v(dout1_65) AT=430.025n

* CHECK dout1_66 Vdout1_66ck85 = 0 time = 430
.meas tran vdout1_66ck85 FIND v(dout1_66) AT=430.025n

* CHECK dout1_67 Vdout1_67ck85 = 0 time = 430
.meas tran vdout1_67ck85 FIND v(dout1_67) AT=430.025n

* CHECK dout1_68 Vdout1_68ck85 = 0.9 time = 430
.meas tran vdout1_68ck85 FIND v(dout1_68) AT=430.025n

* CHECK dout1_69 Vdout1_69ck85 = 0 time = 430
.meas tran vdout1_69ck85 FIND v(dout1_69) AT=430.025n

* CHECK dout1_70 Vdout1_70ck85 = 0.9 time = 430
.meas tran vdout1_70ck85 FIND v(dout1_70) AT=430.025n

* CHECK dout1_71 Vdout1_71ck85 = 0 time = 430
.meas tran vdout1_71ck85 FIND v(dout1_71) AT=430.025n

* CHECK dout1_72 Vdout1_72ck85 = 0 time = 430
.meas tran vdout1_72ck85 FIND v(dout1_72) AT=430.025n

* CHECK dout1_73 Vdout1_73ck85 = 0 time = 430
.meas tran vdout1_73ck85 FIND v(dout1_73) AT=430.025n

* CHECK dout1_74 Vdout1_74ck85 = 0 time = 430
.meas tran vdout1_74ck85 FIND v(dout1_74) AT=430.025n

* CHECK dout1_75 Vdout1_75ck85 = 0 time = 430
.meas tran vdout1_75ck85 FIND v(dout1_75) AT=430.025n

* CHECK dout1_76 Vdout1_76ck85 = 0 time = 430
.meas tran vdout1_76ck85 FIND v(dout1_76) AT=430.025n

* CHECK dout1_77 Vdout1_77ck85 = 0.9 time = 430
.meas tran vdout1_77ck85 FIND v(dout1_77) AT=430.025n

* CHECK dout1_78 Vdout1_78ck85 = 0 time = 430
.meas tran vdout1_78ck85 FIND v(dout1_78) AT=430.025n

* CHECK dout1_79 Vdout1_79ck85 = 0.9 time = 430
.meas tran vdout1_79ck85 FIND v(dout1_79) AT=430.025n

* CHECK dout1_80 Vdout1_80ck85 = 0 time = 430
.meas tran vdout1_80ck85 FIND v(dout1_80) AT=430.025n

* CHECK dout1_81 Vdout1_81ck85 = 0 time = 430
.meas tran vdout1_81ck85 FIND v(dout1_81) AT=430.025n

* CHECK dout1_82 Vdout1_82ck85 = 0.9 time = 430
.meas tran vdout1_82ck85 FIND v(dout1_82) AT=430.025n

* CHECK dout1_83 Vdout1_83ck85 = 0 time = 430
.meas tran vdout1_83ck85 FIND v(dout1_83) AT=430.025n

* CHECK dout1_84 Vdout1_84ck85 = 0 time = 430
.meas tran vdout1_84ck85 FIND v(dout1_84) AT=430.025n

* CHECK dout1_85 Vdout1_85ck85 = 0.9 time = 430
.meas tran vdout1_85ck85 FIND v(dout1_85) AT=430.025n

* CHECK dout1_86 Vdout1_86ck85 = 0.9 time = 430
.meas tran vdout1_86ck85 FIND v(dout1_86) AT=430.025n

* CHECK dout1_87 Vdout1_87ck85 = 0 time = 430
.meas tran vdout1_87ck85 FIND v(dout1_87) AT=430.025n

* CHECK dout1_88 Vdout1_88ck85 = 0.9 time = 430
.meas tran vdout1_88ck85 FIND v(dout1_88) AT=430.025n

* CHECK dout1_89 Vdout1_89ck85 = 0.9 time = 430
.meas tran vdout1_89ck85 FIND v(dout1_89) AT=430.025n

* CHECK dout1_90 Vdout1_90ck85 = 0.9 time = 430
.meas tran vdout1_90ck85 FIND v(dout1_90) AT=430.025n

* CHECK dout1_91 Vdout1_91ck85 = 0.9 time = 430
.meas tran vdout1_91ck85 FIND v(dout1_91) AT=430.025n

* CHECK dout1_92 Vdout1_92ck85 = 0.9 time = 430
.meas tran vdout1_92ck85 FIND v(dout1_92) AT=430.025n

* CHECK dout1_93 Vdout1_93ck85 = 0.9 time = 430
.meas tran vdout1_93ck85 FIND v(dout1_93) AT=430.025n

* CHECK dout1_94 Vdout1_94ck85 = 0.9 time = 430
.meas tran vdout1_94ck85 FIND v(dout1_94) AT=430.025n

* CHECK dout1_95 Vdout1_95ck85 = 0 time = 430
.meas tran vdout1_95ck85 FIND v(dout1_95) AT=430.025n

* CHECK dout1_0 Vdout1_0ck86 = 0 time = 435
.meas tran vdout1_0ck86 FIND v(dout1_0) AT=435.025n

* CHECK dout1_1 Vdout1_1ck86 = 0 time = 435
.meas tran vdout1_1ck86 FIND v(dout1_1) AT=435.025n

* CHECK dout1_2 Vdout1_2ck86 = 0.9 time = 435
.meas tran vdout1_2ck86 FIND v(dout1_2) AT=435.025n

* CHECK dout1_3 Vdout1_3ck86 = 0.9 time = 435
.meas tran vdout1_3ck86 FIND v(dout1_3) AT=435.025n

* CHECK dout1_4 Vdout1_4ck86 = 0.9 time = 435
.meas tran vdout1_4ck86 FIND v(dout1_4) AT=435.025n

* CHECK dout1_5 Vdout1_5ck86 = 0.9 time = 435
.meas tran vdout1_5ck86 FIND v(dout1_5) AT=435.025n

* CHECK dout1_6 Vdout1_6ck86 = 0 time = 435
.meas tran vdout1_6ck86 FIND v(dout1_6) AT=435.025n

* CHECK dout1_7 Vdout1_7ck86 = 0 time = 435
.meas tran vdout1_7ck86 FIND v(dout1_7) AT=435.025n

* CHECK dout1_8 Vdout1_8ck86 = 0.9 time = 435
.meas tran vdout1_8ck86 FIND v(dout1_8) AT=435.025n

* CHECK dout1_9 Vdout1_9ck86 = 0 time = 435
.meas tran vdout1_9ck86 FIND v(dout1_9) AT=435.025n

* CHECK dout1_10 Vdout1_10ck86 = 0.9 time = 435
.meas tran vdout1_10ck86 FIND v(dout1_10) AT=435.025n

* CHECK dout1_11 Vdout1_11ck86 = 0 time = 435
.meas tran vdout1_11ck86 FIND v(dout1_11) AT=435.025n

* CHECK dout1_12 Vdout1_12ck86 = 0 time = 435
.meas tran vdout1_12ck86 FIND v(dout1_12) AT=435.025n

* CHECK dout1_13 Vdout1_13ck86 = 0 time = 435
.meas tran vdout1_13ck86 FIND v(dout1_13) AT=435.025n

* CHECK dout1_14 Vdout1_14ck86 = 0.9 time = 435
.meas tran vdout1_14ck86 FIND v(dout1_14) AT=435.025n

* CHECK dout1_15 Vdout1_15ck86 = 0.9 time = 435
.meas tran vdout1_15ck86 FIND v(dout1_15) AT=435.025n

* CHECK dout1_16 Vdout1_16ck86 = 0.9 time = 435
.meas tran vdout1_16ck86 FIND v(dout1_16) AT=435.025n

* CHECK dout1_17 Vdout1_17ck86 = 0.9 time = 435
.meas tran vdout1_17ck86 FIND v(dout1_17) AT=435.025n

* CHECK dout1_18 Vdout1_18ck86 = 0.9 time = 435
.meas tran vdout1_18ck86 FIND v(dout1_18) AT=435.025n

* CHECK dout1_19 Vdout1_19ck86 = 0.9 time = 435
.meas tran vdout1_19ck86 FIND v(dout1_19) AT=435.025n

* CHECK dout1_20 Vdout1_20ck86 = 0 time = 435
.meas tran vdout1_20ck86 FIND v(dout1_20) AT=435.025n

* CHECK dout1_21 Vdout1_21ck86 = 0 time = 435
.meas tran vdout1_21ck86 FIND v(dout1_21) AT=435.025n

* CHECK dout1_22 Vdout1_22ck86 = 0.9 time = 435
.meas tran vdout1_22ck86 FIND v(dout1_22) AT=435.025n

* CHECK dout1_23 Vdout1_23ck86 = 0.9 time = 435
.meas tran vdout1_23ck86 FIND v(dout1_23) AT=435.025n

* CHECK dout1_24 Vdout1_24ck86 = 0 time = 435
.meas tran vdout1_24ck86 FIND v(dout1_24) AT=435.025n

* CHECK dout1_25 Vdout1_25ck86 = 0 time = 435
.meas tran vdout1_25ck86 FIND v(dout1_25) AT=435.025n

* CHECK dout1_26 Vdout1_26ck86 = 0 time = 435
.meas tran vdout1_26ck86 FIND v(dout1_26) AT=435.025n

* CHECK dout1_27 Vdout1_27ck86 = 0 time = 435
.meas tran vdout1_27ck86 FIND v(dout1_27) AT=435.025n

* CHECK dout1_28 Vdout1_28ck86 = 0.9 time = 435
.meas tran vdout1_28ck86 FIND v(dout1_28) AT=435.025n

* CHECK dout1_29 Vdout1_29ck86 = 0.9 time = 435
.meas tran vdout1_29ck86 FIND v(dout1_29) AT=435.025n

* CHECK dout1_30 Vdout1_30ck86 = 0.9 time = 435
.meas tran vdout1_30ck86 FIND v(dout1_30) AT=435.025n

* CHECK dout1_31 Vdout1_31ck86 = 0 time = 435
.meas tran vdout1_31ck86 FIND v(dout1_31) AT=435.025n

* CHECK dout1_32 Vdout1_32ck86 = 0.9 time = 435
.meas tran vdout1_32ck86 FIND v(dout1_32) AT=435.025n

* CHECK dout1_33 Vdout1_33ck86 = 0 time = 435
.meas tran vdout1_33ck86 FIND v(dout1_33) AT=435.025n

* CHECK dout1_34 Vdout1_34ck86 = 0.9 time = 435
.meas tran vdout1_34ck86 FIND v(dout1_34) AT=435.025n

* CHECK dout1_35 Vdout1_35ck86 = 0 time = 435
.meas tran vdout1_35ck86 FIND v(dout1_35) AT=435.025n

* CHECK dout1_36 Vdout1_36ck86 = 0 time = 435
.meas tran vdout1_36ck86 FIND v(dout1_36) AT=435.025n

* CHECK dout1_37 Vdout1_37ck86 = 0.9 time = 435
.meas tran vdout1_37ck86 FIND v(dout1_37) AT=435.025n

* CHECK dout1_38 Vdout1_38ck86 = 0 time = 435
.meas tran vdout1_38ck86 FIND v(dout1_38) AT=435.025n

* CHECK dout1_39 Vdout1_39ck86 = 0.9 time = 435
.meas tran vdout1_39ck86 FIND v(dout1_39) AT=435.025n

* CHECK dout1_40 Vdout1_40ck86 = 0 time = 435
.meas tran vdout1_40ck86 FIND v(dout1_40) AT=435.025n

* CHECK dout1_41 Vdout1_41ck86 = 0 time = 435
.meas tran vdout1_41ck86 FIND v(dout1_41) AT=435.025n

* CHECK dout1_42 Vdout1_42ck86 = 0.9 time = 435
.meas tran vdout1_42ck86 FIND v(dout1_42) AT=435.025n

* CHECK dout1_43 Vdout1_43ck86 = 0 time = 435
.meas tran vdout1_43ck86 FIND v(dout1_43) AT=435.025n

* CHECK dout1_44 Vdout1_44ck86 = 0.9 time = 435
.meas tran vdout1_44ck86 FIND v(dout1_44) AT=435.025n

* CHECK dout1_45 Vdout1_45ck86 = 0.9 time = 435
.meas tran vdout1_45ck86 FIND v(dout1_45) AT=435.025n

* CHECK dout1_46 Vdout1_46ck86 = 0.9 time = 435
.meas tran vdout1_46ck86 FIND v(dout1_46) AT=435.025n

* CHECK dout1_47 Vdout1_47ck86 = 0 time = 435
.meas tran vdout1_47ck86 FIND v(dout1_47) AT=435.025n

* CHECK dout1_48 Vdout1_48ck86 = 0 time = 435
.meas tran vdout1_48ck86 FIND v(dout1_48) AT=435.025n

* CHECK dout1_49 Vdout1_49ck86 = 0.9 time = 435
.meas tran vdout1_49ck86 FIND v(dout1_49) AT=435.025n

* CHECK dout1_50 Vdout1_50ck86 = 0.9 time = 435
.meas tran vdout1_50ck86 FIND v(dout1_50) AT=435.025n

* CHECK dout1_51 Vdout1_51ck86 = 0.9 time = 435
.meas tran vdout1_51ck86 FIND v(dout1_51) AT=435.025n

* CHECK dout1_52 Vdout1_52ck86 = 0.9 time = 435
.meas tran vdout1_52ck86 FIND v(dout1_52) AT=435.025n

* CHECK dout1_53 Vdout1_53ck86 = 0 time = 435
.meas tran vdout1_53ck86 FIND v(dout1_53) AT=435.025n

* CHECK dout1_54 Vdout1_54ck86 = 0 time = 435
.meas tran vdout1_54ck86 FIND v(dout1_54) AT=435.025n

* CHECK dout1_55 Vdout1_55ck86 = 0.9 time = 435
.meas tran vdout1_55ck86 FIND v(dout1_55) AT=435.025n

* CHECK dout1_56 Vdout1_56ck86 = 0.9 time = 435
.meas tran vdout1_56ck86 FIND v(dout1_56) AT=435.025n

* CHECK dout1_57 Vdout1_57ck86 = 0 time = 435
.meas tran vdout1_57ck86 FIND v(dout1_57) AT=435.025n

* CHECK dout1_58 Vdout1_58ck86 = 0.9 time = 435
.meas tran vdout1_58ck86 FIND v(dout1_58) AT=435.025n

* CHECK dout1_59 Vdout1_59ck86 = 0.9 time = 435
.meas tran vdout1_59ck86 FIND v(dout1_59) AT=435.025n

* CHECK dout1_60 Vdout1_60ck86 = 0.9 time = 435
.meas tran vdout1_60ck86 FIND v(dout1_60) AT=435.025n

* CHECK dout1_61 Vdout1_61ck86 = 0.9 time = 435
.meas tran vdout1_61ck86 FIND v(dout1_61) AT=435.025n

* CHECK dout1_62 Vdout1_62ck86 = 0.9 time = 435
.meas tran vdout1_62ck86 FIND v(dout1_62) AT=435.025n

* CHECK dout1_63 Vdout1_63ck86 = 0.9 time = 435
.meas tran vdout1_63ck86 FIND v(dout1_63) AT=435.025n

* CHECK dout1_64 Vdout1_64ck86 = 0 time = 435
.meas tran vdout1_64ck86 FIND v(dout1_64) AT=435.025n

* CHECK dout1_65 Vdout1_65ck86 = 0 time = 435
.meas tran vdout1_65ck86 FIND v(dout1_65) AT=435.025n

* CHECK dout1_66 Vdout1_66ck86 = 0.9 time = 435
.meas tran vdout1_66ck86 FIND v(dout1_66) AT=435.025n

* CHECK dout1_67 Vdout1_67ck86 = 0 time = 435
.meas tran vdout1_67ck86 FIND v(dout1_67) AT=435.025n

* CHECK dout1_68 Vdout1_68ck86 = 0 time = 435
.meas tran vdout1_68ck86 FIND v(dout1_68) AT=435.025n

* CHECK dout1_69 Vdout1_69ck86 = 0.9 time = 435
.meas tran vdout1_69ck86 FIND v(dout1_69) AT=435.025n

* CHECK dout1_70 Vdout1_70ck86 = 0.9 time = 435
.meas tran vdout1_70ck86 FIND v(dout1_70) AT=435.025n

* CHECK dout1_71 Vdout1_71ck86 = 0 time = 435
.meas tran vdout1_71ck86 FIND v(dout1_71) AT=435.025n

* CHECK dout1_72 Vdout1_72ck86 = 0 time = 435
.meas tran vdout1_72ck86 FIND v(dout1_72) AT=435.025n

* CHECK dout1_73 Vdout1_73ck86 = 0.9 time = 435
.meas tran vdout1_73ck86 FIND v(dout1_73) AT=435.025n

* CHECK dout1_74 Vdout1_74ck86 = 0 time = 435
.meas tran vdout1_74ck86 FIND v(dout1_74) AT=435.025n

* CHECK dout1_75 Vdout1_75ck86 = 0.9 time = 435
.meas tran vdout1_75ck86 FIND v(dout1_75) AT=435.025n

* CHECK dout1_76 Vdout1_76ck86 = 0.9 time = 435
.meas tran vdout1_76ck86 FIND v(dout1_76) AT=435.025n

* CHECK dout1_77 Vdout1_77ck86 = 0 time = 435
.meas tran vdout1_77ck86 FIND v(dout1_77) AT=435.025n

* CHECK dout1_78 Vdout1_78ck86 = 0.9 time = 435
.meas tran vdout1_78ck86 FIND v(dout1_78) AT=435.025n

* CHECK dout1_79 Vdout1_79ck86 = 0.9 time = 435
.meas tran vdout1_79ck86 FIND v(dout1_79) AT=435.025n

* CHECK dout1_80 Vdout1_80ck86 = 0 time = 435
.meas tran vdout1_80ck86 FIND v(dout1_80) AT=435.025n

* CHECK dout1_81 Vdout1_81ck86 = 0.9 time = 435
.meas tran vdout1_81ck86 FIND v(dout1_81) AT=435.025n

* CHECK dout1_82 Vdout1_82ck86 = 0 time = 435
.meas tran vdout1_82ck86 FIND v(dout1_82) AT=435.025n

* CHECK dout1_83 Vdout1_83ck86 = 0 time = 435
.meas tran vdout1_83ck86 FIND v(dout1_83) AT=435.025n

* CHECK dout1_84 Vdout1_84ck86 = 0.9 time = 435
.meas tran vdout1_84ck86 FIND v(dout1_84) AT=435.025n

* CHECK dout1_85 Vdout1_85ck86 = 0.9 time = 435
.meas tran vdout1_85ck86 FIND v(dout1_85) AT=435.025n

* CHECK dout1_86 Vdout1_86ck86 = 0.9 time = 435
.meas tran vdout1_86ck86 FIND v(dout1_86) AT=435.025n

* CHECK dout1_87 Vdout1_87ck86 = 0.9 time = 435
.meas tran vdout1_87ck86 FIND v(dout1_87) AT=435.025n

* CHECK dout1_88 Vdout1_88ck86 = 0.9 time = 435
.meas tran vdout1_88ck86 FIND v(dout1_88) AT=435.025n

* CHECK dout1_89 Vdout1_89ck86 = 0 time = 435
.meas tran vdout1_89ck86 FIND v(dout1_89) AT=435.025n

* CHECK dout1_90 Vdout1_90ck86 = 0 time = 435
.meas tran vdout1_90ck86 FIND v(dout1_90) AT=435.025n

* CHECK dout1_91 Vdout1_91ck86 = 0.9 time = 435
.meas tran vdout1_91ck86 FIND v(dout1_91) AT=435.025n

* CHECK dout1_92 Vdout1_92ck86 = 0.9 time = 435
.meas tran vdout1_92ck86 FIND v(dout1_92) AT=435.025n

* CHECK dout1_93 Vdout1_93ck86 = 0 time = 435
.meas tran vdout1_93ck86 FIND v(dout1_93) AT=435.025n

* CHECK dout1_94 Vdout1_94ck86 = 0 time = 435
.meas tran vdout1_94ck86 FIND v(dout1_94) AT=435.025n

* CHECK dout1_95 Vdout1_95ck86 = 0.9 time = 435
.meas tran vdout1_95ck86 FIND v(dout1_95) AT=435.025n

* CHECK dout1_0 Vdout1_0ck90 = 0.9 time = 455
.meas tran vdout1_0ck90 FIND v(dout1_0) AT=455.025n

* CHECK dout1_1 Vdout1_1ck90 = 0 time = 455
.meas tran vdout1_1ck90 FIND v(dout1_1) AT=455.025n

* CHECK dout1_2 Vdout1_2ck90 = 0 time = 455
.meas tran vdout1_2ck90 FIND v(dout1_2) AT=455.025n

* CHECK dout1_3 Vdout1_3ck90 = 0 time = 455
.meas tran vdout1_3ck90 FIND v(dout1_3) AT=455.025n

* CHECK dout1_4 Vdout1_4ck90 = 0.9 time = 455
.meas tran vdout1_4ck90 FIND v(dout1_4) AT=455.025n

* CHECK dout1_5 Vdout1_5ck90 = 0.9 time = 455
.meas tran vdout1_5ck90 FIND v(dout1_5) AT=455.025n

* CHECK dout1_6 Vdout1_6ck90 = 0.9 time = 455
.meas tran vdout1_6ck90 FIND v(dout1_6) AT=455.025n

* CHECK dout1_7 Vdout1_7ck90 = 0.9 time = 455
.meas tran vdout1_7ck90 FIND v(dout1_7) AT=455.025n

* CHECK dout1_8 Vdout1_8ck90 = 0 time = 455
.meas tran vdout1_8ck90 FIND v(dout1_8) AT=455.025n

* CHECK dout1_9 Vdout1_9ck90 = 0.9 time = 455
.meas tran vdout1_9ck90 FIND v(dout1_9) AT=455.025n

* CHECK dout1_10 Vdout1_10ck90 = 0 time = 455
.meas tran vdout1_10ck90 FIND v(dout1_10) AT=455.025n

* CHECK dout1_11 Vdout1_11ck90 = 0 time = 455
.meas tran vdout1_11ck90 FIND v(dout1_11) AT=455.025n

* CHECK dout1_12 Vdout1_12ck90 = 0 time = 455
.meas tran vdout1_12ck90 FIND v(dout1_12) AT=455.025n

* CHECK dout1_13 Vdout1_13ck90 = 0.9 time = 455
.meas tran vdout1_13ck90 FIND v(dout1_13) AT=455.025n

* CHECK dout1_14 Vdout1_14ck90 = 0.9 time = 455
.meas tran vdout1_14ck90 FIND v(dout1_14) AT=455.025n

* CHECK dout1_15 Vdout1_15ck90 = 0 time = 455
.meas tran vdout1_15ck90 FIND v(dout1_15) AT=455.025n

* CHECK dout1_16 Vdout1_16ck90 = 0.9 time = 455
.meas tran vdout1_16ck90 FIND v(dout1_16) AT=455.025n

* CHECK dout1_17 Vdout1_17ck90 = 0 time = 455
.meas tran vdout1_17ck90 FIND v(dout1_17) AT=455.025n

* CHECK dout1_18 Vdout1_18ck90 = 0 time = 455
.meas tran vdout1_18ck90 FIND v(dout1_18) AT=455.025n

* CHECK dout1_19 Vdout1_19ck90 = 0.9 time = 455
.meas tran vdout1_19ck90 FIND v(dout1_19) AT=455.025n

* CHECK dout1_20 Vdout1_20ck90 = 0.9 time = 455
.meas tran vdout1_20ck90 FIND v(dout1_20) AT=455.025n

* CHECK dout1_21 Vdout1_21ck90 = 0.9 time = 455
.meas tran vdout1_21ck90 FIND v(dout1_21) AT=455.025n

* CHECK dout1_22 Vdout1_22ck90 = 0 time = 455
.meas tran vdout1_22ck90 FIND v(dout1_22) AT=455.025n

* CHECK dout1_23 Vdout1_23ck90 = 0.9 time = 455
.meas tran vdout1_23ck90 FIND v(dout1_23) AT=455.025n

* CHECK dout1_24 Vdout1_24ck90 = 0 time = 455
.meas tran vdout1_24ck90 FIND v(dout1_24) AT=455.025n

* CHECK dout1_25 Vdout1_25ck90 = 0.9 time = 455
.meas tran vdout1_25ck90 FIND v(dout1_25) AT=455.025n

* CHECK dout1_26 Vdout1_26ck90 = 0.9 time = 455
.meas tran vdout1_26ck90 FIND v(dout1_26) AT=455.025n

* CHECK dout1_27 Vdout1_27ck90 = 0.9 time = 455
.meas tran vdout1_27ck90 FIND v(dout1_27) AT=455.025n

* CHECK dout1_28 Vdout1_28ck90 = 0.9 time = 455
.meas tran vdout1_28ck90 FIND v(dout1_28) AT=455.025n

* CHECK dout1_29 Vdout1_29ck90 = 0.9 time = 455
.meas tran vdout1_29ck90 FIND v(dout1_29) AT=455.025n

* CHECK dout1_30 Vdout1_30ck90 = 0 time = 455
.meas tran vdout1_30ck90 FIND v(dout1_30) AT=455.025n

* CHECK dout1_31 Vdout1_31ck90 = 0.9 time = 455
.meas tran vdout1_31ck90 FIND v(dout1_31) AT=455.025n

* CHECK dout1_32 Vdout1_32ck90 = 0 time = 455
.meas tran vdout1_32ck90 FIND v(dout1_32) AT=455.025n

* CHECK dout1_33 Vdout1_33ck90 = 0.9 time = 455
.meas tran vdout1_33ck90 FIND v(dout1_33) AT=455.025n

* CHECK dout1_34 Vdout1_34ck90 = 0.9 time = 455
.meas tran vdout1_34ck90 FIND v(dout1_34) AT=455.025n

* CHECK dout1_35 Vdout1_35ck90 = 0.9 time = 455
.meas tran vdout1_35ck90 FIND v(dout1_35) AT=455.025n

* CHECK dout1_36 Vdout1_36ck90 = 0.9 time = 455
.meas tran vdout1_36ck90 FIND v(dout1_36) AT=455.025n

* CHECK dout1_37 Vdout1_37ck90 = 0 time = 455
.meas tran vdout1_37ck90 FIND v(dout1_37) AT=455.025n

* CHECK dout1_38 Vdout1_38ck90 = 0.9 time = 455
.meas tran vdout1_38ck90 FIND v(dout1_38) AT=455.025n

* CHECK dout1_39 Vdout1_39ck90 = 0 time = 455
.meas tran vdout1_39ck90 FIND v(dout1_39) AT=455.025n

* CHECK dout1_40 Vdout1_40ck90 = 0 time = 455
.meas tran vdout1_40ck90 FIND v(dout1_40) AT=455.025n

* CHECK dout1_41 Vdout1_41ck90 = 0.9 time = 455
.meas tran vdout1_41ck90 FIND v(dout1_41) AT=455.025n

* CHECK dout1_42 Vdout1_42ck90 = 0 time = 455
.meas tran vdout1_42ck90 FIND v(dout1_42) AT=455.025n

* CHECK dout1_43 Vdout1_43ck90 = 0 time = 455
.meas tran vdout1_43ck90 FIND v(dout1_43) AT=455.025n

* CHECK dout1_44 Vdout1_44ck90 = 0 time = 455
.meas tran vdout1_44ck90 FIND v(dout1_44) AT=455.025n

* CHECK dout1_45 Vdout1_45ck90 = 0.9 time = 455
.meas tran vdout1_45ck90 FIND v(dout1_45) AT=455.025n

* CHECK dout1_46 Vdout1_46ck90 = 0 time = 455
.meas tran vdout1_46ck90 FIND v(dout1_46) AT=455.025n

* CHECK dout1_47 Vdout1_47ck90 = 0 time = 455
.meas tran vdout1_47ck90 FIND v(dout1_47) AT=455.025n

* CHECK dout1_48 Vdout1_48ck90 = 0.9 time = 455
.meas tran vdout1_48ck90 FIND v(dout1_48) AT=455.025n

* CHECK dout1_49 Vdout1_49ck90 = 0.9 time = 455
.meas tran vdout1_49ck90 FIND v(dout1_49) AT=455.025n

* CHECK dout1_50 Vdout1_50ck90 = 0 time = 455
.meas tran vdout1_50ck90 FIND v(dout1_50) AT=455.025n

* CHECK dout1_51 Vdout1_51ck90 = 0.9 time = 455
.meas tran vdout1_51ck90 FIND v(dout1_51) AT=455.025n

* CHECK dout1_52 Vdout1_52ck90 = 0 time = 455
.meas tran vdout1_52ck90 FIND v(dout1_52) AT=455.025n

* CHECK dout1_53 Vdout1_53ck90 = 0 time = 455
.meas tran vdout1_53ck90 FIND v(dout1_53) AT=455.025n

* CHECK dout1_54 Vdout1_54ck90 = 0.9 time = 455
.meas tran vdout1_54ck90 FIND v(dout1_54) AT=455.025n

* CHECK dout1_55 Vdout1_55ck90 = 0.9 time = 455
.meas tran vdout1_55ck90 FIND v(dout1_55) AT=455.025n

* CHECK dout1_56 Vdout1_56ck90 = 0 time = 455
.meas tran vdout1_56ck90 FIND v(dout1_56) AT=455.025n

* CHECK dout1_57 Vdout1_57ck90 = 0.9 time = 455
.meas tran vdout1_57ck90 FIND v(dout1_57) AT=455.025n

* CHECK dout1_58 Vdout1_58ck90 = 0.9 time = 455
.meas tran vdout1_58ck90 FIND v(dout1_58) AT=455.025n

* CHECK dout1_59 Vdout1_59ck90 = 0.9 time = 455
.meas tran vdout1_59ck90 FIND v(dout1_59) AT=455.025n

* CHECK dout1_60 Vdout1_60ck90 = 0 time = 455
.meas tran vdout1_60ck90 FIND v(dout1_60) AT=455.025n

* CHECK dout1_61 Vdout1_61ck90 = 0.9 time = 455
.meas tran vdout1_61ck90 FIND v(dout1_61) AT=455.025n

* CHECK dout1_62 Vdout1_62ck90 = 0.9 time = 455
.meas tran vdout1_62ck90 FIND v(dout1_62) AT=455.025n

* CHECK dout1_63 Vdout1_63ck90 = 0 time = 455
.meas tran vdout1_63ck90 FIND v(dout1_63) AT=455.025n

* CHECK dout1_64 Vdout1_64ck90 = 0.9 time = 455
.meas tran vdout1_64ck90 FIND v(dout1_64) AT=455.025n

* CHECK dout1_65 Vdout1_65ck90 = 0.9 time = 455
.meas tran vdout1_65ck90 FIND v(dout1_65) AT=455.025n

* CHECK dout1_66 Vdout1_66ck90 = 0.9 time = 455
.meas tran vdout1_66ck90 FIND v(dout1_66) AT=455.025n

* CHECK dout1_67 Vdout1_67ck90 = 0 time = 455
.meas tran vdout1_67ck90 FIND v(dout1_67) AT=455.025n

* CHECK dout1_68 Vdout1_68ck90 = 0 time = 455
.meas tran vdout1_68ck90 FIND v(dout1_68) AT=455.025n

* CHECK dout1_69 Vdout1_69ck90 = 0 time = 455
.meas tran vdout1_69ck90 FIND v(dout1_69) AT=455.025n

* CHECK dout1_70 Vdout1_70ck90 = 0 time = 455
.meas tran vdout1_70ck90 FIND v(dout1_70) AT=455.025n

* CHECK dout1_71 Vdout1_71ck90 = 0 time = 455
.meas tran vdout1_71ck90 FIND v(dout1_71) AT=455.025n

* CHECK dout1_72 Vdout1_72ck90 = 0 time = 455
.meas tran vdout1_72ck90 FIND v(dout1_72) AT=455.025n

* CHECK dout1_73 Vdout1_73ck90 = 0.9 time = 455
.meas tran vdout1_73ck90 FIND v(dout1_73) AT=455.025n

* CHECK dout1_74 Vdout1_74ck90 = 0.9 time = 455
.meas tran vdout1_74ck90 FIND v(dout1_74) AT=455.025n

* CHECK dout1_75 Vdout1_75ck90 = 0 time = 455
.meas tran vdout1_75ck90 FIND v(dout1_75) AT=455.025n

* CHECK dout1_76 Vdout1_76ck90 = 0.9 time = 455
.meas tran vdout1_76ck90 FIND v(dout1_76) AT=455.025n

* CHECK dout1_77 Vdout1_77ck90 = 0 time = 455
.meas tran vdout1_77ck90 FIND v(dout1_77) AT=455.025n

* CHECK dout1_78 Vdout1_78ck90 = 0.9 time = 455
.meas tran vdout1_78ck90 FIND v(dout1_78) AT=455.025n

* CHECK dout1_79 Vdout1_79ck90 = 0.9 time = 455
.meas tran vdout1_79ck90 FIND v(dout1_79) AT=455.025n

* CHECK dout1_80 Vdout1_80ck90 = 0.9 time = 455
.meas tran vdout1_80ck90 FIND v(dout1_80) AT=455.025n

* CHECK dout1_81 Vdout1_81ck90 = 0.9 time = 455
.meas tran vdout1_81ck90 FIND v(dout1_81) AT=455.025n

* CHECK dout1_82 Vdout1_82ck90 = 0 time = 455
.meas tran vdout1_82ck90 FIND v(dout1_82) AT=455.025n

* CHECK dout1_83 Vdout1_83ck90 = 0 time = 455
.meas tran vdout1_83ck90 FIND v(dout1_83) AT=455.025n

* CHECK dout1_84 Vdout1_84ck90 = 0.9 time = 455
.meas tran vdout1_84ck90 FIND v(dout1_84) AT=455.025n

* CHECK dout1_85 Vdout1_85ck90 = 0.9 time = 455
.meas tran vdout1_85ck90 FIND v(dout1_85) AT=455.025n

* CHECK dout1_86 Vdout1_86ck90 = 0 time = 455
.meas tran vdout1_86ck90 FIND v(dout1_86) AT=455.025n

* CHECK dout1_87 Vdout1_87ck90 = 0 time = 455
.meas tran vdout1_87ck90 FIND v(dout1_87) AT=455.025n

* CHECK dout1_88 Vdout1_88ck90 = 0.9 time = 455
.meas tran vdout1_88ck90 FIND v(dout1_88) AT=455.025n

* CHECK dout1_89 Vdout1_89ck90 = 0.9 time = 455
.meas tran vdout1_89ck90 FIND v(dout1_89) AT=455.025n

* CHECK dout1_90 Vdout1_90ck90 = 0.9 time = 455
.meas tran vdout1_90ck90 FIND v(dout1_90) AT=455.025n

* CHECK dout1_91 Vdout1_91ck90 = 0.9 time = 455
.meas tran vdout1_91ck90 FIND v(dout1_91) AT=455.025n

* CHECK dout1_92 Vdout1_92ck90 = 0.9 time = 455
.meas tran vdout1_92ck90 FIND v(dout1_92) AT=455.025n

* CHECK dout1_93 Vdout1_93ck90 = 0.9 time = 455
.meas tran vdout1_93ck90 FIND v(dout1_93) AT=455.025n

* CHECK dout1_94 Vdout1_94ck90 = 0.9 time = 455
.meas tran vdout1_94ck90 FIND v(dout1_94) AT=455.025n

* CHECK dout1_95 Vdout1_95ck90 = 0 time = 455
.meas tran vdout1_95ck90 FIND v(dout1_95) AT=455.025n

* CHECK dout1_0 Vdout1_0ck93 = 0.9 time = 470
.meas tran vdout1_0ck93 FIND v(dout1_0) AT=470.025n

* CHECK dout1_1 Vdout1_1ck93 = 0.9 time = 470
.meas tran vdout1_1ck93 FIND v(dout1_1) AT=470.025n

* CHECK dout1_2 Vdout1_2ck93 = 0.9 time = 470
.meas tran vdout1_2ck93 FIND v(dout1_2) AT=470.025n

* CHECK dout1_3 Vdout1_3ck93 = 0 time = 470
.meas tran vdout1_3ck93 FIND v(dout1_3) AT=470.025n

* CHECK dout1_4 Vdout1_4ck93 = 0 time = 470
.meas tran vdout1_4ck93 FIND v(dout1_4) AT=470.025n

* CHECK dout1_5 Vdout1_5ck93 = 0 time = 470
.meas tran vdout1_5ck93 FIND v(dout1_5) AT=470.025n

* CHECK dout1_6 Vdout1_6ck93 = 0 time = 470
.meas tran vdout1_6ck93 FIND v(dout1_6) AT=470.025n

* CHECK dout1_7 Vdout1_7ck93 = 0 time = 470
.meas tran vdout1_7ck93 FIND v(dout1_7) AT=470.025n

* CHECK dout1_8 Vdout1_8ck93 = 0 time = 470
.meas tran vdout1_8ck93 FIND v(dout1_8) AT=470.025n

* CHECK dout1_9 Vdout1_9ck93 = 0 time = 470
.meas tran vdout1_9ck93 FIND v(dout1_9) AT=470.025n

* CHECK dout1_10 Vdout1_10ck93 = 0.9 time = 470
.meas tran vdout1_10ck93 FIND v(dout1_10) AT=470.025n

* CHECK dout1_11 Vdout1_11ck93 = 0 time = 470
.meas tran vdout1_11ck93 FIND v(dout1_11) AT=470.025n

* CHECK dout1_12 Vdout1_12ck93 = 0 time = 470
.meas tran vdout1_12ck93 FIND v(dout1_12) AT=470.025n

* CHECK dout1_13 Vdout1_13ck93 = 0 time = 470
.meas tran vdout1_13ck93 FIND v(dout1_13) AT=470.025n

* CHECK dout1_14 Vdout1_14ck93 = 0.9 time = 470
.meas tran vdout1_14ck93 FIND v(dout1_14) AT=470.025n

* CHECK dout1_15 Vdout1_15ck93 = 0 time = 470
.meas tran vdout1_15ck93 FIND v(dout1_15) AT=470.025n

* CHECK dout1_16 Vdout1_16ck93 = 0.9 time = 470
.meas tran vdout1_16ck93 FIND v(dout1_16) AT=470.025n

* CHECK dout1_17 Vdout1_17ck93 = 0.9 time = 470
.meas tran vdout1_17ck93 FIND v(dout1_17) AT=470.025n

* CHECK dout1_18 Vdout1_18ck93 = 0 time = 470
.meas tran vdout1_18ck93 FIND v(dout1_18) AT=470.025n

* CHECK dout1_19 Vdout1_19ck93 = 0 time = 470
.meas tran vdout1_19ck93 FIND v(dout1_19) AT=470.025n

* CHECK dout1_20 Vdout1_20ck93 = 0.9 time = 470
.meas tran vdout1_20ck93 FIND v(dout1_20) AT=470.025n

* CHECK dout1_21 Vdout1_21ck93 = 0 time = 470
.meas tran vdout1_21ck93 FIND v(dout1_21) AT=470.025n

* CHECK dout1_22 Vdout1_22ck93 = 0 time = 470
.meas tran vdout1_22ck93 FIND v(dout1_22) AT=470.025n

* CHECK dout1_23 Vdout1_23ck93 = 0 time = 470
.meas tran vdout1_23ck93 FIND v(dout1_23) AT=470.025n

* CHECK dout1_24 Vdout1_24ck93 = 0 time = 470
.meas tran vdout1_24ck93 FIND v(dout1_24) AT=470.025n

* CHECK dout1_25 Vdout1_25ck93 = 0.9 time = 470
.meas tran vdout1_25ck93 FIND v(dout1_25) AT=470.025n

* CHECK dout1_26 Vdout1_26ck93 = 0.9 time = 470
.meas tran vdout1_26ck93 FIND v(dout1_26) AT=470.025n

* CHECK dout1_27 Vdout1_27ck93 = 0 time = 470
.meas tran vdout1_27ck93 FIND v(dout1_27) AT=470.025n

* CHECK dout1_28 Vdout1_28ck93 = 0 time = 470
.meas tran vdout1_28ck93 FIND v(dout1_28) AT=470.025n

* CHECK dout1_29 Vdout1_29ck93 = 0.9 time = 470
.meas tran vdout1_29ck93 FIND v(dout1_29) AT=470.025n

* CHECK dout1_30 Vdout1_30ck93 = 0.9 time = 470
.meas tran vdout1_30ck93 FIND v(dout1_30) AT=470.025n

* CHECK dout1_31 Vdout1_31ck93 = 0 time = 470
.meas tran vdout1_31ck93 FIND v(dout1_31) AT=470.025n

* CHECK dout1_32 Vdout1_32ck93 = 0 time = 470
.meas tran vdout1_32ck93 FIND v(dout1_32) AT=470.025n

* CHECK dout1_33 Vdout1_33ck93 = 0.9 time = 470
.meas tran vdout1_33ck93 FIND v(dout1_33) AT=470.025n

* CHECK dout1_34 Vdout1_34ck93 = 0.9 time = 470
.meas tran vdout1_34ck93 FIND v(dout1_34) AT=470.025n

* CHECK dout1_35 Vdout1_35ck93 = 0.9 time = 470
.meas tran vdout1_35ck93 FIND v(dout1_35) AT=470.025n

* CHECK dout1_36 Vdout1_36ck93 = 0.9 time = 470
.meas tran vdout1_36ck93 FIND v(dout1_36) AT=470.025n

* CHECK dout1_37 Vdout1_37ck93 = 0 time = 470
.meas tran vdout1_37ck93 FIND v(dout1_37) AT=470.025n

* CHECK dout1_38 Vdout1_38ck93 = 0.9 time = 470
.meas tran vdout1_38ck93 FIND v(dout1_38) AT=470.025n

* CHECK dout1_39 Vdout1_39ck93 = 0 time = 470
.meas tran vdout1_39ck93 FIND v(dout1_39) AT=470.025n

* CHECK dout1_40 Vdout1_40ck93 = 0 time = 470
.meas tran vdout1_40ck93 FIND v(dout1_40) AT=470.025n

* CHECK dout1_41 Vdout1_41ck93 = 0.9 time = 470
.meas tran vdout1_41ck93 FIND v(dout1_41) AT=470.025n

* CHECK dout1_42 Vdout1_42ck93 = 0 time = 470
.meas tran vdout1_42ck93 FIND v(dout1_42) AT=470.025n

* CHECK dout1_43 Vdout1_43ck93 = 0 time = 470
.meas tran vdout1_43ck93 FIND v(dout1_43) AT=470.025n

* CHECK dout1_44 Vdout1_44ck93 = 0 time = 470
.meas tran vdout1_44ck93 FIND v(dout1_44) AT=470.025n

* CHECK dout1_45 Vdout1_45ck93 = 0.9 time = 470
.meas tran vdout1_45ck93 FIND v(dout1_45) AT=470.025n

* CHECK dout1_46 Vdout1_46ck93 = 0 time = 470
.meas tran vdout1_46ck93 FIND v(dout1_46) AT=470.025n

* CHECK dout1_47 Vdout1_47ck93 = 0 time = 470
.meas tran vdout1_47ck93 FIND v(dout1_47) AT=470.025n

* CHECK dout1_48 Vdout1_48ck93 = 0.9 time = 470
.meas tran vdout1_48ck93 FIND v(dout1_48) AT=470.025n

* CHECK dout1_49 Vdout1_49ck93 = 0.9 time = 470
.meas tran vdout1_49ck93 FIND v(dout1_49) AT=470.025n

* CHECK dout1_50 Vdout1_50ck93 = 0 time = 470
.meas tran vdout1_50ck93 FIND v(dout1_50) AT=470.025n

* CHECK dout1_51 Vdout1_51ck93 = 0.9 time = 470
.meas tran vdout1_51ck93 FIND v(dout1_51) AT=470.025n

* CHECK dout1_52 Vdout1_52ck93 = 0 time = 470
.meas tran vdout1_52ck93 FIND v(dout1_52) AT=470.025n

* CHECK dout1_53 Vdout1_53ck93 = 0 time = 470
.meas tran vdout1_53ck93 FIND v(dout1_53) AT=470.025n

* CHECK dout1_54 Vdout1_54ck93 = 0.9 time = 470
.meas tran vdout1_54ck93 FIND v(dout1_54) AT=470.025n

* CHECK dout1_55 Vdout1_55ck93 = 0.9 time = 470
.meas tran vdout1_55ck93 FIND v(dout1_55) AT=470.025n

* CHECK dout1_56 Vdout1_56ck93 = 0 time = 470
.meas tran vdout1_56ck93 FIND v(dout1_56) AT=470.025n

* CHECK dout1_57 Vdout1_57ck93 = 0.9 time = 470
.meas tran vdout1_57ck93 FIND v(dout1_57) AT=470.025n

* CHECK dout1_58 Vdout1_58ck93 = 0.9 time = 470
.meas tran vdout1_58ck93 FIND v(dout1_58) AT=470.025n

* CHECK dout1_59 Vdout1_59ck93 = 0.9 time = 470
.meas tran vdout1_59ck93 FIND v(dout1_59) AT=470.025n

* CHECK dout1_60 Vdout1_60ck93 = 0 time = 470
.meas tran vdout1_60ck93 FIND v(dout1_60) AT=470.025n

* CHECK dout1_61 Vdout1_61ck93 = 0.9 time = 470
.meas tran vdout1_61ck93 FIND v(dout1_61) AT=470.025n

* CHECK dout1_62 Vdout1_62ck93 = 0.9 time = 470
.meas tran vdout1_62ck93 FIND v(dout1_62) AT=470.025n

* CHECK dout1_63 Vdout1_63ck93 = 0 time = 470
.meas tran vdout1_63ck93 FIND v(dout1_63) AT=470.025n

* CHECK dout1_64 Vdout1_64ck93 = 0 time = 470
.meas tran vdout1_64ck93 FIND v(dout1_64) AT=470.025n

* CHECK dout1_65 Vdout1_65ck93 = 0 time = 470
.meas tran vdout1_65ck93 FIND v(dout1_65) AT=470.025n

* CHECK dout1_66 Vdout1_66ck93 = 0 time = 470
.meas tran vdout1_66ck93 FIND v(dout1_66) AT=470.025n

* CHECK dout1_67 Vdout1_67ck93 = 0 time = 470
.meas tran vdout1_67ck93 FIND v(dout1_67) AT=470.025n

* CHECK dout1_68 Vdout1_68ck93 = 0.9 time = 470
.meas tran vdout1_68ck93 FIND v(dout1_68) AT=470.025n

* CHECK dout1_69 Vdout1_69ck93 = 0 time = 470
.meas tran vdout1_69ck93 FIND v(dout1_69) AT=470.025n

* CHECK dout1_70 Vdout1_70ck93 = 0.9 time = 470
.meas tran vdout1_70ck93 FIND v(dout1_70) AT=470.025n

* CHECK dout1_71 Vdout1_71ck93 = 0.9 time = 470
.meas tran vdout1_71ck93 FIND v(dout1_71) AT=470.025n

* CHECK dout1_72 Vdout1_72ck93 = 0.9 time = 470
.meas tran vdout1_72ck93 FIND v(dout1_72) AT=470.025n

* CHECK dout1_73 Vdout1_73ck93 = 0 time = 470
.meas tran vdout1_73ck93 FIND v(dout1_73) AT=470.025n

* CHECK dout1_74 Vdout1_74ck93 = 0 time = 470
.meas tran vdout1_74ck93 FIND v(dout1_74) AT=470.025n

* CHECK dout1_75 Vdout1_75ck93 = 0.9 time = 470
.meas tran vdout1_75ck93 FIND v(dout1_75) AT=470.025n

* CHECK dout1_76 Vdout1_76ck93 = 0.9 time = 470
.meas tran vdout1_76ck93 FIND v(dout1_76) AT=470.025n

* CHECK dout1_77 Vdout1_77ck93 = 0 time = 470
.meas tran vdout1_77ck93 FIND v(dout1_77) AT=470.025n

* CHECK dout1_78 Vdout1_78ck93 = 0.9 time = 470
.meas tran vdout1_78ck93 FIND v(dout1_78) AT=470.025n

* CHECK dout1_79 Vdout1_79ck93 = 0 time = 470
.meas tran vdout1_79ck93 FIND v(dout1_79) AT=470.025n

* CHECK dout1_80 Vdout1_80ck93 = 0.9 time = 470
.meas tran vdout1_80ck93 FIND v(dout1_80) AT=470.025n

* CHECK dout1_81 Vdout1_81ck93 = 0.9 time = 470
.meas tran vdout1_81ck93 FIND v(dout1_81) AT=470.025n

* CHECK dout1_82 Vdout1_82ck93 = 0.9 time = 470
.meas tran vdout1_82ck93 FIND v(dout1_82) AT=470.025n

* CHECK dout1_83 Vdout1_83ck93 = 0.9 time = 470
.meas tran vdout1_83ck93 FIND v(dout1_83) AT=470.025n

* CHECK dout1_84 Vdout1_84ck93 = 0.9 time = 470
.meas tran vdout1_84ck93 FIND v(dout1_84) AT=470.025n

* CHECK dout1_85 Vdout1_85ck93 = 0.9 time = 470
.meas tran vdout1_85ck93 FIND v(dout1_85) AT=470.025n

* CHECK dout1_86 Vdout1_86ck93 = 0.9 time = 470
.meas tran vdout1_86ck93 FIND v(dout1_86) AT=470.025n

* CHECK dout1_87 Vdout1_87ck93 = 0 time = 470
.meas tran vdout1_87ck93 FIND v(dout1_87) AT=470.025n

* CHECK dout1_88 Vdout1_88ck93 = 0.9 time = 470
.meas tran vdout1_88ck93 FIND v(dout1_88) AT=470.025n

* CHECK dout1_89 Vdout1_89ck93 = 0.9 time = 470
.meas tran vdout1_89ck93 FIND v(dout1_89) AT=470.025n

* CHECK dout1_90 Vdout1_90ck93 = 0 time = 470
.meas tran vdout1_90ck93 FIND v(dout1_90) AT=470.025n

* CHECK dout1_91 Vdout1_91ck93 = 0.9 time = 470
.meas tran vdout1_91ck93 FIND v(dout1_91) AT=470.025n

* CHECK dout1_92 Vdout1_92ck93 = 0 time = 470
.meas tran vdout1_92ck93 FIND v(dout1_92) AT=470.025n

* CHECK dout1_93 Vdout1_93ck93 = 0.9 time = 470
.meas tran vdout1_93ck93 FIND v(dout1_93) AT=470.025n

* CHECK dout1_94 Vdout1_94ck93 = 0.9 time = 470
.meas tran vdout1_94ck93 FIND v(dout1_94) AT=470.025n

* CHECK dout1_95 Vdout1_95ck93 = 0.9 time = 470
.meas tran vdout1_95ck93 FIND v(dout1_95) AT=470.025n

* CHECK dout1_0 Vdout1_0ck96 = 0.9 time = 485
.meas tran vdout1_0ck96 FIND v(dout1_0) AT=485.025n

* CHECK dout1_1 Vdout1_1ck96 = 0.9 time = 485
.meas tran vdout1_1ck96 FIND v(dout1_1) AT=485.025n

* CHECK dout1_2 Vdout1_2ck96 = 0.9 time = 485
.meas tran vdout1_2ck96 FIND v(dout1_2) AT=485.025n

* CHECK dout1_3 Vdout1_3ck96 = 0 time = 485
.meas tran vdout1_3ck96 FIND v(dout1_3) AT=485.025n

* CHECK dout1_4 Vdout1_4ck96 = 0 time = 485
.meas tran vdout1_4ck96 FIND v(dout1_4) AT=485.025n

* CHECK dout1_5 Vdout1_5ck96 = 0 time = 485
.meas tran vdout1_5ck96 FIND v(dout1_5) AT=485.025n

* CHECK dout1_6 Vdout1_6ck96 = 0 time = 485
.meas tran vdout1_6ck96 FIND v(dout1_6) AT=485.025n

* CHECK dout1_7 Vdout1_7ck96 = 0 time = 485
.meas tran vdout1_7ck96 FIND v(dout1_7) AT=485.025n

* CHECK dout1_8 Vdout1_8ck96 = 0 time = 485
.meas tran vdout1_8ck96 FIND v(dout1_8) AT=485.025n

* CHECK dout1_9 Vdout1_9ck96 = 0 time = 485
.meas tran vdout1_9ck96 FIND v(dout1_9) AT=485.025n

* CHECK dout1_10 Vdout1_10ck96 = 0.9 time = 485
.meas tran vdout1_10ck96 FIND v(dout1_10) AT=485.025n

* CHECK dout1_11 Vdout1_11ck96 = 0 time = 485
.meas tran vdout1_11ck96 FIND v(dout1_11) AT=485.025n

* CHECK dout1_12 Vdout1_12ck96 = 0 time = 485
.meas tran vdout1_12ck96 FIND v(dout1_12) AT=485.025n

* CHECK dout1_13 Vdout1_13ck96 = 0 time = 485
.meas tran vdout1_13ck96 FIND v(dout1_13) AT=485.025n

* CHECK dout1_14 Vdout1_14ck96 = 0.9 time = 485
.meas tran vdout1_14ck96 FIND v(dout1_14) AT=485.025n

* CHECK dout1_15 Vdout1_15ck96 = 0 time = 485
.meas tran vdout1_15ck96 FIND v(dout1_15) AT=485.025n

* CHECK dout1_16 Vdout1_16ck96 = 0.9 time = 485
.meas tran vdout1_16ck96 FIND v(dout1_16) AT=485.025n

* CHECK dout1_17 Vdout1_17ck96 = 0.9 time = 485
.meas tran vdout1_17ck96 FIND v(dout1_17) AT=485.025n

* CHECK dout1_18 Vdout1_18ck96 = 0 time = 485
.meas tran vdout1_18ck96 FIND v(dout1_18) AT=485.025n

* CHECK dout1_19 Vdout1_19ck96 = 0 time = 485
.meas tran vdout1_19ck96 FIND v(dout1_19) AT=485.025n

* CHECK dout1_20 Vdout1_20ck96 = 0.9 time = 485
.meas tran vdout1_20ck96 FIND v(dout1_20) AT=485.025n

* CHECK dout1_21 Vdout1_21ck96 = 0 time = 485
.meas tran vdout1_21ck96 FIND v(dout1_21) AT=485.025n

* CHECK dout1_22 Vdout1_22ck96 = 0 time = 485
.meas tran vdout1_22ck96 FIND v(dout1_22) AT=485.025n

* CHECK dout1_23 Vdout1_23ck96 = 0 time = 485
.meas tran vdout1_23ck96 FIND v(dout1_23) AT=485.025n

* CHECK dout1_24 Vdout1_24ck96 = 0 time = 485
.meas tran vdout1_24ck96 FIND v(dout1_24) AT=485.025n

* CHECK dout1_25 Vdout1_25ck96 = 0.9 time = 485
.meas tran vdout1_25ck96 FIND v(dout1_25) AT=485.025n

* CHECK dout1_26 Vdout1_26ck96 = 0.9 time = 485
.meas tran vdout1_26ck96 FIND v(dout1_26) AT=485.025n

* CHECK dout1_27 Vdout1_27ck96 = 0 time = 485
.meas tran vdout1_27ck96 FIND v(dout1_27) AT=485.025n

* CHECK dout1_28 Vdout1_28ck96 = 0 time = 485
.meas tran vdout1_28ck96 FIND v(dout1_28) AT=485.025n

* CHECK dout1_29 Vdout1_29ck96 = 0.9 time = 485
.meas tran vdout1_29ck96 FIND v(dout1_29) AT=485.025n

* CHECK dout1_30 Vdout1_30ck96 = 0.9 time = 485
.meas tran vdout1_30ck96 FIND v(dout1_30) AT=485.025n

* CHECK dout1_31 Vdout1_31ck96 = 0 time = 485
.meas tran vdout1_31ck96 FIND v(dout1_31) AT=485.025n

* CHECK dout1_32 Vdout1_32ck96 = 0 time = 485
.meas tran vdout1_32ck96 FIND v(dout1_32) AT=485.025n

* CHECK dout1_33 Vdout1_33ck96 = 0.9 time = 485
.meas tran vdout1_33ck96 FIND v(dout1_33) AT=485.025n

* CHECK dout1_34 Vdout1_34ck96 = 0.9 time = 485
.meas tran vdout1_34ck96 FIND v(dout1_34) AT=485.025n

* CHECK dout1_35 Vdout1_35ck96 = 0.9 time = 485
.meas tran vdout1_35ck96 FIND v(dout1_35) AT=485.025n

* CHECK dout1_36 Vdout1_36ck96 = 0.9 time = 485
.meas tran vdout1_36ck96 FIND v(dout1_36) AT=485.025n

* CHECK dout1_37 Vdout1_37ck96 = 0 time = 485
.meas tran vdout1_37ck96 FIND v(dout1_37) AT=485.025n

* CHECK dout1_38 Vdout1_38ck96 = 0.9 time = 485
.meas tran vdout1_38ck96 FIND v(dout1_38) AT=485.025n

* CHECK dout1_39 Vdout1_39ck96 = 0 time = 485
.meas tran vdout1_39ck96 FIND v(dout1_39) AT=485.025n

* CHECK dout1_40 Vdout1_40ck96 = 0 time = 485
.meas tran vdout1_40ck96 FIND v(dout1_40) AT=485.025n

* CHECK dout1_41 Vdout1_41ck96 = 0.9 time = 485
.meas tran vdout1_41ck96 FIND v(dout1_41) AT=485.025n

* CHECK dout1_42 Vdout1_42ck96 = 0 time = 485
.meas tran vdout1_42ck96 FIND v(dout1_42) AT=485.025n

* CHECK dout1_43 Vdout1_43ck96 = 0 time = 485
.meas tran vdout1_43ck96 FIND v(dout1_43) AT=485.025n

* CHECK dout1_44 Vdout1_44ck96 = 0 time = 485
.meas tran vdout1_44ck96 FIND v(dout1_44) AT=485.025n

* CHECK dout1_45 Vdout1_45ck96 = 0.9 time = 485
.meas tran vdout1_45ck96 FIND v(dout1_45) AT=485.025n

* CHECK dout1_46 Vdout1_46ck96 = 0 time = 485
.meas tran vdout1_46ck96 FIND v(dout1_46) AT=485.025n

* CHECK dout1_47 Vdout1_47ck96 = 0 time = 485
.meas tran vdout1_47ck96 FIND v(dout1_47) AT=485.025n

* CHECK dout1_48 Vdout1_48ck96 = 0.9 time = 485
.meas tran vdout1_48ck96 FIND v(dout1_48) AT=485.025n

* CHECK dout1_49 Vdout1_49ck96 = 0.9 time = 485
.meas tran vdout1_49ck96 FIND v(dout1_49) AT=485.025n

* CHECK dout1_50 Vdout1_50ck96 = 0 time = 485
.meas tran vdout1_50ck96 FIND v(dout1_50) AT=485.025n

* CHECK dout1_51 Vdout1_51ck96 = 0.9 time = 485
.meas tran vdout1_51ck96 FIND v(dout1_51) AT=485.025n

* CHECK dout1_52 Vdout1_52ck96 = 0 time = 485
.meas tran vdout1_52ck96 FIND v(dout1_52) AT=485.025n

* CHECK dout1_53 Vdout1_53ck96 = 0 time = 485
.meas tran vdout1_53ck96 FIND v(dout1_53) AT=485.025n

* CHECK dout1_54 Vdout1_54ck96 = 0.9 time = 485
.meas tran vdout1_54ck96 FIND v(dout1_54) AT=485.025n

* CHECK dout1_55 Vdout1_55ck96 = 0.9 time = 485
.meas tran vdout1_55ck96 FIND v(dout1_55) AT=485.025n

* CHECK dout1_56 Vdout1_56ck96 = 0 time = 485
.meas tran vdout1_56ck96 FIND v(dout1_56) AT=485.025n

* CHECK dout1_57 Vdout1_57ck96 = 0.9 time = 485
.meas tran vdout1_57ck96 FIND v(dout1_57) AT=485.025n

* CHECK dout1_58 Vdout1_58ck96 = 0.9 time = 485
.meas tran vdout1_58ck96 FIND v(dout1_58) AT=485.025n

* CHECK dout1_59 Vdout1_59ck96 = 0.9 time = 485
.meas tran vdout1_59ck96 FIND v(dout1_59) AT=485.025n

* CHECK dout1_60 Vdout1_60ck96 = 0 time = 485
.meas tran vdout1_60ck96 FIND v(dout1_60) AT=485.025n

* CHECK dout1_61 Vdout1_61ck96 = 0.9 time = 485
.meas tran vdout1_61ck96 FIND v(dout1_61) AT=485.025n

* CHECK dout1_62 Vdout1_62ck96 = 0.9 time = 485
.meas tran vdout1_62ck96 FIND v(dout1_62) AT=485.025n

* CHECK dout1_63 Vdout1_63ck96 = 0 time = 485
.meas tran vdout1_63ck96 FIND v(dout1_63) AT=485.025n

* CHECK dout1_64 Vdout1_64ck96 = 0 time = 485
.meas tran vdout1_64ck96 FIND v(dout1_64) AT=485.025n

* CHECK dout1_65 Vdout1_65ck96 = 0 time = 485
.meas tran vdout1_65ck96 FIND v(dout1_65) AT=485.025n

* CHECK dout1_66 Vdout1_66ck96 = 0 time = 485
.meas tran vdout1_66ck96 FIND v(dout1_66) AT=485.025n

* CHECK dout1_67 Vdout1_67ck96 = 0 time = 485
.meas tran vdout1_67ck96 FIND v(dout1_67) AT=485.025n

* CHECK dout1_68 Vdout1_68ck96 = 0.9 time = 485
.meas tran vdout1_68ck96 FIND v(dout1_68) AT=485.025n

* CHECK dout1_69 Vdout1_69ck96 = 0 time = 485
.meas tran vdout1_69ck96 FIND v(dout1_69) AT=485.025n

* CHECK dout1_70 Vdout1_70ck96 = 0.9 time = 485
.meas tran vdout1_70ck96 FIND v(dout1_70) AT=485.025n

* CHECK dout1_71 Vdout1_71ck96 = 0.9 time = 485
.meas tran vdout1_71ck96 FIND v(dout1_71) AT=485.025n

* CHECK dout1_72 Vdout1_72ck96 = 0.9 time = 485
.meas tran vdout1_72ck96 FIND v(dout1_72) AT=485.025n

* CHECK dout1_73 Vdout1_73ck96 = 0 time = 485
.meas tran vdout1_73ck96 FIND v(dout1_73) AT=485.025n

* CHECK dout1_74 Vdout1_74ck96 = 0 time = 485
.meas tran vdout1_74ck96 FIND v(dout1_74) AT=485.025n

* CHECK dout1_75 Vdout1_75ck96 = 0.9 time = 485
.meas tran vdout1_75ck96 FIND v(dout1_75) AT=485.025n

* CHECK dout1_76 Vdout1_76ck96 = 0.9 time = 485
.meas tran vdout1_76ck96 FIND v(dout1_76) AT=485.025n

* CHECK dout1_77 Vdout1_77ck96 = 0 time = 485
.meas tran vdout1_77ck96 FIND v(dout1_77) AT=485.025n

* CHECK dout1_78 Vdout1_78ck96 = 0.9 time = 485
.meas tran vdout1_78ck96 FIND v(dout1_78) AT=485.025n

* CHECK dout1_79 Vdout1_79ck96 = 0 time = 485
.meas tran vdout1_79ck96 FIND v(dout1_79) AT=485.025n

* CHECK dout1_80 Vdout1_80ck96 = 0.9 time = 485
.meas tran vdout1_80ck96 FIND v(dout1_80) AT=485.025n

* CHECK dout1_81 Vdout1_81ck96 = 0.9 time = 485
.meas tran vdout1_81ck96 FIND v(dout1_81) AT=485.025n

* CHECK dout1_82 Vdout1_82ck96 = 0.9 time = 485
.meas tran vdout1_82ck96 FIND v(dout1_82) AT=485.025n

* CHECK dout1_83 Vdout1_83ck96 = 0.9 time = 485
.meas tran vdout1_83ck96 FIND v(dout1_83) AT=485.025n

* CHECK dout1_84 Vdout1_84ck96 = 0.9 time = 485
.meas tran vdout1_84ck96 FIND v(dout1_84) AT=485.025n

* CHECK dout1_85 Vdout1_85ck96 = 0.9 time = 485
.meas tran vdout1_85ck96 FIND v(dout1_85) AT=485.025n

* CHECK dout1_86 Vdout1_86ck96 = 0.9 time = 485
.meas tran vdout1_86ck96 FIND v(dout1_86) AT=485.025n

* CHECK dout1_87 Vdout1_87ck96 = 0 time = 485
.meas tran vdout1_87ck96 FIND v(dout1_87) AT=485.025n

* CHECK dout1_88 Vdout1_88ck96 = 0.9 time = 485
.meas tran vdout1_88ck96 FIND v(dout1_88) AT=485.025n

* CHECK dout1_89 Vdout1_89ck96 = 0.9 time = 485
.meas tran vdout1_89ck96 FIND v(dout1_89) AT=485.025n

* CHECK dout1_90 Vdout1_90ck96 = 0 time = 485
.meas tran vdout1_90ck96 FIND v(dout1_90) AT=485.025n

* CHECK dout1_91 Vdout1_91ck96 = 0.9 time = 485
.meas tran vdout1_91ck96 FIND v(dout1_91) AT=485.025n

* CHECK dout1_92 Vdout1_92ck96 = 0 time = 485
.meas tran vdout1_92ck96 FIND v(dout1_92) AT=485.025n

* CHECK dout1_93 Vdout1_93ck96 = 0.9 time = 485
.meas tran vdout1_93ck96 FIND v(dout1_93) AT=485.025n

* CHECK dout1_94 Vdout1_94ck96 = 0.9 time = 485
.meas tran vdout1_94ck96 FIND v(dout1_94) AT=485.025n

* CHECK dout1_95 Vdout1_95ck96 = 0.9 time = 485
.meas tran vdout1_95ck96 FIND v(dout1_95) AT=485.025n

* CHECK dout1_0 Vdout1_0ck101 = 0 time = 510
.meas tran vdout1_0ck101 FIND v(dout1_0) AT=510.025n

* CHECK dout1_1 Vdout1_1ck101 = 0.9 time = 510
.meas tran vdout1_1ck101 FIND v(dout1_1) AT=510.025n

* CHECK dout1_2 Vdout1_2ck101 = 0.9 time = 510
.meas tran vdout1_2ck101 FIND v(dout1_2) AT=510.025n

* CHECK dout1_3 Vdout1_3ck101 = 0.9 time = 510
.meas tran vdout1_3ck101 FIND v(dout1_3) AT=510.025n

* CHECK dout1_4 Vdout1_4ck101 = 0.9 time = 510
.meas tran vdout1_4ck101 FIND v(dout1_4) AT=510.025n

* CHECK dout1_5 Vdout1_5ck101 = 0 time = 510
.meas tran vdout1_5ck101 FIND v(dout1_5) AT=510.025n

* CHECK dout1_6 Vdout1_6ck101 = 0.9 time = 510
.meas tran vdout1_6ck101 FIND v(dout1_6) AT=510.025n

* CHECK dout1_7 Vdout1_7ck101 = 0 time = 510
.meas tran vdout1_7ck101 FIND v(dout1_7) AT=510.025n

* CHECK dout1_8 Vdout1_8ck101 = 0 time = 510
.meas tran vdout1_8ck101 FIND v(dout1_8) AT=510.025n

* CHECK dout1_9 Vdout1_9ck101 = 0 time = 510
.meas tran vdout1_9ck101 FIND v(dout1_9) AT=510.025n

* CHECK dout1_10 Vdout1_10ck101 = 0 time = 510
.meas tran vdout1_10ck101 FIND v(dout1_10) AT=510.025n

* CHECK dout1_11 Vdout1_11ck101 = 0.9 time = 510
.meas tran vdout1_11ck101 FIND v(dout1_11) AT=510.025n

* CHECK dout1_12 Vdout1_12ck101 = 0 time = 510
.meas tran vdout1_12ck101 FIND v(dout1_12) AT=510.025n

* CHECK dout1_13 Vdout1_13ck101 = 0 time = 510
.meas tran vdout1_13ck101 FIND v(dout1_13) AT=510.025n

* CHECK dout1_14 Vdout1_14ck101 = 0 time = 510
.meas tran vdout1_14ck101 FIND v(dout1_14) AT=510.025n

* CHECK dout1_15 Vdout1_15ck101 = 0.9 time = 510
.meas tran vdout1_15ck101 FIND v(dout1_15) AT=510.025n

* CHECK dout1_16 Vdout1_16ck101 = 0.9 time = 510
.meas tran vdout1_16ck101 FIND v(dout1_16) AT=510.025n

* CHECK dout1_17 Vdout1_17ck101 = 0 time = 510
.meas tran vdout1_17ck101 FIND v(dout1_17) AT=510.025n

* CHECK dout1_18 Vdout1_18ck101 = 0.9 time = 510
.meas tran vdout1_18ck101 FIND v(dout1_18) AT=510.025n

* CHECK dout1_19 Vdout1_19ck101 = 0.9 time = 510
.meas tran vdout1_19ck101 FIND v(dout1_19) AT=510.025n

* CHECK dout1_20 Vdout1_20ck101 = 0.9 time = 510
.meas tran vdout1_20ck101 FIND v(dout1_20) AT=510.025n

* CHECK dout1_21 Vdout1_21ck101 = 0.9 time = 510
.meas tran vdout1_21ck101 FIND v(dout1_21) AT=510.025n

* CHECK dout1_22 Vdout1_22ck101 = 0.9 time = 510
.meas tran vdout1_22ck101 FIND v(dout1_22) AT=510.025n

* CHECK dout1_23 Vdout1_23ck101 = 0.9 time = 510
.meas tran vdout1_23ck101 FIND v(dout1_23) AT=510.025n

* CHECK dout1_24 Vdout1_24ck101 = 0.9 time = 510
.meas tran vdout1_24ck101 FIND v(dout1_24) AT=510.025n

* CHECK dout1_25 Vdout1_25ck101 = 0.9 time = 510
.meas tran vdout1_25ck101 FIND v(dout1_25) AT=510.025n

* CHECK dout1_26 Vdout1_26ck101 = 0 time = 510
.meas tran vdout1_26ck101 FIND v(dout1_26) AT=510.025n

* CHECK dout1_27 Vdout1_27ck101 = 0 time = 510
.meas tran vdout1_27ck101 FIND v(dout1_27) AT=510.025n

* CHECK dout1_28 Vdout1_28ck101 = 0.9 time = 510
.meas tran vdout1_28ck101 FIND v(dout1_28) AT=510.025n

* CHECK dout1_29 Vdout1_29ck101 = 0 time = 510
.meas tran vdout1_29ck101 FIND v(dout1_29) AT=510.025n

* CHECK dout1_30 Vdout1_30ck101 = 0.9 time = 510
.meas tran vdout1_30ck101 FIND v(dout1_30) AT=510.025n

* CHECK dout1_31 Vdout1_31ck101 = 0 time = 510
.meas tran vdout1_31ck101 FIND v(dout1_31) AT=510.025n

* CHECK dout1_32 Vdout1_32ck101 = 0 time = 510
.meas tran vdout1_32ck101 FIND v(dout1_32) AT=510.025n

* CHECK dout1_33 Vdout1_33ck101 = 0.9 time = 510
.meas tran vdout1_33ck101 FIND v(dout1_33) AT=510.025n

* CHECK dout1_34 Vdout1_34ck101 = 0 time = 510
.meas tran vdout1_34ck101 FIND v(dout1_34) AT=510.025n

* CHECK dout1_35 Vdout1_35ck101 = 0.9 time = 510
.meas tran vdout1_35ck101 FIND v(dout1_35) AT=510.025n

* CHECK dout1_36 Vdout1_36ck101 = 0.9 time = 510
.meas tran vdout1_36ck101 FIND v(dout1_36) AT=510.025n

* CHECK dout1_37 Vdout1_37ck101 = 0.9 time = 510
.meas tran vdout1_37ck101 FIND v(dout1_37) AT=510.025n

* CHECK dout1_38 Vdout1_38ck101 = 0.9 time = 510
.meas tran vdout1_38ck101 FIND v(dout1_38) AT=510.025n

* CHECK dout1_39 Vdout1_39ck101 = 0 time = 510
.meas tran vdout1_39ck101 FIND v(dout1_39) AT=510.025n

* CHECK dout1_40 Vdout1_40ck101 = 0 time = 510
.meas tran vdout1_40ck101 FIND v(dout1_40) AT=510.025n

* CHECK dout1_41 Vdout1_41ck101 = 0.9 time = 510
.meas tran vdout1_41ck101 FIND v(dout1_41) AT=510.025n

* CHECK dout1_42 Vdout1_42ck101 = 0.9 time = 510
.meas tran vdout1_42ck101 FIND v(dout1_42) AT=510.025n

* CHECK dout1_43 Vdout1_43ck101 = 0.9 time = 510
.meas tran vdout1_43ck101 FIND v(dout1_43) AT=510.025n

* CHECK dout1_44 Vdout1_44ck101 = 0 time = 510
.meas tran vdout1_44ck101 FIND v(dout1_44) AT=510.025n

* CHECK dout1_45 Vdout1_45ck101 = 0.9 time = 510
.meas tran vdout1_45ck101 FIND v(dout1_45) AT=510.025n

* CHECK dout1_46 Vdout1_46ck101 = 0 time = 510
.meas tran vdout1_46ck101 FIND v(dout1_46) AT=510.025n

* CHECK dout1_47 Vdout1_47ck101 = 0.9 time = 510
.meas tran vdout1_47ck101 FIND v(dout1_47) AT=510.025n

* CHECK dout1_48 Vdout1_48ck101 = 0 time = 510
.meas tran vdout1_48ck101 FIND v(dout1_48) AT=510.025n

* CHECK dout1_49 Vdout1_49ck101 = 0 time = 510
.meas tran vdout1_49ck101 FIND v(dout1_49) AT=510.025n

* CHECK dout1_50 Vdout1_50ck101 = 0.9 time = 510
.meas tran vdout1_50ck101 FIND v(dout1_50) AT=510.025n

* CHECK dout1_51 Vdout1_51ck101 = 0.9 time = 510
.meas tran vdout1_51ck101 FIND v(dout1_51) AT=510.025n

* CHECK dout1_52 Vdout1_52ck101 = 0.9 time = 510
.meas tran vdout1_52ck101 FIND v(dout1_52) AT=510.025n

* CHECK dout1_53 Vdout1_53ck101 = 0 time = 510
.meas tran vdout1_53ck101 FIND v(dout1_53) AT=510.025n

* CHECK dout1_54 Vdout1_54ck101 = 0 time = 510
.meas tran vdout1_54ck101 FIND v(dout1_54) AT=510.025n

* CHECK dout1_55 Vdout1_55ck101 = 0.9 time = 510
.meas tran vdout1_55ck101 FIND v(dout1_55) AT=510.025n

* CHECK dout1_56 Vdout1_56ck101 = 0.9 time = 510
.meas tran vdout1_56ck101 FIND v(dout1_56) AT=510.025n

* CHECK dout1_57 Vdout1_57ck101 = 0.9 time = 510
.meas tran vdout1_57ck101 FIND v(dout1_57) AT=510.025n

* CHECK dout1_58 Vdout1_58ck101 = 0 time = 510
.meas tran vdout1_58ck101 FIND v(dout1_58) AT=510.025n

* CHECK dout1_59 Vdout1_59ck101 = 0 time = 510
.meas tran vdout1_59ck101 FIND v(dout1_59) AT=510.025n

* CHECK dout1_60 Vdout1_60ck101 = 0 time = 510
.meas tran vdout1_60ck101 FIND v(dout1_60) AT=510.025n

* CHECK dout1_61 Vdout1_61ck101 = 0 time = 510
.meas tran vdout1_61ck101 FIND v(dout1_61) AT=510.025n

* CHECK dout1_62 Vdout1_62ck101 = 0.9 time = 510
.meas tran vdout1_62ck101 FIND v(dout1_62) AT=510.025n

* CHECK dout1_63 Vdout1_63ck101 = 0 time = 510
.meas tran vdout1_63ck101 FIND v(dout1_63) AT=510.025n

* CHECK dout1_64 Vdout1_64ck101 = 0.9 time = 510
.meas tran vdout1_64ck101 FIND v(dout1_64) AT=510.025n

* CHECK dout1_65 Vdout1_65ck101 = 0.9 time = 510
.meas tran vdout1_65ck101 FIND v(dout1_65) AT=510.025n

* CHECK dout1_66 Vdout1_66ck101 = 0 time = 510
.meas tran vdout1_66ck101 FIND v(dout1_66) AT=510.025n

* CHECK dout1_67 Vdout1_67ck101 = 0 time = 510
.meas tran vdout1_67ck101 FIND v(dout1_67) AT=510.025n

* CHECK dout1_68 Vdout1_68ck101 = 0 time = 510
.meas tran vdout1_68ck101 FIND v(dout1_68) AT=510.025n

* CHECK dout1_69 Vdout1_69ck101 = 0.9 time = 510
.meas tran vdout1_69ck101 FIND v(dout1_69) AT=510.025n

* CHECK dout1_70 Vdout1_70ck101 = 0 time = 510
.meas tran vdout1_70ck101 FIND v(dout1_70) AT=510.025n

* CHECK dout1_71 Vdout1_71ck101 = 0.9 time = 510
.meas tran vdout1_71ck101 FIND v(dout1_71) AT=510.025n

* CHECK dout1_72 Vdout1_72ck101 = 0.9 time = 510
.meas tran vdout1_72ck101 FIND v(dout1_72) AT=510.025n

* CHECK dout1_73 Vdout1_73ck101 = 0 time = 510
.meas tran vdout1_73ck101 FIND v(dout1_73) AT=510.025n

* CHECK dout1_74 Vdout1_74ck101 = 0.9 time = 510
.meas tran vdout1_74ck101 FIND v(dout1_74) AT=510.025n

* CHECK dout1_75 Vdout1_75ck101 = 0.9 time = 510
.meas tran vdout1_75ck101 FIND v(dout1_75) AT=510.025n

* CHECK dout1_76 Vdout1_76ck101 = 0 time = 510
.meas tran vdout1_76ck101 FIND v(dout1_76) AT=510.025n

* CHECK dout1_77 Vdout1_77ck101 = 0.9 time = 510
.meas tran vdout1_77ck101 FIND v(dout1_77) AT=510.025n

* CHECK dout1_78 Vdout1_78ck101 = 0.9 time = 510
.meas tran vdout1_78ck101 FIND v(dout1_78) AT=510.025n

* CHECK dout1_79 Vdout1_79ck101 = 0 time = 510
.meas tran vdout1_79ck101 FIND v(dout1_79) AT=510.025n

* CHECK dout1_80 Vdout1_80ck101 = 0.9 time = 510
.meas tran vdout1_80ck101 FIND v(dout1_80) AT=510.025n

* CHECK dout1_81 Vdout1_81ck101 = 0.9 time = 510
.meas tran vdout1_81ck101 FIND v(dout1_81) AT=510.025n

* CHECK dout1_82 Vdout1_82ck101 = 0.9 time = 510
.meas tran vdout1_82ck101 FIND v(dout1_82) AT=510.025n

* CHECK dout1_83 Vdout1_83ck101 = 0 time = 510
.meas tran vdout1_83ck101 FIND v(dout1_83) AT=510.025n

* CHECK dout1_84 Vdout1_84ck101 = 0.9 time = 510
.meas tran vdout1_84ck101 FIND v(dout1_84) AT=510.025n

* CHECK dout1_85 Vdout1_85ck101 = 0.9 time = 510
.meas tran vdout1_85ck101 FIND v(dout1_85) AT=510.025n

* CHECK dout1_86 Vdout1_86ck101 = 0 time = 510
.meas tran vdout1_86ck101 FIND v(dout1_86) AT=510.025n

* CHECK dout1_87 Vdout1_87ck101 = 0 time = 510
.meas tran vdout1_87ck101 FIND v(dout1_87) AT=510.025n

* CHECK dout1_88 Vdout1_88ck101 = 0 time = 510
.meas tran vdout1_88ck101 FIND v(dout1_88) AT=510.025n

* CHECK dout1_89 Vdout1_89ck101 = 0.9 time = 510
.meas tran vdout1_89ck101 FIND v(dout1_89) AT=510.025n

* CHECK dout1_90 Vdout1_90ck101 = 0.9 time = 510
.meas tran vdout1_90ck101 FIND v(dout1_90) AT=510.025n

* CHECK dout1_91 Vdout1_91ck101 = 0.9 time = 510
.meas tran vdout1_91ck101 FIND v(dout1_91) AT=510.025n

* CHECK dout1_92 Vdout1_92ck101 = 0.9 time = 510
.meas tran vdout1_92ck101 FIND v(dout1_92) AT=510.025n

* CHECK dout1_93 Vdout1_93ck101 = 0 time = 510
.meas tran vdout1_93ck101 FIND v(dout1_93) AT=510.025n

* CHECK dout1_94 Vdout1_94ck101 = 0 time = 510
.meas tran vdout1_94ck101 FIND v(dout1_94) AT=510.025n

* CHECK dout1_95 Vdout1_95ck101 = 0.9 time = 510
.meas tran vdout1_95ck101 FIND v(dout1_95) AT=510.025n

* CHECK dout1_0 Vdout1_0ck103 = 0 time = 520
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=520.025n

* CHECK dout1_1 Vdout1_1ck103 = 0 time = 520
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=520.025n

* CHECK dout1_2 Vdout1_2ck103 = 0.9 time = 520
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=520.025n

* CHECK dout1_3 Vdout1_3ck103 = 0.9 time = 520
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=520.025n

* CHECK dout1_4 Vdout1_4ck103 = 0.9 time = 520
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=520.025n

* CHECK dout1_5 Vdout1_5ck103 = 0.9 time = 520
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=520.025n

* CHECK dout1_6 Vdout1_6ck103 = 0 time = 520
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=520.025n

* CHECK dout1_7 Vdout1_7ck103 = 0 time = 520
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=520.025n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 520
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=520.025n

* CHECK dout1_9 Vdout1_9ck103 = 0.9 time = 520
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=520.025n

* CHECK dout1_10 Vdout1_10ck103 = 0.9 time = 520
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=520.025n

* CHECK dout1_11 Vdout1_11ck103 = 0.9 time = 520
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=520.025n

* CHECK dout1_12 Vdout1_12ck103 = 0 time = 520
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=520.025n

* CHECK dout1_13 Vdout1_13ck103 = 0 time = 520
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=520.025n

* CHECK dout1_14 Vdout1_14ck103 = 0 time = 520
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=520.025n

* CHECK dout1_15 Vdout1_15ck103 = 0.9 time = 520
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=520.025n

* CHECK dout1_16 Vdout1_16ck103 = 0 time = 520
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=520.025n

* CHECK dout1_17 Vdout1_17ck103 = 0 time = 520
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=520.025n

* CHECK dout1_18 Vdout1_18ck103 = 0 time = 520
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=520.025n

* CHECK dout1_19 Vdout1_19ck103 = 0 time = 520
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=520.025n

* CHECK dout1_20 Vdout1_20ck103 = 0 time = 520
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=520.025n

* CHECK dout1_21 Vdout1_21ck103 = 0.9 time = 520
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=520.025n

* CHECK dout1_22 Vdout1_22ck103 = 0 time = 520
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=520.025n

* CHECK dout1_23 Vdout1_23ck103 = 0 time = 520
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=520.025n

* CHECK dout1_24 Vdout1_24ck103 = 0.9 time = 520
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=520.025n

* CHECK dout1_25 Vdout1_25ck103 = 0.9 time = 520
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=520.025n

* CHECK dout1_26 Vdout1_26ck103 = 0 time = 520
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=520.025n

* CHECK dout1_27 Vdout1_27ck103 = 0 time = 520
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=520.025n

* CHECK dout1_28 Vdout1_28ck103 = 0 time = 520
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=520.025n

* CHECK dout1_29 Vdout1_29ck103 = 0 time = 520
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=520.025n

* CHECK dout1_30 Vdout1_30ck103 = 0.9 time = 520
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=520.025n

* CHECK dout1_31 Vdout1_31ck103 = 0 time = 520
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=520.025n

* CHECK dout1_32 Vdout1_32ck103 = 0 time = 520
.meas tran vdout1_32ck103 FIND v(dout1_32) AT=520.025n

* CHECK dout1_33 Vdout1_33ck103 = 0 time = 520
.meas tran vdout1_33ck103 FIND v(dout1_33) AT=520.025n

* CHECK dout1_34 Vdout1_34ck103 = 0 time = 520
.meas tran vdout1_34ck103 FIND v(dout1_34) AT=520.025n

* CHECK dout1_35 Vdout1_35ck103 = 0.9 time = 520
.meas tran vdout1_35ck103 FIND v(dout1_35) AT=520.025n

* CHECK dout1_36 Vdout1_36ck103 = 0 time = 520
.meas tran vdout1_36ck103 FIND v(dout1_36) AT=520.025n

* CHECK dout1_37 Vdout1_37ck103 = 0 time = 520
.meas tran vdout1_37ck103 FIND v(dout1_37) AT=520.025n

* CHECK dout1_38 Vdout1_38ck103 = 0 time = 520
.meas tran vdout1_38ck103 FIND v(dout1_38) AT=520.025n

* CHECK dout1_39 Vdout1_39ck103 = 0.9 time = 520
.meas tran vdout1_39ck103 FIND v(dout1_39) AT=520.025n

* CHECK dout1_40 Vdout1_40ck103 = 0.9 time = 520
.meas tran vdout1_40ck103 FIND v(dout1_40) AT=520.025n

* CHECK dout1_41 Vdout1_41ck103 = 0.9 time = 520
.meas tran vdout1_41ck103 FIND v(dout1_41) AT=520.025n

* CHECK dout1_42 Vdout1_42ck103 = 0.9 time = 520
.meas tran vdout1_42ck103 FIND v(dout1_42) AT=520.025n

* CHECK dout1_43 Vdout1_43ck103 = 0 time = 520
.meas tran vdout1_43ck103 FIND v(dout1_43) AT=520.025n

* CHECK dout1_44 Vdout1_44ck103 = 0 time = 520
.meas tran vdout1_44ck103 FIND v(dout1_44) AT=520.025n

* CHECK dout1_45 Vdout1_45ck103 = 0 time = 520
.meas tran vdout1_45ck103 FIND v(dout1_45) AT=520.025n

* CHECK dout1_46 Vdout1_46ck103 = 0 time = 520
.meas tran vdout1_46ck103 FIND v(dout1_46) AT=520.025n

* CHECK dout1_47 Vdout1_47ck103 = 0 time = 520
.meas tran vdout1_47ck103 FIND v(dout1_47) AT=520.025n

* CHECK dout1_48 Vdout1_48ck103 = 0.9 time = 520
.meas tran vdout1_48ck103 FIND v(dout1_48) AT=520.025n

* CHECK dout1_49 Vdout1_49ck103 = 0.9 time = 520
.meas tran vdout1_49ck103 FIND v(dout1_49) AT=520.025n

* CHECK dout1_50 Vdout1_50ck103 = 0.9 time = 520
.meas tran vdout1_50ck103 FIND v(dout1_50) AT=520.025n

* CHECK dout1_51 Vdout1_51ck103 = 0.9 time = 520
.meas tran vdout1_51ck103 FIND v(dout1_51) AT=520.025n

* CHECK dout1_52 Vdout1_52ck103 = 0 time = 520
.meas tran vdout1_52ck103 FIND v(dout1_52) AT=520.025n

* CHECK dout1_53 Vdout1_53ck103 = 0.9 time = 520
.meas tran vdout1_53ck103 FIND v(dout1_53) AT=520.025n

* CHECK dout1_54 Vdout1_54ck103 = 0.9 time = 520
.meas tran vdout1_54ck103 FIND v(dout1_54) AT=520.025n

* CHECK dout1_55 Vdout1_55ck103 = 0.9 time = 520
.meas tran vdout1_55ck103 FIND v(dout1_55) AT=520.025n

* CHECK dout1_56 Vdout1_56ck103 = 0.9 time = 520
.meas tran vdout1_56ck103 FIND v(dout1_56) AT=520.025n

* CHECK dout1_57 Vdout1_57ck103 = 0 time = 520
.meas tran vdout1_57ck103 FIND v(dout1_57) AT=520.025n

* CHECK dout1_58 Vdout1_58ck103 = 0.9 time = 520
.meas tran vdout1_58ck103 FIND v(dout1_58) AT=520.025n

* CHECK dout1_59 Vdout1_59ck103 = 0 time = 520
.meas tran vdout1_59ck103 FIND v(dout1_59) AT=520.025n

* CHECK dout1_60 Vdout1_60ck103 = 0 time = 520
.meas tran vdout1_60ck103 FIND v(dout1_60) AT=520.025n

* CHECK dout1_61 Vdout1_61ck103 = 0.9 time = 520
.meas tran vdout1_61ck103 FIND v(dout1_61) AT=520.025n

* CHECK dout1_62 Vdout1_62ck103 = 0 time = 520
.meas tran vdout1_62ck103 FIND v(dout1_62) AT=520.025n

* CHECK dout1_63 Vdout1_63ck103 = 0 time = 520
.meas tran vdout1_63ck103 FIND v(dout1_63) AT=520.025n

* CHECK dout1_64 Vdout1_64ck103 = 0 time = 520
.meas tran vdout1_64ck103 FIND v(dout1_64) AT=520.025n

* CHECK dout1_65 Vdout1_65ck103 = 0 time = 520
.meas tran vdout1_65ck103 FIND v(dout1_65) AT=520.025n

* CHECK dout1_66 Vdout1_66ck103 = 0.9 time = 520
.meas tran vdout1_66ck103 FIND v(dout1_66) AT=520.025n

* CHECK dout1_67 Vdout1_67ck103 = 0.9 time = 520
.meas tran vdout1_67ck103 FIND v(dout1_67) AT=520.025n

* CHECK dout1_68 Vdout1_68ck103 = 0.9 time = 520
.meas tran vdout1_68ck103 FIND v(dout1_68) AT=520.025n

* CHECK dout1_69 Vdout1_69ck103 = 0.9 time = 520
.meas tran vdout1_69ck103 FIND v(dout1_69) AT=520.025n

* CHECK dout1_70 Vdout1_70ck103 = 0 time = 520
.meas tran vdout1_70ck103 FIND v(dout1_70) AT=520.025n

* CHECK dout1_71 Vdout1_71ck103 = 0.9 time = 520
.meas tran vdout1_71ck103 FIND v(dout1_71) AT=520.025n

* CHECK dout1_72 Vdout1_72ck103 = 0.9 time = 520
.meas tran vdout1_72ck103 FIND v(dout1_72) AT=520.025n

* CHECK dout1_73 Vdout1_73ck103 = 0.9 time = 520
.meas tran vdout1_73ck103 FIND v(dout1_73) AT=520.025n

* CHECK dout1_74 Vdout1_74ck103 = 0 time = 520
.meas tran vdout1_74ck103 FIND v(dout1_74) AT=520.025n

* CHECK dout1_75 Vdout1_75ck103 = 0.9 time = 520
.meas tran vdout1_75ck103 FIND v(dout1_75) AT=520.025n

* CHECK dout1_76 Vdout1_76ck103 = 0 time = 520
.meas tran vdout1_76ck103 FIND v(dout1_76) AT=520.025n

* CHECK dout1_77 Vdout1_77ck103 = 0.9 time = 520
.meas tran vdout1_77ck103 FIND v(dout1_77) AT=520.025n

* CHECK dout1_78 Vdout1_78ck103 = 0 time = 520
.meas tran vdout1_78ck103 FIND v(dout1_78) AT=520.025n

* CHECK dout1_79 Vdout1_79ck103 = 0 time = 520
.meas tran vdout1_79ck103 FIND v(dout1_79) AT=520.025n

* CHECK dout1_80 Vdout1_80ck103 = 0.9 time = 520
.meas tran vdout1_80ck103 FIND v(dout1_80) AT=520.025n

* CHECK dout1_81 Vdout1_81ck103 = 0.9 time = 520
.meas tran vdout1_81ck103 FIND v(dout1_81) AT=520.025n

* CHECK dout1_82 Vdout1_82ck103 = 0 time = 520
.meas tran vdout1_82ck103 FIND v(dout1_82) AT=520.025n

* CHECK dout1_83 Vdout1_83ck103 = 0 time = 520
.meas tran vdout1_83ck103 FIND v(dout1_83) AT=520.025n

* CHECK dout1_84 Vdout1_84ck103 = 0 time = 520
.meas tran vdout1_84ck103 FIND v(dout1_84) AT=520.025n

* CHECK dout1_85 Vdout1_85ck103 = 0.9 time = 520
.meas tran vdout1_85ck103 FIND v(dout1_85) AT=520.025n

* CHECK dout1_86 Vdout1_86ck103 = 0.9 time = 520
.meas tran vdout1_86ck103 FIND v(dout1_86) AT=520.025n

* CHECK dout1_87 Vdout1_87ck103 = 0.9 time = 520
.meas tran vdout1_87ck103 FIND v(dout1_87) AT=520.025n

* CHECK dout1_88 Vdout1_88ck103 = 0.9 time = 520
.meas tran vdout1_88ck103 FIND v(dout1_88) AT=520.025n

* CHECK dout1_89 Vdout1_89ck103 = 0 time = 520
.meas tran vdout1_89ck103 FIND v(dout1_89) AT=520.025n

* CHECK dout1_90 Vdout1_90ck103 = 0 time = 520
.meas tran vdout1_90ck103 FIND v(dout1_90) AT=520.025n

* CHECK dout1_91 Vdout1_91ck103 = 0 time = 520
.meas tran vdout1_91ck103 FIND v(dout1_91) AT=520.025n

* CHECK dout1_92 Vdout1_92ck103 = 0.9 time = 520
.meas tran vdout1_92ck103 FIND v(dout1_92) AT=520.025n

* CHECK dout1_93 Vdout1_93ck103 = 0 time = 520
.meas tran vdout1_93ck103 FIND v(dout1_93) AT=520.025n

* CHECK dout1_94 Vdout1_94ck103 = 0.9 time = 520
.meas tran vdout1_94ck103 FIND v(dout1_94) AT=520.025n

* CHECK dout1_95 Vdout1_95ck103 = 0.9 time = 520
.meas tran vdout1_95ck103 FIND v(dout1_95) AT=520.025n

* CHECK dout1_0 Vdout1_0ck105 = 0 time = 530
.meas tran vdout1_0ck105 FIND v(dout1_0) AT=530.025n

* CHECK dout1_1 Vdout1_1ck105 = 0 time = 530
.meas tran vdout1_1ck105 FIND v(dout1_1) AT=530.025n

* CHECK dout1_2 Vdout1_2ck105 = 0 time = 530
.meas tran vdout1_2ck105 FIND v(dout1_2) AT=530.025n

* CHECK dout1_3 Vdout1_3ck105 = 0 time = 530
.meas tran vdout1_3ck105 FIND v(dout1_3) AT=530.025n

* CHECK dout1_4 Vdout1_4ck105 = 0 time = 530
.meas tran vdout1_4ck105 FIND v(dout1_4) AT=530.025n

* CHECK dout1_5 Vdout1_5ck105 = 0 time = 530
.meas tran vdout1_5ck105 FIND v(dout1_5) AT=530.025n

* CHECK dout1_6 Vdout1_6ck105 = 0 time = 530
.meas tran vdout1_6ck105 FIND v(dout1_6) AT=530.025n

* CHECK dout1_7 Vdout1_7ck105 = 0 time = 530
.meas tran vdout1_7ck105 FIND v(dout1_7) AT=530.025n

* CHECK dout1_8 Vdout1_8ck105 = 0 time = 530
.meas tran vdout1_8ck105 FIND v(dout1_8) AT=530.025n

* CHECK dout1_9 Vdout1_9ck105 = 0 time = 530
.meas tran vdout1_9ck105 FIND v(dout1_9) AT=530.025n

* CHECK dout1_10 Vdout1_10ck105 = 0.9 time = 530
.meas tran vdout1_10ck105 FIND v(dout1_10) AT=530.025n

* CHECK dout1_11 Vdout1_11ck105 = 0 time = 530
.meas tran vdout1_11ck105 FIND v(dout1_11) AT=530.025n

* CHECK dout1_12 Vdout1_12ck105 = 0.9 time = 530
.meas tran vdout1_12ck105 FIND v(dout1_12) AT=530.025n

* CHECK dout1_13 Vdout1_13ck105 = 0.9 time = 530
.meas tran vdout1_13ck105 FIND v(dout1_13) AT=530.025n

* CHECK dout1_14 Vdout1_14ck105 = 0.9 time = 530
.meas tran vdout1_14ck105 FIND v(dout1_14) AT=530.025n

* CHECK dout1_15 Vdout1_15ck105 = 0 time = 530
.meas tran vdout1_15ck105 FIND v(dout1_15) AT=530.025n

* CHECK dout1_16 Vdout1_16ck105 = 0 time = 530
.meas tran vdout1_16ck105 FIND v(dout1_16) AT=530.025n

* CHECK dout1_17 Vdout1_17ck105 = 0.9 time = 530
.meas tran vdout1_17ck105 FIND v(dout1_17) AT=530.025n

* CHECK dout1_18 Vdout1_18ck105 = 0.9 time = 530
.meas tran vdout1_18ck105 FIND v(dout1_18) AT=530.025n

* CHECK dout1_19 Vdout1_19ck105 = 0.9 time = 530
.meas tran vdout1_19ck105 FIND v(dout1_19) AT=530.025n

* CHECK dout1_20 Vdout1_20ck105 = 0 time = 530
.meas tran vdout1_20ck105 FIND v(dout1_20) AT=530.025n

* CHECK dout1_21 Vdout1_21ck105 = 0 time = 530
.meas tran vdout1_21ck105 FIND v(dout1_21) AT=530.025n

* CHECK dout1_22 Vdout1_22ck105 = 0 time = 530
.meas tran vdout1_22ck105 FIND v(dout1_22) AT=530.025n

* CHECK dout1_23 Vdout1_23ck105 = 0.9 time = 530
.meas tran vdout1_23ck105 FIND v(dout1_23) AT=530.025n

* CHECK dout1_24 Vdout1_24ck105 = 0 time = 530
.meas tran vdout1_24ck105 FIND v(dout1_24) AT=530.025n

* CHECK dout1_25 Vdout1_25ck105 = 0 time = 530
.meas tran vdout1_25ck105 FIND v(dout1_25) AT=530.025n

* CHECK dout1_26 Vdout1_26ck105 = 0 time = 530
.meas tran vdout1_26ck105 FIND v(dout1_26) AT=530.025n

* CHECK dout1_27 Vdout1_27ck105 = 0 time = 530
.meas tran vdout1_27ck105 FIND v(dout1_27) AT=530.025n

* CHECK dout1_28 Vdout1_28ck105 = 0.9 time = 530
.meas tran vdout1_28ck105 FIND v(dout1_28) AT=530.025n

* CHECK dout1_29 Vdout1_29ck105 = 0 time = 530
.meas tran vdout1_29ck105 FIND v(dout1_29) AT=530.025n

* CHECK dout1_30 Vdout1_30ck105 = 0 time = 530
.meas tran vdout1_30ck105 FIND v(dout1_30) AT=530.025n

* CHECK dout1_31 Vdout1_31ck105 = 0 time = 530
.meas tran vdout1_31ck105 FIND v(dout1_31) AT=530.025n

* CHECK dout1_32 Vdout1_32ck105 = 0 time = 530
.meas tran vdout1_32ck105 FIND v(dout1_32) AT=530.025n

* CHECK dout1_33 Vdout1_33ck105 = 0.9 time = 530
.meas tran vdout1_33ck105 FIND v(dout1_33) AT=530.025n

* CHECK dout1_34 Vdout1_34ck105 = 0 time = 530
.meas tran vdout1_34ck105 FIND v(dout1_34) AT=530.025n

* CHECK dout1_35 Vdout1_35ck105 = 0.9 time = 530
.meas tran vdout1_35ck105 FIND v(dout1_35) AT=530.025n

* CHECK dout1_36 Vdout1_36ck105 = 0.9 time = 530
.meas tran vdout1_36ck105 FIND v(dout1_36) AT=530.025n

* CHECK dout1_37 Vdout1_37ck105 = 0.9 time = 530
.meas tran vdout1_37ck105 FIND v(dout1_37) AT=530.025n

* CHECK dout1_38 Vdout1_38ck105 = 0.9 time = 530
.meas tran vdout1_38ck105 FIND v(dout1_38) AT=530.025n

* CHECK dout1_39 Vdout1_39ck105 = 0 time = 530
.meas tran vdout1_39ck105 FIND v(dout1_39) AT=530.025n

* CHECK dout1_40 Vdout1_40ck105 = 0 time = 530
.meas tran vdout1_40ck105 FIND v(dout1_40) AT=530.025n

* CHECK dout1_41 Vdout1_41ck105 = 0.9 time = 530
.meas tran vdout1_41ck105 FIND v(dout1_41) AT=530.025n

* CHECK dout1_42 Vdout1_42ck105 = 0.9 time = 530
.meas tran vdout1_42ck105 FIND v(dout1_42) AT=530.025n

* CHECK dout1_43 Vdout1_43ck105 = 0.9 time = 530
.meas tran vdout1_43ck105 FIND v(dout1_43) AT=530.025n

* CHECK dout1_44 Vdout1_44ck105 = 0 time = 530
.meas tran vdout1_44ck105 FIND v(dout1_44) AT=530.025n

* CHECK dout1_45 Vdout1_45ck105 = 0.9 time = 530
.meas tran vdout1_45ck105 FIND v(dout1_45) AT=530.025n

* CHECK dout1_46 Vdout1_46ck105 = 0 time = 530
.meas tran vdout1_46ck105 FIND v(dout1_46) AT=530.025n

* CHECK dout1_47 Vdout1_47ck105 = 0.9 time = 530
.meas tran vdout1_47ck105 FIND v(dout1_47) AT=530.025n

* CHECK dout1_48 Vdout1_48ck105 = 0 time = 530
.meas tran vdout1_48ck105 FIND v(dout1_48) AT=530.025n

* CHECK dout1_49 Vdout1_49ck105 = 0 time = 530
.meas tran vdout1_49ck105 FIND v(dout1_49) AT=530.025n

* CHECK dout1_50 Vdout1_50ck105 = 0.9 time = 530
.meas tran vdout1_50ck105 FIND v(dout1_50) AT=530.025n

* CHECK dout1_51 Vdout1_51ck105 = 0.9 time = 530
.meas tran vdout1_51ck105 FIND v(dout1_51) AT=530.025n

* CHECK dout1_52 Vdout1_52ck105 = 0.9 time = 530
.meas tran vdout1_52ck105 FIND v(dout1_52) AT=530.025n

* CHECK dout1_53 Vdout1_53ck105 = 0 time = 530
.meas tran vdout1_53ck105 FIND v(dout1_53) AT=530.025n

* CHECK dout1_54 Vdout1_54ck105 = 0 time = 530
.meas tran vdout1_54ck105 FIND v(dout1_54) AT=530.025n

* CHECK dout1_55 Vdout1_55ck105 = 0.9 time = 530
.meas tran vdout1_55ck105 FIND v(dout1_55) AT=530.025n

* CHECK dout1_56 Vdout1_56ck105 = 0.9 time = 530
.meas tran vdout1_56ck105 FIND v(dout1_56) AT=530.025n

* CHECK dout1_57 Vdout1_57ck105 = 0.9 time = 530
.meas tran vdout1_57ck105 FIND v(dout1_57) AT=530.025n

* CHECK dout1_58 Vdout1_58ck105 = 0 time = 530
.meas tran vdout1_58ck105 FIND v(dout1_58) AT=530.025n

* CHECK dout1_59 Vdout1_59ck105 = 0 time = 530
.meas tran vdout1_59ck105 FIND v(dout1_59) AT=530.025n

* CHECK dout1_60 Vdout1_60ck105 = 0 time = 530
.meas tran vdout1_60ck105 FIND v(dout1_60) AT=530.025n

* CHECK dout1_61 Vdout1_61ck105 = 0 time = 530
.meas tran vdout1_61ck105 FIND v(dout1_61) AT=530.025n

* CHECK dout1_62 Vdout1_62ck105 = 0.9 time = 530
.meas tran vdout1_62ck105 FIND v(dout1_62) AT=530.025n

* CHECK dout1_63 Vdout1_63ck105 = 0 time = 530
.meas tran vdout1_63ck105 FIND v(dout1_63) AT=530.025n

* CHECK dout1_64 Vdout1_64ck105 = 0.9 time = 530
.meas tran vdout1_64ck105 FIND v(dout1_64) AT=530.025n

* CHECK dout1_65 Vdout1_65ck105 = 0.9 time = 530
.meas tran vdout1_65ck105 FIND v(dout1_65) AT=530.025n

* CHECK dout1_66 Vdout1_66ck105 = 0.9 time = 530
.meas tran vdout1_66ck105 FIND v(dout1_66) AT=530.025n

* CHECK dout1_67 Vdout1_67ck105 = 0.9 time = 530
.meas tran vdout1_67ck105 FIND v(dout1_67) AT=530.025n

* CHECK dout1_68 Vdout1_68ck105 = 0 time = 530
.meas tran vdout1_68ck105 FIND v(dout1_68) AT=530.025n

* CHECK dout1_69 Vdout1_69ck105 = 0 time = 530
.meas tran vdout1_69ck105 FIND v(dout1_69) AT=530.025n

* CHECK dout1_70 Vdout1_70ck105 = 0 time = 530
.meas tran vdout1_70ck105 FIND v(dout1_70) AT=530.025n

* CHECK dout1_71 Vdout1_71ck105 = 0.9 time = 530
.meas tran vdout1_71ck105 FIND v(dout1_71) AT=530.025n

* CHECK dout1_72 Vdout1_72ck105 = 0.9 time = 530
.meas tran vdout1_72ck105 FIND v(dout1_72) AT=530.025n

* CHECK dout1_73 Vdout1_73ck105 = 0 time = 530
.meas tran vdout1_73ck105 FIND v(dout1_73) AT=530.025n

* CHECK dout1_74 Vdout1_74ck105 = 0 time = 530
.meas tran vdout1_74ck105 FIND v(dout1_74) AT=530.025n

* CHECK dout1_75 Vdout1_75ck105 = 0 time = 530
.meas tran vdout1_75ck105 FIND v(dout1_75) AT=530.025n

* CHECK dout1_76 Vdout1_76ck105 = 0.9 time = 530
.meas tran vdout1_76ck105 FIND v(dout1_76) AT=530.025n

* CHECK dout1_77 Vdout1_77ck105 = 0.9 time = 530
.meas tran vdout1_77ck105 FIND v(dout1_77) AT=530.025n

* CHECK dout1_78 Vdout1_78ck105 = 0 time = 530
.meas tran vdout1_78ck105 FIND v(dout1_78) AT=530.025n

* CHECK dout1_79 Vdout1_79ck105 = 0.9 time = 530
.meas tran vdout1_79ck105 FIND v(dout1_79) AT=530.025n

* CHECK dout1_80 Vdout1_80ck105 = 0.9 time = 530
.meas tran vdout1_80ck105 FIND v(dout1_80) AT=530.025n

* CHECK dout1_81 Vdout1_81ck105 = 0 time = 530
.meas tran vdout1_81ck105 FIND v(dout1_81) AT=530.025n

* CHECK dout1_82 Vdout1_82ck105 = 0 time = 530
.meas tran vdout1_82ck105 FIND v(dout1_82) AT=530.025n

* CHECK dout1_83 Vdout1_83ck105 = 0.9 time = 530
.meas tran vdout1_83ck105 FIND v(dout1_83) AT=530.025n

* CHECK dout1_84 Vdout1_84ck105 = 0.9 time = 530
.meas tran vdout1_84ck105 FIND v(dout1_84) AT=530.025n

* CHECK dout1_85 Vdout1_85ck105 = 0.9 time = 530
.meas tran vdout1_85ck105 FIND v(dout1_85) AT=530.025n

* CHECK dout1_86 Vdout1_86ck105 = 0.9 time = 530
.meas tran vdout1_86ck105 FIND v(dout1_86) AT=530.025n

* CHECK dout1_87 Vdout1_87ck105 = 0.9 time = 530
.meas tran vdout1_87ck105 FIND v(dout1_87) AT=530.025n

* CHECK dout1_88 Vdout1_88ck105 = 0 time = 530
.meas tran vdout1_88ck105 FIND v(dout1_88) AT=530.025n

* CHECK dout1_89 Vdout1_89ck105 = 0 time = 530
.meas tran vdout1_89ck105 FIND v(dout1_89) AT=530.025n

* CHECK dout1_90 Vdout1_90ck105 = 0 time = 530
.meas tran vdout1_90ck105 FIND v(dout1_90) AT=530.025n

* CHECK dout1_91 Vdout1_91ck105 = 0.9 time = 530
.meas tran vdout1_91ck105 FIND v(dout1_91) AT=530.025n

* CHECK dout1_92 Vdout1_92ck105 = 0.9 time = 530
.meas tran vdout1_92ck105 FIND v(dout1_92) AT=530.025n

* CHECK dout1_93 Vdout1_93ck105 = 0 time = 530
.meas tran vdout1_93ck105 FIND v(dout1_93) AT=530.025n

* CHECK dout1_94 Vdout1_94ck105 = 0 time = 530
.meas tran vdout1_94ck105 FIND v(dout1_94) AT=530.025n

* CHECK dout1_95 Vdout1_95ck105 = 0 time = 530
.meas tran vdout1_95ck105 FIND v(dout1_95) AT=530.025n

* CHECK dout1_0 Vdout1_0ck107 = 0 time = 540
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=540.025n

* CHECK dout1_1 Vdout1_1ck107 = 0 time = 540
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=540.025n

* CHECK dout1_2 Vdout1_2ck107 = 0 time = 540
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=540.025n

* CHECK dout1_3 Vdout1_3ck107 = 0 time = 540
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=540.025n

* CHECK dout1_4 Vdout1_4ck107 = 0 time = 540
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=540.025n

* CHECK dout1_5 Vdout1_5ck107 = 0 time = 540
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=540.025n

* CHECK dout1_6 Vdout1_6ck107 = 0 time = 540
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=540.025n

* CHECK dout1_7 Vdout1_7ck107 = 0 time = 540
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=540.025n

* CHECK dout1_8 Vdout1_8ck107 = 0 time = 540
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=540.025n

* CHECK dout1_9 Vdout1_9ck107 = 0 time = 540
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=540.025n

* CHECK dout1_10 Vdout1_10ck107 = 0.9 time = 540
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=540.025n

* CHECK dout1_11 Vdout1_11ck107 = 0 time = 540
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=540.025n

* CHECK dout1_12 Vdout1_12ck107 = 0.9 time = 540
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=540.025n

* CHECK dout1_13 Vdout1_13ck107 = 0.9 time = 540
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=540.025n

* CHECK dout1_14 Vdout1_14ck107 = 0.9 time = 540
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=540.025n

* CHECK dout1_15 Vdout1_15ck107 = 0 time = 540
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=540.025n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 540
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=540.025n

* CHECK dout1_17 Vdout1_17ck107 = 0.9 time = 540
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=540.025n

* CHECK dout1_18 Vdout1_18ck107 = 0.9 time = 540
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=540.025n

* CHECK dout1_19 Vdout1_19ck107 = 0.9 time = 540
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=540.025n

* CHECK dout1_20 Vdout1_20ck107 = 0 time = 540
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=540.025n

* CHECK dout1_21 Vdout1_21ck107 = 0 time = 540
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=540.025n

* CHECK dout1_22 Vdout1_22ck107 = 0 time = 540
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=540.025n

* CHECK dout1_23 Vdout1_23ck107 = 0.9 time = 540
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=540.025n

* CHECK dout1_24 Vdout1_24ck107 = 0 time = 540
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=540.025n

* CHECK dout1_25 Vdout1_25ck107 = 0 time = 540
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=540.025n

* CHECK dout1_26 Vdout1_26ck107 = 0 time = 540
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=540.025n

* CHECK dout1_27 Vdout1_27ck107 = 0 time = 540
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=540.025n

* CHECK dout1_28 Vdout1_28ck107 = 0.9 time = 540
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=540.025n

* CHECK dout1_29 Vdout1_29ck107 = 0 time = 540
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=540.025n

* CHECK dout1_30 Vdout1_30ck107 = 0 time = 540
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=540.025n

* CHECK dout1_31 Vdout1_31ck107 = 0 time = 540
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=540.025n

* CHECK dout1_32 Vdout1_32ck107 = 0.9 time = 540
.meas tran vdout1_32ck107 FIND v(dout1_32) AT=540.025n

* CHECK dout1_33 Vdout1_33ck107 = 0 time = 540
.meas tran vdout1_33ck107 FIND v(dout1_33) AT=540.025n

* CHECK dout1_34 Vdout1_34ck107 = 0.9 time = 540
.meas tran vdout1_34ck107 FIND v(dout1_34) AT=540.025n

* CHECK dout1_35 Vdout1_35ck107 = 0 time = 540
.meas tran vdout1_35ck107 FIND v(dout1_35) AT=540.025n

* CHECK dout1_36 Vdout1_36ck107 = 0 time = 540
.meas tran vdout1_36ck107 FIND v(dout1_36) AT=540.025n

* CHECK dout1_37 Vdout1_37ck107 = 0.9 time = 540
.meas tran vdout1_37ck107 FIND v(dout1_37) AT=540.025n

* CHECK dout1_38 Vdout1_38ck107 = 0.9 time = 540
.meas tran vdout1_38ck107 FIND v(dout1_38) AT=540.025n

* CHECK dout1_39 Vdout1_39ck107 = 0 time = 540
.meas tran vdout1_39ck107 FIND v(dout1_39) AT=540.025n

* CHECK dout1_40 Vdout1_40ck107 = 0.9 time = 540
.meas tran vdout1_40ck107 FIND v(dout1_40) AT=540.025n

* CHECK dout1_41 Vdout1_41ck107 = 0.9 time = 540
.meas tran vdout1_41ck107 FIND v(dout1_41) AT=540.025n

* CHECK dout1_42 Vdout1_42ck107 = 0 time = 540
.meas tran vdout1_42ck107 FIND v(dout1_42) AT=540.025n

* CHECK dout1_43 Vdout1_43ck107 = 0.9 time = 540
.meas tran vdout1_43ck107 FIND v(dout1_43) AT=540.025n

* CHECK dout1_44 Vdout1_44ck107 = 0.9 time = 540
.meas tran vdout1_44ck107 FIND v(dout1_44) AT=540.025n

* CHECK dout1_45 Vdout1_45ck107 = 0.9 time = 540
.meas tran vdout1_45ck107 FIND v(dout1_45) AT=540.025n

* CHECK dout1_46 Vdout1_46ck107 = 0 time = 540
.meas tran vdout1_46ck107 FIND v(dout1_46) AT=540.025n

* CHECK dout1_47 Vdout1_47ck107 = 0.9 time = 540
.meas tran vdout1_47ck107 FIND v(dout1_47) AT=540.025n

* CHECK dout1_48 Vdout1_48ck107 = 0 time = 540
.meas tran vdout1_48ck107 FIND v(dout1_48) AT=540.025n

* CHECK dout1_49 Vdout1_49ck107 = 0 time = 540
.meas tran vdout1_49ck107 FIND v(dout1_49) AT=540.025n

* CHECK dout1_50 Vdout1_50ck107 = 0 time = 540
.meas tran vdout1_50ck107 FIND v(dout1_50) AT=540.025n

* CHECK dout1_51 Vdout1_51ck107 = 0.9 time = 540
.meas tran vdout1_51ck107 FIND v(dout1_51) AT=540.025n

* CHECK dout1_52 Vdout1_52ck107 = 0.9 time = 540
.meas tran vdout1_52ck107 FIND v(dout1_52) AT=540.025n

* CHECK dout1_53 Vdout1_53ck107 = 0.9 time = 540
.meas tran vdout1_53ck107 FIND v(dout1_53) AT=540.025n

* CHECK dout1_54 Vdout1_54ck107 = 0 time = 540
.meas tran vdout1_54ck107 FIND v(dout1_54) AT=540.025n

* CHECK dout1_55 Vdout1_55ck107 = 0.9 time = 540
.meas tran vdout1_55ck107 FIND v(dout1_55) AT=540.025n

* CHECK dout1_56 Vdout1_56ck107 = 0 time = 540
.meas tran vdout1_56ck107 FIND v(dout1_56) AT=540.025n

* CHECK dout1_57 Vdout1_57ck107 = 0.9 time = 540
.meas tran vdout1_57ck107 FIND v(dout1_57) AT=540.025n

* CHECK dout1_58 Vdout1_58ck107 = 0 time = 540
.meas tran vdout1_58ck107 FIND v(dout1_58) AT=540.025n

* CHECK dout1_59 Vdout1_59ck107 = 0 time = 540
.meas tran vdout1_59ck107 FIND v(dout1_59) AT=540.025n

* CHECK dout1_60 Vdout1_60ck107 = 0.9 time = 540
.meas tran vdout1_60ck107 FIND v(dout1_60) AT=540.025n

* CHECK dout1_61 Vdout1_61ck107 = 0.9 time = 540
.meas tran vdout1_61ck107 FIND v(dout1_61) AT=540.025n

* CHECK dout1_62 Vdout1_62ck107 = 0.9 time = 540
.meas tran vdout1_62ck107 FIND v(dout1_62) AT=540.025n

* CHECK dout1_63 Vdout1_63ck107 = 0 time = 540
.meas tran vdout1_63ck107 FIND v(dout1_63) AT=540.025n

* CHECK dout1_64 Vdout1_64ck107 = 0.9 time = 540
.meas tran vdout1_64ck107 FIND v(dout1_64) AT=540.025n

* CHECK dout1_65 Vdout1_65ck107 = 0.9 time = 540
.meas tran vdout1_65ck107 FIND v(dout1_65) AT=540.025n

* CHECK dout1_66 Vdout1_66ck107 = 0.9 time = 540
.meas tran vdout1_66ck107 FIND v(dout1_66) AT=540.025n

* CHECK dout1_67 Vdout1_67ck107 = 0.9 time = 540
.meas tran vdout1_67ck107 FIND v(dout1_67) AT=540.025n

* CHECK dout1_68 Vdout1_68ck107 = 0 time = 540
.meas tran vdout1_68ck107 FIND v(dout1_68) AT=540.025n

* CHECK dout1_69 Vdout1_69ck107 = 0 time = 540
.meas tran vdout1_69ck107 FIND v(dout1_69) AT=540.025n

* CHECK dout1_70 Vdout1_70ck107 = 0 time = 540
.meas tran vdout1_70ck107 FIND v(dout1_70) AT=540.025n

* CHECK dout1_71 Vdout1_71ck107 = 0.9 time = 540
.meas tran vdout1_71ck107 FIND v(dout1_71) AT=540.025n

* CHECK dout1_72 Vdout1_72ck107 = 0.9 time = 540
.meas tran vdout1_72ck107 FIND v(dout1_72) AT=540.025n

* CHECK dout1_73 Vdout1_73ck107 = 0 time = 540
.meas tran vdout1_73ck107 FIND v(dout1_73) AT=540.025n

* CHECK dout1_74 Vdout1_74ck107 = 0 time = 540
.meas tran vdout1_74ck107 FIND v(dout1_74) AT=540.025n

* CHECK dout1_75 Vdout1_75ck107 = 0 time = 540
.meas tran vdout1_75ck107 FIND v(dout1_75) AT=540.025n

* CHECK dout1_76 Vdout1_76ck107 = 0.9 time = 540
.meas tran vdout1_76ck107 FIND v(dout1_76) AT=540.025n

* CHECK dout1_77 Vdout1_77ck107 = 0.9 time = 540
.meas tran vdout1_77ck107 FIND v(dout1_77) AT=540.025n

* CHECK dout1_78 Vdout1_78ck107 = 0 time = 540
.meas tran vdout1_78ck107 FIND v(dout1_78) AT=540.025n

* CHECK dout1_79 Vdout1_79ck107 = 0.9 time = 540
.meas tran vdout1_79ck107 FIND v(dout1_79) AT=540.025n

* CHECK dout1_80 Vdout1_80ck107 = 0.9 time = 540
.meas tran vdout1_80ck107 FIND v(dout1_80) AT=540.025n

* CHECK dout1_81 Vdout1_81ck107 = 0 time = 540
.meas tran vdout1_81ck107 FIND v(dout1_81) AT=540.025n

* CHECK dout1_82 Vdout1_82ck107 = 0 time = 540
.meas tran vdout1_82ck107 FIND v(dout1_82) AT=540.025n

* CHECK dout1_83 Vdout1_83ck107 = 0.9 time = 540
.meas tran vdout1_83ck107 FIND v(dout1_83) AT=540.025n

* CHECK dout1_84 Vdout1_84ck107 = 0.9 time = 540
.meas tran vdout1_84ck107 FIND v(dout1_84) AT=540.025n

* CHECK dout1_85 Vdout1_85ck107 = 0.9 time = 540
.meas tran vdout1_85ck107 FIND v(dout1_85) AT=540.025n

* CHECK dout1_86 Vdout1_86ck107 = 0.9 time = 540
.meas tran vdout1_86ck107 FIND v(dout1_86) AT=540.025n

* CHECK dout1_87 Vdout1_87ck107 = 0.9 time = 540
.meas tran vdout1_87ck107 FIND v(dout1_87) AT=540.025n

* CHECK dout1_88 Vdout1_88ck107 = 0 time = 540
.meas tran vdout1_88ck107 FIND v(dout1_88) AT=540.025n

* CHECK dout1_89 Vdout1_89ck107 = 0 time = 540
.meas tran vdout1_89ck107 FIND v(dout1_89) AT=540.025n

* CHECK dout1_90 Vdout1_90ck107 = 0 time = 540
.meas tran vdout1_90ck107 FIND v(dout1_90) AT=540.025n

* CHECK dout1_91 Vdout1_91ck107 = 0.9 time = 540
.meas tran vdout1_91ck107 FIND v(dout1_91) AT=540.025n

* CHECK dout1_92 Vdout1_92ck107 = 0.9 time = 540
.meas tran vdout1_92ck107 FIND v(dout1_92) AT=540.025n

* CHECK dout1_93 Vdout1_93ck107 = 0 time = 540
.meas tran vdout1_93ck107 FIND v(dout1_93) AT=540.025n

* CHECK dout1_94 Vdout1_94ck107 = 0 time = 540
.meas tran vdout1_94ck107 FIND v(dout1_94) AT=540.025n

* CHECK dout1_95 Vdout1_95ck107 = 0 time = 540
.meas tran vdout1_95ck107 FIND v(dout1_95) AT=540.025n

* CHECK dout1_0 Vdout1_0ck110 = 0.9 time = 555
.meas tran vdout1_0ck110 FIND v(dout1_0) AT=555.025n

* CHECK dout1_1 Vdout1_1ck110 = 0.9 time = 555
.meas tran vdout1_1ck110 FIND v(dout1_1) AT=555.025n

* CHECK dout1_2 Vdout1_2ck110 = 0 time = 555
.meas tran vdout1_2ck110 FIND v(dout1_2) AT=555.025n

* CHECK dout1_3 Vdout1_3ck110 = 0 time = 555
.meas tran vdout1_3ck110 FIND v(dout1_3) AT=555.025n

* CHECK dout1_4 Vdout1_4ck110 = 0.9 time = 555
.meas tran vdout1_4ck110 FIND v(dout1_4) AT=555.025n

* CHECK dout1_5 Vdout1_5ck110 = 0.9 time = 555
.meas tran vdout1_5ck110 FIND v(dout1_5) AT=555.025n

* CHECK dout1_6 Vdout1_6ck110 = 0.9 time = 555
.meas tran vdout1_6ck110 FIND v(dout1_6) AT=555.025n

* CHECK dout1_7 Vdout1_7ck110 = 0.9 time = 555
.meas tran vdout1_7ck110 FIND v(dout1_7) AT=555.025n

* CHECK dout1_8 Vdout1_8ck110 = 0.9 time = 555
.meas tran vdout1_8ck110 FIND v(dout1_8) AT=555.025n

* CHECK dout1_9 Vdout1_9ck110 = 0 time = 555
.meas tran vdout1_9ck110 FIND v(dout1_9) AT=555.025n

* CHECK dout1_10 Vdout1_10ck110 = 0.9 time = 555
.meas tran vdout1_10ck110 FIND v(dout1_10) AT=555.025n

* CHECK dout1_11 Vdout1_11ck110 = 0 time = 555
.meas tran vdout1_11ck110 FIND v(dout1_11) AT=555.025n

* CHECK dout1_12 Vdout1_12ck110 = 0.9 time = 555
.meas tran vdout1_12ck110 FIND v(dout1_12) AT=555.025n

* CHECK dout1_13 Vdout1_13ck110 = 0.9 time = 555
.meas tran vdout1_13ck110 FIND v(dout1_13) AT=555.025n

* CHECK dout1_14 Vdout1_14ck110 = 0 time = 555
.meas tran vdout1_14ck110 FIND v(dout1_14) AT=555.025n

* CHECK dout1_15 Vdout1_15ck110 = 0.9 time = 555
.meas tran vdout1_15ck110 FIND v(dout1_15) AT=555.025n

* CHECK dout1_16 Vdout1_16ck110 = 0.9 time = 555
.meas tran vdout1_16ck110 FIND v(dout1_16) AT=555.025n

* CHECK dout1_17 Vdout1_17ck110 = 0 time = 555
.meas tran vdout1_17ck110 FIND v(dout1_17) AT=555.025n

* CHECK dout1_18 Vdout1_18ck110 = 0 time = 555
.meas tran vdout1_18ck110 FIND v(dout1_18) AT=555.025n

* CHECK dout1_19 Vdout1_19ck110 = 0 time = 555
.meas tran vdout1_19ck110 FIND v(dout1_19) AT=555.025n

* CHECK dout1_20 Vdout1_20ck110 = 0 time = 555
.meas tran vdout1_20ck110 FIND v(dout1_20) AT=555.025n

* CHECK dout1_21 Vdout1_21ck110 = 0.9 time = 555
.meas tran vdout1_21ck110 FIND v(dout1_21) AT=555.025n

* CHECK dout1_22 Vdout1_22ck110 = 0 time = 555
.meas tran vdout1_22ck110 FIND v(dout1_22) AT=555.025n

* CHECK dout1_23 Vdout1_23ck110 = 0 time = 555
.meas tran vdout1_23ck110 FIND v(dout1_23) AT=555.025n

* CHECK dout1_24 Vdout1_24ck110 = 0.9 time = 555
.meas tran vdout1_24ck110 FIND v(dout1_24) AT=555.025n

* CHECK dout1_25 Vdout1_25ck110 = 0 time = 555
.meas tran vdout1_25ck110 FIND v(dout1_25) AT=555.025n

* CHECK dout1_26 Vdout1_26ck110 = 0 time = 555
.meas tran vdout1_26ck110 FIND v(dout1_26) AT=555.025n

* CHECK dout1_27 Vdout1_27ck110 = 0 time = 555
.meas tran vdout1_27ck110 FIND v(dout1_27) AT=555.025n

* CHECK dout1_28 Vdout1_28ck110 = 0.9 time = 555
.meas tran vdout1_28ck110 FIND v(dout1_28) AT=555.025n

* CHECK dout1_29 Vdout1_29ck110 = 0 time = 555
.meas tran vdout1_29ck110 FIND v(dout1_29) AT=555.025n

* CHECK dout1_30 Vdout1_30ck110 = 0.9 time = 555
.meas tran vdout1_30ck110 FIND v(dout1_30) AT=555.025n

* CHECK dout1_31 Vdout1_31ck110 = 0 time = 555
.meas tran vdout1_31ck110 FIND v(dout1_31) AT=555.025n

* CHECK dout1_32 Vdout1_32ck110 = 0.9 time = 555
.meas tran vdout1_32ck110 FIND v(dout1_32) AT=555.025n

* CHECK dout1_33 Vdout1_33ck110 = 0 time = 555
.meas tran vdout1_33ck110 FIND v(dout1_33) AT=555.025n

* CHECK dout1_34 Vdout1_34ck110 = 0.9 time = 555
.meas tran vdout1_34ck110 FIND v(dout1_34) AT=555.025n

* CHECK dout1_35 Vdout1_35ck110 = 0 time = 555
.meas tran vdout1_35ck110 FIND v(dout1_35) AT=555.025n

* CHECK dout1_36 Vdout1_36ck110 = 0 time = 555
.meas tran vdout1_36ck110 FIND v(dout1_36) AT=555.025n

* CHECK dout1_37 Vdout1_37ck110 = 0.9 time = 555
.meas tran vdout1_37ck110 FIND v(dout1_37) AT=555.025n

* CHECK dout1_38 Vdout1_38ck110 = 0.9 time = 555
.meas tran vdout1_38ck110 FIND v(dout1_38) AT=555.025n

* CHECK dout1_39 Vdout1_39ck110 = 0 time = 555
.meas tran vdout1_39ck110 FIND v(dout1_39) AT=555.025n

* CHECK dout1_40 Vdout1_40ck110 = 0.9 time = 555
.meas tran vdout1_40ck110 FIND v(dout1_40) AT=555.025n

* CHECK dout1_41 Vdout1_41ck110 = 0.9 time = 555
.meas tran vdout1_41ck110 FIND v(dout1_41) AT=555.025n

* CHECK dout1_42 Vdout1_42ck110 = 0 time = 555
.meas tran vdout1_42ck110 FIND v(dout1_42) AT=555.025n

* CHECK dout1_43 Vdout1_43ck110 = 0.9 time = 555
.meas tran vdout1_43ck110 FIND v(dout1_43) AT=555.025n

* CHECK dout1_44 Vdout1_44ck110 = 0.9 time = 555
.meas tran vdout1_44ck110 FIND v(dout1_44) AT=555.025n

* CHECK dout1_45 Vdout1_45ck110 = 0.9 time = 555
.meas tran vdout1_45ck110 FIND v(dout1_45) AT=555.025n

* CHECK dout1_46 Vdout1_46ck110 = 0 time = 555
.meas tran vdout1_46ck110 FIND v(dout1_46) AT=555.025n

* CHECK dout1_47 Vdout1_47ck110 = 0.9 time = 555
.meas tran vdout1_47ck110 FIND v(dout1_47) AT=555.025n

* CHECK dout1_48 Vdout1_48ck110 = 0 time = 555
.meas tran vdout1_48ck110 FIND v(dout1_48) AT=555.025n

* CHECK dout1_49 Vdout1_49ck110 = 0 time = 555
.meas tran vdout1_49ck110 FIND v(dout1_49) AT=555.025n

* CHECK dout1_50 Vdout1_50ck110 = 0 time = 555
.meas tran vdout1_50ck110 FIND v(dout1_50) AT=555.025n

* CHECK dout1_51 Vdout1_51ck110 = 0.9 time = 555
.meas tran vdout1_51ck110 FIND v(dout1_51) AT=555.025n

* CHECK dout1_52 Vdout1_52ck110 = 0.9 time = 555
.meas tran vdout1_52ck110 FIND v(dout1_52) AT=555.025n

* CHECK dout1_53 Vdout1_53ck110 = 0.9 time = 555
.meas tran vdout1_53ck110 FIND v(dout1_53) AT=555.025n

* CHECK dout1_54 Vdout1_54ck110 = 0 time = 555
.meas tran vdout1_54ck110 FIND v(dout1_54) AT=555.025n

* CHECK dout1_55 Vdout1_55ck110 = 0.9 time = 555
.meas tran vdout1_55ck110 FIND v(dout1_55) AT=555.025n

* CHECK dout1_56 Vdout1_56ck110 = 0 time = 555
.meas tran vdout1_56ck110 FIND v(dout1_56) AT=555.025n

* CHECK dout1_57 Vdout1_57ck110 = 0.9 time = 555
.meas tran vdout1_57ck110 FIND v(dout1_57) AT=555.025n

* CHECK dout1_58 Vdout1_58ck110 = 0 time = 555
.meas tran vdout1_58ck110 FIND v(dout1_58) AT=555.025n

* CHECK dout1_59 Vdout1_59ck110 = 0 time = 555
.meas tran vdout1_59ck110 FIND v(dout1_59) AT=555.025n

* CHECK dout1_60 Vdout1_60ck110 = 0.9 time = 555
.meas tran vdout1_60ck110 FIND v(dout1_60) AT=555.025n

* CHECK dout1_61 Vdout1_61ck110 = 0.9 time = 555
.meas tran vdout1_61ck110 FIND v(dout1_61) AT=555.025n

* CHECK dout1_62 Vdout1_62ck110 = 0.9 time = 555
.meas tran vdout1_62ck110 FIND v(dout1_62) AT=555.025n

* CHECK dout1_63 Vdout1_63ck110 = 0 time = 555
.meas tran vdout1_63ck110 FIND v(dout1_63) AT=555.025n

* CHECK dout1_64 Vdout1_64ck110 = 0.9 time = 555
.meas tran vdout1_64ck110 FIND v(dout1_64) AT=555.025n

* CHECK dout1_65 Vdout1_65ck110 = 0.9 time = 555
.meas tran vdout1_65ck110 FIND v(dout1_65) AT=555.025n

* CHECK dout1_66 Vdout1_66ck110 = 0.9 time = 555
.meas tran vdout1_66ck110 FIND v(dout1_66) AT=555.025n

* CHECK dout1_67 Vdout1_67ck110 = 0 time = 555
.meas tran vdout1_67ck110 FIND v(dout1_67) AT=555.025n

* CHECK dout1_68 Vdout1_68ck110 = 0.9 time = 555
.meas tran vdout1_68ck110 FIND v(dout1_68) AT=555.025n

* CHECK dout1_69 Vdout1_69ck110 = 0 time = 555
.meas tran vdout1_69ck110 FIND v(dout1_69) AT=555.025n

* CHECK dout1_70 Vdout1_70ck110 = 0.9 time = 555
.meas tran vdout1_70ck110 FIND v(dout1_70) AT=555.025n

* CHECK dout1_71 Vdout1_71ck110 = 0 time = 555
.meas tran vdout1_71ck110 FIND v(dout1_71) AT=555.025n

* CHECK dout1_72 Vdout1_72ck110 = 0 time = 555
.meas tran vdout1_72ck110 FIND v(dout1_72) AT=555.025n

* CHECK dout1_73 Vdout1_73ck110 = 0.9 time = 555
.meas tran vdout1_73ck110 FIND v(dout1_73) AT=555.025n

* CHECK dout1_74 Vdout1_74ck110 = 0 time = 555
.meas tran vdout1_74ck110 FIND v(dout1_74) AT=555.025n

* CHECK dout1_75 Vdout1_75ck110 = 0.9 time = 555
.meas tran vdout1_75ck110 FIND v(dout1_75) AT=555.025n

* CHECK dout1_76 Vdout1_76ck110 = 0 time = 555
.meas tran vdout1_76ck110 FIND v(dout1_76) AT=555.025n

* CHECK dout1_77 Vdout1_77ck110 = 0 time = 555
.meas tran vdout1_77ck110 FIND v(dout1_77) AT=555.025n

* CHECK dout1_78 Vdout1_78ck110 = 0.9 time = 555
.meas tran vdout1_78ck110 FIND v(dout1_78) AT=555.025n

* CHECK dout1_79 Vdout1_79ck110 = 0 time = 555
.meas tran vdout1_79ck110 FIND v(dout1_79) AT=555.025n

* CHECK dout1_80 Vdout1_80ck110 = 0 time = 555
.meas tran vdout1_80ck110 FIND v(dout1_80) AT=555.025n

* CHECK dout1_81 Vdout1_81ck110 = 0 time = 555
.meas tran vdout1_81ck110 FIND v(dout1_81) AT=555.025n

* CHECK dout1_82 Vdout1_82ck110 = 0 time = 555
.meas tran vdout1_82ck110 FIND v(dout1_82) AT=555.025n

* CHECK dout1_83 Vdout1_83ck110 = 0 time = 555
.meas tran vdout1_83ck110 FIND v(dout1_83) AT=555.025n

* CHECK dout1_84 Vdout1_84ck110 = 0.9 time = 555
.meas tran vdout1_84ck110 FIND v(dout1_84) AT=555.025n

* CHECK dout1_85 Vdout1_85ck110 = 0 time = 555
.meas tran vdout1_85ck110 FIND v(dout1_85) AT=555.025n

* CHECK dout1_86 Vdout1_86ck110 = 0.9 time = 555
.meas tran vdout1_86ck110 FIND v(dout1_86) AT=555.025n

* CHECK dout1_87 Vdout1_87ck110 = 0.9 time = 555
.meas tran vdout1_87ck110 FIND v(dout1_87) AT=555.025n

* CHECK dout1_88 Vdout1_88ck110 = 0 time = 555
.meas tran vdout1_88ck110 FIND v(dout1_88) AT=555.025n

* CHECK dout1_89 Vdout1_89ck110 = 0 time = 555
.meas tran vdout1_89ck110 FIND v(dout1_89) AT=555.025n

* CHECK dout1_90 Vdout1_90ck110 = 0.9 time = 555
.meas tran vdout1_90ck110 FIND v(dout1_90) AT=555.025n

* CHECK dout1_91 Vdout1_91ck110 = 0 time = 555
.meas tran vdout1_91ck110 FIND v(dout1_91) AT=555.025n

* CHECK dout1_92 Vdout1_92ck110 = 0 time = 555
.meas tran vdout1_92ck110 FIND v(dout1_92) AT=555.025n

* CHECK dout1_93 Vdout1_93ck110 = 0 time = 555
.meas tran vdout1_93ck110 FIND v(dout1_93) AT=555.025n

* CHECK dout1_94 Vdout1_94ck110 = 0.9 time = 555
.meas tran vdout1_94ck110 FIND v(dout1_94) AT=555.025n

* CHECK dout1_95 Vdout1_95ck110 = 0 time = 555
.meas tran vdout1_95ck110 FIND v(dout1_95) AT=555.025n

* CHECK dout1_0 Vdout1_0ck113 = 0.9 time = 570
.meas tran vdout1_0ck113 FIND v(dout1_0) AT=570.025n

* CHECK dout1_1 Vdout1_1ck113 = 0.9 time = 570
.meas tran vdout1_1ck113 FIND v(dout1_1) AT=570.025n

* CHECK dout1_2 Vdout1_2ck113 = 0.9 time = 570
.meas tran vdout1_2ck113 FIND v(dout1_2) AT=570.025n

* CHECK dout1_3 Vdout1_3ck113 = 0 time = 570
.meas tran vdout1_3ck113 FIND v(dout1_3) AT=570.025n

* CHECK dout1_4 Vdout1_4ck113 = 0.9 time = 570
.meas tran vdout1_4ck113 FIND v(dout1_4) AT=570.025n

* CHECK dout1_5 Vdout1_5ck113 = 0.9 time = 570
.meas tran vdout1_5ck113 FIND v(dout1_5) AT=570.025n

* CHECK dout1_6 Vdout1_6ck113 = 0.9 time = 570
.meas tran vdout1_6ck113 FIND v(dout1_6) AT=570.025n

* CHECK dout1_7 Vdout1_7ck113 = 0.9 time = 570
.meas tran vdout1_7ck113 FIND v(dout1_7) AT=570.025n

* CHECK dout1_8 Vdout1_8ck113 = 0.9 time = 570
.meas tran vdout1_8ck113 FIND v(dout1_8) AT=570.025n

* CHECK dout1_9 Vdout1_9ck113 = 0 time = 570
.meas tran vdout1_9ck113 FIND v(dout1_9) AT=570.025n

* CHECK dout1_10 Vdout1_10ck113 = 0.9 time = 570
.meas tran vdout1_10ck113 FIND v(dout1_10) AT=570.025n

* CHECK dout1_11 Vdout1_11ck113 = 0 time = 570
.meas tran vdout1_11ck113 FIND v(dout1_11) AT=570.025n

* CHECK dout1_12 Vdout1_12ck113 = 0.9 time = 570
.meas tran vdout1_12ck113 FIND v(dout1_12) AT=570.025n

* CHECK dout1_13 Vdout1_13ck113 = 0 time = 570
.meas tran vdout1_13ck113 FIND v(dout1_13) AT=570.025n

* CHECK dout1_14 Vdout1_14ck113 = 0.9 time = 570
.meas tran vdout1_14ck113 FIND v(dout1_14) AT=570.025n

* CHECK dout1_15 Vdout1_15ck113 = 0.9 time = 570
.meas tran vdout1_15ck113 FIND v(dout1_15) AT=570.025n

* CHECK dout1_16 Vdout1_16ck113 = 0.9 time = 570
.meas tran vdout1_16ck113 FIND v(dout1_16) AT=570.025n

* CHECK dout1_17 Vdout1_17ck113 = 0.9 time = 570
.meas tran vdout1_17ck113 FIND v(dout1_17) AT=570.025n

* CHECK dout1_18 Vdout1_18ck113 = 0.9 time = 570
.meas tran vdout1_18ck113 FIND v(dout1_18) AT=570.025n

* CHECK dout1_19 Vdout1_19ck113 = 0.9 time = 570
.meas tran vdout1_19ck113 FIND v(dout1_19) AT=570.025n

* CHECK dout1_20 Vdout1_20ck113 = 0 time = 570
.meas tran vdout1_20ck113 FIND v(dout1_20) AT=570.025n

* CHECK dout1_21 Vdout1_21ck113 = 0 time = 570
.meas tran vdout1_21ck113 FIND v(dout1_21) AT=570.025n

* CHECK dout1_22 Vdout1_22ck113 = 0 time = 570
.meas tran vdout1_22ck113 FIND v(dout1_22) AT=570.025n

* CHECK dout1_23 Vdout1_23ck113 = 0 time = 570
.meas tran vdout1_23ck113 FIND v(dout1_23) AT=570.025n

* CHECK dout1_24 Vdout1_24ck113 = 0 time = 570
.meas tran vdout1_24ck113 FIND v(dout1_24) AT=570.025n

* CHECK dout1_25 Vdout1_25ck113 = 0.9 time = 570
.meas tran vdout1_25ck113 FIND v(dout1_25) AT=570.025n

* CHECK dout1_26 Vdout1_26ck113 = 0 time = 570
.meas tran vdout1_26ck113 FIND v(dout1_26) AT=570.025n

* CHECK dout1_27 Vdout1_27ck113 = 0.9 time = 570
.meas tran vdout1_27ck113 FIND v(dout1_27) AT=570.025n

* CHECK dout1_28 Vdout1_28ck113 = 0 time = 570
.meas tran vdout1_28ck113 FIND v(dout1_28) AT=570.025n

* CHECK dout1_29 Vdout1_29ck113 = 0.9 time = 570
.meas tran vdout1_29ck113 FIND v(dout1_29) AT=570.025n

* CHECK dout1_30 Vdout1_30ck113 = 0.9 time = 570
.meas tran vdout1_30ck113 FIND v(dout1_30) AT=570.025n

* CHECK dout1_31 Vdout1_31ck113 = 0.9 time = 570
.meas tran vdout1_31ck113 FIND v(dout1_31) AT=570.025n

* CHECK dout1_32 Vdout1_32ck113 = 0.9 time = 570
.meas tran vdout1_32ck113 FIND v(dout1_32) AT=570.025n

* CHECK dout1_33 Vdout1_33ck113 = 0 time = 570
.meas tran vdout1_33ck113 FIND v(dout1_33) AT=570.025n

* CHECK dout1_34 Vdout1_34ck113 = 0 time = 570
.meas tran vdout1_34ck113 FIND v(dout1_34) AT=570.025n

* CHECK dout1_35 Vdout1_35ck113 = 0.9 time = 570
.meas tran vdout1_35ck113 FIND v(dout1_35) AT=570.025n

* CHECK dout1_36 Vdout1_36ck113 = 0 time = 570
.meas tran vdout1_36ck113 FIND v(dout1_36) AT=570.025n

* CHECK dout1_37 Vdout1_37ck113 = 0 time = 570
.meas tran vdout1_37ck113 FIND v(dout1_37) AT=570.025n

* CHECK dout1_38 Vdout1_38ck113 = 0.9 time = 570
.meas tran vdout1_38ck113 FIND v(dout1_38) AT=570.025n

* CHECK dout1_39 Vdout1_39ck113 = 0 time = 570
.meas tran vdout1_39ck113 FIND v(dout1_39) AT=570.025n

* CHECK dout1_40 Vdout1_40ck113 = 0 time = 570
.meas tran vdout1_40ck113 FIND v(dout1_40) AT=570.025n

* CHECK dout1_41 Vdout1_41ck113 = 0 time = 570
.meas tran vdout1_41ck113 FIND v(dout1_41) AT=570.025n

* CHECK dout1_42 Vdout1_42ck113 = 0.9 time = 570
.meas tran vdout1_42ck113 FIND v(dout1_42) AT=570.025n

* CHECK dout1_43 Vdout1_43ck113 = 0.9 time = 570
.meas tran vdout1_43ck113 FIND v(dout1_43) AT=570.025n

* CHECK dout1_44 Vdout1_44ck113 = 0.9 time = 570
.meas tran vdout1_44ck113 FIND v(dout1_44) AT=570.025n

* CHECK dout1_45 Vdout1_45ck113 = 0 time = 570
.meas tran vdout1_45ck113 FIND v(dout1_45) AT=570.025n

* CHECK dout1_46 Vdout1_46ck113 = 0.9 time = 570
.meas tran vdout1_46ck113 FIND v(dout1_46) AT=570.025n

* CHECK dout1_47 Vdout1_47ck113 = 0 time = 570
.meas tran vdout1_47ck113 FIND v(dout1_47) AT=570.025n

* CHECK dout1_48 Vdout1_48ck113 = 0.9 time = 570
.meas tran vdout1_48ck113 FIND v(dout1_48) AT=570.025n

* CHECK dout1_49 Vdout1_49ck113 = 0 time = 570
.meas tran vdout1_49ck113 FIND v(dout1_49) AT=570.025n

* CHECK dout1_50 Vdout1_50ck113 = 0.9 time = 570
.meas tran vdout1_50ck113 FIND v(dout1_50) AT=570.025n

* CHECK dout1_51 Vdout1_51ck113 = 0 time = 570
.meas tran vdout1_51ck113 FIND v(dout1_51) AT=570.025n

* CHECK dout1_52 Vdout1_52ck113 = 0.9 time = 570
.meas tran vdout1_52ck113 FIND v(dout1_52) AT=570.025n

* CHECK dout1_53 Vdout1_53ck113 = 0.9 time = 570
.meas tran vdout1_53ck113 FIND v(dout1_53) AT=570.025n

* CHECK dout1_54 Vdout1_54ck113 = 0.9 time = 570
.meas tran vdout1_54ck113 FIND v(dout1_54) AT=570.025n

* CHECK dout1_55 Vdout1_55ck113 = 0 time = 570
.meas tran vdout1_55ck113 FIND v(dout1_55) AT=570.025n

* CHECK dout1_56 Vdout1_56ck113 = 0 time = 570
.meas tran vdout1_56ck113 FIND v(dout1_56) AT=570.025n

* CHECK dout1_57 Vdout1_57ck113 = 0.9 time = 570
.meas tran vdout1_57ck113 FIND v(dout1_57) AT=570.025n

* CHECK dout1_58 Vdout1_58ck113 = 0 time = 570
.meas tran vdout1_58ck113 FIND v(dout1_58) AT=570.025n

* CHECK dout1_59 Vdout1_59ck113 = 0.9 time = 570
.meas tran vdout1_59ck113 FIND v(dout1_59) AT=570.025n

* CHECK dout1_60 Vdout1_60ck113 = 0.9 time = 570
.meas tran vdout1_60ck113 FIND v(dout1_60) AT=570.025n

* CHECK dout1_61 Vdout1_61ck113 = 0 time = 570
.meas tran vdout1_61ck113 FIND v(dout1_61) AT=570.025n

* CHECK dout1_62 Vdout1_62ck113 = 0 time = 570
.meas tran vdout1_62ck113 FIND v(dout1_62) AT=570.025n

* CHECK dout1_63 Vdout1_63ck113 = 0 time = 570
.meas tran vdout1_63ck113 FIND v(dout1_63) AT=570.025n

* CHECK dout1_64 Vdout1_64ck113 = 0.9 time = 570
.meas tran vdout1_64ck113 FIND v(dout1_64) AT=570.025n

* CHECK dout1_65 Vdout1_65ck113 = 0 time = 570
.meas tran vdout1_65ck113 FIND v(dout1_65) AT=570.025n

* CHECK dout1_66 Vdout1_66ck113 = 0.9 time = 570
.meas tran vdout1_66ck113 FIND v(dout1_66) AT=570.025n

* CHECK dout1_67 Vdout1_67ck113 = 0.9 time = 570
.meas tran vdout1_67ck113 FIND v(dout1_67) AT=570.025n

* CHECK dout1_68 Vdout1_68ck113 = 0.9 time = 570
.meas tran vdout1_68ck113 FIND v(dout1_68) AT=570.025n

* CHECK dout1_69 Vdout1_69ck113 = 0.9 time = 570
.meas tran vdout1_69ck113 FIND v(dout1_69) AT=570.025n

* CHECK dout1_70 Vdout1_70ck113 = 0 time = 570
.meas tran vdout1_70ck113 FIND v(dout1_70) AT=570.025n

* CHECK dout1_71 Vdout1_71ck113 = 0.9 time = 570
.meas tran vdout1_71ck113 FIND v(dout1_71) AT=570.025n

* CHECK dout1_72 Vdout1_72ck113 = 0.9 time = 570
.meas tran vdout1_72ck113 FIND v(dout1_72) AT=570.025n

* CHECK dout1_73 Vdout1_73ck113 = 0 time = 570
.meas tran vdout1_73ck113 FIND v(dout1_73) AT=570.025n

* CHECK dout1_74 Vdout1_74ck113 = 0.9 time = 570
.meas tran vdout1_74ck113 FIND v(dout1_74) AT=570.025n

* CHECK dout1_75 Vdout1_75ck113 = 0 time = 570
.meas tran vdout1_75ck113 FIND v(dout1_75) AT=570.025n

* CHECK dout1_76 Vdout1_76ck113 = 0.9 time = 570
.meas tran vdout1_76ck113 FIND v(dout1_76) AT=570.025n

* CHECK dout1_77 Vdout1_77ck113 = 0 time = 570
.meas tran vdout1_77ck113 FIND v(dout1_77) AT=570.025n

* CHECK dout1_78 Vdout1_78ck113 = 0 time = 570
.meas tran vdout1_78ck113 FIND v(dout1_78) AT=570.025n

* CHECK dout1_79 Vdout1_79ck113 = 0 time = 570
.meas tran vdout1_79ck113 FIND v(dout1_79) AT=570.025n

* CHECK dout1_80 Vdout1_80ck113 = 0.9 time = 570
.meas tran vdout1_80ck113 FIND v(dout1_80) AT=570.025n

* CHECK dout1_81 Vdout1_81ck113 = 0.9 time = 570
.meas tran vdout1_81ck113 FIND v(dout1_81) AT=570.025n

* CHECK dout1_82 Vdout1_82ck113 = 0 time = 570
.meas tran vdout1_82ck113 FIND v(dout1_82) AT=570.025n

* CHECK dout1_83 Vdout1_83ck113 = 0.9 time = 570
.meas tran vdout1_83ck113 FIND v(dout1_83) AT=570.025n

* CHECK dout1_84 Vdout1_84ck113 = 0 time = 570
.meas tran vdout1_84ck113 FIND v(dout1_84) AT=570.025n

* CHECK dout1_85 Vdout1_85ck113 = 0.9 time = 570
.meas tran vdout1_85ck113 FIND v(dout1_85) AT=570.025n

* CHECK dout1_86 Vdout1_86ck113 = 0 time = 570
.meas tran vdout1_86ck113 FIND v(dout1_86) AT=570.025n

* CHECK dout1_87 Vdout1_87ck113 = 0.9 time = 570
.meas tran vdout1_87ck113 FIND v(dout1_87) AT=570.025n

* CHECK dout1_88 Vdout1_88ck113 = 0 time = 570
.meas tran vdout1_88ck113 FIND v(dout1_88) AT=570.025n

* CHECK dout1_89 Vdout1_89ck113 = 0.9 time = 570
.meas tran vdout1_89ck113 FIND v(dout1_89) AT=570.025n

* CHECK dout1_90 Vdout1_90ck113 = 0 time = 570
.meas tran vdout1_90ck113 FIND v(dout1_90) AT=570.025n

* CHECK dout1_91 Vdout1_91ck113 = 0 time = 570
.meas tran vdout1_91ck113 FIND v(dout1_91) AT=570.025n

* CHECK dout1_92 Vdout1_92ck113 = 0.9 time = 570
.meas tran vdout1_92ck113 FIND v(dout1_92) AT=570.025n

* CHECK dout1_93 Vdout1_93ck113 = 0.9 time = 570
.meas tran vdout1_93ck113 FIND v(dout1_93) AT=570.025n

* CHECK dout1_94 Vdout1_94ck113 = 0 time = 570
.meas tran vdout1_94ck113 FIND v(dout1_94) AT=570.025n

* CHECK dout1_95 Vdout1_95ck113 = 0 time = 570
.meas tran vdout1_95ck113 FIND v(dout1_95) AT=570.025n

* CHECK dout1_0 Vdout1_0ck120 = 0.9 time = 605
.meas tran vdout1_0ck120 FIND v(dout1_0) AT=605.025n

* CHECK dout1_1 Vdout1_1ck120 = 0.9 time = 605
.meas tran vdout1_1ck120 FIND v(dout1_1) AT=605.025n

* CHECK dout1_2 Vdout1_2ck120 = 0.9 time = 605
.meas tran vdout1_2ck120 FIND v(dout1_2) AT=605.025n

* CHECK dout1_3 Vdout1_3ck120 = 0 time = 605
.meas tran vdout1_3ck120 FIND v(dout1_3) AT=605.025n

* CHECK dout1_4 Vdout1_4ck120 = 0.9 time = 605
.meas tran vdout1_4ck120 FIND v(dout1_4) AT=605.025n

* CHECK dout1_5 Vdout1_5ck120 = 0.9 time = 605
.meas tran vdout1_5ck120 FIND v(dout1_5) AT=605.025n

* CHECK dout1_6 Vdout1_6ck120 = 0.9 time = 605
.meas tran vdout1_6ck120 FIND v(dout1_6) AT=605.025n

* CHECK dout1_7 Vdout1_7ck120 = 0.9 time = 605
.meas tran vdout1_7ck120 FIND v(dout1_7) AT=605.025n

* CHECK dout1_8 Vdout1_8ck120 = 0.9 time = 605
.meas tran vdout1_8ck120 FIND v(dout1_8) AT=605.025n

* CHECK dout1_9 Vdout1_9ck120 = 0 time = 605
.meas tran vdout1_9ck120 FIND v(dout1_9) AT=605.025n

* CHECK dout1_10 Vdout1_10ck120 = 0.9 time = 605
.meas tran vdout1_10ck120 FIND v(dout1_10) AT=605.025n

* CHECK dout1_11 Vdout1_11ck120 = 0 time = 605
.meas tran vdout1_11ck120 FIND v(dout1_11) AT=605.025n

* CHECK dout1_12 Vdout1_12ck120 = 0.9 time = 605
.meas tran vdout1_12ck120 FIND v(dout1_12) AT=605.025n

* CHECK dout1_13 Vdout1_13ck120 = 0 time = 605
.meas tran vdout1_13ck120 FIND v(dout1_13) AT=605.025n

* CHECK dout1_14 Vdout1_14ck120 = 0.9 time = 605
.meas tran vdout1_14ck120 FIND v(dout1_14) AT=605.025n

* CHECK dout1_15 Vdout1_15ck120 = 0.9 time = 605
.meas tran vdout1_15ck120 FIND v(dout1_15) AT=605.025n

* CHECK dout1_16 Vdout1_16ck120 = 0.9 time = 605
.meas tran vdout1_16ck120 FIND v(dout1_16) AT=605.025n

* CHECK dout1_17 Vdout1_17ck120 = 0.9 time = 605
.meas tran vdout1_17ck120 FIND v(dout1_17) AT=605.025n

* CHECK dout1_18 Vdout1_18ck120 = 0.9 time = 605
.meas tran vdout1_18ck120 FIND v(dout1_18) AT=605.025n

* CHECK dout1_19 Vdout1_19ck120 = 0.9 time = 605
.meas tran vdout1_19ck120 FIND v(dout1_19) AT=605.025n

* CHECK dout1_20 Vdout1_20ck120 = 0 time = 605
.meas tran vdout1_20ck120 FIND v(dout1_20) AT=605.025n

* CHECK dout1_21 Vdout1_21ck120 = 0 time = 605
.meas tran vdout1_21ck120 FIND v(dout1_21) AT=605.025n

* CHECK dout1_22 Vdout1_22ck120 = 0 time = 605
.meas tran vdout1_22ck120 FIND v(dout1_22) AT=605.025n

* CHECK dout1_23 Vdout1_23ck120 = 0 time = 605
.meas tran vdout1_23ck120 FIND v(dout1_23) AT=605.025n

* CHECK dout1_24 Vdout1_24ck120 = 0 time = 605
.meas tran vdout1_24ck120 FIND v(dout1_24) AT=605.025n

* CHECK dout1_25 Vdout1_25ck120 = 0.9 time = 605
.meas tran vdout1_25ck120 FIND v(dout1_25) AT=605.025n

* CHECK dout1_26 Vdout1_26ck120 = 0 time = 605
.meas tran vdout1_26ck120 FIND v(dout1_26) AT=605.025n

* CHECK dout1_27 Vdout1_27ck120 = 0.9 time = 605
.meas tran vdout1_27ck120 FIND v(dout1_27) AT=605.025n

* CHECK dout1_28 Vdout1_28ck120 = 0 time = 605
.meas tran vdout1_28ck120 FIND v(dout1_28) AT=605.025n

* CHECK dout1_29 Vdout1_29ck120 = 0.9 time = 605
.meas tran vdout1_29ck120 FIND v(dout1_29) AT=605.025n

* CHECK dout1_30 Vdout1_30ck120 = 0.9 time = 605
.meas tran vdout1_30ck120 FIND v(dout1_30) AT=605.025n

* CHECK dout1_31 Vdout1_31ck120 = 0.9 time = 605
.meas tran vdout1_31ck120 FIND v(dout1_31) AT=605.025n

* CHECK dout1_32 Vdout1_32ck120 = 0.9 time = 605
.meas tran vdout1_32ck120 FIND v(dout1_32) AT=605.025n

* CHECK dout1_33 Vdout1_33ck120 = 0 time = 605
.meas tran vdout1_33ck120 FIND v(dout1_33) AT=605.025n

* CHECK dout1_34 Vdout1_34ck120 = 0.9 time = 605
.meas tran vdout1_34ck120 FIND v(dout1_34) AT=605.025n

* CHECK dout1_35 Vdout1_35ck120 = 0 time = 605
.meas tran vdout1_35ck120 FIND v(dout1_35) AT=605.025n

* CHECK dout1_36 Vdout1_36ck120 = 0.9 time = 605
.meas tran vdout1_36ck120 FIND v(dout1_36) AT=605.025n

* CHECK dout1_37 Vdout1_37ck120 = 0 time = 605
.meas tran vdout1_37ck120 FIND v(dout1_37) AT=605.025n

* CHECK dout1_38 Vdout1_38ck120 = 0 time = 605
.meas tran vdout1_38ck120 FIND v(dout1_38) AT=605.025n

* CHECK dout1_39 Vdout1_39ck120 = 0.9 time = 605
.meas tran vdout1_39ck120 FIND v(dout1_39) AT=605.025n

* CHECK dout1_40 Vdout1_40ck120 = 0.9 time = 605
.meas tran vdout1_40ck120 FIND v(dout1_40) AT=605.025n

* CHECK dout1_41 Vdout1_41ck120 = 0.9 time = 605
.meas tran vdout1_41ck120 FIND v(dout1_41) AT=605.025n

* CHECK dout1_42 Vdout1_42ck120 = 0.9 time = 605
.meas tran vdout1_42ck120 FIND v(dout1_42) AT=605.025n

* CHECK dout1_43 Vdout1_43ck120 = 0 time = 605
.meas tran vdout1_43ck120 FIND v(dout1_43) AT=605.025n

* CHECK dout1_44 Vdout1_44ck120 = 0.9 time = 605
.meas tran vdout1_44ck120 FIND v(dout1_44) AT=605.025n

* CHECK dout1_45 Vdout1_45ck120 = 0.9 time = 605
.meas tran vdout1_45ck120 FIND v(dout1_45) AT=605.025n

* CHECK dout1_46 Vdout1_46ck120 = 0 time = 605
.meas tran vdout1_46ck120 FIND v(dout1_46) AT=605.025n

* CHECK dout1_47 Vdout1_47ck120 = 0.9 time = 605
.meas tran vdout1_47ck120 FIND v(dout1_47) AT=605.025n

* CHECK dout1_48 Vdout1_48ck120 = 0.9 time = 605
.meas tran vdout1_48ck120 FIND v(dout1_48) AT=605.025n

* CHECK dout1_49 Vdout1_49ck120 = 0 time = 605
.meas tran vdout1_49ck120 FIND v(dout1_49) AT=605.025n

* CHECK dout1_50 Vdout1_50ck120 = 0 time = 605
.meas tran vdout1_50ck120 FIND v(dout1_50) AT=605.025n

* CHECK dout1_51 Vdout1_51ck120 = 0 time = 605
.meas tran vdout1_51ck120 FIND v(dout1_51) AT=605.025n

* CHECK dout1_52 Vdout1_52ck120 = 0.9 time = 605
.meas tran vdout1_52ck120 FIND v(dout1_52) AT=605.025n

* CHECK dout1_53 Vdout1_53ck120 = 0.9 time = 605
.meas tran vdout1_53ck120 FIND v(dout1_53) AT=605.025n

* CHECK dout1_54 Vdout1_54ck120 = 0 time = 605
.meas tran vdout1_54ck120 FIND v(dout1_54) AT=605.025n

* CHECK dout1_55 Vdout1_55ck120 = 0.9 time = 605
.meas tran vdout1_55ck120 FIND v(dout1_55) AT=605.025n

* CHECK dout1_56 Vdout1_56ck120 = 0 time = 605
.meas tran vdout1_56ck120 FIND v(dout1_56) AT=605.025n

* CHECK dout1_57 Vdout1_57ck120 = 0.9 time = 605
.meas tran vdout1_57ck120 FIND v(dout1_57) AT=605.025n

* CHECK dout1_58 Vdout1_58ck120 = 0.9 time = 605
.meas tran vdout1_58ck120 FIND v(dout1_58) AT=605.025n

* CHECK dout1_59 Vdout1_59ck120 = 0.9 time = 605
.meas tran vdout1_59ck120 FIND v(dout1_59) AT=605.025n

* CHECK dout1_60 Vdout1_60ck120 = 0 time = 605
.meas tran vdout1_60ck120 FIND v(dout1_60) AT=605.025n

* CHECK dout1_61 Vdout1_61ck120 = 0.9 time = 605
.meas tran vdout1_61ck120 FIND v(dout1_61) AT=605.025n

* CHECK dout1_62 Vdout1_62ck120 = 0 time = 605
.meas tran vdout1_62ck120 FIND v(dout1_62) AT=605.025n

* CHECK dout1_63 Vdout1_63ck120 = 0.9 time = 605
.meas tran vdout1_63ck120 FIND v(dout1_63) AT=605.025n

* CHECK dout1_64 Vdout1_64ck120 = 0 time = 605
.meas tran vdout1_64ck120 FIND v(dout1_64) AT=605.025n

* CHECK dout1_65 Vdout1_65ck120 = 0 time = 605
.meas tran vdout1_65ck120 FIND v(dout1_65) AT=605.025n

* CHECK dout1_66 Vdout1_66ck120 = 0.9 time = 605
.meas tran vdout1_66ck120 FIND v(dout1_66) AT=605.025n

* CHECK dout1_67 Vdout1_67ck120 = 0 time = 605
.meas tran vdout1_67ck120 FIND v(dout1_67) AT=605.025n

* CHECK dout1_68 Vdout1_68ck120 = 0 time = 605
.meas tran vdout1_68ck120 FIND v(dout1_68) AT=605.025n

* CHECK dout1_69 Vdout1_69ck120 = 0 time = 605
.meas tran vdout1_69ck120 FIND v(dout1_69) AT=605.025n

* CHECK dout1_70 Vdout1_70ck120 = 0.9 time = 605
.meas tran vdout1_70ck120 FIND v(dout1_70) AT=605.025n

* CHECK dout1_71 Vdout1_71ck120 = 0.9 time = 605
.meas tran vdout1_71ck120 FIND v(dout1_71) AT=605.025n

* CHECK dout1_72 Vdout1_72ck120 = 0 time = 605
.meas tran vdout1_72ck120 FIND v(dout1_72) AT=605.025n

* CHECK dout1_73 Vdout1_73ck120 = 0 time = 605
.meas tran vdout1_73ck120 FIND v(dout1_73) AT=605.025n

* CHECK dout1_74 Vdout1_74ck120 = 0 time = 605
.meas tran vdout1_74ck120 FIND v(dout1_74) AT=605.025n

* CHECK dout1_75 Vdout1_75ck120 = 0 time = 605
.meas tran vdout1_75ck120 FIND v(dout1_75) AT=605.025n

* CHECK dout1_76 Vdout1_76ck120 = 0 time = 605
.meas tran vdout1_76ck120 FIND v(dout1_76) AT=605.025n

* CHECK dout1_77 Vdout1_77ck120 = 0 time = 605
.meas tran vdout1_77ck120 FIND v(dout1_77) AT=605.025n

* CHECK dout1_78 Vdout1_78ck120 = 0.9 time = 605
.meas tran vdout1_78ck120 FIND v(dout1_78) AT=605.025n

* CHECK dout1_79 Vdout1_79ck120 = 0.9 time = 605
.meas tran vdout1_79ck120 FIND v(dout1_79) AT=605.025n

* CHECK dout1_80 Vdout1_80ck120 = 0.9 time = 605
.meas tran vdout1_80ck120 FIND v(dout1_80) AT=605.025n

* CHECK dout1_81 Vdout1_81ck120 = 0 time = 605
.meas tran vdout1_81ck120 FIND v(dout1_81) AT=605.025n

* CHECK dout1_82 Vdout1_82ck120 = 0.9 time = 605
.meas tran vdout1_82ck120 FIND v(dout1_82) AT=605.025n

* CHECK dout1_83 Vdout1_83ck120 = 0 time = 605
.meas tran vdout1_83ck120 FIND v(dout1_83) AT=605.025n

* CHECK dout1_84 Vdout1_84ck120 = 0.9 time = 605
.meas tran vdout1_84ck120 FIND v(dout1_84) AT=605.025n

* CHECK dout1_85 Vdout1_85ck120 = 0.9 time = 605
.meas tran vdout1_85ck120 FIND v(dout1_85) AT=605.025n

* CHECK dout1_86 Vdout1_86ck120 = 0.9 time = 605
.meas tran vdout1_86ck120 FIND v(dout1_86) AT=605.025n

* CHECK dout1_87 Vdout1_87ck120 = 0.9 time = 605
.meas tran vdout1_87ck120 FIND v(dout1_87) AT=605.025n

* CHECK dout1_88 Vdout1_88ck120 = 0.9 time = 605
.meas tran vdout1_88ck120 FIND v(dout1_88) AT=605.025n

* CHECK dout1_89 Vdout1_89ck120 = 0 time = 605
.meas tran vdout1_89ck120 FIND v(dout1_89) AT=605.025n

* CHECK dout1_90 Vdout1_90ck120 = 0 time = 605
.meas tran vdout1_90ck120 FIND v(dout1_90) AT=605.025n

* CHECK dout1_91 Vdout1_91ck120 = 0.9 time = 605
.meas tran vdout1_91ck120 FIND v(dout1_91) AT=605.025n

* CHECK dout1_92 Vdout1_92ck120 = 0 time = 605
.meas tran vdout1_92ck120 FIND v(dout1_92) AT=605.025n

* CHECK dout1_93 Vdout1_93ck120 = 0.9 time = 605
.meas tran vdout1_93ck120 FIND v(dout1_93) AT=605.025n

* CHECK dout1_94 Vdout1_94ck120 = 0 time = 605
.meas tran vdout1_94ck120 FIND v(dout1_94) AT=605.025n

* CHECK dout1_95 Vdout1_95ck120 = 0 time = 605
.meas tran vdout1_95ck120 FIND v(dout1_95) AT=605.025n

* CHECK dout1_0 Vdout1_0ck122 = 0.9 time = 615
.meas tran vdout1_0ck122 FIND v(dout1_0) AT=615.025n

* CHECK dout1_1 Vdout1_1ck122 = 0.9 time = 615
.meas tran vdout1_1ck122 FIND v(dout1_1) AT=615.025n

* CHECK dout1_2 Vdout1_2ck122 = 0.9 time = 615
.meas tran vdout1_2ck122 FIND v(dout1_2) AT=615.025n

* CHECK dout1_3 Vdout1_3ck122 = 0 time = 615
.meas tran vdout1_3ck122 FIND v(dout1_3) AT=615.025n

* CHECK dout1_4 Vdout1_4ck122 = 0.9 time = 615
.meas tran vdout1_4ck122 FIND v(dout1_4) AT=615.025n

* CHECK dout1_5 Vdout1_5ck122 = 0.9 time = 615
.meas tran vdout1_5ck122 FIND v(dout1_5) AT=615.025n

* CHECK dout1_6 Vdout1_6ck122 = 0.9 time = 615
.meas tran vdout1_6ck122 FIND v(dout1_6) AT=615.025n

* CHECK dout1_7 Vdout1_7ck122 = 0.9 time = 615
.meas tran vdout1_7ck122 FIND v(dout1_7) AT=615.025n

* CHECK dout1_8 Vdout1_8ck122 = 0.9 time = 615
.meas tran vdout1_8ck122 FIND v(dout1_8) AT=615.025n

* CHECK dout1_9 Vdout1_9ck122 = 0 time = 615
.meas tran vdout1_9ck122 FIND v(dout1_9) AT=615.025n

* CHECK dout1_10 Vdout1_10ck122 = 0.9 time = 615
.meas tran vdout1_10ck122 FIND v(dout1_10) AT=615.025n

* CHECK dout1_11 Vdout1_11ck122 = 0 time = 615
.meas tran vdout1_11ck122 FIND v(dout1_11) AT=615.025n

* CHECK dout1_12 Vdout1_12ck122 = 0.9 time = 615
.meas tran vdout1_12ck122 FIND v(dout1_12) AT=615.025n

* CHECK dout1_13 Vdout1_13ck122 = 0 time = 615
.meas tran vdout1_13ck122 FIND v(dout1_13) AT=615.025n

* CHECK dout1_14 Vdout1_14ck122 = 0.9 time = 615
.meas tran vdout1_14ck122 FIND v(dout1_14) AT=615.025n

* CHECK dout1_15 Vdout1_15ck122 = 0.9 time = 615
.meas tran vdout1_15ck122 FIND v(dout1_15) AT=615.025n

* CHECK dout1_16 Vdout1_16ck122 = 0.9 time = 615
.meas tran vdout1_16ck122 FIND v(dout1_16) AT=615.025n

* CHECK dout1_17 Vdout1_17ck122 = 0.9 time = 615
.meas tran vdout1_17ck122 FIND v(dout1_17) AT=615.025n

* CHECK dout1_18 Vdout1_18ck122 = 0.9 time = 615
.meas tran vdout1_18ck122 FIND v(dout1_18) AT=615.025n

* CHECK dout1_19 Vdout1_19ck122 = 0.9 time = 615
.meas tran vdout1_19ck122 FIND v(dout1_19) AT=615.025n

* CHECK dout1_20 Vdout1_20ck122 = 0 time = 615
.meas tran vdout1_20ck122 FIND v(dout1_20) AT=615.025n

* CHECK dout1_21 Vdout1_21ck122 = 0 time = 615
.meas tran vdout1_21ck122 FIND v(dout1_21) AT=615.025n

* CHECK dout1_22 Vdout1_22ck122 = 0 time = 615
.meas tran vdout1_22ck122 FIND v(dout1_22) AT=615.025n

* CHECK dout1_23 Vdout1_23ck122 = 0 time = 615
.meas tran vdout1_23ck122 FIND v(dout1_23) AT=615.025n

* CHECK dout1_24 Vdout1_24ck122 = 0 time = 615
.meas tran vdout1_24ck122 FIND v(dout1_24) AT=615.025n

* CHECK dout1_25 Vdout1_25ck122 = 0.9 time = 615
.meas tran vdout1_25ck122 FIND v(dout1_25) AT=615.025n

* CHECK dout1_26 Vdout1_26ck122 = 0 time = 615
.meas tran vdout1_26ck122 FIND v(dout1_26) AT=615.025n

* CHECK dout1_27 Vdout1_27ck122 = 0.9 time = 615
.meas tran vdout1_27ck122 FIND v(dout1_27) AT=615.025n

* CHECK dout1_28 Vdout1_28ck122 = 0 time = 615
.meas tran vdout1_28ck122 FIND v(dout1_28) AT=615.025n

* CHECK dout1_29 Vdout1_29ck122 = 0.9 time = 615
.meas tran vdout1_29ck122 FIND v(dout1_29) AT=615.025n

* CHECK dout1_30 Vdout1_30ck122 = 0.9 time = 615
.meas tran vdout1_30ck122 FIND v(dout1_30) AT=615.025n

* CHECK dout1_31 Vdout1_31ck122 = 0.9 time = 615
.meas tran vdout1_31ck122 FIND v(dout1_31) AT=615.025n

* CHECK dout1_32 Vdout1_32ck122 = 0.9 time = 615
.meas tran vdout1_32ck122 FIND v(dout1_32) AT=615.025n

* CHECK dout1_33 Vdout1_33ck122 = 0.9 time = 615
.meas tran vdout1_33ck122 FIND v(dout1_33) AT=615.025n

* CHECK dout1_34 Vdout1_34ck122 = 0 time = 615
.meas tran vdout1_34ck122 FIND v(dout1_34) AT=615.025n

* CHECK dout1_35 Vdout1_35ck122 = 0.9 time = 615
.meas tran vdout1_35ck122 FIND v(dout1_35) AT=615.025n

* CHECK dout1_36 Vdout1_36ck122 = 0 time = 615
.meas tran vdout1_36ck122 FIND v(dout1_36) AT=615.025n

* CHECK dout1_37 Vdout1_37ck122 = 0 time = 615
.meas tran vdout1_37ck122 FIND v(dout1_37) AT=615.025n

* CHECK dout1_38 Vdout1_38ck122 = 0 time = 615
.meas tran vdout1_38ck122 FIND v(dout1_38) AT=615.025n

* CHECK dout1_39 Vdout1_39ck122 = 0.9 time = 615
.meas tran vdout1_39ck122 FIND v(dout1_39) AT=615.025n

* CHECK dout1_40 Vdout1_40ck122 = 0.9 time = 615
.meas tran vdout1_40ck122 FIND v(dout1_40) AT=615.025n

* CHECK dout1_41 Vdout1_41ck122 = 0 time = 615
.meas tran vdout1_41ck122 FIND v(dout1_41) AT=615.025n

* CHECK dout1_42 Vdout1_42ck122 = 0 time = 615
.meas tran vdout1_42ck122 FIND v(dout1_42) AT=615.025n

* CHECK dout1_43 Vdout1_43ck122 = 0 time = 615
.meas tran vdout1_43ck122 FIND v(dout1_43) AT=615.025n

* CHECK dout1_44 Vdout1_44ck122 = 0 time = 615
.meas tran vdout1_44ck122 FIND v(dout1_44) AT=615.025n

* CHECK dout1_45 Vdout1_45ck122 = 0.9 time = 615
.meas tran vdout1_45ck122 FIND v(dout1_45) AT=615.025n

* CHECK dout1_46 Vdout1_46ck122 = 0.9 time = 615
.meas tran vdout1_46ck122 FIND v(dout1_46) AT=615.025n

* CHECK dout1_47 Vdout1_47ck122 = 0 time = 615
.meas tran vdout1_47ck122 FIND v(dout1_47) AT=615.025n

* CHECK dout1_48 Vdout1_48ck122 = 0.9 time = 615
.meas tran vdout1_48ck122 FIND v(dout1_48) AT=615.025n

* CHECK dout1_49 Vdout1_49ck122 = 0.9 time = 615
.meas tran vdout1_49ck122 FIND v(dout1_49) AT=615.025n

* CHECK dout1_50 Vdout1_50ck122 = 0.9 time = 615
.meas tran vdout1_50ck122 FIND v(dout1_50) AT=615.025n

* CHECK dout1_51 Vdout1_51ck122 = 0 time = 615
.meas tran vdout1_51ck122 FIND v(dout1_51) AT=615.025n

* CHECK dout1_52 Vdout1_52ck122 = 0.9 time = 615
.meas tran vdout1_52ck122 FIND v(dout1_52) AT=615.025n

* CHECK dout1_53 Vdout1_53ck122 = 0.9 time = 615
.meas tran vdout1_53ck122 FIND v(dout1_53) AT=615.025n

* CHECK dout1_54 Vdout1_54ck122 = 0.9 time = 615
.meas tran vdout1_54ck122 FIND v(dout1_54) AT=615.025n

* CHECK dout1_55 Vdout1_55ck122 = 0 time = 615
.meas tran vdout1_55ck122 FIND v(dout1_55) AT=615.025n

* CHECK dout1_56 Vdout1_56ck122 = 0 time = 615
.meas tran vdout1_56ck122 FIND v(dout1_56) AT=615.025n

* CHECK dout1_57 Vdout1_57ck122 = 0.9 time = 615
.meas tran vdout1_57ck122 FIND v(dout1_57) AT=615.025n

* CHECK dout1_58 Vdout1_58ck122 = 0 time = 615
.meas tran vdout1_58ck122 FIND v(dout1_58) AT=615.025n

* CHECK dout1_59 Vdout1_59ck122 = 0 time = 615
.meas tran vdout1_59ck122 FIND v(dout1_59) AT=615.025n

* CHECK dout1_60 Vdout1_60ck122 = 0 time = 615
.meas tran vdout1_60ck122 FIND v(dout1_60) AT=615.025n

* CHECK dout1_61 Vdout1_61ck122 = 0.9 time = 615
.meas tran vdout1_61ck122 FIND v(dout1_61) AT=615.025n

* CHECK dout1_62 Vdout1_62ck122 = 0 time = 615
.meas tran vdout1_62ck122 FIND v(dout1_62) AT=615.025n

* CHECK dout1_63 Vdout1_63ck122 = 0.9 time = 615
.meas tran vdout1_63ck122 FIND v(dout1_63) AT=615.025n

* CHECK dout1_64 Vdout1_64ck122 = 0 time = 615
.meas tran vdout1_64ck122 FIND v(dout1_64) AT=615.025n

* CHECK dout1_65 Vdout1_65ck122 = 0 time = 615
.meas tran vdout1_65ck122 FIND v(dout1_65) AT=615.025n

* CHECK dout1_66 Vdout1_66ck122 = 0.9 time = 615
.meas tran vdout1_66ck122 FIND v(dout1_66) AT=615.025n

* CHECK dout1_67 Vdout1_67ck122 = 0 time = 615
.meas tran vdout1_67ck122 FIND v(dout1_67) AT=615.025n

* CHECK dout1_68 Vdout1_68ck122 = 0 time = 615
.meas tran vdout1_68ck122 FIND v(dout1_68) AT=615.025n

* CHECK dout1_69 Vdout1_69ck122 = 0 time = 615
.meas tran vdout1_69ck122 FIND v(dout1_69) AT=615.025n

* CHECK dout1_70 Vdout1_70ck122 = 0.9 time = 615
.meas tran vdout1_70ck122 FIND v(dout1_70) AT=615.025n

* CHECK dout1_71 Vdout1_71ck122 = 0.9 time = 615
.meas tran vdout1_71ck122 FIND v(dout1_71) AT=615.025n

* CHECK dout1_72 Vdout1_72ck122 = 0 time = 615
.meas tran vdout1_72ck122 FIND v(dout1_72) AT=615.025n

* CHECK dout1_73 Vdout1_73ck122 = 0 time = 615
.meas tran vdout1_73ck122 FIND v(dout1_73) AT=615.025n

* CHECK dout1_74 Vdout1_74ck122 = 0 time = 615
.meas tran vdout1_74ck122 FIND v(dout1_74) AT=615.025n

* CHECK dout1_75 Vdout1_75ck122 = 0 time = 615
.meas tran vdout1_75ck122 FIND v(dout1_75) AT=615.025n

* CHECK dout1_76 Vdout1_76ck122 = 0 time = 615
.meas tran vdout1_76ck122 FIND v(dout1_76) AT=615.025n

* CHECK dout1_77 Vdout1_77ck122 = 0 time = 615
.meas tran vdout1_77ck122 FIND v(dout1_77) AT=615.025n

* CHECK dout1_78 Vdout1_78ck122 = 0.9 time = 615
.meas tran vdout1_78ck122 FIND v(dout1_78) AT=615.025n

* CHECK dout1_79 Vdout1_79ck122 = 0.9 time = 615
.meas tran vdout1_79ck122 FIND v(dout1_79) AT=615.025n

* CHECK dout1_80 Vdout1_80ck122 = 0.9 time = 615
.meas tran vdout1_80ck122 FIND v(dout1_80) AT=615.025n

* CHECK dout1_81 Vdout1_81ck122 = 0 time = 615
.meas tran vdout1_81ck122 FIND v(dout1_81) AT=615.025n

* CHECK dout1_82 Vdout1_82ck122 = 0.9 time = 615
.meas tran vdout1_82ck122 FIND v(dout1_82) AT=615.025n

* CHECK dout1_83 Vdout1_83ck122 = 0 time = 615
.meas tran vdout1_83ck122 FIND v(dout1_83) AT=615.025n

* CHECK dout1_84 Vdout1_84ck122 = 0.9 time = 615
.meas tran vdout1_84ck122 FIND v(dout1_84) AT=615.025n

* CHECK dout1_85 Vdout1_85ck122 = 0.9 time = 615
.meas tran vdout1_85ck122 FIND v(dout1_85) AT=615.025n

* CHECK dout1_86 Vdout1_86ck122 = 0.9 time = 615
.meas tran vdout1_86ck122 FIND v(dout1_86) AT=615.025n

* CHECK dout1_87 Vdout1_87ck122 = 0.9 time = 615
.meas tran vdout1_87ck122 FIND v(dout1_87) AT=615.025n

* CHECK dout1_88 Vdout1_88ck122 = 0.9 time = 615
.meas tran vdout1_88ck122 FIND v(dout1_88) AT=615.025n

* CHECK dout1_89 Vdout1_89ck122 = 0 time = 615
.meas tran vdout1_89ck122 FIND v(dout1_89) AT=615.025n

* CHECK dout1_90 Vdout1_90ck122 = 0 time = 615
.meas tran vdout1_90ck122 FIND v(dout1_90) AT=615.025n

* CHECK dout1_91 Vdout1_91ck122 = 0.9 time = 615
.meas tran vdout1_91ck122 FIND v(dout1_91) AT=615.025n

* CHECK dout1_92 Vdout1_92ck122 = 0 time = 615
.meas tran vdout1_92ck122 FIND v(dout1_92) AT=615.025n

* CHECK dout1_93 Vdout1_93ck122 = 0.9 time = 615
.meas tran vdout1_93ck122 FIND v(dout1_93) AT=615.025n

* CHECK dout1_94 Vdout1_94ck122 = 0 time = 615
.meas tran vdout1_94ck122 FIND v(dout1_94) AT=615.025n

* CHECK dout1_95 Vdout1_95ck122 = 0 time = 615
.meas tran vdout1_95ck122 FIND v(dout1_95) AT=615.025n

* CHECK dout1_0 Vdout1_0ck130 = 0.9 time = 655
.meas tran vdout1_0ck130 FIND v(dout1_0) AT=655.025n

* CHECK dout1_1 Vdout1_1ck130 = 0.9 time = 655
.meas tran vdout1_1ck130 FIND v(dout1_1) AT=655.025n

* CHECK dout1_2 Vdout1_2ck130 = 0.9 time = 655
.meas tran vdout1_2ck130 FIND v(dout1_2) AT=655.025n

* CHECK dout1_3 Vdout1_3ck130 = 0 time = 655
.meas tran vdout1_3ck130 FIND v(dout1_3) AT=655.025n

* CHECK dout1_4 Vdout1_4ck130 = 0.9 time = 655
.meas tran vdout1_4ck130 FIND v(dout1_4) AT=655.025n

* CHECK dout1_5 Vdout1_5ck130 = 0.9 time = 655
.meas tran vdout1_5ck130 FIND v(dout1_5) AT=655.025n

* CHECK dout1_6 Vdout1_6ck130 = 0.9 time = 655
.meas tran vdout1_6ck130 FIND v(dout1_6) AT=655.025n

* CHECK dout1_7 Vdout1_7ck130 = 0.9 time = 655
.meas tran vdout1_7ck130 FIND v(dout1_7) AT=655.025n

* CHECK dout1_8 Vdout1_8ck130 = 0.9 time = 655
.meas tran vdout1_8ck130 FIND v(dout1_8) AT=655.025n

* CHECK dout1_9 Vdout1_9ck130 = 0 time = 655
.meas tran vdout1_9ck130 FIND v(dout1_9) AT=655.025n

* CHECK dout1_10 Vdout1_10ck130 = 0.9 time = 655
.meas tran vdout1_10ck130 FIND v(dout1_10) AT=655.025n

* CHECK dout1_11 Vdout1_11ck130 = 0 time = 655
.meas tran vdout1_11ck130 FIND v(dout1_11) AT=655.025n

* CHECK dout1_12 Vdout1_12ck130 = 0.9 time = 655
.meas tran vdout1_12ck130 FIND v(dout1_12) AT=655.025n

* CHECK dout1_13 Vdout1_13ck130 = 0 time = 655
.meas tran vdout1_13ck130 FIND v(dout1_13) AT=655.025n

* CHECK dout1_14 Vdout1_14ck130 = 0.9 time = 655
.meas tran vdout1_14ck130 FIND v(dout1_14) AT=655.025n

* CHECK dout1_15 Vdout1_15ck130 = 0.9 time = 655
.meas tran vdout1_15ck130 FIND v(dout1_15) AT=655.025n

* CHECK dout1_16 Vdout1_16ck130 = 0.9 time = 655
.meas tran vdout1_16ck130 FIND v(dout1_16) AT=655.025n

* CHECK dout1_17 Vdout1_17ck130 = 0.9 time = 655
.meas tran vdout1_17ck130 FIND v(dout1_17) AT=655.025n

* CHECK dout1_18 Vdout1_18ck130 = 0.9 time = 655
.meas tran vdout1_18ck130 FIND v(dout1_18) AT=655.025n

* CHECK dout1_19 Vdout1_19ck130 = 0.9 time = 655
.meas tran vdout1_19ck130 FIND v(dout1_19) AT=655.025n

* CHECK dout1_20 Vdout1_20ck130 = 0 time = 655
.meas tran vdout1_20ck130 FIND v(dout1_20) AT=655.025n

* CHECK dout1_21 Vdout1_21ck130 = 0 time = 655
.meas tran vdout1_21ck130 FIND v(dout1_21) AT=655.025n

* CHECK dout1_22 Vdout1_22ck130 = 0 time = 655
.meas tran vdout1_22ck130 FIND v(dout1_22) AT=655.025n

* CHECK dout1_23 Vdout1_23ck130 = 0 time = 655
.meas tran vdout1_23ck130 FIND v(dout1_23) AT=655.025n

* CHECK dout1_24 Vdout1_24ck130 = 0 time = 655
.meas tran vdout1_24ck130 FIND v(dout1_24) AT=655.025n

* CHECK dout1_25 Vdout1_25ck130 = 0.9 time = 655
.meas tran vdout1_25ck130 FIND v(dout1_25) AT=655.025n

* CHECK dout1_26 Vdout1_26ck130 = 0 time = 655
.meas tran vdout1_26ck130 FIND v(dout1_26) AT=655.025n

* CHECK dout1_27 Vdout1_27ck130 = 0.9 time = 655
.meas tran vdout1_27ck130 FIND v(dout1_27) AT=655.025n

* CHECK dout1_28 Vdout1_28ck130 = 0 time = 655
.meas tran vdout1_28ck130 FIND v(dout1_28) AT=655.025n

* CHECK dout1_29 Vdout1_29ck130 = 0.9 time = 655
.meas tran vdout1_29ck130 FIND v(dout1_29) AT=655.025n

* CHECK dout1_30 Vdout1_30ck130 = 0.9 time = 655
.meas tran vdout1_30ck130 FIND v(dout1_30) AT=655.025n

* CHECK dout1_31 Vdout1_31ck130 = 0.9 time = 655
.meas tran vdout1_31ck130 FIND v(dout1_31) AT=655.025n

* CHECK dout1_32 Vdout1_32ck130 = 0.9 time = 655
.meas tran vdout1_32ck130 FIND v(dout1_32) AT=655.025n

* CHECK dout1_33 Vdout1_33ck130 = 0.9 time = 655
.meas tran vdout1_33ck130 FIND v(dout1_33) AT=655.025n

* CHECK dout1_34 Vdout1_34ck130 = 0.9 time = 655
.meas tran vdout1_34ck130 FIND v(dout1_34) AT=655.025n

* CHECK dout1_35 Vdout1_35ck130 = 0 time = 655
.meas tran vdout1_35ck130 FIND v(dout1_35) AT=655.025n

* CHECK dout1_36 Vdout1_36ck130 = 0 time = 655
.meas tran vdout1_36ck130 FIND v(dout1_36) AT=655.025n

* CHECK dout1_37 Vdout1_37ck130 = 0 time = 655
.meas tran vdout1_37ck130 FIND v(dout1_37) AT=655.025n

* CHECK dout1_38 Vdout1_38ck130 = 0.9 time = 655
.meas tran vdout1_38ck130 FIND v(dout1_38) AT=655.025n

* CHECK dout1_39 Vdout1_39ck130 = 0 time = 655
.meas tran vdout1_39ck130 FIND v(dout1_39) AT=655.025n

* CHECK dout1_40 Vdout1_40ck130 = 0 time = 655
.meas tran vdout1_40ck130 FIND v(dout1_40) AT=655.025n

* CHECK dout1_41 Vdout1_41ck130 = 0 time = 655
.meas tran vdout1_41ck130 FIND v(dout1_41) AT=655.025n

* CHECK dout1_42 Vdout1_42ck130 = 0.9 time = 655
.meas tran vdout1_42ck130 FIND v(dout1_42) AT=655.025n

* CHECK dout1_43 Vdout1_43ck130 = 0 time = 655
.meas tran vdout1_43ck130 FIND v(dout1_43) AT=655.025n

* CHECK dout1_44 Vdout1_44ck130 = 0.9 time = 655
.meas tran vdout1_44ck130 FIND v(dout1_44) AT=655.025n

* CHECK dout1_45 Vdout1_45ck130 = 0.9 time = 655
.meas tran vdout1_45ck130 FIND v(dout1_45) AT=655.025n

* CHECK dout1_46 Vdout1_46ck130 = 0.9 time = 655
.meas tran vdout1_46ck130 FIND v(dout1_46) AT=655.025n

* CHECK dout1_47 Vdout1_47ck130 = 0 time = 655
.meas tran vdout1_47ck130 FIND v(dout1_47) AT=655.025n

* CHECK dout1_48 Vdout1_48ck130 = 0.9 time = 655
.meas tran vdout1_48ck130 FIND v(dout1_48) AT=655.025n

* CHECK dout1_49 Vdout1_49ck130 = 0 time = 655
.meas tran vdout1_49ck130 FIND v(dout1_49) AT=655.025n

* CHECK dout1_50 Vdout1_50ck130 = 0 time = 655
.meas tran vdout1_50ck130 FIND v(dout1_50) AT=655.025n

* CHECK dout1_51 Vdout1_51ck130 = 0 time = 655
.meas tran vdout1_51ck130 FIND v(dout1_51) AT=655.025n

* CHECK dout1_52 Vdout1_52ck130 = 0.9 time = 655
.meas tran vdout1_52ck130 FIND v(dout1_52) AT=655.025n

* CHECK dout1_53 Vdout1_53ck130 = 0.9 time = 655
.meas tran vdout1_53ck130 FIND v(dout1_53) AT=655.025n

* CHECK dout1_54 Vdout1_54ck130 = 0.9 time = 655
.meas tran vdout1_54ck130 FIND v(dout1_54) AT=655.025n

* CHECK dout1_55 Vdout1_55ck130 = 0 time = 655
.meas tran vdout1_55ck130 FIND v(dout1_55) AT=655.025n

* CHECK dout1_56 Vdout1_56ck130 = 0 time = 655
.meas tran vdout1_56ck130 FIND v(dout1_56) AT=655.025n

* CHECK dout1_57 Vdout1_57ck130 = 0.9 time = 655
.meas tran vdout1_57ck130 FIND v(dout1_57) AT=655.025n

* CHECK dout1_58 Vdout1_58ck130 = 0 time = 655
.meas tran vdout1_58ck130 FIND v(dout1_58) AT=655.025n

* CHECK dout1_59 Vdout1_59ck130 = 0.9 time = 655
.meas tran vdout1_59ck130 FIND v(dout1_59) AT=655.025n

* CHECK dout1_60 Vdout1_60ck130 = 0.9 time = 655
.meas tran vdout1_60ck130 FIND v(dout1_60) AT=655.025n

* CHECK dout1_61 Vdout1_61ck130 = 0.9 time = 655
.meas tran vdout1_61ck130 FIND v(dout1_61) AT=655.025n

* CHECK dout1_62 Vdout1_62ck130 = 0.9 time = 655
.meas tran vdout1_62ck130 FIND v(dout1_62) AT=655.025n

* CHECK dout1_63 Vdout1_63ck130 = 0.9 time = 655
.meas tran vdout1_63ck130 FIND v(dout1_63) AT=655.025n

* CHECK dout1_64 Vdout1_64ck130 = 0 time = 655
.meas tran vdout1_64ck130 FIND v(dout1_64) AT=655.025n

* CHECK dout1_65 Vdout1_65ck130 = 0 time = 655
.meas tran vdout1_65ck130 FIND v(dout1_65) AT=655.025n

* CHECK dout1_66 Vdout1_66ck130 = 0.9 time = 655
.meas tran vdout1_66ck130 FIND v(dout1_66) AT=655.025n

* CHECK dout1_67 Vdout1_67ck130 = 0 time = 655
.meas tran vdout1_67ck130 FIND v(dout1_67) AT=655.025n

* CHECK dout1_68 Vdout1_68ck130 = 0 time = 655
.meas tran vdout1_68ck130 FIND v(dout1_68) AT=655.025n

* CHECK dout1_69 Vdout1_69ck130 = 0 time = 655
.meas tran vdout1_69ck130 FIND v(dout1_69) AT=655.025n

* CHECK dout1_70 Vdout1_70ck130 = 0.9 time = 655
.meas tran vdout1_70ck130 FIND v(dout1_70) AT=655.025n

* CHECK dout1_71 Vdout1_71ck130 = 0 time = 655
.meas tran vdout1_71ck130 FIND v(dout1_71) AT=655.025n

* CHECK dout1_72 Vdout1_72ck130 = 0.9 time = 655
.meas tran vdout1_72ck130 FIND v(dout1_72) AT=655.025n

* CHECK dout1_73 Vdout1_73ck130 = 0.9 time = 655
.meas tran vdout1_73ck130 FIND v(dout1_73) AT=655.025n

* CHECK dout1_74 Vdout1_74ck130 = 0.9 time = 655
.meas tran vdout1_74ck130 FIND v(dout1_74) AT=655.025n

* CHECK dout1_75 Vdout1_75ck130 = 0 time = 655
.meas tran vdout1_75ck130 FIND v(dout1_75) AT=655.025n

* CHECK dout1_76 Vdout1_76ck130 = 0 time = 655
.meas tran vdout1_76ck130 FIND v(dout1_76) AT=655.025n

* CHECK dout1_77 Vdout1_77ck130 = 0.9 time = 655
.meas tran vdout1_77ck130 FIND v(dout1_77) AT=655.025n

* CHECK dout1_78 Vdout1_78ck130 = 0.9 time = 655
.meas tran vdout1_78ck130 FIND v(dout1_78) AT=655.025n

* CHECK dout1_79 Vdout1_79ck130 = 0 time = 655
.meas tran vdout1_79ck130 FIND v(dout1_79) AT=655.025n

* CHECK dout1_80 Vdout1_80ck130 = 0.9 time = 655
.meas tran vdout1_80ck130 FIND v(dout1_80) AT=655.025n

* CHECK dout1_81 Vdout1_81ck130 = 0 time = 655
.meas tran vdout1_81ck130 FIND v(dout1_81) AT=655.025n

* CHECK dout1_82 Vdout1_82ck130 = 0 time = 655
.meas tran vdout1_82ck130 FIND v(dout1_82) AT=655.025n

* CHECK dout1_83 Vdout1_83ck130 = 0 time = 655
.meas tran vdout1_83ck130 FIND v(dout1_83) AT=655.025n

* CHECK dout1_84 Vdout1_84ck130 = 0 time = 655
.meas tran vdout1_84ck130 FIND v(dout1_84) AT=655.025n

* CHECK dout1_85 Vdout1_85ck130 = 0 time = 655
.meas tran vdout1_85ck130 FIND v(dout1_85) AT=655.025n

* CHECK dout1_86 Vdout1_86ck130 = 0.9 time = 655
.meas tran vdout1_86ck130 FIND v(dout1_86) AT=655.025n

* CHECK dout1_87 Vdout1_87ck130 = 0 time = 655
.meas tran vdout1_87ck130 FIND v(dout1_87) AT=655.025n

* CHECK dout1_88 Vdout1_88ck130 = 0.9 time = 655
.meas tran vdout1_88ck130 FIND v(dout1_88) AT=655.025n

* CHECK dout1_89 Vdout1_89ck130 = 0.9 time = 655
.meas tran vdout1_89ck130 FIND v(dout1_89) AT=655.025n

* CHECK dout1_90 Vdout1_90ck130 = 0 time = 655
.meas tran vdout1_90ck130 FIND v(dout1_90) AT=655.025n

* CHECK dout1_91 Vdout1_91ck130 = 0.9 time = 655
.meas tran vdout1_91ck130 FIND v(dout1_91) AT=655.025n

* CHECK dout1_92 Vdout1_92ck130 = 0.9 time = 655
.meas tran vdout1_92ck130 FIND v(dout1_92) AT=655.025n

* CHECK dout1_93 Vdout1_93ck130 = 0 time = 655
.meas tran vdout1_93ck130 FIND v(dout1_93) AT=655.025n

* CHECK dout1_94 Vdout1_94ck130 = 0 time = 655
.meas tran vdout1_94ck130 FIND v(dout1_94) AT=655.025n

* CHECK dout1_95 Vdout1_95ck130 = 0.9 time = 655
.meas tran vdout1_95ck130 FIND v(dout1_95) AT=655.025n

* CHECK dout1_0 Vdout1_0ck131 = 0.9 time = 660
.meas tran vdout1_0ck131 FIND v(dout1_0) AT=660.025n

* CHECK dout1_1 Vdout1_1ck131 = 0.9 time = 660
.meas tran vdout1_1ck131 FIND v(dout1_1) AT=660.025n

* CHECK dout1_2 Vdout1_2ck131 = 0.9 time = 660
.meas tran vdout1_2ck131 FIND v(dout1_2) AT=660.025n

* CHECK dout1_3 Vdout1_3ck131 = 0 time = 660
.meas tran vdout1_3ck131 FIND v(dout1_3) AT=660.025n

* CHECK dout1_4 Vdout1_4ck131 = 0.9 time = 660
.meas tran vdout1_4ck131 FIND v(dout1_4) AT=660.025n

* CHECK dout1_5 Vdout1_5ck131 = 0.9 time = 660
.meas tran vdout1_5ck131 FIND v(dout1_5) AT=660.025n

* CHECK dout1_6 Vdout1_6ck131 = 0.9 time = 660
.meas tran vdout1_6ck131 FIND v(dout1_6) AT=660.025n

* CHECK dout1_7 Vdout1_7ck131 = 0.9 time = 660
.meas tran vdout1_7ck131 FIND v(dout1_7) AT=660.025n

* CHECK dout1_8 Vdout1_8ck131 = 0.9 time = 660
.meas tran vdout1_8ck131 FIND v(dout1_8) AT=660.025n

* CHECK dout1_9 Vdout1_9ck131 = 0 time = 660
.meas tran vdout1_9ck131 FIND v(dout1_9) AT=660.025n

* CHECK dout1_10 Vdout1_10ck131 = 0.9 time = 660
.meas tran vdout1_10ck131 FIND v(dout1_10) AT=660.025n

* CHECK dout1_11 Vdout1_11ck131 = 0 time = 660
.meas tran vdout1_11ck131 FIND v(dout1_11) AT=660.025n

* CHECK dout1_12 Vdout1_12ck131 = 0.9 time = 660
.meas tran vdout1_12ck131 FIND v(dout1_12) AT=660.025n

* CHECK dout1_13 Vdout1_13ck131 = 0 time = 660
.meas tran vdout1_13ck131 FIND v(dout1_13) AT=660.025n

* CHECK dout1_14 Vdout1_14ck131 = 0.9 time = 660
.meas tran vdout1_14ck131 FIND v(dout1_14) AT=660.025n

* CHECK dout1_15 Vdout1_15ck131 = 0.9 time = 660
.meas tran vdout1_15ck131 FIND v(dout1_15) AT=660.025n

* CHECK dout1_16 Vdout1_16ck131 = 0.9 time = 660
.meas tran vdout1_16ck131 FIND v(dout1_16) AT=660.025n

* CHECK dout1_17 Vdout1_17ck131 = 0.9 time = 660
.meas tran vdout1_17ck131 FIND v(dout1_17) AT=660.025n

* CHECK dout1_18 Vdout1_18ck131 = 0.9 time = 660
.meas tran vdout1_18ck131 FIND v(dout1_18) AT=660.025n

* CHECK dout1_19 Vdout1_19ck131 = 0.9 time = 660
.meas tran vdout1_19ck131 FIND v(dout1_19) AT=660.025n

* CHECK dout1_20 Vdout1_20ck131 = 0 time = 660
.meas tran vdout1_20ck131 FIND v(dout1_20) AT=660.025n

* CHECK dout1_21 Vdout1_21ck131 = 0 time = 660
.meas tran vdout1_21ck131 FIND v(dout1_21) AT=660.025n

* CHECK dout1_22 Vdout1_22ck131 = 0 time = 660
.meas tran vdout1_22ck131 FIND v(dout1_22) AT=660.025n

* CHECK dout1_23 Vdout1_23ck131 = 0 time = 660
.meas tran vdout1_23ck131 FIND v(dout1_23) AT=660.025n

* CHECK dout1_24 Vdout1_24ck131 = 0 time = 660
.meas tran vdout1_24ck131 FIND v(dout1_24) AT=660.025n

* CHECK dout1_25 Vdout1_25ck131 = 0.9 time = 660
.meas tran vdout1_25ck131 FIND v(dout1_25) AT=660.025n

* CHECK dout1_26 Vdout1_26ck131 = 0 time = 660
.meas tran vdout1_26ck131 FIND v(dout1_26) AT=660.025n

* CHECK dout1_27 Vdout1_27ck131 = 0.9 time = 660
.meas tran vdout1_27ck131 FIND v(dout1_27) AT=660.025n

* CHECK dout1_28 Vdout1_28ck131 = 0 time = 660
.meas tran vdout1_28ck131 FIND v(dout1_28) AT=660.025n

* CHECK dout1_29 Vdout1_29ck131 = 0.9 time = 660
.meas tran vdout1_29ck131 FIND v(dout1_29) AT=660.025n

* CHECK dout1_30 Vdout1_30ck131 = 0.9 time = 660
.meas tran vdout1_30ck131 FIND v(dout1_30) AT=660.025n

* CHECK dout1_31 Vdout1_31ck131 = 0.9 time = 660
.meas tran vdout1_31ck131 FIND v(dout1_31) AT=660.025n

* CHECK dout1_32 Vdout1_32ck131 = 0.9 time = 660
.meas tran vdout1_32ck131 FIND v(dout1_32) AT=660.025n

* CHECK dout1_33 Vdout1_33ck131 = 0.9 time = 660
.meas tran vdout1_33ck131 FIND v(dout1_33) AT=660.025n

* CHECK dout1_34 Vdout1_34ck131 = 0.9 time = 660
.meas tran vdout1_34ck131 FIND v(dout1_34) AT=660.025n

* CHECK dout1_35 Vdout1_35ck131 = 0 time = 660
.meas tran vdout1_35ck131 FIND v(dout1_35) AT=660.025n

* CHECK dout1_36 Vdout1_36ck131 = 0 time = 660
.meas tran vdout1_36ck131 FIND v(dout1_36) AT=660.025n

* CHECK dout1_37 Vdout1_37ck131 = 0 time = 660
.meas tran vdout1_37ck131 FIND v(dout1_37) AT=660.025n

* CHECK dout1_38 Vdout1_38ck131 = 0.9 time = 660
.meas tran vdout1_38ck131 FIND v(dout1_38) AT=660.025n

* CHECK dout1_39 Vdout1_39ck131 = 0 time = 660
.meas tran vdout1_39ck131 FIND v(dout1_39) AT=660.025n

* CHECK dout1_40 Vdout1_40ck131 = 0 time = 660
.meas tran vdout1_40ck131 FIND v(dout1_40) AT=660.025n

* CHECK dout1_41 Vdout1_41ck131 = 0 time = 660
.meas tran vdout1_41ck131 FIND v(dout1_41) AT=660.025n

* CHECK dout1_42 Vdout1_42ck131 = 0.9 time = 660
.meas tran vdout1_42ck131 FIND v(dout1_42) AT=660.025n

* CHECK dout1_43 Vdout1_43ck131 = 0 time = 660
.meas tran vdout1_43ck131 FIND v(dout1_43) AT=660.025n

* CHECK dout1_44 Vdout1_44ck131 = 0.9 time = 660
.meas tran vdout1_44ck131 FIND v(dout1_44) AT=660.025n

* CHECK dout1_45 Vdout1_45ck131 = 0.9 time = 660
.meas tran vdout1_45ck131 FIND v(dout1_45) AT=660.025n

* CHECK dout1_46 Vdout1_46ck131 = 0.9 time = 660
.meas tran vdout1_46ck131 FIND v(dout1_46) AT=660.025n

* CHECK dout1_47 Vdout1_47ck131 = 0 time = 660
.meas tran vdout1_47ck131 FIND v(dout1_47) AT=660.025n

* CHECK dout1_48 Vdout1_48ck131 = 0.9 time = 660
.meas tran vdout1_48ck131 FIND v(dout1_48) AT=660.025n

* CHECK dout1_49 Vdout1_49ck131 = 0 time = 660
.meas tran vdout1_49ck131 FIND v(dout1_49) AT=660.025n

* CHECK dout1_50 Vdout1_50ck131 = 0 time = 660
.meas tran vdout1_50ck131 FIND v(dout1_50) AT=660.025n

* CHECK dout1_51 Vdout1_51ck131 = 0 time = 660
.meas tran vdout1_51ck131 FIND v(dout1_51) AT=660.025n

* CHECK dout1_52 Vdout1_52ck131 = 0.9 time = 660
.meas tran vdout1_52ck131 FIND v(dout1_52) AT=660.025n

* CHECK dout1_53 Vdout1_53ck131 = 0.9 time = 660
.meas tran vdout1_53ck131 FIND v(dout1_53) AT=660.025n

* CHECK dout1_54 Vdout1_54ck131 = 0.9 time = 660
.meas tran vdout1_54ck131 FIND v(dout1_54) AT=660.025n

* CHECK dout1_55 Vdout1_55ck131 = 0 time = 660
.meas tran vdout1_55ck131 FIND v(dout1_55) AT=660.025n

* CHECK dout1_56 Vdout1_56ck131 = 0 time = 660
.meas tran vdout1_56ck131 FIND v(dout1_56) AT=660.025n

* CHECK dout1_57 Vdout1_57ck131 = 0.9 time = 660
.meas tran vdout1_57ck131 FIND v(dout1_57) AT=660.025n

* CHECK dout1_58 Vdout1_58ck131 = 0 time = 660
.meas tran vdout1_58ck131 FIND v(dout1_58) AT=660.025n

* CHECK dout1_59 Vdout1_59ck131 = 0.9 time = 660
.meas tran vdout1_59ck131 FIND v(dout1_59) AT=660.025n

* CHECK dout1_60 Vdout1_60ck131 = 0.9 time = 660
.meas tran vdout1_60ck131 FIND v(dout1_60) AT=660.025n

* CHECK dout1_61 Vdout1_61ck131 = 0.9 time = 660
.meas tran vdout1_61ck131 FIND v(dout1_61) AT=660.025n

* CHECK dout1_62 Vdout1_62ck131 = 0.9 time = 660
.meas tran vdout1_62ck131 FIND v(dout1_62) AT=660.025n

* CHECK dout1_63 Vdout1_63ck131 = 0.9 time = 660
.meas tran vdout1_63ck131 FIND v(dout1_63) AT=660.025n

* CHECK dout1_64 Vdout1_64ck131 = 0 time = 660
.meas tran vdout1_64ck131 FIND v(dout1_64) AT=660.025n

* CHECK dout1_65 Vdout1_65ck131 = 0 time = 660
.meas tran vdout1_65ck131 FIND v(dout1_65) AT=660.025n

* CHECK dout1_66 Vdout1_66ck131 = 0.9 time = 660
.meas tran vdout1_66ck131 FIND v(dout1_66) AT=660.025n

* CHECK dout1_67 Vdout1_67ck131 = 0 time = 660
.meas tran vdout1_67ck131 FIND v(dout1_67) AT=660.025n

* CHECK dout1_68 Vdout1_68ck131 = 0 time = 660
.meas tran vdout1_68ck131 FIND v(dout1_68) AT=660.025n

* CHECK dout1_69 Vdout1_69ck131 = 0 time = 660
.meas tran vdout1_69ck131 FIND v(dout1_69) AT=660.025n

* CHECK dout1_70 Vdout1_70ck131 = 0.9 time = 660
.meas tran vdout1_70ck131 FIND v(dout1_70) AT=660.025n

* CHECK dout1_71 Vdout1_71ck131 = 0 time = 660
.meas tran vdout1_71ck131 FIND v(dout1_71) AT=660.025n

* CHECK dout1_72 Vdout1_72ck131 = 0.9 time = 660
.meas tran vdout1_72ck131 FIND v(dout1_72) AT=660.025n

* CHECK dout1_73 Vdout1_73ck131 = 0.9 time = 660
.meas tran vdout1_73ck131 FIND v(dout1_73) AT=660.025n

* CHECK dout1_74 Vdout1_74ck131 = 0.9 time = 660
.meas tran vdout1_74ck131 FIND v(dout1_74) AT=660.025n

* CHECK dout1_75 Vdout1_75ck131 = 0 time = 660
.meas tran vdout1_75ck131 FIND v(dout1_75) AT=660.025n

* CHECK dout1_76 Vdout1_76ck131 = 0 time = 660
.meas tran vdout1_76ck131 FIND v(dout1_76) AT=660.025n

* CHECK dout1_77 Vdout1_77ck131 = 0.9 time = 660
.meas tran vdout1_77ck131 FIND v(dout1_77) AT=660.025n

* CHECK dout1_78 Vdout1_78ck131 = 0.9 time = 660
.meas tran vdout1_78ck131 FIND v(dout1_78) AT=660.025n

* CHECK dout1_79 Vdout1_79ck131 = 0 time = 660
.meas tran vdout1_79ck131 FIND v(dout1_79) AT=660.025n

* CHECK dout1_80 Vdout1_80ck131 = 0.9 time = 660
.meas tran vdout1_80ck131 FIND v(dout1_80) AT=660.025n

* CHECK dout1_81 Vdout1_81ck131 = 0 time = 660
.meas tran vdout1_81ck131 FIND v(dout1_81) AT=660.025n

* CHECK dout1_82 Vdout1_82ck131 = 0 time = 660
.meas tran vdout1_82ck131 FIND v(dout1_82) AT=660.025n

* CHECK dout1_83 Vdout1_83ck131 = 0 time = 660
.meas tran vdout1_83ck131 FIND v(dout1_83) AT=660.025n

* CHECK dout1_84 Vdout1_84ck131 = 0 time = 660
.meas tran vdout1_84ck131 FIND v(dout1_84) AT=660.025n

* CHECK dout1_85 Vdout1_85ck131 = 0 time = 660
.meas tran vdout1_85ck131 FIND v(dout1_85) AT=660.025n

* CHECK dout1_86 Vdout1_86ck131 = 0.9 time = 660
.meas tran vdout1_86ck131 FIND v(dout1_86) AT=660.025n

* CHECK dout1_87 Vdout1_87ck131 = 0 time = 660
.meas tran vdout1_87ck131 FIND v(dout1_87) AT=660.025n

* CHECK dout1_88 Vdout1_88ck131 = 0.9 time = 660
.meas tran vdout1_88ck131 FIND v(dout1_88) AT=660.025n

* CHECK dout1_89 Vdout1_89ck131 = 0.9 time = 660
.meas tran vdout1_89ck131 FIND v(dout1_89) AT=660.025n

* CHECK dout1_90 Vdout1_90ck131 = 0 time = 660
.meas tran vdout1_90ck131 FIND v(dout1_90) AT=660.025n

* CHECK dout1_91 Vdout1_91ck131 = 0.9 time = 660
.meas tran vdout1_91ck131 FIND v(dout1_91) AT=660.025n

* CHECK dout1_92 Vdout1_92ck131 = 0.9 time = 660
.meas tran vdout1_92ck131 FIND v(dout1_92) AT=660.025n

* CHECK dout1_93 Vdout1_93ck131 = 0 time = 660
.meas tran vdout1_93ck131 FIND v(dout1_93) AT=660.025n

* CHECK dout1_94 Vdout1_94ck131 = 0 time = 660
.meas tran vdout1_94ck131 FIND v(dout1_94) AT=660.025n

* CHECK dout1_95 Vdout1_95ck131 = 0.9 time = 660
.meas tran vdout1_95ck131 FIND v(dout1_95) AT=660.025n

* CHECK dout1_0 Vdout1_0ck133 = 0.9 time = 670
.meas tran vdout1_0ck133 FIND v(dout1_0) AT=670.025n

* CHECK dout1_1 Vdout1_1ck133 = 0.9 time = 670
.meas tran vdout1_1ck133 FIND v(dout1_1) AT=670.025n

* CHECK dout1_2 Vdout1_2ck133 = 0.9 time = 670
.meas tran vdout1_2ck133 FIND v(dout1_2) AT=670.025n

* CHECK dout1_3 Vdout1_3ck133 = 0 time = 670
.meas tran vdout1_3ck133 FIND v(dout1_3) AT=670.025n

* CHECK dout1_4 Vdout1_4ck133 = 0.9 time = 670
.meas tran vdout1_4ck133 FIND v(dout1_4) AT=670.025n

* CHECK dout1_5 Vdout1_5ck133 = 0.9 time = 670
.meas tran vdout1_5ck133 FIND v(dout1_5) AT=670.025n

* CHECK dout1_6 Vdout1_6ck133 = 0.9 time = 670
.meas tran vdout1_6ck133 FIND v(dout1_6) AT=670.025n

* CHECK dout1_7 Vdout1_7ck133 = 0.9 time = 670
.meas tran vdout1_7ck133 FIND v(dout1_7) AT=670.025n

* CHECK dout1_8 Vdout1_8ck133 = 0.9 time = 670
.meas tran vdout1_8ck133 FIND v(dout1_8) AT=670.025n

* CHECK dout1_9 Vdout1_9ck133 = 0 time = 670
.meas tran vdout1_9ck133 FIND v(dout1_9) AT=670.025n

* CHECK dout1_10 Vdout1_10ck133 = 0.9 time = 670
.meas tran vdout1_10ck133 FIND v(dout1_10) AT=670.025n

* CHECK dout1_11 Vdout1_11ck133 = 0 time = 670
.meas tran vdout1_11ck133 FIND v(dout1_11) AT=670.025n

* CHECK dout1_12 Vdout1_12ck133 = 0.9 time = 670
.meas tran vdout1_12ck133 FIND v(dout1_12) AT=670.025n

* CHECK dout1_13 Vdout1_13ck133 = 0 time = 670
.meas tran vdout1_13ck133 FIND v(dout1_13) AT=670.025n

* CHECK dout1_14 Vdout1_14ck133 = 0.9 time = 670
.meas tran vdout1_14ck133 FIND v(dout1_14) AT=670.025n

* CHECK dout1_15 Vdout1_15ck133 = 0.9 time = 670
.meas tran vdout1_15ck133 FIND v(dout1_15) AT=670.025n

* CHECK dout1_16 Vdout1_16ck133 = 0.9 time = 670
.meas tran vdout1_16ck133 FIND v(dout1_16) AT=670.025n

* CHECK dout1_17 Vdout1_17ck133 = 0.9 time = 670
.meas tran vdout1_17ck133 FIND v(dout1_17) AT=670.025n

* CHECK dout1_18 Vdout1_18ck133 = 0.9 time = 670
.meas tran vdout1_18ck133 FIND v(dout1_18) AT=670.025n

* CHECK dout1_19 Vdout1_19ck133 = 0.9 time = 670
.meas tran vdout1_19ck133 FIND v(dout1_19) AT=670.025n

* CHECK dout1_20 Vdout1_20ck133 = 0 time = 670
.meas tran vdout1_20ck133 FIND v(dout1_20) AT=670.025n

* CHECK dout1_21 Vdout1_21ck133 = 0 time = 670
.meas tran vdout1_21ck133 FIND v(dout1_21) AT=670.025n

* CHECK dout1_22 Vdout1_22ck133 = 0 time = 670
.meas tran vdout1_22ck133 FIND v(dout1_22) AT=670.025n

* CHECK dout1_23 Vdout1_23ck133 = 0 time = 670
.meas tran vdout1_23ck133 FIND v(dout1_23) AT=670.025n

* CHECK dout1_24 Vdout1_24ck133 = 0 time = 670
.meas tran vdout1_24ck133 FIND v(dout1_24) AT=670.025n

* CHECK dout1_25 Vdout1_25ck133 = 0.9 time = 670
.meas tran vdout1_25ck133 FIND v(dout1_25) AT=670.025n

* CHECK dout1_26 Vdout1_26ck133 = 0 time = 670
.meas tran vdout1_26ck133 FIND v(dout1_26) AT=670.025n

* CHECK dout1_27 Vdout1_27ck133 = 0.9 time = 670
.meas tran vdout1_27ck133 FIND v(dout1_27) AT=670.025n

* CHECK dout1_28 Vdout1_28ck133 = 0 time = 670
.meas tran vdout1_28ck133 FIND v(dout1_28) AT=670.025n

* CHECK dout1_29 Vdout1_29ck133 = 0.9 time = 670
.meas tran vdout1_29ck133 FIND v(dout1_29) AT=670.025n

* CHECK dout1_30 Vdout1_30ck133 = 0.9 time = 670
.meas tran vdout1_30ck133 FIND v(dout1_30) AT=670.025n

* CHECK dout1_31 Vdout1_31ck133 = 0.9 time = 670
.meas tran vdout1_31ck133 FIND v(dout1_31) AT=670.025n

* CHECK dout1_32 Vdout1_32ck133 = 0.9 time = 670
.meas tran vdout1_32ck133 FIND v(dout1_32) AT=670.025n

* CHECK dout1_33 Vdout1_33ck133 = 0.9 time = 670
.meas tran vdout1_33ck133 FIND v(dout1_33) AT=670.025n

* CHECK dout1_34 Vdout1_34ck133 = 0.9 time = 670
.meas tran vdout1_34ck133 FIND v(dout1_34) AT=670.025n

* CHECK dout1_35 Vdout1_35ck133 = 0 time = 670
.meas tran vdout1_35ck133 FIND v(dout1_35) AT=670.025n

* CHECK dout1_36 Vdout1_36ck133 = 0 time = 670
.meas tran vdout1_36ck133 FIND v(dout1_36) AT=670.025n

* CHECK dout1_37 Vdout1_37ck133 = 0 time = 670
.meas tran vdout1_37ck133 FIND v(dout1_37) AT=670.025n

* CHECK dout1_38 Vdout1_38ck133 = 0.9 time = 670
.meas tran vdout1_38ck133 FIND v(dout1_38) AT=670.025n

* CHECK dout1_39 Vdout1_39ck133 = 0 time = 670
.meas tran vdout1_39ck133 FIND v(dout1_39) AT=670.025n

* CHECK dout1_40 Vdout1_40ck133 = 0 time = 670
.meas tran vdout1_40ck133 FIND v(dout1_40) AT=670.025n

* CHECK dout1_41 Vdout1_41ck133 = 0 time = 670
.meas tran vdout1_41ck133 FIND v(dout1_41) AT=670.025n

* CHECK dout1_42 Vdout1_42ck133 = 0.9 time = 670
.meas tran vdout1_42ck133 FIND v(dout1_42) AT=670.025n

* CHECK dout1_43 Vdout1_43ck133 = 0 time = 670
.meas tran vdout1_43ck133 FIND v(dout1_43) AT=670.025n

* CHECK dout1_44 Vdout1_44ck133 = 0.9 time = 670
.meas tran vdout1_44ck133 FIND v(dout1_44) AT=670.025n

* CHECK dout1_45 Vdout1_45ck133 = 0.9 time = 670
.meas tran vdout1_45ck133 FIND v(dout1_45) AT=670.025n

* CHECK dout1_46 Vdout1_46ck133 = 0.9 time = 670
.meas tran vdout1_46ck133 FIND v(dout1_46) AT=670.025n

* CHECK dout1_47 Vdout1_47ck133 = 0 time = 670
.meas tran vdout1_47ck133 FIND v(dout1_47) AT=670.025n

* CHECK dout1_48 Vdout1_48ck133 = 0.9 time = 670
.meas tran vdout1_48ck133 FIND v(dout1_48) AT=670.025n

* CHECK dout1_49 Vdout1_49ck133 = 0 time = 670
.meas tran vdout1_49ck133 FIND v(dout1_49) AT=670.025n

* CHECK dout1_50 Vdout1_50ck133 = 0 time = 670
.meas tran vdout1_50ck133 FIND v(dout1_50) AT=670.025n

* CHECK dout1_51 Vdout1_51ck133 = 0 time = 670
.meas tran vdout1_51ck133 FIND v(dout1_51) AT=670.025n

* CHECK dout1_52 Vdout1_52ck133 = 0.9 time = 670
.meas tran vdout1_52ck133 FIND v(dout1_52) AT=670.025n

* CHECK dout1_53 Vdout1_53ck133 = 0.9 time = 670
.meas tran vdout1_53ck133 FIND v(dout1_53) AT=670.025n

* CHECK dout1_54 Vdout1_54ck133 = 0.9 time = 670
.meas tran vdout1_54ck133 FIND v(dout1_54) AT=670.025n

* CHECK dout1_55 Vdout1_55ck133 = 0 time = 670
.meas tran vdout1_55ck133 FIND v(dout1_55) AT=670.025n

* CHECK dout1_56 Vdout1_56ck133 = 0 time = 670
.meas tran vdout1_56ck133 FIND v(dout1_56) AT=670.025n

* CHECK dout1_57 Vdout1_57ck133 = 0.9 time = 670
.meas tran vdout1_57ck133 FIND v(dout1_57) AT=670.025n

* CHECK dout1_58 Vdout1_58ck133 = 0 time = 670
.meas tran vdout1_58ck133 FIND v(dout1_58) AT=670.025n

* CHECK dout1_59 Vdout1_59ck133 = 0.9 time = 670
.meas tran vdout1_59ck133 FIND v(dout1_59) AT=670.025n

* CHECK dout1_60 Vdout1_60ck133 = 0.9 time = 670
.meas tran vdout1_60ck133 FIND v(dout1_60) AT=670.025n

* CHECK dout1_61 Vdout1_61ck133 = 0.9 time = 670
.meas tran vdout1_61ck133 FIND v(dout1_61) AT=670.025n

* CHECK dout1_62 Vdout1_62ck133 = 0.9 time = 670
.meas tran vdout1_62ck133 FIND v(dout1_62) AT=670.025n

* CHECK dout1_63 Vdout1_63ck133 = 0.9 time = 670
.meas tran vdout1_63ck133 FIND v(dout1_63) AT=670.025n

* CHECK dout1_64 Vdout1_64ck133 = 0 time = 670
.meas tran vdout1_64ck133 FIND v(dout1_64) AT=670.025n

* CHECK dout1_65 Vdout1_65ck133 = 0 time = 670
.meas tran vdout1_65ck133 FIND v(dout1_65) AT=670.025n

* CHECK dout1_66 Vdout1_66ck133 = 0.9 time = 670
.meas tran vdout1_66ck133 FIND v(dout1_66) AT=670.025n

* CHECK dout1_67 Vdout1_67ck133 = 0 time = 670
.meas tran vdout1_67ck133 FIND v(dout1_67) AT=670.025n

* CHECK dout1_68 Vdout1_68ck133 = 0 time = 670
.meas tran vdout1_68ck133 FIND v(dout1_68) AT=670.025n

* CHECK dout1_69 Vdout1_69ck133 = 0 time = 670
.meas tran vdout1_69ck133 FIND v(dout1_69) AT=670.025n

* CHECK dout1_70 Vdout1_70ck133 = 0.9 time = 670
.meas tran vdout1_70ck133 FIND v(dout1_70) AT=670.025n

* CHECK dout1_71 Vdout1_71ck133 = 0 time = 670
.meas tran vdout1_71ck133 FIND v(dout1_71) AT=670.025n

* CHECK dout1_72 Vdout1_72ck133 = 0.9 time = 670
.meas tran vdout1_72ck133 FIND v(dout1_72) AT=670.025n

* CHECK dout1_73 Vdout1_73ck133 = 0.9 time = 670
.meas tran vdout1_73ck133 FIND v(dout1_73) AT=670.025n

* CHECK dout1_74 Vdout1_74ck133 = 0.9 time = 670
.meas tran vdout1_74ck133 FIND v(dout1_74) AT=670.025n

* CHECK dout1_75 Vdout1_75ck133 = 0 time = 670
.meas tran vdout1_75ck133 FIND v(dout1_75) AT=670.025n

* CHECK dout1_76 Vdout1_76ck133 = 0 time = 670
.meas tran vdout1_76ck133 FIND v(dout1_76) AT=670.025n

* CHECK dout1_77 Vdout1_77ck133 = 0.9 time = 670
.meas tran vdout1_77ck133 FIND v(dout1_77) AT=670.025n

* CHECK dout1_78 Vdout1_78ck133 = 0.9 time = 670
.meas tran vdout1_78ck133 FIND v(dout1_78) AT=670.025n

* CHECK dout1_79 Vdout1_79ck133 = 0 time = 670
.meas tran vdout1_79ck133 FIND v(dout1_79) AT=670.025n

* CHECK dout1_80 Vdout1_80ck133 = 0.9 time = 670
.meas tran vdout1_80ck133 FIND v(dout1_80) AT=670.025n

* CHECK dout1_81 Vdout1_81ck133 = 0 time = 670
.meas tran vdout1_81ck133 FIND v(dout1_81) AT=670.025n

* CHECK dout1_82 Vdout1_82ck133 = 0 time = 670
.meas tran vdout1_82ck133 FIND v(dout1_82) AT=670.025n

* CHECK dout1_83 Vdout1_83ck133 = 0 time = 670
.meas tran vdout1_83ck133 FIND v(dout1_83) AT=670.025n

* CHECK dout1_84 Vdout1_84ck133 = 0 time = 670
.meas tran vdout1_84ck133 FIND v(dout1_84) AT=670.025n

* CHECK dout1_85 Vdout1_85ck133 = 0 time = 670
.meas tran vdout1_85ck133 FIND v(dout1_85) AT=670.025n

* CHECK dout1_86 Vdout1_86ck133 = 0.9 time = 670
.meas tran vdout1_86ck133 FIND v(dout1_86) AT=670.025n

* CHECK dout1_87 Vdout1_87ck133 = 0 time = 670
.meas tran vdout1_87ck133 FIND v(dout1_87) AT=670.025n

* CHECK dout1_88 Vdout1_88ck133 = 0.9 time = 670
.meas tran vdout1_88ck133 FIND v(dout1_88) AT=670.025n

* CHECK dout1_89 Vdout1_89ck133 = 0.9 time = 670
.meas tran vdout1_89ck133 FIND v(dout1_89) AT=670.025n

* CHECK dout1_90 Vdout1_90ck133 = 0 time = 670
.meas tran vdout1_90ck133 FIND v(dout1_90) AT=670.025n

* CHECK dout1_91 Vdout1_91ck133 = 0.9 time = 670
.meas tran vdout1_91ck133 FIND v(dout1_91) AT=670.025n

* CHECK dout1_92 Vdout1_92ck133 = 0.9 time = 670
.meas tran vdout1_92ck133 FIND v(dout1_92) AT=670.025n

* CHECK dout1_93 Vdout1_93ck133 = 0 time = 670
.meas tran vdout1_93ck133 FIND v(dout1_93) AT=670.025n

* CHECK dout1_94 Vdout1_94ck133 = 0 time = 670
.meas tran vdout1_94ck133 FIND v(dout1_94) AT=670.025n

* CHECK dout1_95 Vdout1_95ck133 = 0.9 time = 670
.meas tran vdout1_95ck133 FIND v(dout1_95) AT=670.025n

* CHECK dout1_0 Vdout1_0ck143 = 0.9 time = 720
.meas tran vdout1_0ck143 FIND v(dout1_0) AT=720.025n

* CHECK dout1_1 Vdout1_1ck143 = 0 time = 720
.meas tran vdout1_1ck143 FIND v(dout1_1) AT=720.025n

* CHECK dout1_2 Vdout1_2ck143 = 0.9 time = 720
.meas tran vdout1_2ck143 FIND v(dout1_2) AT=720.025n

* CHECK dout1_3 Vdout1_3ck143 = 0.9 time = 720
.meas tran vdout1_3ck143 FIND v(dout1_3) AT=720.025n

* CHECK dout1_4 Vdout1_4ck143 = 0 time = 720
.meas tran vdout1_4ck143 FIND v(dout1_4) AT=720.025n

* CHECK dout1_5 Vdout1_5ck143 = 0 time = 720
.meas tran vdout1_5ck143 FIND v(dout1_5) AT=720.025n

* CHECK dout1_6 Vdout1_6ck143 = 0 time = 720
.meas tran vdout1_6ck143 FIND v(dout1_6) AT=720.025n

* CHECK dout1_7 Vdout1_7ck143 = 0 time = 720
.meas tran vdout1_7ck143 FIND v(dout1_7) AT=720.025n

* CHECK dout1_8 Vdout1_8ck143 = 0 time = 720
.meas tran vdout1_8ck143 FIND v(dout1_8) AT=720.025n

* CHECK dout1_9 Vdout1_9ck143 = 0 time = 720
.meas tran vdout1_9ck143 FIND v(dout1_9) AT=720.025n

* CHECK dout1_10 Vdout1_10ck143 = 0 time = 720
.meas tran vdout1_10ck143 FIND v(dout1_10) AT=720.025n

* CHECK dout1_11 Vdout1_11ck143 = 0 time = 720
.meas tran vdout1_11ck143 FIND v(dout1_11) AT=720.025n

* CHECK dout1_12 Vdout1_12ck143 = 0 time = 720
.meas tran vdout1_12ck143 FIND v(dout1_12) AT=720.025n

* CHECK dout1_13 Vdout1_13ck143 = 0.9 time = 720
.meas tran vdout1_13ck143 FIND v(dout1_13) AT=720.025n

* CHECK dout1_14 Vdout1_14ck143 = 0.9 time = 720
.meas tran vdout1_14ck143 FIND v(dout1_14) AT=720.025n

* CHECK dout1_15 Vdout1_15ck143 = 0 time = 720
.meas tran vdout1_15ck143 FIND v(dout1_15) AT=720.025n

* CHECK dout1_16 Vdout1_16ck143 = 0 time = 720
.meas tran vdout1_16ck143 FIND v(dout1_16) AT=720.025n

* CHECK dout1_17 Vdout1_17ck143 = 0.9 time = 720
.meas tran vdout1_17ck143 FIND v(dout1_17) AT=720.025n

* CHECK dout1_18 Vdout1_18ck143 = 0 time = 720
.meas tran vdout1_18ck143 FIND v(dout1_18) AT=720.025n

* CHECK dout1_19 Vdout1_19ck143 = 0 time = 720
.meas tran vdout1_19ck143 FIND v(dout1_19) AT=720.025n

* CHECK dout1_20 Vdout1_20ck143 = 0.9 time = 720
.meas tran vdout1_20ck143 FIND v(dout1_20) AT=720.025n

* CHECK dout1_21 Vdout1_21ck143 = 0.9 time = 720
.meas tran vdout1_21ck143 FIND v(dout1_21) AT=720.025n

* CHECK dout1_22 Vdout1_22ck143 = 0 time = 720
.meas tran vdout1_22ck143 FIND v(dout1_22) AT=720.025n

* CHECK dout1_23 Vdout1_23ck143 = 0 time = 720
.meas tran vdout1_23ck143 FIND v(dout1_23) AT=720.025n

* CHECK dout1_24 Vdout1_24ck143 = 0 time = 720
.meas tran vdout1_24ck143 FIND v(dout1_24) AT=720.025n

* CHECK dout1_25 Vdout1_25ck143 = 0.9 time = 720
.meas tran vdout1_25ck143 FIND v(dout1_25) AT=720.025n

* CHECK dout1_26 Vdout1_26ck143 = 0 time = 720
.meas tran vdout1_26ck143 FIND v(dout1_26) AT=720.025n

* CHECK dout1_27 Vdout1_27ck143 = 0 time = 720
.meas tran vdout1_27ck143 FIND v(dout1_27) AT=720.025n

* CHECK dout1_28 Vdout1_28ck143 = 0.9 time = 720
.meas tran vdout1_28ck143 FIND v(dout1_28) AT=720.025n

* CHECK dout1_29 Vdout1_29ck143 = 0.9 time = 720
.meas tran vdout1_29ck143 FIND v(dout1_29) AT=720.025n

* CHECK dout1_30 Vdout1_30ck143 = 0.9 time = 720
.meas tran vdout1_30ck143 FIND v(dout1_30) AT=720.025n

* CHECK dout1_31 Vdout1_31ck143 = 0.9 time = 720
.meas tran vdout1_31ck143 FIND v(dout1_31) AT=720.025n

* CHECK dout1_32 Vdout1_32ck143 = 0 time = 720
.meas tran vdout1_32ck143 FIND v(dout1_32) AT=720.025n

* CHECK dout1_33 Vdout1_33ck143 = 0.9 time = 720
.meas tran vdout1_33ck143 FIND v(dout1_33) AT=720.025n

* CHECK dout1_34 Vdout1_34ck143 = 0.9 time = 720
.meas tran vdout1_34ck143 FIND v(dout1_34) AT=720.025n

* CHECK dout1_35 Vdout1_35ck143 = 0 time = 720
.meas tran vdout1_35ck143 FIND v(dout1_35) AT=720.025n

* CHECK dout1_36 Vdout1_36ck143 = 0 time = 720
.meas tran vdout1_36ck143 FIND v(dout1_36) AT=720.025n

* CHECK dout1_37 Vdout1_37ck143 = 0 time = 720
.meas tran vdout1_37ck143 FIND v(dout1_37) AT=720.025n

* CHECK dout1_38 Vdout1_38ck143 = 0.9 time = 720
.meas tran vdout1_38ck143 FIND v(dout1_38) AT=720.025n

* CHECK dout1_39 Vdout1_39ck143 = 0.9 time = 720
.meas tran vdout1_39ck143 FIND v(dout1_39) AT=720.025n

* CHECK dout1_40 Vdout1_40ck143 = 0.9 time = 720
.meas tran vdout1_40ck143 FIND v(dout1_40) AT=720.025n

* CHECK dout1_41 Vdout1_41ck143 = 0 time = 720
.meas tran vdout1_41ck143 FIND v(dout1_41) AT=720.025n

* CHECK dout1_42 Vdout1_42ck143 = 0.9 time = 720
.meas tran vdout1_42ck143 FIND v(dout1_42) AT=720.025n

* CHECK dout1_43 Vdout1_43ck143 = 0 time = 720
.meas tran vdout1_43ck143 FIND v(dout1_43) AT=720.025n

* CHECK dout1_44 Vdout1_44ck143 = 0.9 time = 720
.meas tran vdout1_44ck143 FIND v(dout1_44) AT=720.025n

* CHECK dout1_45 Vdout1_45ck143 = 0.9 time = 720
.meas tran vdout1_45ck143 FIND v(dout1_45) AT=720.025n

* CHECK dout1_46 Vdout1_46ck143 = 0 time = 720
.meas tran vdout1_46ck143 FIND v(dout1_46) AT=720.025n

* CHECK dout1_47 Vdout1_47ck143 = 0.9 time = 720
.meas tran vdout1_47ck143 FIND v(dout1_47) AT=720.025n

* CHECK dout1_48 Vdout1_48ck143 = 0 time = 720
.meas tran vdout1_48ck143 FIND v(dout1_48) AT=720.025n

* CHECK dout1_49 Vdout1_49ck143 = 0 time = 720
.meas tran vdout1_49ck143 FIND v(dout1_49) AT=720.025n

* CHECK dout1_50 Vdout1_50ck143 = 0 time = 720
.meas tran vdout1_50ck143 FIND v(dout1_50) AT=720.025n

* CHECK dout1_51 Vdout1_51ck143 = 0.9 time = 720
.meas tran vdout1_51ck143 FIND v(dout1_51) AT=720.025n

* CHECK dout1_52 Vdout1_52ck143 = 0 time = 720
.meas tran vdout1_52ck143 FIND v(dout1_52) AT=720.025n

* CHECK dout1_53 Vdout1_53ck143 = 0.9 time = 720
.meas tran vdout1_53ck143 FIND v(dout1_53) AT=720.025n

* CHECK dout1_54 Vdout1_54ck143 = 0 time = 720
.meas tran vdout1_54ck143 FIND v(dout1_54) AT=720.025n

* CHECK dout1_55 Vdout1_55ck143 = 0.9 time = 720
.meas tran vdout1_55ck143 FIND v(dout1_55) AT=720.025n

* CHECK dout1_56 Vdout1_56ck143 = 0.9 time = 720
.meas tran vdout1_56ck143 FIND v(dout1_56) AT=720.025n

* CHECK dout1_57 Vdout1_57ck143 = 0 time = 720
.meas tran vdout1_57ck143 FIND v(dout1_57) AT=720.025n

* CHECK dout1_58 Vdout1_58ck143 = 0 time = 720
.meas tran vdout1_58ck143 FIND v(dout1_58) AT=720.025n

* CHECK dout1_59 Vdout1_59ck143 = 0 time = 720
.meas tran vdout1_59ck143 FIND v(dout1_59) AT=720.025n

* CHECK dout1_60 Vdout1_60ck143 = 0 time = 720
.meas tran vdout1_60ck143 FIND v(dout1_60) AT=720.025n

* CHECK dout1_61 Vdout1_61ck143 = 0 time = 720
.meas tran vdout1_61ck143 FIND v(dout1_61) AT=720.025n

* CHECK dout1_62 Vdout1_62ck143 = 0.9 time = 720
.meas tran vdout1_62ck143 FIND v(dout1_62) AT=720.025n

* CHECK dout1_63 Vdout1_63ck143 = 0.9 time = 720
.meas tran vdout1_63ck143 FIND v(dout1_63) AT=720.025n

* CHECK dout1_64 Vdout1_64ck143 = 0.9 time = 720
.meas tran vdout1_64ck143 FIND v(dout1_64) AT=720.025n

* CHECK dout1_65 Vdout1_65ck143 = 0.9 time = 720
.meas tran vdout1_65ck143 FIND v(dout1_65) AT=720.025n

* CHECK dout1_66 Vdout1_66ck143 = 0 time = 720
.meas tran vdout1_66ck143 FIND v(dout1_66) AT=720.025n

* CHECK dout1_67 Vdout1_67ck143 = 0 time = 720
.meas tran vdout1_67ck143 FIND v(dout1_67) AT=720.025n

* CHECK dout1_68 Vdout1_68ck143 = 0.9 time = 720
.meas tran vdout1_68ck143 FIND v(dout1_68) AT=720.025n

* CHECK dout1_69 Vdout1_69ck143 = 0.9 time = 720
.meas tran vdout1_69ck143 FIND v(dout1_69) AT=720.025n

* CHECK dout1_70 Vdout1_70ck143 = 0.9 time = 720
.meas tran vdout1_70ck143 FIND v(dout1_70) AT=720.025n

* CHECK dout1_71 Vdout1_71ck143 = 0 time = 720
.meas tran vdout1_71ck143 FIND v(dout1_71) AT=720.025n

* CHECK dout1_72 Vdout1_72ck143 = 0 time = 720
.meas tran vdout1_72ck143 FIND v(dout1_72) AT=720.025n

* CHECK dout1_73 Vdout1_73ck143 = 0.9 time = 720
.meas tran vdout1_73ck143 FIND v(dout1_73) AT=720.025n

* CHECK dout1_74 Vdout1_74ck143 = 0 time = 720
.meas tran vdout1_74ck143 FIND v(dout1_74) AT=720.025n

* CHECK dout1_75 Vdout1_75ck143 = 0 time = 720
.meas tran vdout1_75ck143 FIND v(dout1_75) AT=720.025n

* CHECK dout1_76 Vdout1_76ck143 = 0.9 time = 720
.meas tran vdout1_76ck143 FIND v(dout1_76) AT=720.025n

* CHECK dout1_77 Vdout1_77ck143 = 0.9 time = 720
.meas tran vdout1_77ck143 FIND v(dout1_77) AT=720.025n

* CHECK dout1_78 Vdout1_78ck143 = 0.9 time = 720
.meas tran vdout1_78ck143 FIND v(dout1_78) AT=720.025n

* CHECK dout1_79 Vdout1_79ck143 = 0.9 time = 720
.meas tran vdout1_79ck143 FIND v(dout1_79) AT=720.025n

* CHECK dout1_80 Vdout1_80ck143 = 0 time = 720
.meas tran vdout1_80ck143 FIND v(dout1_80) AT=720.025n

* CHECK dout1_81 Vdout1_81ck143 = 0 time = 720
.meas tran vdout1_81ck143 FIND v(dout1_81) AT=720.025n

* CHECK dout1_82 Vdout1_82ck143 = 0.9 time = 720
.meas tran vdout1_82ck143 FIND v(dout1_82) AT=720.025n

* CHECK dout1_83 Vdout1_83ck143 = 0.9 time = 720
.meas tran vdout1_83ck143 FIND v(dout1_83) AT=720.025n

* CHECK dout1_84 Vdout1_84ck143 = 0.9 time = 720
.meas tran vdout1_84ck143 FIND v(dout1_84) AT=720.025n

* CHECK dout1_85 Vdout1_85ck143 = 0.9 time = 720
.meas tran vdout1_85ck143 FIND v(dout1_85) AT=720.025n

* CHECK dout1_86 Vdout1_86ck143 = 0.9 time = 720
.meas tran vdout1_86ck143 FIND v(dout1_86) AT=720.025n

* CHECK dout1_87 Vdout1_87ck143 = 0 time = 720
.meas tran vdout1_87ck143 FIND v(dout1_87) AT=720.025n

* CHECK dout1_88 Vdout1_88ck143 = 0.9 time = 720
.meas tran vdout1_88ck143 FIND v(dout1_88) AT=720.025n

* CHECK dout1_89 Vdout1_89ck143 = 0 time = 720
.meas tran vdout1_89ck143 FIND v(dout1_89) AT=720.025n

* CHECK dout1_90 Vdout1_90ck143 = 0.9 time = 720
.meas tran vdout1_90ck143 FIND v(dout1_90) AT=720.025n

* CHECK dout1_91 Vdout1_91ck143 = 0.9 time = 720
.meas tran vdout1_91ck143 FIND v(dout1_91) AT=720.025n

* CHECK dout1_92 Vdout1_92ck143 = 0 time = 720
.meas tran vdout1_92ck143 FIND v(dout1_92) AT=720.025n

* CHECK dout1_93 Vdout1_93ck143 = 0 time = 720
.meas tran vdout1_93ck143 FIND v(dout1_93) AT=720.025n

* CHECK dout1_94 Vdout1_94ck143 = 0 time = 720
.meas tran vdout1_94ck143 FIND v(dout1_94) AT=720.025n

* CHECK dout1_95 Vdout1_95ck143 = 0.9 time = 720
.meas tran vdout1_95ck143 FIND v(dout1_95) AT=720.025n

* CHECK dout1_0 Vdout1_0ck144 = 0 time = 725
.meas tran vdout1_0ck144 FIND v(dout1_0) AT=725.025n

* CHECK dout1_1 Vdout1_1ck144 = 0.9 time = 725
.meas tran vdout1_1ck144 FIND v(dout1_1) AT=725.025n

* CHECK dout1_2 Vdout1_2ck144 = 0 time = 725
.meas tran vdout1_2ck144 FIND v(dout1_2) AT=725.025n

* CHECK dout1_3 Vdout1_3ck144 = 0 time = 725
.meas tran vdout1_3ck144 FIND v(dout1_3) AT=725.025n

* CHECK dout1_4 Vdout1_4ck144 = 0.9 time = 725
.meas tran vdout1_4ck144 FIND v(dout1_4) AT=725.025n

* CHECK dout1_5 Vdout1_5ck144 = 0 time = 725
.meas tran vdout1_5ck144 FIND v(dout1_5) AT=725.025n

* CHECK dout1_6 Vdout1_6ck144 = 0.9 time = 725
.meas tran vdout1_6ck144 FIND v(dout1_6) AT=725.025n

* CHECK dout1_7 Vdout1_7ck144 = 0 time = 725
.meas tran vdout1_7ck144 FIND v(dout1_7) AT=725.025n

* CHECK dout1_8 Vdout1_8ck144 = 0.9 time = 725
.meas tran vdout1_8ck144 FIND v(dout1_8) AT=725.025n

* CHECK dout1_9 Vdout1_9ck144 = 0 time = 725
.meas tran vdout1_9ck144 FIND v(dout1_9) AT=725.025n

* CHECK dout1_10 Vdout1_10ck144 = 0.9 time = 725
.meas tran vdout1_10ck144 FIND v(dout1_10) AT=725.025n

* CHECK dout1_11 Vdout1_11ck144 = 0 time = 725
.meas tran vdout1_11ck144 FIND v(dout1_11) AT=725.025n

* CHECK dout1_12 Vdout1_12ck144 = 0.9 time = 725
.meas tran vdout1_12ck144 FIND v(dout1_12) AT=725.025n

* CHECK dout1_13 Vdout1_13ck144 = 0 time = 725
.meas tran vdout1_13ck144 FIND v(dout1_13) AT=725.025n

* CHECK dout1_14 Vdout1_14ck144 = 0.9 time = 725
.meas tran vdout1_14ck144 FIND v(dout1_14) AT=725.025n

* CHECK dout1_15 Vdout1_15ck144 = 0.9 time = 725
.meas tran vdout1_15ck144 FIND v(dout1_15) AT=725.025n

* CHECK dout1_16 Vdout1_16ck144 = 0.9 time = 725
.meas tran vdout1_16ck144 FIND v(dout1_16) AT=725.025n

* CHECK dout1_17 Vdout1_17ck144 = 0.9 time = 725
.meas tran vdout1_17ck144 FIND v(dout1_17) AT=725.025n

* CHECK dout1_18 Vdout1_18ck144 = 0 time = 725
.meas tran vdout1_18ck144 FIND v(dout1_18) AT=725.025n

* CHECK dout1_19 Vdout1_19ck144 = 0.9 time = 725
.meas tran vdout1_19ck144 FIND v(dout1_19) AT=725.025n

* CHECK dout1_20 Vdout1_20ck144 = 0 time = 725
.meas tran vdout1_20ck144 FIND v(dout1_20) AT=725.025n

* CHECK dout1_21 Vdout1_21ck144 = 0 time = 725
.meas tran vdout1_21ck144 FIND v(dout1_21) AT=725.025n

* CHECK dout1_22 Vdout1_22ck144 = 0 time = 725
.meas tran vdout1_22ck144 FIND v(dout1_22) AT=725.025n

* CHECK dout1_23 Vdout1_23ck144 = 0.9 time = 725
.meas tran vdout1_23ck144 FIND v(dout1_23) AT=725.025n

* CHECK dout1_24 Vdout1_24ck144 = 0 time = 725
.meas tran vdout1_24ck144 FIND v(dout1_24) AT=725.025n

* CHECK dout1_25 Vdout1_25ck144 = 0.9 time = 725
.meas tran vdout1_25ck144 FIND v(dout1_25) AT=725.025n

* CHECK dout1_26 Vdout1_26ck144 = 0 time = 725
.meas tran vdout1_26ck144 FIND v(dout1_26) AT=725.025n

* CHECK dout1_27 Vdout1_27ck144 = 0 time = 725
.meas tran vdout1_27ck144 FIND v(dout1_27) AT=725.025n

* CHECK dout1_28 Vdout1_28ck144 = 0.9 time = 725
.meas tran vdout1_28ck144 FIND v(dout1_28) AT=725.025n

* CHECK dout1_29 Vdout1_29ck144 = 0.9 time = 725
.meas tran vdout1_29ck144 FIND v(dout1_29) AT=725.025n

* CHECK dout1_30 Vdout1_30ck144 = 0.9 time = 725
.meas tran vdout1_30ck144 FIND v(dout1_30) AT=725.025n

* CHECK dout1_31 Vdout1_31ck144 = 0.9 time = 725
.meas tran vdout1_31ck144 FIND v(dout1_31) AT=725.025n

* CHECK dout1_32 Vdout1_32ck144 = 0 time = 725
.meas tran vdout1_32ck144 FIND v(dout1_32) AT=725.025n

* CHECK dout1_33 Vdout1_33ck144 = 0.9 time = 725
.meas tran vdout1_33ck144 FIND v(dout1_33) AT=725.025n

* CHECK dout1_34 Vdout1_34ck144 = 0.9 time = 725
.meas tran vdout1_34ck144 FIND v(dout1_34) AT=725.025n

* CHECK dout1_35 Vdout1_35ck144 = 0 time = 725
.meas tran vdout1_35ck144 FIND v(dout1_35) AT=725.025n

* CHECK dout1_36 Vdout1_36ck144 = 0.9 time = 725
.meas tran vdout1_36ck144 FIND v(dout1_36) AT=725.025n

* CHECK dout1_37 Vdout1_37ck144 = 0 time = 725
.meas tran vdout1_37ck144 FIND v(dout1_37) AT=725.025n

* CHECK dout1_38 Vdout1_38ck144 = 0.9 time = 725
.meas tran vdout1_38ck144 FIND v(dout1_38) AT=725.025n

* CHECK dout1_39 Vdout1_39ck144 = 0.9 time = 725
.meas tran vdout1_39ck144 FIND v(dout1_39) AT=725.025n

* CHECK dout1_40 Vdout1_40ck144 = 0.9 time = 725
.meas tran vdout1_40ck144 FIND v(dout1_40) AT=725.025n

* CHECK dout1_41 Vdout1_41ck144 = 0 time = 725
.meas tran vdout1_41ck144 FIND v(dout1_41) AT=725.025n

* CHECK dout1_42 Vdout1_42ck144 = 0 time = 725
.meas tran vdout1_42ck144 FIND v(dout1_42) AT=725.025n

* CHECK dout1_43 Vdout1_43ck144 = 0 time = 725
.meas tran vdout1_43ck144 FIND v(dout1_43) AT=725.025n

* CHECK dout1_44 Vdout1_44ck144 = 0 time = 725
.meas tran vdout1_44ck144 FIND v(dout1_44) AT=725.025n

* CHECK dout1_45 Vdout1_45ck144 = 0 time = 725
.meas tran vdout1_45ck144 FIND v(dout1_45) AT=725.025n

* CHECK dout1_46 Vdout1_46ck144 = 0.9 time = 725
.meas tran vdout1_46ck144 FIND v(dout1_46) AT=725.025n

* CHECK dout1_47 Vdout1_47ck144 = 0 time = 725
.meas tran vdout1_47ck144 FIND v(dout1_47) AT=725.025n

* CHECK dout1_48 Vdout1_48ck144 = 0 time = 725
.meas tran vdout1_48ck144 FIND v(dout1_48) AT=725.025n

* CHECK dout1_49 Vdout1_49ck144 = 0.9 time = 725
.meas tran vdout1_49ck144 FIND v(dout1_49) AT=725.025n

* CHECK dout1_50 Vdout1_50ck144 = 0 time = 725
.meas tran vdout1_50ck144 FIND v(dout1_50) AT=725.025n

* CHECK dout1_51 Vdout1_51ck144 = 0.9 time = 725
.meas tran vdout1_51ck144 FIND v(dout1_51) AT=725.025n

* CHECK dout1_52 Vdout1_52ck144 = 0.9 time = 725
.meas tran vdout1_52ck144 FIND v(dout1_52) AT=725.025n

* CHECK dout1_53 Vdout1_53ck144 = 0.9 time = 725
.meas tran vdout1_53ck144 FIND v(dout1_53) AT=725.025n

* CHECK dout1_54 Vdout1_54ck144 = 0.9 time = 725
.meas tran vdout1_54ck144 FIND v(dout1_54) AT=725.025n

* CHECK dout1_55 Vdout1_55ck144 = 0 time = 725
.meas tran vdout1_55ck144 FIND v(dout1_55) AT=725.025n

* CHECK dout1_56 Vdout1_56ck144 = 0.9 time = 725
.meas tran vdout1_56ck144 FIND v(dout1_56) AT=725.025n

* CHECK dout1_57 Vdout1_57ck144 = 0 time = 725
.meas tran vdout1_57ck144 FIND v(dout1_57) AT=725.025n

* CHECK dout1_58 Vdout1_58ck144 = 0 time = 725
.meas tran vdout1_58ck144 FIND v(dout1_58) AT=725.025n

* CHECK dout1_59 Vdout1_59ck144 = 0.9 time = 725
.meas tran vdout1_59ck144 FIND v(dout1_59) AT=725.025n

* CHECK dout1_60 Vdout1_60ck144 = 0.9 time = 725
.meas tran vdout1_60ck144 FIND v(dout1_60) AT=725.025n

* CHECK dout1_61 Vdout1_61ck144 = 0.9 time = 725
.meas tran vdout1_61ck144 FIND v(dout1_61) AT=725.025n

* CHECK dout1_62 Vdout1_62ck144 = 0.9 time = 725
.meas tran vdout1_62ck144 FIND v(dout1_62) AT=725.025n

* CHECK dout1_63 Vdout1_63ck144 = 0.9 time = 725
.meas tran vdout1_63ck144 FIND v(dout1_63) AT=725.025n

* CHECK dout1_64 Vdout1_64ck144 = 0 time = 725
.meas tran vdout1_64ck144 FIND v(dout1_64) AT=725.025n

* CHECK dout1_65 Vdout1_65ck144 = 0.9 time = 725
.meas tran vdout1_65ck144 FIND v(dout1_65) AT=725.025n

* CHECK dout1_66 Vdout1_66ck144 = 0.9 time = 725
.meas tran vdout1_66ck144 FIND v(dout1_66) AT=725.025n

* CHECK dout1_67 Vdout1_67ck144 = 0 time = 725
.meas tran vdout1_67ck144 FIND v(dout1_67) AT=725.025n

* CHECK dout1_68 Vdout1_68ck144 = 0 time = 725
.meas tran vdout1_68ck144 FIND v(dout1_68) AT=725.025n

* CHECK dout1_69 Vdout1_69ck144 = 0.9 time = 725
.meas tran vdout1_69ck144 FIND v(dout1_69) AT=725.025n

* CHECK dout1_70 Vdout1_70ck144 = 0.9 time = 725
.meas tran vdout1_70ck144 FIND v(dout1_70) AT=725.025n

* CHECK dout1_71 Vdout1_71ck144 = 0 time = 725
.meas tran vdout1_71ck144 FIND v(dout1_71) AT=725.025n

* CHECK dout1_72 Vdout1_72ck144 = 0 time = 725
.meas tran vdout1_72ck144 FIND v(dout1_72) AT=725.025n

* CHECK dout1_73 Vdout1_73ck144 = 0.9 time = 725
.meas tran vdout1_73ck144 FIND v(dout1_73) AT=725.025n

* CHECK dout1_74 Vdout1_74ck144 = 0 time = 725
.meas tran vdout1_74ck144 FIND v(dout1_74) AT=725.025n

* CHECK dout1_75 Vdout1_75ck144 = 0 time = 725
.meas tran vdout1_75ck144 FIND v(dout1_75) AT=725.025n

* CHECK dout1_76 Vdout1_76ck144 = 0 time = 725
.meas tran vdout1_76ck144 FIND v(dout1_76) AT=725.025n

* CHECK dout1_77 Vdout1_77ck144 = 0.9 time = 725
.meas tran vdout1_77ck144 FIND v(dout1_77) AT=725.025n

* CHECK dout1_78 Vdout1_78ck144 = 0 time = 725
.meas tran vdout1_78ck144 FIND v(dout1_78) AT=725.025n

* CHECK dout1_79 Vdout1_79ck144 = 0.9 time = 725
.meas tran vdout1_79ck144 FIND v(dout1_79) AT=725.025n

* CHECK dout1_80 Vdout1_80ck144 = 0.9 time = 725
.meas tran vdout1_80ck144 FIND v(dout1_80) AT=725.025n

* CHECK dout1_81 Vdout1_81ck144 = 0.9 time = 725
.meas tran vdout1_81ck144 FIND v(dout1_81) AT=725.025n

* CHECK dout1_82 Vdout1_82ck144 = 0 time = 725
.meas tran vdout1_82ck144 FIND v(dout1_82) AT=725.025n

* CHECK dout1_83 Vdout1_83ck144 = 0.9 time = 725
.meas tran vdout1_83ck144 FIND v(dout1_83) AT=725.025n

* CHECK dout1_84 Vdout1_84ck144 = 0.9 time = 725
.meas tran vdout1_84ck144 FIND v(dout1_84) AT=725.025n

* CHECK dout1_85 Vdout1_85ck144 = 0.9 time = 725
.meas tran vdout1_85ck144 FIND v(dout1_85) AT=725.025n

* CHECK dout1_86 Vdout1_86ck144 = 0.9 time = 725
.meas tran vdout1_86ck144 FIND v(dout1_86) AT=725.025n

* CHECK dout1_87 Vdout1_87ck144 = 0 time = 725
.meas tran vdout1_87ck144 FIND v(dout1_87) AT=725.025n

* CHECK dout1_88 Vdout1_88ck144 = 0 time = 725
.meas tran vdout1_88ck144 FIND v(dout1_88) AT=725.025n

* CHECK dout1_89 Vdout1_89ck144 = 0.9 time = 725
.meas tran vdout1_89ck144 FIND v(dout1_89) AT=725.025n

* CHECK dout1_90 Vdout1_90ck144 = 0 time = 725
.meas tran vdout1_90ck144 FIND v(dout1_90) AT=725.025n

* CHECK dout1_91 Vdout1_91ck144 = 0.9 time = 725
.meas tran vdout1_91ck144 FIND v(dout1_91) AT=725.025n

* CHECK dout1_92 Vdout1_92ck144 = 0.9 time = 725
.meas tran vdout1_92ck144 FIND v(dout1_92) AT=725.025n

* CHECK dout1_93 Vdout1_93ck144 = 0.9 time = 725
.meas tran vdout1_93ck144 FIND v(dout1_93) AT=725.025n

* CHECK dout1_94 Vdout1_94ck144 = 0 time = 725
.meas tran vdout1_94ck144 FIND v(dout1_94) AT=725.025n

* CHECK dout1_95 Vdout1_95ck144 = 0.9 time = 725
.meas tran vdout1_95ck144 FIND v(dout1_95) AT=725.025n

* CHECK dout1_0 Vdout1_0ck155 = 0.9 time = 780
.meas tran vdout1_0ck155 FIND v(dout1_0) AT=780.025n

* CHECK dout1_1 Vdout1_1ck155 = 0.9 time = 780
.meas tran vdout1_1ck155 FIND v(dout1_1) AT=780.025n

* CHECK dout1_2 Vdout1_2ck155 = 0.9 time = 780
.meas tran vdout1_2ck155 FIND v(dout1_2) AT=780.025n

* CHECK dout1_3 Vdout1_3ck155 = 0.9 time = 780
.meas tran vdout1_3ck155 FIND v(dout1_3) AT=780.025n

* CHECK dout1_4 Vdout1_4ck155 = 0.9 time = 780
.meas tran vdout1_4ck155 FIND v(dout1_4) AT=780.025n

* CHECK dout1_5 Vdout1_5ck155 = 0 time = 780
.meas tran vdout1_5ck155 FIND v(dout1_5) AT=780.025n

* CHECK dout1_6 Vdout1_6ck155 = 0.9 time = 780
.meas tran vdout1_6ck155 FIND v(dout1_6) AT=780.025n

* CHECK dout1_7 Vdout1_7ck155 = 0.9 time = 780
.meas tran vdout1_7ck155 FIND v(dout1_7) AT=780.025n

* CHECK dout1_8 Vdout1_8ck155 = 0.9 time = 780
.meas tran vdout1_8ck155 FIND v(dout1_8) AT=780.025n

* CHECK dout1_9 Vdout1_9ck155 = 0.9 time = 780
.meas tran vdout1_9ck155 FIND v(dout1_9) AT=780.025n

* CHECK dout1_10 Vdout1_10ck155 = 0.9 time = 780
.meas tran vdout1_10ck155 FIND v(dout1_10) AT=780.025n

* CHECK dout1_11 Vdout1_11ck155 = 0 time = 780
.meas tran vdout1_11ck155 FIND v(dout1_11) AT=780.025n

* CHECK dout1_12 Vdout1_12ck155 = 0.9 time = 780
.meas tran vdout1_12ck155 FIND v(dout1_12) AT=780.025n

* CHECK dout1_13 Vdout1_13ck155 = 0.9 time = 780
.meas tran vdout1_13ck155 FIND v(dout1_13) AT=780.025n

* CHECK dout1_14 Vdout1_14ck155 = 0 time = 780
.meas tran vdout1_14ck155 FIND v(dout1_14) AT=780.025n

* CHECK dout1_15 Vdout1_15ck155 = 0.9 time = 780
.meas tran vdout1_15ck155 FIND v(dout1_15) AT=780.025n

* CHECK dout1_16 Vdout1_16ck155 = 0.9 time = 780
.meas tran vdout1_16ck155 FIND v(dout1_16) AT=780.025n

* CHECK dout1_17 Vdout1_17ck155 = 0.9 time = 780
.meas tran vdout1_17ck155 FIND v(dout1_17) AT=780.025n

* CHECK dout1_18 Vdout1_18ck155 = 0 time = 780
.meas tran vdout1_18ck155 FIND v(dout1_18) AT=780.025n

* CHECK dout1_19 Vdout1_19ck155 = 0.9 time = 780
.meas tran vdout1_19ck155 FIND v(dout1_19) AT=780.025n

* CHECK dout1_20 Vdout1_20ck155 = 0 time = 780
.meas tran vdout1_20ck155 FIND v(dout1_20) AT=780.025n

* CHECK dout1_21 Vdout1_21ck155 = 0 time = 780
.meas tran vdout1_21ck155 FIND v(dout1_21) AT=780.025n

* CHECK dout1_22 Vdout1_22ck155 = 0.9 time = 780
.meas tran vdout1_22ck155 FIND v(dout1_22) AT=780.025n

* CHECK dout1_23 Vdout1_23ck155 = 0 time = 780
.meas tran vdout1_23ck155 FIND v(dout1_23) AT=780.025n

* CHECK dout1_24 Vdout1_24ck155 = 0 time = 780
.meas tran vdout1_24ck155 FIND v(dout1_24) AT=780.025n

* CHECK dout1_25 Vdout1_25ck155 = 0.9 time = 780
.meas tran vdout1_25ck155 FIND v(dout1_25) AT=780.025n

* CHECK dout1_26 Vdout1_26ck155 = 0 time = 780
.meas tran vdout1_26ck155 FIND v(dout1_26) AT=780.025n

* CHECK dout1_27 Vdout1_27ck155 = 0.9 time = 780
.meas tran vdout1_27ck155 FIND v(dout1_27) AT=780.025n

* CHECK dout1_28 Vdout1_28ck155 = 0.9 time = 780
.meas tran vdout1_28ck155 FIND v(dout1_28) AT=780.025n

* CHECK dout1_29 Vdout1_29ck155 = 0 time = 780
.meas tran vdout1_29ck155 FIND v(dout1_29) AT=780.025n

* CHECK dout1_30 Vdout1_30ck155 = 0.9 time = 780
.meas tran vdout1_30ck155 FIND v(dout1_30) AT=780.025n

* CHECK dout1_31 Vdout1_31ck155 = 0 time = 780
.meas tran vdout1_31ck155 FIND v(dout1_31) AT=780.025n

* CHECK dout1_32 Vdout1_32ck155 = 0 time = 780
.meas tran vdout1_32ck155 FIND v(dout1_32) AT=780.025n

* CHECK dout1_33 Vdout1_33ck155 = 0 time = 780
.meas tran vdout1_33ck155 FIND v(dout1_33) AT=780.025n

* CHECK dout1_34 Vdout1_34ck155 = 0 time = 780
.meas tran vdout1_34ck155 FIND v(dout1_34) AT=780.025n

* CHECK dout1_35 Vdout1_35ck155 = 0 time = 780
.meas tran vdout1_35ck155 FIND v(dout1_35) AT=780.025n

* CHECK dout1_36 Vdout1_36ck155 = 0.9 time = 780
.meas tran vdout1_36ck155 FIND v(dout1_36) AT=780.025n

* CHECK dout1_37 Vdout1_37ck155 = 0 time = 780
.meas tran vdout1_37ck155 FIND v(dout1_37) AT=780.025n

* CHECK dout1_38 Vdout1_38ck155 = 0 time = 780
.meas tran vdout1_38ck155 FIND v(dout1_38) AT=780.025n

* CHECK dout1_39 Vdout1_39ck155 = 0 time = 780
.meas tran vdout1_39ck155 FIND v(dout1_39) AT=780.025n

* CHECK dout1_40 Vdout1_40ck155 = 0 time = 780
.meas tran vdout1_40ck155 FIND v(dout1_40) AT=780.025n

* CHECK dout1_41 Vdout1_41ck155 = 0.9 time = 780
.meas tran vdout1_41ck155 FIND v(dout1_41) AT=780.025n

* CHECK dout1_42 Vdout1_42ck155 = 0 time = 780
.meas tran vdout1_42ck155 FIND v(dout1_42) AT=780.025n

* CHECK dout1_43 Vdout1_43ck155 = 0 time = 780
.meas tran vdout1_43ck155 FIND v(dout1_43) AT=780.025n

* CHECK dout1_44 Vdout1_44ck155 = 0 time = 780
.meas tran vdout1_44ck155 FIND v(dout1_44) AT=780.025n

* CHECK dout1_45 Vdout1_45ck155 = 0.9 time = 780
.meas tran vdout1_45ck155 FIND v(dout1_45) AT=780.025n

* CHECK dout1_46 Vdout1_46ck155 = 0.9 time = 780
.meas tran vdout1_46ck155 FIND v(dout1_46) AT=780.025n

* CHECK dout1_47 Vdout1_47ck155 = 0 time = 780
.meas tran vdout1_47ck155 FIND v(dout1_47) AT=780.025n

* CHECK dout1_48 Vdout1_48ck155 = 0.9 time = 780
.meas tran vdout1_48ck155 FIND v(dout1_48) AT=780.025n

* CHECK dout1_49 Vdout1_49ck155 = 0 time = 780
.meas tran vdout1_49ck155 FIND v(dout1_49) AT=780.025n

* CHECK dout1_50 Vdout1_50ck155 = 0.9 time = 780
.meas tran vdout1_50ck155 FIND v(dout1_50) AT=780.025n

* CHECK dout1_51 Vdout1_51ck155 = 0.9 time = 780
.meas tran vdout1_51ck155 FIND v(dout1_51) AT=780.025n

* CHECK dout1_52 Vdout1_52ck155 = 0.9 time = 780
.meas tran vdout1_52ck155 FIND v(dout1_52) AT=780.025n

* CHECK dout1_53 Vdout1_53ck155 = 0 time = 780
.meas tran vdout1_53ck155 FIND v(dout1_53) AT=780.025n

* CHECK dout1_54 Vdout1_54ck155 = 0.9 time = 780
.meas tran vdout1_54ck155 FIND v(dout1_54) AT=780.025n

* CHECK dout1_55 Vdout1_55ck155 = 0 time = 780
.meas tran vdout1_55ck155 FIND v(dout1_55) AT=780.025n

* CHECK dout1_56 Vdout1_56ck155 = 0.9 time = 780
.meas tran vdout1_56ck155 FIND v(dout1_56) AT=780.025n

* CHECK dout1_57 Vdout1_57ck155 = 0 time = 780
.meas tran vdout1_57ck155 FIND v(dout1_57) AT=780.025n

* CHECK dout1_58 Vdout1_58ck155 = 0 time = 780
.meas tran vdout1_58ck155 FIND v(dout1_58) AT=780.025n

* CHECK dout1_59 Vdout1_59ck155 = 0.9 time = 780
.meas tran vdout1_59ck155 FIND v(dout1_59) AT=780.025n

* CHECK dout1_60 Vdout1_60ck155 = 0.9 time = 780
.meas tran vdout1_60ck155 FIND v(dout1_60) AT=780.025n

* CHECK dout1_61 Vdout1_61ck155 = 0 time = 780
.meas tran vdout1_61ck155 FIND v(dout1_61) AT=780.025n

* CHECK dout1_62 Vdout1_62ck155 = 0 time = 780
.meas tran vdout1_62ck155 FIND v(dout1_62) AT=780.025n

* CHECK dout1_63 Vdout1_63ck155 = 0.9 time = 780
.meas tran vdout1_63ck155 FIND v(dout1_63) AT=780.025n

* CHECK dout1_64 Vdout1_64ck155 = 0.9 time = 780
.meas tran vdout1_64ck155 FIND v(dout1_64) AT=780.025n

* CHECK dout1_65 Vdout1_65ck155 = 0.9 time = 780
.meas tran vdout1_65ck155 FIND v(dout1_65) AT=780.025n

* CHECK dout1_66 Vdout1_66ck155 = 0.9 time = 780
.meas tran vdout1_66ck155 FIND v(dout1_66) AT=780.025n

* CHECK dout1_67 Vdout1_67ck155 = 0.9 time = 780
.meas tran vdout1_67ck155 FIND v(dout1_67) AT=780.025n

* CHECK dout1_68 Vdout1_68ck155 = 0.9 time = 780
.meas tran vdout1_68ck155 FIND v(dout1_68) AT=780.025n

* CHECK dout1_69 Vdout1_69ck155 = 0.9 time = 780
.meas tran vdout1_69ck155 FIND v(dout1_69) AT=780.025n

* CHECK dout1_70 Vdout1_70ck155 = 0 time = 780
.meas tran vdout1_70ck155 FIND v(dout1_70) AT=780.025n

* CHECK dout1_71 Vdout1_71ck155 = 0.9 time = 780
.meas tran vdout1_71ck155 FIND v(dout1_71) AT=780.025n

* CHECK dout1_72 Vdout1_72ck155 = 0.9 time = 780
.meas tran vdout1_72ck155 FIND v(dout1_72) AT=780.025n

* CHECK dout1_73 Vdout1_73ck155 = 0.9 time = 780
.meas tran vdout1_73ck155 FIND v(dout1_73) AT=780.025n

* CHECK dout1_74 Vdout1_74ck155 = 0.9 time = 780
.meas tran vdout1_74ck155 FIND v(dout1_74) AT=780.025n

* CHECK dout1_75 Vdout1_75ck155 = 0 time = 780
.meas tran vdout1_75ck155 FIND v(dout1_75) AT=780.025n

* CHECK dout1_76 Vdout1_76ck155 = 0.9 time = 780
.meas tran vdout1_76ck155 FIND v(dout1_76) AT=780.025n

* CHECK dout1_77 Vdout1_77ck155 = 0 time = 780
.meas tran vdout1_77ck155 FIND v(dout1_77) AT=780.025n

* CHECK dout1_78 Vdout1_78ck155 = 0 time = 780
.meas tran vdout1_78ck155 FIND v(dout1_78) AT=780.025n

* CHECK dout1_79 Vdout1_79ck155 = 0.9 time = 780
.meas tran vdout1_79ck155 FIND v(dout1_79) AT=780.025n

* CHECK dout1_80 Vdout1_80ck155 = 0 time = 780
.meas tran vdout1_80ck155 FIND v(dout1_80) AT=780.025n

* CHECK dout1_81 Vdout1_81ck155 = 0.9 time = 780
.meas tran vdout1_81ck155 FIND v(dout1_81) AT=780.025n

* CHECK dout1_82 Vdout1_82ck155 = 0.9 time = 780
.meas tran vdout1_82ck155 FIND v(dout1_82) AT=780.025n

* CHECK dout1_83 Vdout1_83ck155 = 0 time = 780
.meas tran vdout1_83ck155 FIND v(dout1_83) AT=780.025n

* CHECK dout1_84 Vdout1_84ck155 = 0.9 time = 780
.meas tran vdout1_84ck155 FIND v(dout1_84) AT=780.025n

* CHECK dout1_85 Vdout1_85ck155 = 0 time = 780
.meas tran vdout1_85ck155 FIND v(dout1_85) AT=780.025n

* CHECK dout1_86 Vdout1_86ck155 = 0 time = 780
.meas tran vdout1_86ck155 FIND v(dout1_86) AT=780.025n

* CHECK dout1_87 Vdout1_87ck155 = 0.9 time = 780
.meas tran vdout1_87ck155 FIND v(dout1_87) AT=780.025n

* CHECK dout1_88 Vdout1_88ck155 = 0.9 time = 780
.meas tran vdout1_88ck155 FIND v(dout1_88) AT=780.025n

* CHECK dout1_89 Vdout1_89ck155 = 0.9 time = 780
.meas tran vdout1_89ck155 FIND v(dout1_89) AT=780.025n

* CHECK dout1_90 Vdout1_90ck155 = 0.9 time = 780
.meas tran vdout1_90ck155 FIND v(dout1_90) AT=780.025n

* CHECK dout1_91 Vdout1_91ck155 = 0 time = 780
.meas tran vdout1_91ck155 FIND v(dout1_91) AT=780.025n

* CHECK dout1_92 Vdout1_92ck155 = 0 time = 780
.meas tran vdout1_92ck155 FIND v(dout1_92) AT=780.025n

* CHECK dout1_93 Vdout1_93ck155 = 0 time = 780
.meas tran vdout1_93ck155 FIND v(dout1_93) AT=780.025n

* CHECK dout1_94 Vdout1_94ck155 = 0.9 time = 780
.meas tran vdout1_94ck155 FIND v(dout1_94) AT=780.025n

* CHECK dout1_95 Vdout1_95ck155 = 0 time = 780
.meas tran vdout1_95ck155 FIND v(dout1_95) AT=780.025n

* CHECK dout1_0 Vdout1_0ck157 = 0 time = 790
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=790.025n

* CHECK dout1_1 Vdout1_1ck157 = 0.9 time = 790
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=790.025n

* CHECK dout1_2 Vdout1_2ck157 = 0.9 time = 790
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=790.025n

* CHECK dout1_3 Vdout1_3ck157 = 0 time = 790
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=790.025n

* CHECK dout1_4 Vdout1_4ck157 = 0 time = 790
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=790.025n

* CHECK dout1_5 Vdout1_5ck157 = 0.9 time = 790
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=790.025n

* CHECK dout1_6 Vdout1_6ck157 = 0 time = 790
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=790.025n

* CHECK dout1_7 Vdout1_7ck157 = 0 time = 790
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=790.025n

* CHECK dout1_8 Vdout1_8ck157 = 0.9 time = 790
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=790.025n

* CHECK dout1_9 Vdout1_9ck157 = 0.9 time = 790
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=790.025n

* CHECK dout1_10 Vdout1_10ck157 = 0.9 time = 790
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=790.025n

* CHECK dout1_11 Vdout1_11ck157 = 0.9 time = 790
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=790.025n

* CHECK dout1_12 Vdout1_12ck157 = 0.9 time = 790
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=790.025n

* CHECK dout1_13 Vdout1_13ck157 = 0 time = 790
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=790.025n

* CHECK dout1_14 Vdout1_14ck157 = 0 time = 790
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=790.025n

* CHECK dout1_15 Vdout1_15ck157 = 0.9 time = 790
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=790.025n

* CHECK dout1_16 Vdout1_16ck157 = 0 time = 790
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=790.025n

* CHECK dout1_17 Vdout1_17ck157 = 0.9 time = 790
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=790.025n

* CHECK dout1_18 Vdout1_18ck157 = 0 time = 790
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=790.025n

* CHECK dout1_19 Vdout1_19ck157 = 0.9 time = 790
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=790.025n

* CHECK dout1_20 Vdout1_20ck157 = 0 time = 790
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=790.025n

* CHECK dout1_21 Vdout1_21ck157 = 0 time = 790
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=790.025n

* CHECK dout1_22 Vdout1_22ck157 = 0.9 time = 790
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=790.025n

* CHECK dout1_23 Vdout1_23ck157 = 0.9 time = 790
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=790.025n

* CHECK dout1_24 Vdout1_24ck157 = 0.9 time = 790
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=790.025n

* CHECK dout1_25 Vdout1_25ck157 = 0 time = 790
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=790.025n

* CHECK dout1_26 Vdout1_26ck157 = 0 time = 790
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=790.025n

* CHECK dout1_27 Vdout1_27ck157 = 0.9 time = 790
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=790.025n

* CHECK dout1_28 Vdout1_28ck157 = 0.9 time = 790
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=790.025n

* CHECK dout1_29 Vdout1_29ck157 = 0.9 time = 790
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=790.025n

* CHECK dout1_30 Vdout1_30ck157 = 0 time = 790
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=790.025n

* CHECK dout1_31 Vdout1_31ck157 = 0.9 time = 790
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=790.025n

* CHECK dout1_32 Vdout1_32ck157 = 0 time = 790
.meas tran vdout1_32ck157 FIND v(dout1_32) AT=790.025n

* CHECK dout1_33 Vdout1_33ck157 = 0.9 time = 790
.meas tran vdout1_33ck157 FIND v(dout1_33) AT=790.025n

* CHECK dout1_34 Vdout1_34ck157 = 0.9 time = 790
.meas tran vdout1_34ck157 FIND v(dout1_34) AT=790.025n

* CHECK dout1_35 Vdout1_35ck157 = 0 time = 790
.meas tran vdout1_35ck157 FIND v(dout1_35) AT=790.025n

* CHECK dout1_36 Vdout1_36ck157 = 0.9 time = 790
.meas tran vdout1_36ck157 FIND v(dout1_36) AT=790.025n

* CHECK dout1_37 Vdout1_37ck157 = 0 time = 790
.meas tran vdout1_37ck157 FIND v(dout1_37) AT=790.025n

* CHECK dout1_38 Vdout1_38ck157 = 0.9 time = 790
.meas tran vdout1_38ck157 FIND v(dout1_38) AT=790.025n

* CHECK dout1_39 Vdout1_39ck157 = 0.9 time = 790
.meas tran vdout1_39ck157 FIND v(dout1_39) AT=790.025n

* CHECK dout1_40 Vdout1_40ck157 = 0.9 time = 790
.meas tran vdout1_40ck157 FIND v(dout1_40) AT=790.025n

* CHECK dout1_41 Vdout1_41ck157 = 0.9 time = 790
.meas tran vdout1_41ck157 FIND v(dout1_41) AT=790.025n

* CHECK dout1_42 Vdout1_42ck157 = 0.9 time = 790
.meas tran vdout1_42ck157 FIND v(dout1_42) AT=790.025n

* CHECK dout1_43 Vdout1_43ck157 = 0 time = 790
.meas tran vdout1_43ck157 FIND v(dout1_43) AT=790.025n

* CHECK dout1_44 Vdout1_44ck157 = 0 time = 790
.meas tran vdout1_44ck157 FIND v(dout1_44) AT=790.025n

* CHECK dout1_45 Vdout1_45ck157 = 0 time = 790
.meas tran vdout1_45ck157 FIND v(dout1_45) AT=790.025n

* CHECK dout1_46 Vdout1_46ck157 = 0.9 time = 790
.meas tran vdout1_46ck157 FIND v(dout1_46) AT=790.025n

* CHECK dout1_47 Vdout1_47ck157 = 0.9 time = 790
.meas tran vdout1_47ck157 FIND v(dout1_47) AT=790.025n

* CHECK dout1_48 Vdout1_48ck157 = 0 time = 790
.meas tran vdout1_48ck157 FIND v(dout1_48) AT=790.025n

* CHECK dout1_49 Vdout1_49ck157 = 0.9 time = 790
.meas tran vdout1_49ck157 FIND v(dout1_49) AT=790.025n

* CHECK dout1_50 Vdout1_50ck157 = 0 time = 790
.meas tran vdout1_50ck157 FIND v(dout1_50) AT=790.025n

* CHECK dout1_51 Vdout1_51ck157 = 0.9 time = 790
.meas tran vdout1_51ck157 FIND v(dout1_51) AT=790.025n

* CHECK dout1_52 Vdout1_52ck157 = 0 time = 790
.meas tran vdout1_52ck157 FIND v(dout1_52) AT=790.025n

* CHECK dout1_53 Vdout1_53ck157 = 0 time = 790
.meas tran vdout1_53ck157 FIND v(dout1_53) AT=790.025n

* CHECK dout1_54 Vdout1_54ck157 = 0.9 time = 790
.meas tran vdout1_54ck157 FIND v(dout1_54) AT=790.025n

* CHECK dout1_55 Vdout1_55ck157 = 0.9 time = 790
.meas tran vdout1_55ck157 FIND v(dout1_55) AT=790.025n

* CHECK dout1_56 Vdout1_56ck157 = 0 time = 790
.meas tran vdout1_56ck157 FIND v(dout1_56) AT=790.025n

* CHECK dout1_57 Vdout1_57ck157 = 0 time = 790
.meas tran vdout1_57ck157 FIND v(dout1_57) AT=790.025n

* CHECK dout1_58 Vdout1_58ck157 = 0 time = 790
.meas tran vdout1_58ck157 FIND v(dout1_58) AT=790.025n

* CHECK dout1_59 Vdout1_59ck157 = 0.9 time = 790
.meas tran vdout1_59ck157 FIND v(dout1_59) AT=790.025n

* CHECK dout1_60 Vdout1_60ck157 = 0.9 time = 790
.meas tran vdout1_60ck157 FIND v(dout1_60) AT=790.025n

* CHECK dout1_61 Vdout1_61ck157 = 0.9 time = 790
.meas tran vdout1_61ck157 FIND v(dout1_61) AT=790.025n

* CHECK dout1_62 Vdout1_62ck157 = 0.9 time = 790
.meas tran vdout1_62ck157 FIND v(dout1_62) AT=790.025n

* CHECK dout1_63 Vdout1_63ck157 = 0 time = 790
.meas tran vdout1_63ck157 FIND v(dout1_63) AT=790.025n

* CHECK dout1_64 Vdout1_64ck157 = 0 time = 790
.meas tran vdout1_64ck157 FIND v(dout1_64) AT=790.025n

* CHECK dout1_65 Vdout1_65ck157 = 0 time = 790
.meas tran vdout1_65ck157 FIND v(dout1_65) AT=790.025n

* CHECK dout1_66 Vdout1_66ck157 = 0.9 time = 790
.meas tran vdout1_66ck157 FIND v(dout1_66) AT=790.025n

* CHECK dout1_67 Vdout1_67ck157 = 0.9 time = 790
.meas tran vdout1_67ck157 FIND v(dout1_67) AT=790.025n

* CHECK dout1_68 Vdout1_68ck157 = 0 time = 790
.meas tran vdout1_68ck157 FIND v(dout1_68) AT=790.025n

* CHECK dout1_69 Vdout1_69ck157 = 0 time = 790
.meas tran vdout1_69ck157 FIND v(dout1_69) AT=790.025n

* CHECK dout1_70 Vdout1_70ck157 = 0.9 time = 790
.meas tran vdout1_70ck157 FIND v(dout1_70) AT=790.025n

* CHECK dout1_71 Vdout1_71ck157 = 0.9 time = 790
.meas tran vdout1_71ck157 FIND v(dout1_71) AT=790.025n

* CHECK dout1_72 Vdout1_72ck157 = 0 time = 790
.meas tran vdout1_72ck157 FIND v(dout1_72) AT=790.025n

* CHECK dout1_73 Vdout1_73ck157 = 0.9 time = 790
.meas tran vdout1_73ck157 FIND v(dout1_73) AT=790.025n

* CHECK dout1_74 Vdout1_74ck157 = 0 time = 790
.meas tran vdout1_74ck157 FIND v(dout1_74) AT=790.025n

* CHECK dout1_75 Vdout1_75ck157 = 0 time = 790
.meas tran vdout1_75ck157 FIND v(dout1_75) AT=790.025n

* CHECK dout1_76 Vdout1_76ck157 = 0.9 time = 790
.meas tran vdout1_76ck157 FIND v(dout1_76) AT=790.025n

* CHECK dout1_77 Vdout1_77ck157 = 0 time = 790
.meas tran vdout1_77ck157 FIND v(dout1_77) AT=790.025n

* CHECK dout1_78 Vdout1_78ck157 = 0.9 time = 790
.meas tran vdout1_78ck157 FIND v(dout1_78) AT=790.025n

* CHECK dout1_79 Vdout1_79ck157 = 0 time = 790
.meas tran vdout1_79ck157 FIND v(dout1_79) AT=790.025n

* CHECK dout1_80 Vdout1_80ck157 = 0 time = 790
.meas tran vdout1_80ck157 FIND v(dout1_80) AT=790.025n

* CHECK dout1_81 Vdout1_81ck157 = 0.9 time = 790
.meas tran vdout1_81ck157 FIND v(dout1_81) AT=790.025n

* CHECK dout1_82 Vdout1_82ck157 = 0 time = 790
.meas tran vdout1_82ck157 FIND v(dout1_82) AT=790.025n

* CHECK dout1_83 Vdout1_83ck157 = 0 time = 790
.meas tran vdout1_83ck157 FIND v(dout1_83) AT=790.025n

* CHECK dout1_84 Vdout1_84ck157 = 0.9 time = 790
.meas tran vdout1_84ck157 FIND v(dout1_84) AT=790.025n

* CHECK dout1_85 Vdout1_85ck157 = 0 time = 790
.meas tran vdout1_85ck157 FIND v(dout1_85) AT=790.025n

* CHECK dout1_86 Vdout1_86ck157 = 0 time = 790
.meas tran vdout1_86ck157 FIND v(dout1_86) AT=790.025n

* CHECK dout1_87 Vdout1_87ck157 = 0 time = 790
.meas tran vdout1_87ck157 FIND v(dout1_87) AT=790.025n

* CHECK dout1_88 Vdout1_88ck157 = 0 time = 790
.meas tran vdout1_88ck157 FIND v(dout1_88) AT=790.025n

* CHECK dout1_89 Vdout1_89ck157 = 0.9 time = 790
.meas tran vdout1_89ck157 FIND v(dout1_89) AT=790.025n

* CHECK dout1_90 Vdout1_90ck157 = 0 time = 790
.meas tran vdout1_90ck157 FIND v(dout1_90) AT=790.025n

* CHECK dout1_91 Vdout1_91ck157 = 0.9 time = 790
.meas tran vdout1_91ck157 FIND v(dout1_91) AT=790.025n

* CHECK dout1_92 Vdout1_92ck157 = 0.9 time = 790
.meas tran vdout1_92ck157 FIND v(dout1_92) AT=790.025n

* CHECK dout1_93 Vdout1_93ck157 = 0 time = 790
.meas tran vdout1_93ck157 FIND v(dout1_93) AT=790.025n

* CHECK dout1_94 Vdout1_94ck157 = 0 time = 790
.meas tran vdout1_94ck157 FIND v(dout1_94) AT=790.025n

* CHECK dout1_95 Vdout1_95ck157 = 0 time = 790
.meas tran vdout1_95ck157 FIND v(dout1_95) AT=790.025n

* CHECK dout1_0 Vdout1_0ck161 = 0 time = 810
.meas tran vdout1_0ck161 FIND v(dout1_0) AT=810.025n

* CHECK dout1_1 Vdout1_1ck161 = 0 time = 810
.meas tran vdout1_1ck161 FIND v(dout1_1) AT=810.025n

* CHECK dout1_2 Vdout1_2ck161 = 0 time = 810
.meas tran vdout1_2ck161 FIND v(dout1_2) AT=810.025n

* CHECK dout1_3 Vdout1_3ck161 = 0 time = 810
.meas tran vdout1_3ck161 FIND v(dout1_3) AT=810.025n

* CHECK dout1_4 Vdout1_4ck161 = 0 time = 810
.meas tran vdout1_4ck161 FIND v(dout1_4) AT=810.025n

* CHECK dout1_5 Vdout1_5ck161 = 0.9 time = 810
.meas tran vdout1_5ck161 FIND v(dout1_5) AT=810.025n

* CHECK dout1_6 Vdout1_6ck161 = 0 time = 810
.meas tran vdout1_6ck161 FIND v(dout1_6) AT=810.025n

* CHECK dout1_7 Vdout1_7ck161 = 0.9 time = 810
.meas tran vdout1_7ck161 FIND v(dout1_7) AT=810.025n

* CHECK dout1_8 Vdout1_8ck161 = 0.9 time = 810
.meas tran vdout1_8ck161 FIND v(dout1_8) AT=810.025n

* CHECK dout1_9 Vdout1_9ck161 = 0 time = 810
.meas tran vdout1_9ck161 FIND v(dout1_9) AT=810.025n

* CHECK dout1_10 Vdout1_10ck161 = 0.9 time = 810
.meas tran vdout1_10ck161 FIND v(dout1_10) AT=810.025n

* CHECK dout1_11 Vdout1_11ck161 = 0.9 time = 810
.meas tran vdout1_11ck161 FIND v(dout1_11) AT=810.025n

* CHECK dout1_12 Vdout1_12ck161 = 0 time = 810
.meas tran vdout1_12ck161 FIND v(dout1_12) AT=810.025n

* CHECK dout1_13 Vdout1_13ck161 = 0 time = 810
.meas tran vdout1_13ck161 FIND v(dout1_13) AT=810.025n

* CHECK dout1_14 Vdout1_14ck161 = 0 time = 810
.meas tran vdout1_14ck161 FIND v(dout1_14) AT=810.025n

* CHECK dout1_15 Vdout1_15ck161 = 0.9 time = 810
.meas tran vdout1_15ck161 FIND v(dout1_15) AT=810.025n

* CHECK dout1_16 Vdout1_16ck161 = 0 time = 810
.meas tran vdout1_16ck161 FIND v(dout1_16) AT=810.025n

* CHECK dout1_17 Vdout1_17ck161 = 0.9 time = 810
.meas tran vdout1_17ck161 FIND v(dout1_17) AT=810.025n

* CHECK dout1_18 Vdout1_18ck161 = 0.9 time = 810
.meas tran vdout1_18ck161 FIND v(dout1_18) AT=810.025n

* CHECK dout1_19 Vdout1_19ck161 = 0.9 time = 810
.meas tran vdout1_19ck161 FIND v(dout1_19) AT=810.025n

* CHECK dout1_20 Vdout1_20ck161 = 0 time = 810
.meas tran vdout1_20ck161 FIND v(dout1_20) AT=810.025n

* CHECK dout1_21 Vdout1_21ck161 = 0 time = 810
.meas tran vdout1_21ck161 FIND v(dout1_21) AT=810.025n

* CHECK dout1_22 Vdout1_22ck161 = 0.9 time = 810
.meas tran vdout1_22ck161 FIND v(dout1_22) AT=810.025n

* CHECK dout1_23 Vdout1_23ck161 = 0 time = 810
.meas tran vdout1_23ck161 FIND v(dout1_23) AT=810.025n

* CHECK dout1_24 Vdout1_24ck161 = 0 time = 810
.meas tran vdout1_24ck161 FIND v(dout1_24) AT=810.025n

* CHECK dout1_25 Vdout1_25ck161 = 0.9 time = 810
.meas tran vdout1_25ck161 FIND v(dout1_25) AT=810.025n

* CHECK dout1_26 Vdout1_26ck161 = 0 time = 810
.meas tran vdout1_26ck161 FIND v(dout1_26) AT=810.025n

* CHECK dout1_27 Vdout1_27ck161 = 0.9 time = 810
.meas tran vdout1_27ck161 FIND v(dout1_27) AT=810.025n

* CHECK dout1_28 Vdout1_28ck161 = 0 time = 810
.meas tran vdout1_28ck161 FIND v(dout1_28) AT=810.025n

* CHECK dout1_29 Vdout1_29ck161 = 0 time = 810
.meas tran vdout1_29ck161 FIND v(dout1_29) AT=810.025n

* CHECK dout1_30 Vdout1_30ck161 = 0 time = 810
.meas tran vdout1_30ck161 FIND v(dout1_30) AT=810.025n

* CHECK dout1_31 Vdout1_31ck161 = 0 time = 810
.meas tran vdout1_31ck161 FIND v(dout1_31) AT=810.025n

* CHECK dout1_32 Vdout1_32ck161 = 0.9 time = 810
.meas tran vdout1_32ck161 FIND v(dout1_32) AT=810.025n

* CHECK dout1_33 Vdout1_33ck161 = 0.9 time = 810
.meas tran vdout1_33ck161 FIND v(dout1_33) AT=810.025n

* CHECK dout1_34 Vdout1_34ck161 = 0 time = 810
.meas tran vdout1_34ck161 FIND v(dout1_34) AT=810.025n

* CHECK dout1_35 Vdout1_35ck161 = 0.9 time = 810
.meas tran vdout1_35ck161 FIND v(dout1_35) AT=810.025n

* CHECK dout1_36 Vdout1_36ck161 = 0.9 time = 810
.meas tran vdout1_36ck161 FIND v(dout1_36) AT=810.025n

* CHECK dout1_37 Vdout1_37ck161 = 0.9 time = 810
.meas tran vdout1_37ck161 FIND v(dout1_37) AT=810.025n

* CHECK dout1_38 Vdout1_38ck161 = 0.9 time = 810
.meas tran vdout1_38ck161 FIND v(dout1_38) AT=810.025n

* CHECK dout1_39 Vdout1_39ck161 = 0.9 time = 810
.meas tran vdout1_39ck161 FIND v(dout1_39) AT=810.025n

* CHECK dout1_40 Vdout1_40ck161 = 0.9 time = 810
.meas tran vdout1_40ck161 FIND v(dout1_40) AT=810.025n

* CHECK dout1_41 Vdout1_41ck161 = 0.9 time = 810
.meas tran vdout1_41ck161 FIND v(dout1_41) AT=810.025n

* CHECK dout1_42 Vdout1_42ck161 = 0.9 time = 810
.meas tran vdout1_42ck161 FIND v(dout1_42) AT=810.025n

* CHECK dout1_43 Vdout1_43ck161 = 0 time = 810
.meas tran vdout1_43ck161 FIND v(dout1_43) AT=810.025n

* CHECK dout1_44 Vdout1_44ck161 = 0.9 time = 810
.meas tran vdout1_44ck161 FIND v(dout1_44) AT=810.025n

* CHECK dout1_45 Vdout1_45ck161 = 0.9 time = 810
.meas tran vdout1_45ck161 FIND v(dout1_45) AT=810.025n

* CHECK dout1_46 Vdout1_46ck161 = 0 time = 810
.meas tran vdout1_46ck161 FIND v(dout1_46) AT=810.025n

* CHECK dout1_47 Vdout1_47ck161 = 0 time = 810
.meas tran vdout1_47ck161 FIND v(dout1_47) AT=810.025n

* CHECK dout1_48 Vdout1_48ck161 = 0.9 time = 810
.meas tran vdout1_48ck161 FIND v(dout1_48) AT=810.025n

* CHECK dout1_49 Vdout1_49ck161 = 0 time = 810
.meas tran vdout1_49ck161 FIND v(dout1_49) AT=810.025n

* CHECK dout1_50 Vdout1_50ck161 = 0 time = 810
.meas tran vdout1_50ck161 FIND v(dout1_50) AT=810.025n

* CHECK dout1_51 Vdout1_51ck161 = 0.9 time = 810
.meas tran vdout1_51ck161 FIND v(dout1_51) AT=810.025n

* CHECK dout1_52 Vdout1_52ck161 = 0.9 time = 810
.meas tran vdout1_52ck161 FIND v(dout1_52) AT=810.025n

* CHECK dout1_53 Vdout1_53ck161 = 0.9 time = 810
.meas tran vdout1_53ck161 FIND v(dout1_53) AT=810.025n

* CHECK dout1_54 Vdout1_54ck161 = 0.9 time = 810
.meas tran vdout1_54ck161 FIND v(dout1_54) AT=810.025n

* CHECK dout1_55 Vdout1_55ck161 = 0 time = 810
.meas tran vdout1_55ck161 FIND v(dout1_55) AT=810.025n

* CHECK dout1_56 Vdout1_56ck161 = 0 time = 810
.meas tran vdout1_56ck161 FIND v(dout1_56) AT=810.025n

* CHECK dout1_57 Vdout1_57ck161 = 0.9 time = 810
.meas tran vdout1_57ck161 FIND v(dout1_57) AT=810.025n

* CHECK dout1_58 Vdout1_58ck161 = 0 time = 810
.meas tran vdout1_58ck161 FIND v(dout1_58) AT=810.025n

* CHECK dout1_59 Vdout1_59ck161 = 0 time = 810
.meas tran vdout1_59ck161 FIND v(dout1_59) AT=810.025n

* CHECK dout1_60 Vdout1_60ck161 = 0 time = 810
.meas tran vdout1_60ck161 FIND v(dout1_60) AT=810.025n

* CHECK dout1_61 Vdout1_61ck161 = 0 time = 810
.meas tran vdout1_61ck161 FIND v(dout1_61) AT=810.025n

* CHECK dout1_62 Vdout1_62ck161 = 0.9 time = 810
.meas tran vdout1_62ck161 FIND v(dout1_62) AT=810.025n

* CHECK dout1_63 Vdout1_63ck161 = 0.9 time = 810
.meas tran vdout1_63ck161 FIND v(dout1_63) AT=810.025n

* CHECK dout1_64 Vdout1_64ck161 = 0 time = 810
.meas tran vdout1_64ck161 FIND v(dout1_64) AT=810.025n

* CHECK dout1_65 Vdout1_65ck161 = 0.9 time = 810
.meas tran vdout1_65ck161 FIND v(dout1_65) AT=810.025n

* CHECK dout1_66 Vdout1_66ck161 = 0.9 time = 810
.meas tran vdout1_66ck161 FIND v(dout1_66) AT=810.025n

* CHECK dout1_67 Vdout1_67ck161 = 0 time = 810
.meas tran vdout1_67ck161 FIND v(dout1_67) AT=810.025n

* CHECK dout1_68 Vdout1_68ck161 = 0.9 time = 810
.meas tran vdout1_68ck161 FIND v(dout1_68) AT=810.025n

* CHECK dout1_69 Vdout1_69ck161 = 0 time = 810
.meas tran vdout1_69ck161 FIND v(dout1_69) AT=810.025n

* CHECK dout1_70 Vdout1_70ck161 = 0.9 time = 810
.meas tran vdout1_70ck161 FIND v(dout1_70) AT=810.025n

* CHECK dout1_71 Vdout1_71ck161 = 0.9 time = 810
.meas tran vdout1_71ck161 FIND v(dout1_71) AT=810.025n

* CHECK dout1_72 Vdout1_72ck161 = 0 time = 810
.meas tran vdout1_72ck161 FIND v(dout1_72) AT=810.025n

* CHECK dout1_73 Vdout1_73ck161 = 0.9 time = 810
.meas tran vdout1_73ck161 FIND v(dout1_73) AT=810.025n

* CHECK dout1_74 Vdout1_74ck161 = 0.9 time = 810
.meas tran vdout1_74ck161 FIND v(dout1_74) AT=810.025n

* CHECK dout1_75 Vdout1_75ck161 = 0 time = 810
.meas tran vdout1_75ck161 FIND v(dout1_75) AT=810.025n

* CHECK dout1_76 Vdout1_76ck161 = 0.9 time = 810
.meas tran vdout1_76ck161 FIND v(dout1_76) AT=810.025n

* CHECK dout1_77 Vdout1_77ck161 = 0.9 time = 810
.meas tran vdout1_77ck161 FIND v(dout1_77) AT=810.025n

* CHECK dout1_78 Vdout1_78ck161 = 0.9 time = 810
.meas tran vdout1_78ck161 FIND v(dout1_78) AT=810.025n

* CHECK dout1_79 Vdout1_79ck161 = 0.9 time = 810
.meas tran vdout1_79ck161 FIND v(dout1_79) AT=810.025n

* CHECK dout1_80 Vdout1_80ck161 = 0.9 time = 810
.meas tran vdout1_80ck161 FIND v(dout1_80) AT=810.025n

* CHECK dout1_81 Vdout1_81ck161 = 0 time = 810
.meas tran vdout1_81ck161 FIND v(dout1_81) AT=810.025n

* CHECK dout1_82 Vdout1_82ck161 = 0.9 time = 810
.meas tran vdout1_82ck161 FIND v(dout1_82) AT=810.025n

* CHECK dout1_83 Vdout1_83ck161 = 0.9 time = 810
.meas tran vdout1_83ck161 FIND v(dout1_83) AT=810.025n

* CHECK dout1_84 Vdout1_84ck161 = 0.9 time = 810
.meas tran vdout1_84ck161 FIND v(dout1_84) AT=810.025n

* CHECK dout1_85 Vdout1_85ck161 = 0.9 time = 810
.meas tran vdout1_85ck161 FIND v(dout1_85) AT=810.025n

* CHECK dout1_86 Vdout1_86ck161 = 0 time = 810
.meas tran vdout1_86ck161 FIND v(dout1_86) AT=810.025n

* CHECK dout1_87 Vdout1_87ck161 = 0.9 time = 810
.meas tran vdout1_87ck161 FIND v(dout1_87) AT=810.025n

* CHECK dout1_88 Vdout1_88ck161 = 0.9 time = 810
.meas tran vdout1_88ck161 FIND v(dout1_88) AT=810.025n

* CHECK dout1_89 Vdout1_89ck161 = 0.9 time = 810
.meas tran vdout1_89ck161 FIND v(dout1_89) AT=810.025n

* CHECK dout1_90 Vdout1_90ck161 = 0.9 time = 810
.meas tran vdout1_90ck161 FIND v(dout1_90) AT=810.025n

* CHECK dout1_91 Vdout1_91ck161 = 0 time = 810
.meas tran vdout1_91ck161 FIND v(dout1_91) AT=810.025n

* CHECK dout1_92 Vdout1_92ck161 = 0.9 time = 810
.meas tran vdout1_92ck161 FIND v(dout1_92) AT=810.025n

* CHECK dout1_93 Vdout1_93ck161 = 0.9 time = 810
.meas tran vdout1_93ck161 FIND v(dout1_93) AT=810.025n

* CHECK dout1_94 Vdout1_94ck161 = 0.9 time = 810
.meas tran vdout1_94ck161 FIND v(dout1_94) AT=810.025n

* CHECK dout1_95 Vdout1_95ck161 = 0.9 time = 810
.meas tran vdout1_95ck161 FIND v(dout1_95) AT=810.025n

* CHECK dout1_0 Vdout1_0ck164 = 0 time = 825
.meas tran vdout1_0ck164 FIND v(dout1_0) AT=825.025n

* CHECK dout1_1 Vdout1_1ck164 = 0.9 time = 825
.meas tran vdout1_1ck164 FIND v(dout1_1) AT=825.025n

* CHECK dout1_2 Vdout1_2ck164 = 0 time = 825
.meas tran vdout1_2ck164 FIND v(dout1_2) AT=825.025n

* CHECK dout1_3 Vdout1_3ck164 = 0 time = 825
.meas tran vdout1_3ck164 FIND v(dout1_3) AT=825.025n

* CHECK dout1_4 Vdout1_4ck164 = 0.9 time = 825
.meas tran vdout1_4ck164 FIND v(dout1_4) AT=825.025n

* CHECK dout1_5 Vdout1_5ck164 = 0 time = 825
.meas tran vdout1_5ck164 FIND v(dout1_5) AT=825.025n

* CHECK dout1_6 Vdout1_6ck164 = 0.9 time = 825
.meas tran vdout1_6ck164 FIND v(dout1_6) AT=825.025n

* CHECK dout1_7 Vdout1_7ck164 = 0.9 time = 825
.meas tran vdout1_7ck164 FIND v(dout1_7) AT=825.025n

* CHECK dout1_8 Vdout1_8ck164 = 0 time = 825
.meas tran vdout1_8ck164 FIND v(dout1_8) AT=825.025n

* CHECK dout1_9 Vdout1_9ck164 = 0.9 time = 825
.meas tran vdout1_9ck164 FIND v(dout1_9) AT=825.025n

* CHECK dout1_10 Vdout1_10ck164 = 0.9 time = 825
.meas tran vdout1_10ck164 FIND v(dout1_10) AT=825.025n

* CHECK dout1_11 Vdout1_11ck164 = 0.9 time = 825
.meas tran vdout1_11ck164 FIND v(dout1_11) AT=825.025n

* CHECK dout1_12 Vdout1_12ck164 = 0 time = 825
.meas tran vdout1_12ck164 FIND v(dout1_12) AT=825.025n

* CHECK dout1_13 Vdout1_13ck164 = 0 time = 825
.meas tran vdout1_13ck164 FIND v(dout1_13) AT=825.025n

* CHECK dout1_14 Vdout1_14ck164 = 0 time = 825
.meas tran vdout1_14ck164 FIND v(dout1_14) AT=825.025n

* CHECK dout1_15 Vdout1_15ck164 = 0 time = 825
.meas tran vdout1_15ck164 FIND v(dout1_15) AT=825.025n

* CHECK dout1_16 Vdout1_16ck164 = 0.9 time = 825
.meas tran vdout1_16ck164 FIND v(dout1_16) AT=825.025n

* CHECK dout1_17 Vdout1_17ck164 = 0.9 time = 825
.meas tran vdout1_17ck164 FIND v(dout1_17) AT=825.025n

* CHECK dout1_18 Vdout1_18ck164 = 0 time = 825
.meas tran vdout1_18ck164 FIND v(dout1_18) AT=825.025n

* CHECK dout1_19 Vdout1_19ck164 = 0 time = 825
.meas tran vdout1_19ck164 FIND v(dout1_19) AT=825.025n

* CHECK dout1_20 Vdout1_20ck164 = 0 time = 825
.meas tran vdout1_20ck164 FIND v(dout1_20) AT=825.025n

* CHECK dout1_21 Vdout1_21ck164 = 0.9 time = 825
.meas tran vdout1_21ck164 FIND v(dout1_21) AT=825.025n

* CHECK dout1_22 Vdout1_22ck164 = 0 time = 825
.meas tran vdout1_22ck164 FIND v(dout1_22) AT=825.025n

* CHECK dout1_23 Vdout1_23ck164 = 0.9 time = 825
.meas tran vdout1_23ck164 FIND v(dout1_23) AT=825.025n

* CHECK dout1_24 Vdout1_24ck164 = 0.9 time = 825
.meas tran vdout1_24ck164 FIND v(dout1_24) AT=825.025n

* CHECK dout1_25 Vdout1_25ck164 = 0.9 time = 825
.meas tran vdout1_25ck164 FIND v(dout1_25) AT=825.025n

* CHECK dout1_26 Vdout1_26ck164 = 0 time = 825
.meas tran vdout1_26ck164 FIND v(dout1_26) AT=825.025n

* CHECK dout1_27 Vdout1_27ck164 = 0 time = 825
.meas tran vdout1_27ck164 FIND v(dout1_27) AT=825.025n

* CHECK dout1_28 Vdout1_28ck164 = 0.9 time = 825
.meas tran vdout1_28ck164 FIND v(dout1_28) AT=825.025n

* CHECK dout1_29 Vdout1_29ck164 = 0 time = 825
.meas tran vdout1_29ck164 FIND v(dout1_29) AT=825.025n

* CHECK dout1_30 Vdout1_30ck164 = 0 time = 825
.meas tran vdout1_30ck164 FIND v(dout1_30) AT=825.025n

* CHECK dout1_31 Vdout1_31ck164 = 0 time = 825
.meas tran vdout1_31ck164 FIND v(dout1_31) AT=825.025n

* CHECK dout1_32 Vdout1_32ck164 = 0.9 time = 825
.meas tran vdout1_32ck164 FIND v(dout1_32) AT=825.025n

* CHECK dout1_33 Vdout1_33ck164 = 0 time = 825
.meas tran vdout1_33ck164 FIND v(dout1_33) AT=825.025n

* CHECK dout1_34 Vdout1_34ck164 = 0.9 time = 825
.meas tran vdout1_34ck164 FIND v(dout1_34) AT=825.025n

* CHECK dout1_35 Vdout1_35ck164 = 0 time = 825
.meas tran vdout1_35ck164 FIND v(dout1_35) AT=825.025n

* CHECK dout1_36 Vdout1_36ck164 = 0 time = 825
.meas tran vdout1_36ck164 FIND v(dout1_36) AT=825.025n

* CHECK dout1_37 Vdout1_37ck164 = 0 time = 825
.meas tran vdout1_37ck164 FIND v(dout1_37) AT=825.025n

* CHECK dout1_38 Vdout1_38ck164 = 0.9 time = 825
.meas tran vdout1_38ck164 FIND v(dout1_38) AT=825.025n

* CHECK dout1_39 Vdout1_39ck164 = 0.9 time = 825
.meas tran vdout1_39ck164 FIND v(dout1_39) AT=825.025n

* CHECK dout1_40 Vdout1_40ck164 = 0 time = 825
.meas tran vdout1_40ck164 FIND v(dout1_40) AT=825.025n

* CHECK dout1_41 Vdout1_41ck164 = 0.9 time = 825
.meas tran vdout1_41ck164 FIND v(dout1_41) AT=825.025n

* CHECK dout1_42 Vdout1_42ck164 = 0.9 time = 825
.meas tran vdout1_42ck164 FIND v(dout1_42) AT=825.025n

* CHECK dout1_43 Vdout1_43ck164 = 0 time = 825
.meas tran vdout1_43ck164 FIND v(dout1_43) AT=825.025n

* CHECK dout1_44 Vdout1_44ck164 = 0.9 time = 825
.meas tran vdout1_44ck164 FIND v(dout1_44) AT=825.025n

* CHECK dout1_45 Vdout1_45ck164 = 0 time = 825
.meas tran vdout1_45ck164 FIND v(dout1_45) AT=825.025n

* CHECK dout1_46 Vdout1_46ck164 = 0 time = 825
.meas tran vdout1_46ck164 FIND v(dout1_46) AT=825.025n

* CHECK dout1_47 Vdout1_47ck164 = 0.9 time = 825
.meas tran vdout1_47ck164 FIND v(dout1_47) AT=825.025n

* CHECK dout1_48 Vdout1_48ck164 = 0 time = 825
.meas tran vdout1_48ck164 FIND v(dout1_48) AT=825.025n

* CHECK dout1_49 Vdout1_49ck164 = 0 time = 825
.meas tran vdout1_49ck164 FIND v(dout1_49) AT=825.025n

* CHECK dout1_50 Vdout1_50ck164 = 0 time = 825
.meas tran vdout1_50ck164 FIND v(dout1_50) AT=825.025n

* CHECK dout1_51 Vdout1_51ck164 = 0.9 time = 825
.meas tran vdout1_51ck164 FIND v(dout1_51) AT=825.025n

* CHECK dout1_52 Vdout1_52ck164 = 0 time = 825
.meas tran vdout1_52ck164 FIND v(dout1_52) AT=825.025n

* CHECK dout1_53 Vdout1_53ck164 = 0 time = 825
.meas tran vdout1_53ck164 FIND v(dout1_53) AT=825.025n

* CHECK dout1_54 Vdout1_54ck164 = 0.9 time = 825
.meas tran vdout1_54ck164 FIND v(dout1_54) AT=825.025n

* CHECK dout1_55 Vdout1_55ck164 = 0 time = 825
.meas tran vdout1_55ck164 FIND v(dout1_55) AT=825.025n

* CHECK dout1_56 Vdout1_56ck164 = 0 time = 825
.meas tran vdout1_56ck164 FIND v(dout1_56) AT=825.025n

* CHECK dout1_57 Vdout1_57ck164 = 0.9 time = 825
.meas tran vdout1_57ck164 FIND v(dout1_57) AT=825.025n

* CHECK dout1_58 Vdout1_58ck164 = 0.9 time = 825
.meas tran vdout1_58ck164 FIND v(dout1_58) AT=825.025n

* CHECK dout1_59 Vdout1_59ck164 = 0 time = 825
.meas tran vdout1_59ck164 FIND v(dout1_59) AT=825.025n

* CHECK dout1_60 Vdout1_60ck164 = 0 time = 825
.meas tran vdout1_60ck164 FIND v(dout1_60) AT=825.025n

* CHECK dout1_61 Vdout1_61ck164 = 0 time = 825
.meas tran vdout1_61ck164 FIND v(dout1_61) AT=825.025n

* CHECK dout1_62 Vdout1_62ck164 = 0.9 time = 825
.meas tran vdout1_62ck164 FIND v(dout1_62) AT=825.025n

* CHECK dout1_63 Vdout1_63ck164 = 0 time = 825
.meas tran vdout1_63ck164 FIND v(dout1_63) AT=825.025n

* CHECK dout1_64 Vdout1_64ck164 = 0.9 time = 825
.meas tran vdout1_64ck164 FIND v(dout1_64) AT=825.025n

* CHECK dout1_65 Vdout1_65ck164 = 0.9 time = 825
.meas tran vdout1_65ck164 FIND v(dout1_65) AT=825.025n

* CHECK dout1_66 Vdout1_66ck164 = 0 time = 825
.meas tran vdout1_66ck164 FIND v(dout1_66) AT=825.025n

* CHECK dout1_67 Vdout1_67ck164 = 0 time = 825
.meas tran vdout1_67ck164 FIND v(dout1_67) AT=825.025n

* CHECK dout1_68 Vdout1_68ck164 = 0 time = 825
.meas tran vdout1_68ck164 FIND v(dout1_68) AT=825.025n

* CHECK dout1_69 Vdout1_69ck164 = 0 time = 825
.meas tran vdout1_69ck164 FIND v(dout1_69) AT=825.025n

* CHECK dout1_70 Vdout1_70ck164 = 0 time = 825
.meas tran vdout1_70ck164 FIND v(dout1_70) AT=825.025n

* CHECK dout1_71 Vdout1_71ck164 = 0 time = 825
.meas tran vdout1_71ck164 FIND v(dout1_71) AT=825.025n

* CHECK dout1_72 Vdout1_72ck164 = 0 time = 825
.meas tran vdout1_72ck164 FIND v(dout1_72) AT=825.025n

* CHECK dout1_73 Vdout1_73ck164 = 0.9 time = 825
.meas tran vdout1_73ck164 FIND v(dout1_73) AT=825.025n

* CHECK dout1_74 Vdout1_74ck164 = 0.9 time = 825
.meas tran vdout1_74ck164 FIND v(dout1_74) AT=825.025n

* CHECK dout1_75 Vdout1_75ck164 = 0 time = 825
.meas tran vdout1_75ck164 FIND v(dout1_75) AT=825.025n

* CHECK dout1_76 Vdout1_76ck164 = 0 time = 825
.meas tran vdout1_76ck164 FIND v(dout1_76) AT=825.025n

* CHECK dout1_77 Vdout1_77ck164 = 0.9 time = 825
.meas tran vdout1_77ck164 FIND v(dout1_77) AT=825.025n

* CHECK dout1_78 Vdout1_78ck164 = 0.9 time = 825
.meas tran vdout1_78ck164 FIND v(dout1_78) AT=825.025n

* CHECK dout1_79 Vdout1_79ck164 = 0.9 time = 825
.meas tran vdout1_79ck164 FIND v(dout1_79) AT=825.025n

* CHECK dout1_80 Vdout1_80ck164 = 0.9 time = 825
.meas tran vdout1_80ck164 FIND v(dout1_80) AT=825.025n

* CHECK dout1_81 Vdout1_81ck164 = 0.9 time = 825
.meas tran vdout1_81ck164 FIND v(dout1_81) AT=825.025n

* CHECK dout1_82 Vdout1_82ck164 = 0 time = 825
.meas tran vdout1_82ck164 FIND v(dout1_82) AT=825.025n

* CHECK dout1_83 Vdout1_83ck164 = 0 time = 825
.meas tran vdout1_83ck164 FIND v(dout1_83) AT=825.025n

* CHECK dout1_84 Vdout1_84ck164 = 0 time = 825
.meas tran vdout1_84ck164 FIND v(dout1_84) AT=825.025n

* CHECK dout1_85 Vdout1_85ck164 = 0 time = 825
.meas tran vdout1_85ck164 FIND v(dout1_85) AT=825.025n

* CHECK dout1_86 Vdout1_86ck164 = 0.9 time = 825
.meas tran vdout1_86ck164 FIND v(dout1_86) AT=825.025n

* CHECK dout1_87 Vdout1_87ck164 = 0 time = 825
.meas tran vdout1_87ck164 FIND v(dout1_87) AT=825.025n

* CHECK dout1_88 Vdout1_88ck164 = 0 time = 825
.meas tran vdout1_88ck164 FIND v(dout1_88) AT=825.025n

* CHECK dout1_89 Vdout1_89ck164 = 0.9 time = 825
.meas tran vdout1_89ck164 FIND v(dout1_89) AT=825.025n

* CHECK dout1_90 Vdout1_90ck164 = 0.9 time = 825
.meas tran vdout1_90ck164 FIND v(dout1_90) AT=825.025n

* CHECK dout1_91 Vdout1_91ck164 = 0.9 time = 825
.meas tran vdout1_91ck164 FIND v(dout1_91) AT=825.025n

* CHECK dout1_92 Vdout1_92ck164 = 0.9 time = 825
.meas tran vdout1_92ck164 FIND v(dout1_92) AT=825.025n

* CHECK dout1_93 Vdout1_93ck164 = 0.9 time = 825
.meas tran vdout1_93ck164 FIND v(dout1_93) AT=825.025n

* CHECK dout1_94 Vdout1_94ck164 = 0 time = 825
.meas tran vdout1_94ck164 FIND v(dout1_94) AT=825.025n

* CHECK dout1_95 Vdout1_95ck164 = 0.9 time = 825
.meas tran vdout1_95ck164 FIND v(dout1_95) AT=825.025n

* CHECK dout1_0 Vdout1_0ck165 = 0 time = 830
.meas tran vdout1_0ck165 FIND v(dout1_0) AT=830.025n

* CHECK dout1_1 Vdout1_1ck165 = 0 time = 830
.meas tran vdout1_1ck165 FIND v(dout1_1) AT=830.025n

* CHECK dout1_2 Vdout1_2ck165 = 0 time = 830
.meas tran vdout1_2ck165 FIND v(dout1_2) AT=830.025n

* CHECK dout1_3 Vdout1_3ck165 = 0 time = 830
.meas tran vdout1_3ck165 FIND v(dout1_3) AT=830.025n

* CHECK dout1_4 Vdout1_4ck165 = 0 time = 830
.meas tran vdout1_4ck165 FIND v(dout1_4) AT=830.025n

* CHECK dout1_5 Vdout1_5ck165 = 0.9 time = 830
.meas tran vdout1_5ck165 FIND v(dout1_5) AT=830.025n

* CHECK dout1_6 Vdout1_6ck165 = 0 time = 830
.meas tran vdout1_6ck165 FIND v(dout1_6) AT=830.025n

* CHECK dout1_7 Vdout1_7ck165 = 0.9 time = 830
.meas tran vdout1_7ck165 FIND v(dout1_7) AT=830.025n

* CHECK dout1_8 Vdout1_8ck165 = 0.9 time = 830
.meas tran vdout1_8ck165 FIND v(dout1_8) AT=830.025n

* CHECK dout1_9 Vdout1_9ck165 = 0 time = 830
.meas tran vdout1_9ck165 FIND v(dout1_9) AT=830.025n

* CHECK dout1_10 Vdout1_10ck165 = 0.9 time = 830
.meas tran vdout1_10ck165 FIND v(dout1_10) AT=830.025n

* CHECK dout1_11 Vdout1_11ck165 = 0.9 time = 830
.meas tran vdout1_11ck165 FIND v(dout1_11) AT=830.025n

* CHECK dout1_12 Vdout1_12ck165 = 0 time = 830
.meas tran vdout1_12ck165 FIND v(dout1_12) AT=830.025n

* CHECK dout1_13 Vdout1_13ck165 = 0 time = 830
.meas tran vdout1_13ck165 FIND v(dout1_13) AT=830.025n

* CHECK dout1_14 Vdout1_14ck165 = 0 time = 830
.meas tran vdout1_14ck165 FIND v(dout1_14) AT=830.025n

* CHECK dout1_15 Vdout1_15ck165 = 0.9 time = 830
.meas tran vdout1_15ck165 FIND v(dout1_15) AT=830.025n

* CHECK dout1_16 Vdout1_16ck165 = 0 time = 830
.meas tran vdout1_16ck165 FIND v(dout1_16) AT=830.025n

* CHECK dout1_17 Vdout1_17ck165 = 0.9 time = 830
.meas tran vdout1_17ck165 FIND v(dout1_17) AT=830.025n

* CHECK dout1_18 Vdout1_18ck165 = 0.9 time = 830
.meas tran vdout1_18ck165 FIND v(dout1_18) AT=830.025n

* CHECK dout1_19 Vdout1_19ck165 = 0.9 time = 830
.meas tran vdout1_19ck165 FIND v(dout1_19) AT=830.025n

* CHECK dout1_20 Vdout1_20ck165 = 0 time = 830
.meas tran vdout1_20ck165 FIND v(dout1_20) AT=830.025n

* CHECK dout1_21 Vdout1_21ck165 = 0 time = 830
.meas tran vdout1_21ck165 FIND v(dout1_21) AT=830.025n

* CHECK dout1_22 Vdout1_22ck165 = 0.9 time = 830
.meas tran vdout1_22ck165 FIND v(dout1_22) AT=830.025n

* CHECK dout1_23 Vdout1_23ck165 = 0 time = 830
.meas tran vdout1_23ck165 FIND v(dout1_23) AT=830.025n

* CHECK dout1_24 Vdout1_24ck165 = 0 time = 830
.meas tran vdout1_24ck165 FIND v(dout1_24) AT=830.025n

* CHECK dout1_25 Vdout1_25ck165 = 0.9 time = 830
.meas tran vdout1_25ck165 FIND v(dout1_25) AT=830.025n

* CHECK dout1_26 Vdout1_26ck165 = 0 time = 830
.meas tran vdout1_26ck165 FIND v(dout1_26) AT=830.025n

* CHECK dout1_27 Vdout1_27ck165 = 0.9 time = 830
.meas tran vdout1_27ck165 FIND v(dout1_27) AT=830.025n

* CHECK dout1_28 Vdout1_28ck165 = 0 time = 830
.meas tran vdout1_28ck165 FIND v(dout1_28) AT=830.025n

* CHECK dout1_29 Vdout1_29ck165 = 0 time = 830
.meas tran vdout1_29ck165 FIND v(dout1_29) AT=830.025n

* CHECK dout1_30 Vdout1_30ck165 = 0 time = 830
.meas tran vdout1_30ck165 FIND v(dout1_30) AT=830.025n

* CHECK dout1_31 Vdout1_31ck165 = 0 time = 830
.meas tran vdout1_31ck165 FIND v(dout1_31) AT=830.025n

* CHECK dout1_32 Vdout1_32ck165 = 0.9 time = 830
.meas tran vdout1_32ck165 FIND v(dout1_32) AT=830.025n

* CHECK dout1_33 Vdout1_33ck165 = 0.9 time = 830
.meas tran vdout1_33ck165 FIND v(dout1_33) AT=830.025n

* CHECK dout1_34 Vdout1_34ck165 = 0 time = 830
.meas tran vdout1_34ck165 FIND v(dout1_34) AT=830.025n

* CHECK dout1_35 Vdout1_35ck165 = 0.9 time = 830
.meas tran vdout1_35ck165 FIND v(dout1_35) AT=830.025n

* CHECK dout1_36 Vdout1_36ck165 = 0.9 time = 830
.meas tran vdout1_36ck165 FIND v(dout1_36) AT=830.025n

* CHECK dout1_37 Vdout1_37ck165 = 0.9 time = 830
.meas tran vdout1_37ck165 FIND v(dout1_37) AT=830.025n

* CHECK dout1_38 Vdout1_38ck165 = 0.9 time = 830
.meas tran vdout1_38ck165 FIND v(dout1_38) AT=830.025n

* CHECK dout1_39 Vdout1_39ck165 = 0.9 time = 830
.meas tran vdout1_39ck165 FIND v(dout1_39) AT=830.025n

* CHECK dout1_40 Vdout1_40ck165 = 0.9 time = 830
.meas tran vdout1_40ck165 FIND v(dout1_40) AT=830.025n

* CHECK dout1_41 Vdout1_41ck165 = 0.9 time = 830
.meas tran vdout1_41ck165 FIND v(dout1_41) AT=830.025n

* CHECK dout1_42 Vdout1_42ck165 = 0.9 time = 830
.meas tran vdout1_42ck165 FIND v(dout1_42) AT=830.025n

* CHECK dout1_43 Vdout1_43ck165 = 0 time = 830
.meas tran vdout1_43ck165 FIND v(dout1_43) AT=830.025n

* CHECK dout1_44 Vdout1_44ck165 = 0.9 time = 830
.meas tran vdout1_44ck165 FIND v(dout1_44) AT=830.025n

* CHECK dout1_45 Vdout1_45ck165 = 0.9 time = 830
.meas tran vdout1_45ck165 FIND v(dout1_45) AT=830.025n

* CHECK dout1_46 Vdout1_46ck165 = 0 time = 830
.meas tran vdout1_46ck165 FIND v(dout1_46) AT=830.025n

* CHECK dout1_47 Vdout1_47ck165 = 0 time = 830
.meas tran vdout1_47ck165 FIND v(dout1_47) AT=830.025n

* CHECK dout1_48 Vdout1_48ck165 = 0.9 time = 830
.meas tran vdout1_48ck165 FIND v(dout1_48) AT=830.025n

* CHECK dout1_49 Vdout1_49ck165 = 0 time = 830
.meas tran vdout1_49ck165 FIND v(dout1_49) AT=830.025n

* CHECK dout1_50 Vdout1_50ck165 = 0 time = 830
.meas tran vdout1_50ck165 FIND v(dout1_50) AT=830.025n

* CHECK dout1_51 Vdout1_51ck165 = 0.9 time = 830
.meas tran vdout1_51ck165 FIND v(dout1_51) AT=830.025n

* CHECK dout1_52 Vdout1_52ck165 = 0.9 time = 830
.meas tran vdout1_52ck165 FIND v(dout1_52) AT=830.025n

* CHECK dout1_53 Vdout1_53ck165 = 0.9 time = 830
.meas tran vdout1_53ck165 FIND v(dout1_53) AT=830.025n

* CHECK dout1_54 Vdout1_54ck165 = 0.9 time = 830
.meas tran vdout1_54ck165 FIND v(dout1_54) AT=830.025n

* CHECK dout1_55 Vdout1_55ck165 = 0 time = 830
.meas tran vdout1_55ck165 FIND v(dout1_55) AT=830.025n

* CHECK dout1_56 Vdout1_56ck165 = 0 time = 830
.meas tran vdout1_56ck165 FIND v(dout1_56) AT=830.025n

* CHECK dout1_57 Vdout1_57ck165 = 0.9 time = 830
.meas tran vdout1_57ck165 FIND v(dout1_57) AT=830.025n

* CHECK dout1_58 Vdout1_58ck165 = 0 time = 830
.meas tran vdout1_58ck165 FIND v(dout1_58) AT=830.025n

* CHECK dout1_59 Vdout1_59ck165 = 0 time = 830
.meas tran vdout1_59ck165 FIND v(dout1_59) AT=830.025n

* CHECK dout1_60 Vdout1_60ck165 = 0 time = 830
.meas tran vdout1_60ck165 FIND v(dout1_60) AT=830.025n

* CHECK dout1_61 Vdout1_61ck165 = 0 time = 830
.meas tran vdout1_61ck165 FIND v(dout1_61) AT=830.025n

* CHECK dout1_62 Vdout1_62ck165 = 0.9 time = 830
.meas tran vdout1_62ck165 FIND v(dout1_62) AT=830.025n

* CHECK dout1_63 Vdout1_63ck165 = 0.9 time = 830
.meas tran vdout1_63ck165 FIND v(dout1_63) AT=830.025n

* CHECK dout1_64 Vdout1_64ck165 = 0 time = 830
.meas tran vdout1_64ck165 FIND v(dout1_64) AT=830.025n

* CHECK dout1_65 Vdout1_65ck165 = 0.9 time = 830
.meas tran vdout1_65ck165 FIND v(dout1_65) AT=830.025n

* CHECK dout1_66 Vdout1_66ck165 = 0.9 time = 830
.meas tran vdout1_66ck165 FIND v(dout1_66) AT=830.025n

* CHECK dout1_67 Vdout1_67ck165 = 0 time = 830
.meas tran vdout1_67ck165 FIND v(dout1_67) AT=830.025n

* CHECK dout1_68 Vdout1_68ck165 = 0.9 time = 830
.meas tran vdout1_68ck165 FIND v(dout1_68) AT=830.025n

* CHECK dout1_69 Vdout1_69ck165 = 0 time = 830
.meas tran vdout1_69ck165 FIND v(dout1_69) AT=830.025n

* CHECK dout1_70 Vdout1_70ck165 = 0.9 time = 830
.meas tran vdout1_70ck165 FIND v(dout1_70) AT=830.025n

* CHECK dout1_71 Vdout1_71ck165 = 0.9 time = 830
.meas tran vdout1_71ck165 FIND v(dout1_71) AT=830.025n

* CHECK dout1_72 Vdout1_72ck165 = 0 time = 830
.meas tran vdout1_72ck165 FIND v(dout1_72) AT=830.025n

* CHECK dout1_73 Vdout1_73ck165 = 0.9 time = 830
.meas tran vdout1_73ck165 FIND v(dout1_73) AT=830.025n

* CHECK dout1_74 Vdout1_74ck165 = 0.9 time = 830
.meas tran vdout1_74ck165 FIND v(dout1_74) AT=830.025n

* CHECK dout1_75 Vdout1_75ck165 = 0 time = 830
.meas tran vdout1_75ck165 FIND v(dout1_75) AT=830.025n

* CHECK dout1_76 Vdout1_76ck165 = 0.9 time = 830
.meas tran vdout1_76ck165 FIND v(dout1_76) AT=830.025n

* CHECK dout1_77 Vdout1_77ck165 = 0.9 time = 830
.meas tran vdout1_77ck165 FIND v(dout1_77) AT=830.025n

* CHECK dout1_78 Vdout1_78ck165 = 0.9 time = 830
.meas tran vdout1_78ck165 FIND v(dout1_78) AT=830.025n

* CHECK dout1_79 Vdout1_79ck165 = 0.9 time = 830
.meas tran vdout1_79ck165 FIND v(dout1_79) AT=830.025n

* CHECK dout1_80 Vdout1_80ck165 = 0.9 time = 830
.meas tran vdout1_80ck165 FIND v(dout1_80) AT=830.025n

* CHECK dout1_81 Vdout1_81ck165 = 0 time = 830
.meas tran vdout1_81ck165 FIND v(dout1_81) AT=830.025n

* CHECK dout1_82 Vdout1_82ck165 = 0.9 time = 830
.meas tran vdout1_82ck165 FIND v(dout1_82) AT=830.025n

* CHECK dout1_83 Vdout1_83ck165 = 0.9 time = 830
.meas tran vdout1_83ck165 FIND v(dout1_83) AT=830.025n

* CHECK dout1_84 Vdout1_84ck165 = 0.9 time = 830
.meas tran vdout1_84ck165 FIND v(dout1_84) AT=830.025n

* CHECK dout1_85 Vdout1_85ck165 = 0.9 time = 830
.meas tran vdout1_85ck165 FIND v(dout1_85) AT=830.025n

* CHECK dout1_86 Vdout1_86ck165 = 0 time = 830
.meas tran vdout1_86ck165 FIND v(dout1_86) AT=830.025n

* CHECK dout1_87 Vdout1_87ck165 = 0.9 time = 830
.meas tran vdout1_87ck165 FIND v(dout1_87) AT=830.025n

* CHECK dout1_88 Vdout1_88ck165 = 0.9 time = 830
.meas tran vdout1_88ck165 FIND v(dout1_88) AT=830.025n

* CHECK dout1_89 Vdout1_89ck165 = 0.9 time = 830
.meas tran vdout1_89ck165 FIND v(dout1_89) AT=830.025n

* CHECK dout1_90 Vdout1_90ck165 = 0.9 time = 830
.meas tran vdout1_90ck165 FIND v(dout1_90) AT=830.025n

* CHECK dout1_91 Vdout1_91ck165 = 0 time = 830
.meas tran vdout1_91ck165 FIND v(dout1_91) AT=830.025n

* CHECK dout1_92 Vdout1_92ck165 = 0.9 time = 830
.meas tran vdout1_92ck165 FIND v(dout1_92) AT=830.025n

* CHECK dout1_93 Vdout1_93ck165 = 0.9 time = 830
.meas tran vdout1_93ck165 FIND v(dout1_93) AT=830.025n

* CHECK dout1_94 Vdout1_94ck165 = 0.9 time = 830
.meas tran vdout1_94ck165 FIND v(dout1_94) AT=830.025n

* CHECK dout1_95 Vdout1_95ck165 = 0.9 time = 830
.meas tran vdout1_95ck165 FIND v(dout1_95) AT=830.025n

* CHECK dout1_0 Vdout1_0ck177 = 0.9 time = 890
.meas tran vdout1_0ck177 FIND v(dout1_0) AT=890.025n

* CHECK dout1_1 Vdout1_1ck177 = 0.9 time = 890
.meas tran vdout1_1ck177 FIND v(dout1_1) AT=890.025n

* CHECK dout1_2 Vdout1_2ck177 = 0 time = 890
.meas tran vdout1_2ck177 FIND v(dout1_2) AT=890.025n

* CHECK dout1_3 Vdout1_3ck177 = 0.9 time = 890
.meas tran vdout1_3ck177 FIND v(dout1_3) AT=890.025n

* CHECK dout1_4 Vdout1_4ck177 = 0.9 time = 890
.meas tran vdout1_4ck177 FIND v(dout1_4) AT=890.025n

* CHECK dout1_5 Vdout1_5ck177 = 0.9 time = 890
.meas tran vdout1_5ck177 FIND v(dout1_5) AT=890.025n

* CHECK dout1_6 Vdout1_6ck177 = 0.9 time = 890
.meas tran vdout1_6ck177 FIND v(dout1_6) AT=890.025n

* CHECK dout1_7 Vdout1_7ck177 = 0.9 time = 890
.meas tran vdout1_7ck177 FIND v(dout1_7) AT=890.025n

* CHECK dout1_8 Vdout1_8ck177 = 0.9 time = 890
.meas tran vdout1_8ck177 FIND v(dout1_8) AT=890.025n

* CHECK dout1_9 Vdout1_9ck177 = 0.9 time = 890
.meas tran vdout1_9ck177 FIND v(dout1_9) AT=890.025n

* CHECK dout1_10 Vdout1_10ck177 = 0 time = 890
.meas tran vdout1_10ck177 FIND v(dout1_10) AT=890.025n

* CHECK dout1_11 Vdout1_11ck177 = 0 time = 890
.meas tran vdout1_11ck177 FIND v(dout1_11) AT=890.025n

* CHECK dout1_12 Vdout1_12ck177 = 0 time = 890
.meas tran vdout1_12ck177 FIND v(dout1_12) AT=890.025n

* CHECK dout1_13 Vdout1_13ck177 = 0.9 time = 890
.meas tran vdout1_13ck177 FIND v(dout1_13) AT=890.025n

* CHECK dout1_14 Vdout1_14ck177 = 0.9 time = 890
.meas tran vdout1_14ck177 FIND v(dout1_14) AT=890.025n

* CHECK dout1_15 Vdout1_15ck177 = 0.9 time = 890
.meas tran vdout1_15ck177 FIND v(dout1_15) AT=890.025n

* CHECK dout1_16 Vdout1_16ck177 = 0 time = 890
.meas tran vdout1_16ck177 FIND v(dout1_16) AT=890.025n

* CHECK dout1_17 Vdout1_17ck177 = 0.9 time = 890
.meas tran vdout1_17ck177 FIND v(dout1_17) AT=890.025n

* CHECK dout1_18 Vdout1_18ck177 = 0.9 time = 890
.meas tran vdout1_18ck177 FIND v(dout1_18) AT=890.025n

* CHECK dout1_19 Vdout1_19ck177 = 0 time = 890
.meas tran vdout1_19ck177 FIND v(dout1_19) AT=890.025n

* CHECK dout1_20 Vdout1_20ck177 = 0 time = 890
.meas tran vdout1_20ck177 FIND v(dout1_20) AT=890.025n

* CHECK dout1_21 Vdout1_21ck177 = 0 time = 890
.meas tran vdout1_21ck177 FIND v(dout1_21) AT=890.025n

* CHECK dout1_22 Vdout1_22ck177 = 0.9 time = 890
.meas tran vdout1_22ck177 FIND v(dout1_22) AT=890.025n

* CHECK dout1_23 Vdout1_23ck177 = 0 time = 890
.meas tran vdout1_23ck177 FIND v(dout1_23) AT=890.025n

* CHECK dout1_24 Vdout1_24ck177 = 0 time = 890
.meas tran vdout1_24ck177 FIND v(dout1_24) AT=890.025n

* CHECK dout1_25 Vdout1_25ck177 = 0.9 time = 890
.meas tran vdout1_25ck177 FIND v(dout1_25) AT=890.025n

* CHECK dout1_26 Vdout1_26ck177 = 0 time = 890
.meas tran vdout1_26ck177 FIND v(dout1_26) AT=890.025n

* CHECK dout1_27 Vdout1_27ck177 = 0 time = 890
.meas tran vdout1_27ck177 FIND v(dout1_27) AT=890.025n

* CHECK dout1_28 Vdout1_28ck177 = 0.9 time = 890
.meas tran vdout1_28ck177 FIND v(dout1_28) AT=890.025n

* CHECK dout1_29 Vdout1_29ck177 = 0.9 time = 890
.meas tran vdout1_29ck177 FIND v(dout1_29) AT=890.025n

* CHECK dout1_30 Vdout1_30ck177 = 0.9 time = 890
.meas tran vdout1_30ck177 FIND v(dout1_30) AT=890.025n

* CHECK dout1_31 Vdout1_31ck177 = 0.9 time = 890
.meas tran vdout1_31ck177 FIND v(dout1_31) AT=890.025n

* CHECK dout1_32 Vdout1_32ck177 = 0.9 time = 890
.meas tran vdout1_32ck177 FIND v(dout1_32) AT=890.025n

* CHECK dout1_33 Vdout1_33ck177 = 0.9 time = 890
.meas tran vdout1_33ck177 FIND v(dout1_33) AT=890.025n

* CHECK dout1_34 Vdout1_34ck177 = 0 time = 890
.meas tran vdout1_34ck177 FIND v(dout1_34) AT=890.025n

* CHECK dout1_35 Vdout1_35ck177 = 0.9 time = 890
.meas tran vdout1_35ck177 FIND v(dout1_35) AT=890.025n

* CHECK dout1_36 Vdout1_36ck177 = 0 time = 890
.meas tran vdout1_36ck177 FIND v(dout1_36) AT=890.025n

* CHECK dout1_37 Vdout1_37ck177 = 0 time = 890
.meas tran vdout1_37ck177 FIND v(dout1_37) AT=890.025n

* CHECK dout1_38 Vdout1_38ck177 = 0.9 time = 890
.meas tran vdout1_38ck177 FIND v(dout1_38) AT=890.025n

* CHECK dout1_39 Vdout1_39ck177 = 0.9 time = 890
.meas tran vdout1_39ck177 FIND v(dout1_39) AT=890.025n

* CHECK dout1_40 Vdout1_40ck177 = 0.9 time = 890
.meas tran vdout1_40ck177 FIND v(dout1_40) AT=890.025n

* CHECK dout1_41 Vdout1_41ck177 = 0 time = 890
.meas tran vdout1_41ck177 FIND v(dout1_41) AT=890.025n

* CHECK dout1_42 Vdout1_42ck177 = 0 time = 890
.meas tran vdout1_42ck177 FIND v(dout1_42) AT=890.025n

* CHECK dout1_43 Vdout1_43ck177 = 0.9 time = 890
.meas tran vdout1_43ck177 FIND v(dout1_43) AT=890.025n

* CHECK dout1_44 Vdout1_44ck177 = 0.9 time = 890
.meas tran vdout1_44ck177 FIND v(dout1_44) AT=890.025n

* CHECK dout1_45 Vdout1_45ck177 = 0.9 time = 890
.meas tran vdout1_45ck177 FIND v(dout1_45) AT=890.025n

* CHECK dout1_46 Vdout1_46ck177 = 0 time = 890
.meas tran vdout1_46ck177 FIND v(dout1_46) AT=890.025n

* CHECK dout1_47 Vdout1_47ck177 = 0 time = 890
.meas tran vdout1_47ck177 FIND v(dout1_47) AT=890.025n

* CHECK dout1_48 Vdout1_48ck177 = 0 time = 890
.meas tran vdout1_48ck177 FIND v(dout1_48) AT=890.025n

* CHECK dout1_49 Vdout1_49ck177 = 0 time = 890
.meas tran vdout1_49ck177 FIND v(dout1_49) AT=890.025n

* CHECK dout1_50 Vdout1_50ck177 = 0 time = 890
.meas tran vdout1_50ck177 FIND v(dout1_50) AT=890.025n

* CHECK dout1_51 Vdout1_51ck177 = 0.9 time = 890
.meas tran vdout1_51ck177 FIND v(dout1_51) AT=890.025n

* CHECK dout1_52 Vdout1_52ck177 = 0.9 time = 890
.meas tran vdout1_52ck177 FIND v(dout1_52) AT=890.025n

* CHECK dout1_53 Vdout1_53ck177 = 0 time = 890
.meas tran vdout1_53ck177 FIND v(dout1_53) AT=890.025n

* CHECK dout1_54 Vdout1_54ck177 = 0 time = 890
.meas tran vdout1_54ck177 FIND v(dout1_54) AT=890.025n

* CHECK dout1_55 Vdout1_55ck177 = 0 time = 890
.meas tran vdout1_55ck177 FIND v(dout1_55) AT=890.025n

* CHECK dout1_56 Vdout1_56ck177 = 0.9 time = 890
.meas tran vdout1_56ck177 FIND v(dout1_56) AT=890.025n

* CHECK dout1_57 Vdout1_57ck177 = 0.9 time = 890
.meas tran vdout1_57ck177 FIND v(dout1_57) AT=890.025n

* CHECK dout1_58 Vdout1_58ck177 = 0.9 time = 890
.meas tran vdout1_58ck177 FIND v(dout1_58) AT=890.025n

* CHECK dout1_59 Vdout1_59ck177 = 0.9 time = 890
.meas tran vdout1_59ck177 FIND v(dout1_59) AT=890.025n

* CHECK dout1_60 Vdout1_60ck177 = 0.9 time = 890
.meas tran vdout1_60ck177 FIND v(dout1_60) AT=890.025n

* CHECK dout1_61 Vdout1_61ck177 = 0 time = 890
.meas tran vdout1_61ck177 FIND v(dout1_61) AT=890.025n

* CHECK dout1_62 Vdout1_62ck177 = 0 time = 890
.meas tran vdout1_62ck177 FIND v(dout1_62) AT=890.025n

* CHECK dout1_63 Vdout1_63ck177 = 0.9 time = 890
.meas tran vdout1_63ck177 FIND v(dout1_63) AT=890.025n

* CHECK dout1_64 Vdout1_64ck177 = 0.9 time = 890
.meas tran vdout1_64ck177 FIND v(dout1_64) AT=890.025n

* CHECK dout1_65 Vdout1_65ck177 = 0 time = 890
.meas tran vdout1_65ck177 FIND v(dout1_65) AT=890.025n

* CHECK dout1_66 Vdout1_66ck177 = 0 time = 890
.meas tran vdout1_66ck177 FIND v(dout1_66) AT=890.025n

* CHECK dout1_67 Vdout1_67ck177 = 0.9 time = 890
.meas tran vdout1_67ck177 FIND v(dout1_67) AT=890.025n

* CHECK dout1_68 Vdout1_68ck177 = 0.9 time = 890
.meas tran vdout1_68ck177 FIND v(dout1_68) AT=890.025n

* CHECK dout1_69 Vdout1_69ck177 = 0 time = 890
.meas tran vdout1_69ck177 FIND v(dout1_69) AT=890.025n

* CHECK dout1_70 Vdout1_70ck177 = 0.9 time = 890
.meas tran vdout1_70ck177 FIND v(dout1_70) AT=890.025n

* CHECK dout1_71 Vdout1_71ck177 = 0 time = 890
.meas tran vdout1_71ck177 FIND v(dout1_71) AT=890.025n

* CHECK dout1_72 Vdout1_72ck177 = 0.9 time = 890
.meas tran vdout1_72ck177 FIND v(dout1_72) AT=890.025n

* CHECK dout1_73 Vdout1_73ck177 = 0.9 time = 890
.meas tran vdout1_73ck177 FIND v(dout1_73) AT=890.025n

* CHECK dout1_74 Vdout1_74ck177 = 0 time = 890
.meas tran vdout1_74ck177 FIND v(dout1_74) AT=890.025n

* CHECK dout1_75 Vdout1_75ck177 = 0.9 time = 890
.meas tran vdout1_75ck177 FIND v(dout1_75) AT=890.025n

* CHECK dout1_76 Vdout1_76ck177 = 0.9 time = 890
.meas tran vdout1_76ck177 FIND v(dout1_76) AT=890.025n

* CHECK dout1_77 Vdout1_77ck177 = 0.9 time = 890
.meas tran vdout1_77ck177 FIND v(dout1_77) AT=890.025n

* CHECK dout1_78 Vdout1_78ck177 = 0.9 time = 890
.meas tran vdout1_78ck177 FIND v(dout1_78) AT=890.025n

* CHECK dout1_79 Vdout1_79ck177 = 0 time = 890
.meas tran vdout1_79ck177 FIND v(dout1_79) AT=890.025n

* CHECK dout1_80 Vdout1_80ck177 = 0.9 time = 890
.meas tran vdout1_80ck177 FIND v(dout1_80) AT=890.025n

* CHECK dout1_81 Vdout1_81ck177 = 0.9 time = 890
.meas tran vdout1_81ck177 FIND v(dout1_81) AT=890.025n

* CHECK dout1_82 Vdout1_82ck177 = 0.9 time = 890
.meas tran vdout1_82ck177 FIND v(dout1_82) AT=890.025n

* CHECK dout1_83 Vdout1_83ck177 = 0.9 time = 890
.meas tran vdout1_83ck177 FIND v(dout1_83) AT=890.025n

* CHECK dout1_84 Vdout1_84ck177 = 0 time = 890
.meas tran vdout1_84ck177 FIND v(dout1_84) AT=890.025n

* CHECK dout1_85 Vdout1_85ck177 = 0.9 time = 890
.meas tran vdout1_85ck177 FIND v(dout1_85) AT=890.025n

* CHECK dout1_86 Vdout1_86ck177 = 0 time = 890
.meas tran vdout1_86ck177 FIND v(dout1_86) AT=890.025n

* CHECK dout1_87 Vdout1_87ck177 = 0 time = 890
.meas tran vdout1_87ck177 FIND v(dout1_87) AT=890.025n

* CHECK dout1_88 Vdout1_88ck177 = 0.9 time = 890
.meas tran vdout1_88ck177 FIND v(dout1_88) AT=890.025n

* CHECK dout1_89 Vdout1_89ck177 = 0 time = 890
.meas tran vdout1_89ck177 FIND v(dout1_89) AT=890.025n

* CHECK dout1_90 Vdout1_90ck177 = 0.9 time = 890
.meas tran vdout1_90ck177 FIND v(dout1_90) AT=890.025n

* CHECK dout1_91 Vdout1_91ck177 = 0.9 time = 890
.meas tran vdout1_91ck177 FIND v(dout1_91) AT=890.025n

* CHECK dout1_92 Vdout1_92ck177 = 0 time = 890
.meas tran vdout1_92ck177 FIND v(dout1_92) AT=890.025n

* CHECK dout1_93 Vdout1_93ck177 = 0 time = 890
.meas tran vdout1_93ck177 FIND v(dout1_93) AT=890.025n

* CHECK dout1_94 Vdout1_94ck177 = 0.9 time = 890
.meas tran vdout1_94ck177 FIND v(dout1_94) AT=890.025n

* CHECK dout1_95 Vdout1_95ck177 = 0.9 time = 890
.meas tran vdout1_95ck177 FIND v(dout1_95) AT=890.025n

* CHECK dout1_0 Vdout1_0ck182 = 0 time = 915
.meas tran vdout1_0ck182 FIND v(dout1_0) AT=915.025n

* CHECK dout1_1 Vdout1_1ck182 = 0 time = 915
.meas tran vdout1_1ck182 FIND v(dout1_1) AT=915.025n

* CHECK dout1_2 Vdout1_2ck182 = 0.9 time = 915
.meas tran vdout1_2ck182 FIND v(dout1_2) AT=915.025n

* CHECK dout1_3 Vdout1_3ck182 = 0 time = 915
.meas tran vdout1_3ck182 FIND v(dout1_3) AT=915.025n

* CHECK dout1_4 Vdout1_4ck182 = 0 time = 915
.meas tran vdout1_4ck182 FIND v(dout1_4) AT=915.025n

* CHECK dout1_5 Vdout1_5ck182 = 0 time = 915
.meas tran vdout1_5ck182 FIND v(dout1_5) AT=915.025n

* CHECK dout1_6 Vdout1_6ck182 = 0 time = 915
.meas tran vdout1_6ck182 FIND v(dout1_6) AT=915.025n

* CHECK dout1_7 Vdout1_7ck182 = 0.9 time = 915
.meas tran vdout1_7ck182 FIND v(dout1_7) AT=915.025n

* CHECK dout1_8 Vdout1_8ck182 = 0.9 time = 915
.meas tran vdout1_8ck182 FIND v(dout1_8) AT=915.025n

* CHECK dout1_9 Vdout1_9ck182 = 0.9 time = 915
.meas tran vdout1_9ck182 FIND v(dout1_9) AT=915.025n

* CHECK dout1_10 Vdout1_10ck182 = 0 time = 915
.meas tran vdout1_10ck182 FIND v(dout1_10) AT=915.025n

* CHECK dout1_11 Vdout1_11ck182 = 0.9 time = 915
.meas tran vdout1_11ck182 FIND v(dout1_11) AT=915.025n

* CHECK dout1_12 Vdout1_12ck182 = 0 time = 915
.meas tran vdout1_12ck182 FIND v(dout1_12) AT=915.025n

* CHECK dout1_13 Vdout1_13ck182 = 0 time = 915
.meas tran vdout1_13ck182 FIND v(dout1_13) AT=915.025n

* CHECK dout1_14 Vdout1_14ck182 = 0 time = 915
.meas tran vdout1_14ck182 FIND v(dout1_14) AT=915.025n

* CHECK dout1_15 Vdout1_15ck182 = 0 time = 915
.meas tran vdout1_15ck182 FIND v(dout1_15) AT=915.025n

* CHECK dout1_16 Vdout1_16ck182 = 0 time = 915
.meas tran vdout1_16ck182 FIND v(dout1_16) AT=915.025n

* CHECK dout1_17 Vdout1_17ck182 = 0 time = 915
.meas tran vdout1_17ck182 FIND v(dout1_17) AT=915.025n

* CHECK dout1_18 Vdout1_18ck182 = 0.9 time = 915
.meas tran vdout1_18ck182 FIND v(dout1_18) AT=915.025n

* CHECK dout1_19 Vdout1_19ck182 = 0 time = 915
.meas tran vdout1_19ck182 FIND v(dout1_19) AT=915.025n

* CHECK dout1_20 Vdout1_20ck182 = 0 time = 915
.meas tran vdout1_20ck182 FIND v(dout1_20) AT=915.025n

* CHECK dout1_21 Vdout1_21ck182 = 0.9 time = 915
.meas tran vdout1_21ck182 FIND v(dout1_21) AT=915.025n

* CHECK dout1_22 Vdout1_22ck182 = 0 time = 915
.meas tran vdout1_22ck182 FIND v(dout1_22) AT=915.025n

* CHECK dout1_23 Vdout1_23ck182 = 0.9 time = 915
.meas tran vdout1_23ck182 FIND v(dout1_23) AT=915.025n

* CHECK dout1_24 Vdout1_24ck182 = 0 time = 915
.meas tran vdout1_24ck182 FIND v(dout1_24) AT=915.025n

* CHECK dout1_25 Vdout1_25ck182 = 0 time = 915
.meas tran vdout1_25ck182 FIND v(dout1_25) AT=915.025n

* CHECK dout1_26 Vdout1_26ck182 = 0 time = 915
.meas tran vdout1_26ck182 FIND v(dout1_26) AT=915.025n

* CHECK dout1_27 Vdout1_27ck182 = 0 time = 915
.meas tran vdout1_27ck182 FIND v(dout1_27) AT=915.025n

* CHECK dout1_28 Vdout1_28ck182 = 0 time = 915
.meas tran vdout1_28ck182 FIND v(dout1_28) AT=915.025n

* CHECK dout1_29 Vdout1_29ck182 = 0.9 time = 915
.meas tran vdout1_29ck182 FIND v(dout1_29) AT=915.025n

* CHECK dout1_30 Vdout1_30ck182 = 0.9 time = 915
.meas tran vdout1_30ck182 FIND v(dout1_30) AT=915.025n

* CHECK dout1_31 Vdout1_31ck182 = 0.9 time = 915
.meas tran vdout1_31ck182 FIND v(dout1_31) AT=915.025n

* CHECK dout1_32 Vdout1_32ck182 = 0 time = 915
.meas tran vdout1_32ck182 FIND v(dout1_32) AT=915.025n

* CHECK dout1_33 Vdout1_33ck182 = 0.9 time = 915
.meas tran vdout1_33ck182 FIND v(dout1_33) AT=915.025n

* CHECK dout1_34 Vdout1_34ck182 = 0.9 time = 915
.meas tran vdout1_34ck182 FIND v(dout1_34) AT=915.025n

* CHECK dout1_35 Vdout1_35ck182 = 0.9 time = 915
.meas tran vdout1_35ck182 FIND v(dout1_35) AT=915.025n

* CHECK dout1_36 Vdout1_36ck182 = 0.9 time = 915
.meas tran vdout1_36ck182 FIND v(dout1_36) AT=915.025n

* CHECK dout1_37 Vdout1_37ck182 = 0 time = 915
.meas tran vdout1_37ck182 FIND v(dout1_37) AT=915.025n

* CHECK dout1_38 Vdout1_38ck182 = 0.9 time = 915
.meas tran vdout1_38ck182 FIND v(dout1_38) AT=915.025n

* CHECK dout1_39 Vdout1_39ck182 = 0.9 time = 915
.meas tran vdout1_39ck182 FIND v(dout1_39) AT=915.025n

* CHECK dout1_40 Vdout1_40ck182 = 0.9 time = 915
.meas tran vdout1_40ck182 FIND v(dout1_40) AT=915.025n

* CHECK dout1_41 Vdout1_41ck182 = 0 time = 915
.meas tran vdout1_41ck182 FIND v(dout1_41) AT=915.025n

* CHECK dout1_42 Vdout1_42ck182 = 0.9 time = 915
.meas tran vdout1_42ck182 FIND v(dout1_42) AT=915.025n

* CHECK dout1_43 Vdout1_43ck182 = 0.9 time = 915
.meas tran vdout1_43ck182 FIND v(dout1_43) AT=915.025n

* CHECK dout1_44 Vdout1_44ck182 = 0.9 time = 915
.meas tran vdout1_44ck182 FIND v(dout1_44) AT=915.025n

* CHECK dout1_45 Vdout1_45ck182 = 0 time = 915
.meas tran vdout1_45ck182 FIND v(dout1_45) AT=915.025n

* CHECK dout1_46 Vdout1_46ck182 = 0 time = 915
.meas tran vdout1_46ck182 FIND v(dout1_46) AT=915.025n

* CHECK dout1_47 Vdout1_47ck182 = 0 time = 915
.meas tran vdout1_47ck182 FIND v(dout1_47) AT=915.025n

* CHECK dout1_48 Vdout1_48ck182 = 0 time = 915
.meas tran vdout1_48ck182 FIND v(dout1_48) AT=915.025n

* CHECK dout1_49 Vdout1_49ck182 = 0 time = 915
.meas tran vdout1_49ck182 FIND v(dout1_49) AT=915.025n

* CHECK dout1_50 Vdout1_50ck182 = 0.9 time = 915
.meas tran vdout1_50ck182 FIND v(dout1_50) AT=915.025n

* CHECK dout1_51 Vdout1_51ck182 = 0.9 time = 915
.meas tran vdout1_51ck182 FIND v(dout1_51) AT=915.025n

* CHECK dout1_52 Vdout1_52ck182 = 0.9 time = 915
.meas tran vdout1_52ck182 FIND v(dout1_52) AT=915.025n

* CHECK dout1_53 Vdout1_53ck182 = 0.9 time = 915
.meas tran vdout1_53ck182 FIND v(dout1_53) AT=915.025n

* CHECK dout1_54 Vdout1_54ck182 = 0.9 time = 915
.meas tran vdout1_54ck182 FIND v(dout1_54) AT=915.025n

* CHECK dout1_55 Vdout1_55ck182 = 0.9 time = 915
.meas tran vdout1_55ck182 FIND v(dout1_55) AT=915.025n

* CHECK dout1_56 Vdout1_56ck182 = 0.9 time = 915
.meas tran vdout1_56ck182 FIND v(dout1_56) AT=915.025n

* CHECK dout1_57 Vdout1_57ck182 = 0 time = 915
.meas tran vdout1_57ck182 FIND v(dout1_57) AT=915.025n

* CHECK dout1_58 Vdout1_58ck182 = 0.9 time = 915
.meas tran vdout1_58ck182 FIND v(dout1_58) AT=915.025n

* CHECK dout1_59 Vdout1_59ck182 = 0 time = 915
.meas tran vdout1_59ck182 FIND v(dout1_59) AT=915.025n

* CHECK dout1_60 Vdout1_60ck182 = 0 time = 915
.meas tran vdout1_60ck182 FIND v(dout1_60) AT=915.025n

* CHECK dout1_61 Vdout1_61ck182 = 0.9 time = 915
.meas tran vdout1_61ck182 FIND v(dout1_61) AT=915.025n

* CHECK dout1_62 Vdout1_62ck182 = 0 time = 915
.meas tran vdout1_62ck182 FIND v(dout1_62) AT=915.025n

* CHECK dout1_63 Vdout1_63ck182 = 0.9 time = 915
.meas tran vdout1_63ck182 FIND v(dout1_63) AT=915.025n

* CHECK dout1_64 Vdout1_64ck182 = 0 time = 915
.meas tran vdout1_64ck182 FIND v(dout1_64) AT=915.025n

* CHECK dout1_65 Vdout1_65ck182 = 0 time = 915
.meas tran vdout1_65ck182 FIND v(dout1_65) AT=915.025n

* CHECK dout1_66 Vdout1_66ck182 = 0.9 time = 915
.meas tran vdout1_66ck182 FIND v(dout1_66) AT=915.025n

* CHECK dout1_67 Vdout1_67ck182 = 0.9 time = 915
.meas tran vdout1_67ck182 FIND v(dout1_67) AT=915.025n

* CHECK dout1_68 Vdout1_68ck182 = 0 time = 915
.meas tran vdout1_68ck182 FIND v(dout1_68) AT=915.025n

* CHECK dout1_69 Vdout1_69ck182 = 0 time = 915
.meas tran vdout1_69ck182 FIND v(dout1_69) AT=915.025n

* CHECK dout1_70 Vdout1_70ck182 = 0.9 time = 915
.meas tran vdout1_70ck182 FIND v(dout1_70) AT=915.025n

* CHECK dout1_71 Vdout1_71ck182 = 0 time = 915
.meas tran vdout1_71ck182 FIND v(dout1_71) AT=915.025n

* CHECK dout1_72 Vdout1_72ck182 = 0 time = 915
.meas tran vdout1_72ck182 FIND v(dout1_72) AT=915.025n

* CHECK dout1_73 Vdout1_73ck182 = 0.9 time = 915
.meas tran vdout1_73ck182 FIND v(dout1_73) AT=915.025n

* CHECK dout1_74 Vdout1_74ck182 = 0.9 time = 915
.meas tran vdout1_74ck182 FIND v(dout1_74) AT=915.025n

* CHECK dout1_75 Vdout1_75ck182 = 0 time = 915
.meas tran vdout1_75ck182 FIND v(dout1_75) AT=915.025n

* CHECK dout1_76 Vdout1_76ck182 = 0.9 time = 915
.meas tran vdout1_76ck182 FIND v(dout1_76) AT=915.025n

* CHECK dout1_77 Vdout1_77ck182 = 0 time = 915
.meas tran vdout1_77ck182 FIND v(dout1_77) AT=915.025n

* CHECK dout1_78 Vdout1_78ck182 = 0.9 time = 915
.meas tran vdout1_78ck182 FIND v(dout1_78) AT=915.025n

* CHECK dout1_79 Vdout1_79ck182 = 0.9 time = 915
.meas tran vdout1_79ck182 FIND v(dout1_79) AT=915.025n

* CHECK dout1_80 Vdout1_80ck182 = 0 time = 915
.meas tran vdout1_80ck182 FIND v(dout1_80) AT=915.025n

* CHECK dout1_81 Vdout1_81ck182 = 0.9 time = 915
.meas tran vdout1_81ck182 FIND v(dout1_81) AT=915.025n

* CHECK dout1_82 Vdout1_82ck182 = 0 time = 915
.meas tran vdout1_82ck182 FIND v(dout1_82) AT=915.025n

* CHECK dout1_83 Vdout1_83ck182 = 0.9 time = 915
.meas tran vdout1_83ck182 FIND v(dout1_83) AT=915.025n

* CHECK dout1_84 Vdout1_84ck182 = 0 time = 915
.meas tran vdout1_84ck182 FIND v(dout1_84) AT=915.025n

* CHECK dout1_85 Vdout1_85ck182 = 0.9 time = 915
.meas tran vdout1_85ck182 FIND v(dout1_85) AT=915.025n

* CHECK dout1_86 Vdout1_86ck182 = 0.9 time = 915
.meas tran vdout1_86ck182 FIND v(dout1_86) AT=915.025n

* CHECK dout1_87 Vdout1_87ck182 = 0 time = 915
.meas tran vdout1_87ck182 FIND v(dout1_87) AT=915.025n

* CHECK dout1_88 Vdout1_88ck182 = 0 time = 915
.meas tran vdout1_88ck182 FIND v(dout1_88) AT=915.025n

* CHECK dout1_89 Vdout1_89ck182 = 0 time = 915
.meas tran vdout1_89ck182 FIND v(dout1_89) AT=915.025n

* CHECK dout1_90 Vdout1_90ck182 = 0.9 time = 915
.meas tran vdout1_90ck182 FIND v(dout1_90) AT=915.025n

* CHECK dout1_91 Vdout1_91ck182 = 0.9 time = 915
.meas tran vdout1_91ck182 FIND v(dout1_91) AT=915.025n

* CHECK dout1_92 Vdout1_92ck182 = 0 time = 915
.meas tran vdout1_92ck182 FIND v(dout1_92) AT=915.025n

* CHECK dout1_93 Vdout1_93ck182 = 0.9 time = 915
.meas tran vdout1_93ck182 FIND v(dout1_93) AT=915.025n

* CHECK dout1_94 Vdout1_94ck182 = 0.9 time = 915
.meas tran vdout1_94ck182 FIND v(dout1_94) AT=915.025n

* CHECK dout1_95 Vdout1_95ck182 = 0 time = 915
.meas tran vdout1_95ck182 FIND v(dout1_95) AT=915.025n

* CHECK dout1_0 Vdout1_0ck184 = 0 time = 925
.meas tran vdout1_0ck184 FIND v(dout1_0) AT=925.025n

* CHECK dout1_1 Vdout1_1ck184 = 0 time = 925
.meas tran vdout1_1ck184 FIND v(dout1_1) AT=925.025n

* CHECK dout1_2 Vdout1_2ck184 = 0 time = 925
.meas tran vdout1_2ck184 FIND v(dout1_2) AT=925.025n

* CHECK dout1_3 Vdout1_3ck184 = 0.9 time = 925
.meas tran vdout1_3ck184 FIND v(dout1_3) AT=925.025n

* CHECK dout1_4 Vdout1_4ck184 = 0.9 time = 925
.meas tran vdout1_4ck184 FIND v(dout1_4) AT=925.025n

* CHECK dout1_5 Vdout1_5ck184 = 0.9 time = 925
.meas tran vdout1_5ck184 FIND v(dout1_5) AT=925.025n

* CHECK dout1_6 Vdout1_6ck184 = 0.9 time = 925
.meas tran vdout1_6ck184 FIND v(dout1_6) AT=925.025n

* CHECK dout1_7 Vdout1_7ck184 = 0 time = 925
.meas tran vdout1_7ck184 FIND v(dout1_7) AT=925.025n

* CHECK dout1_8 Vdout1_8ck184 = 0.9 time = 925
.meas tran vdout1_8ck184 FIND v(dout1_8) AT=925.025n

* CHECK dout1_9 Vdout1_9ck184 = 0.9 time = 925
.meas tran vdout1_9ck184 FIND v(dout1_9) AT=925.025n

* CHECK dout1_10 Vdout1_10ck184 = 0.9 time = 925
.meas tran vdout1_10ck184 FIND v(dout1_10) AT=925.025n

* CHECK dout1_11 Vdout1_11ck184 = 0.9 time = 925
.meas tran vdout1_11ck184 FIND v(dout1_11) AT=925.025n

* CHECK dout1_12 Vdout1_12ck184 = 0 time = 925
.meas tran vdout1_12ck184 FIND v(dout1_12) AT=925.025n

* CHECK dout1_13 Vdout1_13ck184 = 0 time = 925
.meas tran vdout1_13ck184 FIND v(dout1_13) AT=925.025n

* CHECK dout1_14 Vdout1_14ck184 = 0 time = 925
.meas tran vdout1_14ck184 FIND v(dout1_14) AT=925.025n

* CHECK dout1_15 Vdout1_15ck184 = 0.9 time = 925
.meas tran vdout1_15ck184 FIND v(dout1_15) AT=925.025n

* CHECK dout1_16 Vdout1_16ck184 = 0.9 time = 925
.meas tran vdout1_16ck184 FIND v(dout1_16) AT=925.025n

* CHECK dout1_17 Vdout1_17ck184 = 0 time = 925
.meas tran vdout1_17ck184 FIND v(dout1_17) AT=925.025n

* CHECK dout1_18 Vdout1_18ck184 = 0 time = 925
.meas tran vdout1_18ck184 FIND v(dout1_18) AT=925.025n

* CHECK dout1_19 Vdout1_19ck184 = 0 time = 925
.meas tran vdout1_19ck184 FIND v(dout1_19) AT=925.025n

* CHECK dout1_20 Vdout1_20ck184 = 0.9 time = 925
.meas tran vdout1_20ck184 FIND v(dout1_20) AT=925.025n

* CHECK dout1_21 Vdout1_21ck184 = 0.9 time = 925
.meas tran vdout1_21ck184 FIND v(dout1_21) AT=925.025n

* CHECK dout1_22 Vdout1_22ck184 = 0 time = 925
.meas tran vdout1_22ck184 FIND v(dout1_22) AT=925.025n

* CHECK dout1_23 Vdout1_23ck184 = 0 time = 925
.meas tran vdout1_23ck184 FIND v(dout1_23) AT=925.025n

* CHECK dout1_24 Vdout1_24ck184 = 0.9 time = 925
.meas tran vdout1_24ck184 FIND v(dout1_24) AT=925.025n

* CHECK dout1_25 Vdout1_25ck184 = 0.9 time = 925
.meas tran vdout1_25ck184 FIND v(dout1_25) AT=925.025n

* CHECK dout1_26 Vdout1_26ck184 = 0 time = 925
.meas tran vdout1_26ck184 FIND v(dout1_26) AT=925.025n

* CHECK dout1_27 Vdout1_27ck184 = 0.9 time = 925
.meas tran vdout1_27ck184 FIND v(dout1_27) AT=925.025n

* CHECK dout1_28 Vdout1_28ck184 = 0 time = 925
.meas tran vdout1_28ck184 FIND v(dout1_28) AT=925.025n

* CHECK dout1_29 Vdout1_29ck184 = 0.9 time = 925
.meas tran vdout1_29ck184 FIND v(dout1_29) AT=925.025n

* CHECK dout1_30 Vdout1_30ck184 = 0.9 time = 925
.meas tran vdout1_30ck184 FIND v(dout1_30) AT=925.025n

* CHECK dout1_31 Vdout1_31ck184 = 0 time = 925
.meas tran vdout1_31ck184 FIND v(dout1_31) AT=925.025n

* CHECK dout1_32 Vdout1_32ck184 = 0 time = 925
.meas tran vdout1_32ck184 FIND v(dout1_32) AT=925.025n

* CHECK dout1_33 Vdout1_33ck184 = 0 time = 925
.meas tran vdout1_33ck184 FIND v(dout1_33) AT=925.025n

* CHECK dout1_34 Vdout1_34ck184 = 0 time = 925
.meas tran vdout1_34ck184 FIND v(dout1_34) AT=925.025n

* CHECK dout1_35 Vdout1_35ck184 = 0.9 time = 925
.meas tran vdout1_35ck184 FIND v(dout1_35) AT=925.025n

* CHECK dout1_36 Vdout1_36ck184 = 0.9 time = 925
.meas tran vdout1_36ck184 FIND v(dout1_36) AT=925.025n

* CHECK dout1_37 Vdout1_37ck184 = 0.9 time = 925
.meas tran vdout1_37ck184 FIND v(dout1_37) AT=925.025n

* CHECK dout1_38 Vdout1_38ck184 = 0.9 time = 925
.meas tran vdout1_38ck184 FIND v(dout1_38) AT=925.025n

* CHECK dout1_39 Vdout1_39ck184 = 0.9 time = 925
.meas tran vdout1_39ck184 FIND v(dout1_39) AT=925.025n

* CHECK dout1_40 Vdout1_40ck184 = 0.9 time = 925
.meas tran vdout1_40ck184 FIND v(dout1_40) AT=925.025n

* CHECK dout1_41 Vdout1_41ck184 = 0 time = 925
.meas tran vdout1_41ck184 FIND v(dout1_41) AT=925.025n

* CHECK dout1_42 Vdout1_42ck184 = 0 time = 925
.meas tran vdout1_42ck184 FIND v(dout1_42) AT=925.025n

* CHECK dout1_43 Vdout1_43ck184 = 0 time = 925
.meas tran vdout1_43ck184 FIND v(dout1_43) AT=925.025n

* CHECK dout1_44 Vdout1_44ck184 = 0 time = 925
.meas tran vdout1_44ck184 FIND v(dout1_44) AT=925.025n

* CHECK dout1_45 Vdout1_45ck184 = 0 time = 925
.meas tran vdout1_45ck184 FIND v(dout1_45) AT=925.025n

* CHECK dout1_46 Vdout1_46ck184 = 0.9 time = 925
.meas tran vdout1_46ck184 FIND v(dout1_46) AT=925.025n

* CHECK dout1_47 Vdout1_47ck184 = 0 time = 925
.meas tran vdout1_47ck184 FIND v(dout1_47) AT=925.025n

* CHECK dout1_48 Vdout1_48ck184 = 0 time = 925
.meas tran vdout1_48ck184 FIND v(dout1_48) AT=925.025n

* CHECK dout1_49 Vdout1_49ck184 = 0 time = 925
.meas tran vdout1_49ck184 FIND v(dout1_49) AT=925.025n

* CHECK dout1_50 Vdout1_50ck184 = 0.9 time = 925
.meas tran vdout1_50ck184 FIND v(dout1_50) AT=925.025n

* CHECK dout1_51 Vdout1_51ck184 = 0 time = 925
.meas tran vdout1_51ck184 FIND v(dout1_51) AT=925.025n

* CHECK dout1_52 Vdout1_52ck184 = 0.9 time = 925
.meas tran vdout1_52ck184 FIND v(dout1_52) AT=925.025n

* CHECK dout1_53 Vdout1_53ck184 = 0.9 time = 925
.meas tran vdout1_53ck184 FIND v(dout1_53) AT=925.025n

* CHECK dout1_54 Vdout1_54ck184 = 0.9 time = 925
.meas tran vdout1_54ck184 FIND v(dout1_54) AT=925.025n

* CHECK dout1_55 Vdout1_55ck184 = 0.9 time = 925
.meas tran vdout1_55ck184 FIND v(dout1_55) AT=925.025n

* CHECK dout1_56 Vdout1_56ck184 = 0.9 time = 925
.meas tran vdout1_56ck184 FIND v(dout1_56) AT=925.025n

* CHECK dout1_57 Vdout1_57ck184 = 0.9 time = 925
.meas tran vdout1_57ck184 FIND v(dout1_57) AT=925.025n

* CHECK dout1_58 Vdout1_58ck184 = 0.9 time = 925
.meas tran vdout1_58ck184 FIND v(dout1_58) AT=925.025n

* CHECK dout1_59 Vdout1_59ck184 = 0.9 time = 925
.meas tran vdout1_59ck184 FIND v(dout1_59) AT=925.025n

* CHECK dout1_60 Vdout1_60ck184 = 0 time = 925
.meas tran vdout1_60ck184 FIND v(dout1_60) AT=925.025n

* CHECK dout1_61 Vdout1_61ck184 = 0 time = 925
.meas tran vdout1_61ck184 FIND v(dout1_61) AT=925.025n

* CHECK dout1_62 Vdout1_62ck184 = 0.9 time = 925
.meas tran vdout1_62ck184 FIND v(dout1_62) AT=925.025n

* CHECK dout1_63 Vdout1_63ck184 = 0.9 time = 925
.meas tran vdout1_63ck184 FIND v(dout1_63) AT=925.025n

* CHECK dout1_64 Vdout1_64ck184 = 0 time = 925
.meas tran vdout1_64ck184 FIND v(dout1_64) AT=925.025n

* CHECK dout1_65 Vdout1_65ck184 = 0.9 time = 925
.meas tran vdout1_65ck184 FIND v(dout1_65) AT=925.025n

* CHECK dout1_66 Vdout1_66ck184 = 0 time = 925
.meas tran vdout1_66ck184 FIND v(dout1_66) AT=925.025n

* CHECK dout1_67 Vdout1_67ck184 = 0 time = 925
.meas tran vdout1_67ck184 FIND v(dout1_67) AT=925.025n

* CHECK dout1_68 Vdout1_68ck184 = 0.9 time = 925
.meas tran vdout1_68ck184 FIND v(dout1_68) AT=925.025n

* CHECK dout1_69 Vdout1_69ck184 = 0.9 time = 925
.meas tran vdout1_69ck184 FIND v(dout1_69) AT=925.025n

* CHECK dout1_70 Vdout1_70ck184 = 0.9 time = 925
.meas tran vdout1_70ck184 FIND v(dout1_70) AT=925.025n

* CHECK dout1_71 Vdout1_71ck184 = 0 time = 925
.meas tran vdout1_71ck184 FIND v(dout1_71) AT=925.025n

* CHECK dout1_72 Vdout1_72ck184 = 0 time = 925
.meas tran vdout1_72ck184 FIND v(dout1_72) AT=925.025n

* CHECK dout1_73 Vdout1_73ck184 = 0 time = 925
.meas tran vdout1_73ck184 FIND v(dout1_73) AT=925.025n

* CHECK dout1_74 Vdout1_74ck184 = 0.9 time = 925
.meas tran vdout1_74ck184 FIND v(dout1_74) AT=925.025n

* CHECK dout1_75 Vdout1_75ck184 = 0 time = 925
.meas tran vdout1_75ck184 FIND v(dout1_75) AT=925.025n

* CHECK dout1_76 Vdout1_76ck184 = 0 time = 925
.meas tran vdout1_76ck184 FIND v(dout1_76) AT=925.025n

* CHECK dout1_77 Vdout1_77ck184 = 0 time = 925
.meas tran vdout1_77ck184 FIND v(dout1_77) AT=925.025n

* CHECK dout1_78 Vdout1_78ck184 = 0.9 time = 925
.meas tran vdout1_78ck184 FIND v(dout1_78) AT=925.025n

* CHECK dout1_79 Vdout1_79ck184 = 0.9 time = 925
.meas tran vdout1_79ck184 FIND v(dout1_79) AT=925.025n

* CHECK dout1_80 Vdout1_80ck184 = 0.9 time = 925
.meas tran vdout1_80ck184 FIND v(dout1_80) AT=925.025n

* CHECK dout1_81 Vdout1_81ck184 = 0.9 time = 925
.meas tran vdout1_81ck184 FIND v(dout1_81) AT=925.025n

* CHECK dout1_82 Vdout1_82ck184 = 0 time = 925
.meas tran vdout1_82ck184 FIND v(dout1_82) AT=925.025n

* CHECK dout1_83 Vdout1_83ck184 = 0 time = 925
.meas tran vdout1_83ck184 FIND v(dout1_83) AT=925.025n

* CHECK dout1_84 Vdout1_84ck184 = 0 time = 925
.meas tran vdout1_84ck184 FIND v(dout1_84) AT=925.025n

* CHECK dout1_85 Vdout1_85ck184 = 0 time = 925
.meas tran vdout1_85ck184 FIND v(dout1_85) AT=925.025n

* CHECK dout1_86 Vdout1_86ck184 = 0.9 time = 925
.meas tran vdout1_86ck184 FIND v(dout1_86) AT=925.025n

* CHECK dout1_87 Vdout1_87ck184 = 0 time = 925
.meas tran vdout1_87ck184 FIND v(dout1_87) AT=925.025n

* CHECK dout1_88 Vdout1_88ck184 = 0.9 time = 925
.meas tran vdout1_88ck184 FIND v(dout1_88) AT=925.025n

* CHECK dout1_89 Vdout1_89ck184 = 0.9 time = 925
.meas tran vdout1_89ck184 FIND v(dout1_89) AT=925.025n

* CHECK dout1_90 Vdout1_90ck184 = 0 time = 925
.meas tran vdout1_90ck184 FIND v(dout1_90) AT=925.025n

* CHECK dout1_91 Vdout1_91ck184 = 0 time = 925
.meas tran vdout1_91ck184 FIND v(dout1_91) AT=925.025n

* CHECK dout1_92 Vdout1_92ck184 = 0.9 time = 925
.meas tran vdout1_92ck184 FIND v(dout1_92) AT=925.025n

* CHECK dout1_93 Vdout1_93ck184 = 0.9 time = 925
.meas tran vdout1_93ck184 FIND v(dout1_93) AT=925.025n

* CHECK dout1_94 Vdout1_94ck184 = 0.9 time = 925
.meas tran vdout1_94ck184 FIND v(dout1_94) AT=925.025n

* CHECK dout1_95 Vdout1_95ck184 = 0.9 time = 925
.meas tran vdout1_95ck184 FIND v(dout1_95) AT=925.025n

* CHECK dout1_0 Vdout1_0ck195 = 0 time = 980
.meas tran vdout1_0ck195 FIND v(dout1_0) AT=980.025n

* CHECK dout1_1 Vdout1_1ck195 = 0 time = 980
.meas tran vdout1_1ck195 FIND v(dout1_1) AT=980.025n

* CHECK dout1_2 Vdout1_2ck195 = 0 time = 980
.meas tran vdout1_2ck195 FIND v(dout1_2) AT=980.025n

* CHECK dout1_3 Vdout1_3ck195 = 0 time = 980
.meas tran vdout1_3ck195 FIND v(dout1_3) AT=980.025n

* CHECK dout1_4 Vdout1_4ck195 = 0 time = 980
.meas tran vdout1_4ck195 FIND v(dout1_4) AT=980.025n

* CHECK dout1_5 Vdout1_5ck195 = 0.9 time = 980
.meas tran vdout1_5ck195 FIND v(dout1_5) AT=980.025n

* CHECK dout1_6 Vdout1_6ck195 = 0.9 time = 980
.meas tran vdout1_6ck195 FIND v(dout1_6) AT=980.025n

* CHECK dout1_7 Vdout1_7ck195 = 0 time = 980
.meas tran vdout1_7ck195 FIND v(dout1_7) AT=980.025n

* CHECK dout1_8 Vdout1_8ck195 = 0.9 time = 980
.meas tran vdout1_8ck195 FIND v(dout1_8) AT=980.025n

* CHECK dout1_9 Vdout1_9ck195 = 0 time = 980
.meas tran vdout1_9ck195 FIND v(dout1_9) AT=980.025n

* CHECK dout1_10 Vdout1_10ck195 = 0.9 time = 980
.meas tran vdout1_10ck195 FIND v(dout1_10) AT=980.025n

* CHECK dout1_11 Vdout1_11ck195 = 0 time = 980
.meas tran vdout1_11ck195 FIND v(dout1_11) AT=980.025n

* CHECK dout1_12 Vdout1_12ck195 = 0 time = 980
.meas tran vdout1_12ck195 FIND v(dout1_12) AT=980.025n

* CHECK dout1_13 Vdout1_13ck195 = 0.9 time = 980
.meas tran vdout1_13ck195 FIND v(dout1_13) AT=980.025n

* CHECK dout1_14 Vdout1_14ck195 = 0.9 time = 980
.meas tran vdout1_14ck195 FIND v(dout1_14) AT=980.025n

* CHECK dout1_15 Vdout1_15ck195 = 0.9 time = 980
.meas tran vdout1_15ck195 FIND v(dout1_15) AT=980.025n

* CHECK dout1_16 Vdout1_16ck195 = 0 time = 980
.meas tran vdout1_16ck195 FIND v(dout1_16) AT=980.025n

* CHECK dout1_17 Vdout1_17ck195 = 0 time = 980
.meas tran vdout1_17ck195 FIND v(dout1_17) AT=980.025n

* CHECK dout1_18 Vdout1_18ck195 = 0 time = 980
.meas tran vdout1_18ck195 FIND v(dout1_18) AT=980.025n

* CHECK dout1_19 Vdout1_19ck195 = 0.9 time = 980
.meas tran vdout1_19ck195 FIND v(dout1_19) AT=980.025n

* CHECK dout1_20 Vdout1_20ck195 = 0.9 time = 980
.meas tran vdout1_20ck195 FIND v(dout1_20) AT=980.025n

* CHECK dout1_21 Vdout1_21ck195 = 0 time = 980
.meas tran vdout1_21ck195 FIND v(dout1_21) AT=980.025n

* CHECK dout1_22 Vdout1_22ck195 = 0 time = 980
.meas tran vdout1_22ck195 FIND v(dout1_22) AT=980.025n

* CHECK dout1_23 Vdout1_23ck195 = 0 time = 980
.meas tran vdout1_23ck195 FIND v(dout1_23) AT=980.025n

* CHECK dout1_24 Vdout1_24ck195 = 0.9 time = 980
.meas tran vdout1_24ck195 FIND v(dout1_24) AT=980.025n

* CHECK dout1_25 Vdout1_25ck195 = 0.9 time = 980
.meas tran vdout1_25ck195 FIND v(dout1_25) AT=980.025n

* CHECK dout1_26 Vdout1_26ck195 = 0.9 time = 980
.meas tran vdout1_26ck195 FIND v(dout1_26) AT=980.025n

* CHECK dout1_27 Vdout1_27ck195 = 0 time = 980
.meas tran vdout1_27ck195 FIND v(dout1_27) AT=980.025n

* CHECK dout1_28 Vdout1_28ck195 = 0 time = 980
.meas tran vdout1_28ck195 FIND v(dout1_28) AT=980.025n

* CHECK dout1_29 Vdout1_29ck195 = 0.9 time = 980
.meas tran vdout1_29ck195 FIND v(dout1_29) AT=980.025n

* CHECK dout1_30 Vdout1_30ck195 = 0 time = 980
.meas tran vdout1_30ck195 FIND v(dout1_30) AT=980.025n

* CHECK dout1_31 Vdout1_31ck195 = 0.9 time = 980
.meas tran vdout1_31ck195 FIND v(dout1_31) AT=980.025n

* CHECK dout1_32 Vdout1_32ck195 = 0.9 time = 980
.meas tran vdout1_32ck195 FIND v(dout1_32) AT=980.025n

* CHECK dout1_33 Vdout1_33ck195 = 0.9 time = 980
.meas tran vdout1_33ck195 FIND v(dout1_33) AT=980.025n

* CHECK dout1_34 Vdout1_34ck195 = 0 time = 980
.meas tran vdout1_34ck195 FIND v(dout1_34) AT=980.025n

* CHECK dout1_35 Vdout1_35ck195 = 0.9 time = 980
.meas tran vdout1_35ck195 FIND v(dout1_35) AT=980.025n

* CHECK dout1_36 Vdout1_36ck195 = 0 time = 980
.meas tran vdout1_36ck195 FIND v(dout1_36) AT=980.025n

* CHECK dout1_37 Vdout1_37ck195 = 0 time = 980
.meas tran vdout1_37ck195 FIND v(dout1_37) AT=980.025n

* CHECK dout1_38 Vdout1_38ck195 = 0 time = 980
.meas tran vdout1_38ck195 FIND v(dout1_38) AT=980.025n

* CHECK dout1_39 Vdout1_39ck195 = 0.9 time = 980
.meas tran vdout1_39ck195 FIND v(dout1_39) AT=980.025n

* CHECK dout1_40 Vdout1_40ck195 = 0 time = 980
.meas tran vdout1_40ck195 FIND v(dout1_40) AT=980.025n

* CHECK dout1_41 Vdout1_41ck195 = 0 time = 980
.meas tran vdout1_41ck195 FIND v(dout1_41) AT=980.025n

* CHECK dout1_42 Vdout1_42ck195 = 0.9 time = 980
.meas tran vdout1_42ck195 FIND v(dout1_42) AT=980.025n

* CHECK dout1_43 Vdout1_43ck195 = 0 time = 980
.meas tran vdout1_43ck195 FIND v(dout1_43) AT=980.025n

* CHECK dout1_44 Vdout1_44ck195 = 0.9 time = 980
.meas tran vdout1_44ck195 FIND v(dout1_44) AT=980.025n

* CHECK dout1_45 Vdout1_45ck195 = 0 time = 980
.meas tran vdout1_45ck195 FIND v(dout1_45) AT=980.025n

* CHECK dout1_46 Vdout1_46ck195 = 0.9 time = 980
.meas tran vdout1_46ck195 FIND v(dout1_46) AT=980.025n

* CHECK dout1_47 Vdout1_47ck195 = 0.9 time = 980
.meas tran vdout1_47ck195 FIND v(dout1_47) AT=980.025n

* CHECK dout1_48 Vdout1_48ck195 = 0 time = 980
.meas tran vdout1_48ck195 FIND v(dout1_48) AT=980.025n

* CHECK dout1_49 Vdout1_49ck195 = 0.9 time = 980
.meas tran vdout1_49ck195 FIND v(dout1_49) AT=980.025n

* CHECK dout1_50 Vdout1_50ck195 = 0.9 time = 980
.meas tran vdout1_50ck195 FIND v(dout1_50) AT=980.025n

* CHECK dout1_51 Vdout1_51ck195 = 0.9 time = 980
.meas tran vdout1_51ck195 FIND v(dout1_51) AT=980.025n

* CHECK dout1_52 Vdout1_52ck195 = 0.9 time = 980
.meas tran vdout1_52ck195 FIND v(dout1_52) AT=980.025n

* CHECK dout1_53 Vdout1_53ck195 = 0 time = 980
.meas tran vdout1_53ck195 FIND v(dout1_53) AT=980.025n

* CHECK dout1_54 Vdout1_54ck195 = 0 time = 980
.meas tran vdout1_54ck195 FIND v(dout1_54) AT=980.025n

* CHECK dout1_55 Vdout1_55ck195 = 0 time = 980
.meas tran vdout1_55ck195 FIND v(dout1_55) AT=980.025n

* CHECK dout1_56 Vdout1_56ck195 = 0.9 time = 980
.meas tran vdout1_56ck195 FIND v(dout1_56) AT=980.025n

* CHECK dout1_57 Vdout1_57ck195 = 0 time = 980
.meas tran vdout1_57ck195 FIND v(dout1_57) AT=980.025n

* CHECK dout1_58 Vdout1_58ck195 = 0.9 time = 980
.meas tran vdout1_58ck195 FIND v(dout1_58) AT=980.025n

* CHECK dout1_59 Vdout1_59ck195 = 0.9 time = 980
.meas tran vdout1_59ck195 FIND v(dout1_59) AT=980.025n

* CHECK dout1_60 Vdout1_60ck195 = 0 time = 980
.meas tran vdout1_60ck195 FIND v(dout1_60) AT=980.025n

* CHECK dout1_61 Vdout1_61ck195 = 0 time = 980
.meas tran vdout1_61ck195 FIND v(dout1_61) AT=980.025n

* CHECK dout1_62 Vdout1_62ck195 = 0.9 time = 980
.meas tran vdout1_62ck195 FIND v(dout1_62) AT=980.025n

* CHECK dout1_63 Vdout1_63ck195 = 0 time = 980
.meas tran vdout1_63ck195 FIND v(dout1_63) AT=980.025n

* CHECK dout1_64 Vdout1_64ck195 = 0.9 time = 980
.meas tran vdout1_64ck195 FIND v(dout1_64) AT=980.025n

* CHECK dout1_65 Vdout1_65ck195 = 0 time = 980
.meas tran vdout1_65ck195 FIND v(dout1_65) AT=980.025n

* CHECK dout1_66 Vdout1_66ck195 = 0 time = 980
.meas tran vdout1_66ck195 FIND v(dout1_66) AT=980.025n

* CHECK dout1_67 Vdout1_67ck195 = 0 time = 980
.meas tran vdout1_67ck195 FIND v(dout1_67) AT=980.025n

* CHECK dout1_68 Vdout1_68ck195 = 0.9 time = 980
.meas tran vdout1_68ck195 FIND v(dout1_68) AT=980.025n

* CHECK dout1_69 Vdout1_69ck195 = 0.9 time = 980
.meas tran vdout1_69ck195 FIND v(dout1_69) AT=980.025n

* CHECK dout1_70 Vdout1_70ck195 = 0.9 time = 980
.meas tran vdout1_70ck195 FIND v(dout1_70) AT=980.025n

* CHECK dout1_71 Vdout1_71ck195 = 0.9 time = 980
.meas tran vdout1_71ck195 FIND v(dout1_71) AT=980.025n

* CHECK dout1_72 Vdout1_72ck195 = 0.9 time = 980
.meas tran vdout1_72ck195 FIND v(dout1_72) AT=980.025n

* CHECK dout1_73 Vdout1_73ck195 = 0 time = 980
.meas tran vdout1_73ck195 FIND v(dout1_73) AT=980.025n

* CHECK dout1_74 Vdout1_74ck195 = 0.9 time = 980
.meas tran vdout1_74ck195 FIND v(dout1_74) AT=980.025n

* CHECK dout1_75 Vdout1_75ck195 = 0 time = 980
.meas tran vdout1_75ck195 FIND v(dout1_75) AT=980.025n

* CHECK dout1_76 Vdout1_76ck195 = 0 time = 980
.meas tran vdout1_76ck195 FIND v(dout1_76) AT=980.025n

* CHECK dout1_77 Vdout1_77ck195 = 0 time = 980
.meas tran vdout1_77ck195 FIND v(dout1_77) AT=980.025n

* CHECK dout1_78 Vdout1_78ck195 = 0.9 time = 980
.meas tran vdout1_78ck195 FIND v(dout1_78) AT=980.025n

* CHECK dout1_79 Vdout1_79ck195 = 0 time = 980
.meas tran vdout1_79ck195 FIND v(dout1_79) AT=980.025n

* CHECK dout1_80 Vdout1_80ck195 = 0.9 time = 980
.meas tran vdout1_80ck195 FIND v(dout1_80) AT=980.025n

* CHECK dout1_81 Vdout1_81ck195 = 0 time = 980
.meas tran vdout1_81ck195 FIND v(dout1_81) AT=980.025n

* CHECK dout1_82 Vdout1_82ck195 = 0 time = 980
.meas tran vdout1_82ck195 FIND v(dout1_82) AT=980.025n

* CHECK dout1_83 Vdout1_83ck195 = 0.9 time = 980
.meas tran vdout1_83ck195 FIND v(dout1_83) AT=980.025n

* CHECK dout1_84 Vdout1_84ck195 = 0 time = 980
.meas tran vdout1_84ck195 FIND v(dout1_84) AT=980.025n

* CHECK dout1_85 Vdout1_85ck195 = 0 time = 980
.meas tran vdout1_85ck195 FIND v(dout1_85) AT=980.025n

* CHECK dout1_86 Vdout1_86ck195 = 0.9 time = 980
.meas tran vdout1_86ck195 FIND v(dout1_86) AT=980.025n

* CHECK dout1_87 Vdout1_87ck195 = 0.9 time = 980
.meas tran vdout1_87ck195 FIND v(dout1_87) AT=980.025n

* CHECK dout1_88 Vdout1_88ck195 = 0.9 time = 980
.meas tran vdout1_88ck195 FIND v(dout1_88) AT=980.025n

* CHECK dout1_89 Vdout1_89ck195 = 0 time = 980
.meas tran vdout1_89ck195 FIND v(dout1_89) AT=980.025n

* CHECK dout1_90 Vdout1_90ck195 = 0.9 time = 980
.meas tran vdout1_90ck195 FIND v(dout1_90) AT=980.025n

* CHECK dout1_91 Vdout1_91ck195 = 0.9 time = 980
.meas tran vdout1_91ck195 FIND v(dout1_91) AT=980.025n

* CHECK dout1_92 Vdout1_92ck195 = 0.9 time = 980
.meas tran vdout1_92ck195 FIND v(dout1_92) AT=980.025n

* CHECK dout1_93 Vdout1_93ck195 = 0.9 time = 980
.meas tran vdout1_93ck195 FIND v(dout1_93) AT=980.025n

* CHECK dout1_94 Vdout1_94ck195 = 0.9 time = 980
.meas tran vdout1_94ck195 FIND v(dout1_94) AT=980.025n

* CHECK dout1_95 Vdout1_95ck195 = 0.9 time = 980
.meas tran vdout1_95ck195 FIND v(dout1_95) AT=980.025n

* CHECK dout1_0 Vdout1_0ck196 = 0 time = 985
.meas tran vdout1_0ck196 FIND v(dout1_0) AT=985.025n

* CHECK dout1_1 Vdout1_1ck196 = 0 time = 985
.meas tran vdout1_1ck196 FIND v(dout1_1) AT=985.025n

* CHECK dout1_2 Vdout1_2ck196 = 0 time = 985
.meas tran vdout1_2ck196 FIND v(dout1_2) AT=985.025n

* CHECK dout1_3 Vdout1_3ck196 = 0 time = 985
.meas tran vdout1_3ck196 FIND v(dout1_3) AT=985.025n

* CHECK dout1_4 Vdout1_4ck196 = 0 time = 985
.meas tran vdout1_4ck196 FIND v(dout1_4) AT=985.025n

* CHECK dout1_5 Vdout1_5ck196 = 0.9 time = 985
.meas tran vdout1_5ck196 FIND v(dout1_5) AT=985.025n

* CHECK dout1_6 Vdout1_6ck196 = 0.9 time = 985
.meas tran vdout1_6ck196 FIND v(dout1_6) AT=985.025n

* CHECK dout1_7 Vdout1_7ck196 = 0 time = 985
.meas tran vdout1_7ck196 FIND v(dout1_7) AT=985.025n

* CHECK dout1_8 Vdout1_8ck196 = 0.9 time = 985
.meas tran vdout1_8ck196 FIND v(dout1_8) AT=985.025n

* CHECK dout1_9 Vdout1_9ck196 = 0 time = 985
.meas tran vdout1_9ck196 FIND v(dout1_9) AT=985.025n

* CHECK dout1_10 Vdout1_10ck196 = 0.9 time = 985
.meas tran vdout1_10ck196 FIND v(dout1_10) AT=985.025n

* CHECK dout1_11 Vdout1_11ck196 = 0 time = 985
.meas tran vdout1_11ck196 FIND v(dout1_11) AT=985.025n

* CHECK dout1_12 Vdout1_12ck196 = 0 time = 985
.meas tran vdout1_12ck196 FIND v(dout1_12) AT=985.025n

* CHECK dout1_13 Vdout1_13ck196 = 0.9 time = 985
.meas tran vdout1_13ck196 FIND v(dout1_13) AT=985.025n

* CHECK dout1_14 Vdout1_14ck196 = 0.9 time = 985
.meas tran vdout1_14ck196 FIND v(dout1_14) AT=985.025n

* CHECK dout1_15 Vdout1_15ck196 = 0.9 time = 985
.meas tran vdout1_15ck196 FIND v(dout1_15) AT=985.025n

* CHECK dout1_16 Vdout1_16ck196 = 0 time = 985
.meas tran vdout1_16ck196 FIND v(dout1_16) AT=985.025n

* CHECK dout1_17 Vdout1_17ck196 = 0 time = 985
.meas tran vdout1_17ck196 FIND v(dout1_17) AT=985.025n

* CHECK dout1_18 Vdout1_18ck196 = 0 time = 985
.meas tran vdout1_18ck196 FIND v(dout1_18) AT=985.025n

* CHECK dout1_19 Vdout1_19ck196 = 0.9 time = 985
.meas tran vdout1_19ck196 FIND v(dout1_19) AT=985.025n

* CHECK dout1_20 Vdout1_20ck196 = 0.9 time = 985
.meas tran vdout1_20ck196 FIND v(dout1_20) AT=985.025n

* CHECK dout1_21 Vdout1_21ck196 = 0 time = 985
.meas tran vdout1_21ck196 FIND v(dout1_21) AT=985.025n

* CHECK dout1_22 Vdout1_22ck196 = 0 time = 985
.meas tran vdout1_22ck196 FIND v(dout1_22) AT=985.025n

* CHECK dout1_23 Vdout1_23ck196 = 0 time = 985
.meas tran vdout1_23ck196 FIND v(dout1_23) AT=985.025n

* CHECK dout1_24 Vdout1_24ck196 = 0.9 time = 985
.meas tran vdout1_24ck196 FIND v(dout1_24) AT=985.025n

* CHECK dout1_25 Vdout1_25ck196 = 0.9 time = 985
.meas tran vdout1_25ck196 FIND v(dout1_25) AT=985.025n

* CHECK dout1_26 Vdout1_26ck196 = 0.9 time = 985
.meas tran vdout1_26ck196 FIND v(dout1_26) AT=985.025n

* CHECK dout1_27 Vdout1_27ck196 = 0 time = 985
.meas tran vdout1_27ck196 FIND v(dout1_27) AT=985.025n

* CHECK dout1_28 Vdout1_28ck196 = 0 time = 985
.meas tran vdout1_28ck196 FIND v(dout1_28) AT=985.025n

* CHECK dout1_29 Vdout1_29ck196 = 0.9 time = 985
.meas tran vdout1_29ck196 FIND v(dout1_29) AT=985.025n

* CHECK dout1_30 Vdout1_30ck196 = 0 time = 985
.meas tran vdout1_30ck196 FIND v(dout1_30) AT=985.025n

* CHECK dout1_31 Vdout1_31ck196 = 0.9 time = 985
.meas tran vdout1_31ck196 FIND v(dout1_31) AT=985.025n

* CHECK dout1_32 Vdout1_32ck196 = 0.9 time = 985
.meas tran vdout1_32ck196 FIND v(dout1_32) AT=985.025n

* CHECK dout1_33 Vdout1_33ck196 = 0.9 time = 985
.meas tran vdout1_33ck196 FIND v(dout1_33) AT=985.025n

* CHECK dout1_34 Vdout1_34ck196 = 0 time = 985
.meas tran vdout1_34ck196 FIND v(dout1_34) AT=985.025n

* CHECK dout1_35 Vdout1_35ck196 = 0.9 time = 985
.meas tran vdout1_35ck196 FIND v(dout1_35) AT=985.025n

* CHECK dout1_36 Vdout1_36ck196 = 0 time = 985
.meas tran vdout1_36ck196 FIND v(dout1_36) AT=985.025n

* CHECK dout1_37 Vdout1_37ck196 = 0 time = 985
.meas tran vdout1_37ck196 FIND v(dout1_37) AT=985.025n

* CHECK dout1_38 Vdout1_38ck196 = 0 time = 985
.meas tran vdout1_38ck196 FIND v(dout1_38) AT=985.025n

* CHECK dout1_39 Vdout1_39ck196 = 0.9 time = 985
.meas tran vdout1_39ck196 FIND v(dout1_39) AT=985.025n

* CHECK dout1_40 Vdout1_40ck196 = 0 time = 985
.meas tran vdout1_40ck196 FIND v(dout1_40) AT=985.025n

* CHECK dout1_41 Vdout1_41ck196 = 0 time = 985
.meas tran vdout1_41ck196 FIND v(dout1_41) AT=985.025n

* CHECK dout1_42 Vdout1_42ck196 = 0.9 time = 985
.meas tran vdout1_42ck196 FIND v(dout1_42) AT=985.025n

* CHECK dout1_43 Vdout1_43ck196 = 0 time = 985
.meas tran vdout1_43ck196 FIND v(dout1_43) AT=985.025n

* CHECK dout1_44 Vdout1_44ck196 = 0.9 time = 985
.meas tran vdout1_44ck196 FIND v(dout1_44) AT=985.025n

* CHECK dout1_45 Vdout1_45ck196 = 0 time = 985
.meas tran vdout1_45ck196 FIND v(dout1_45) AT=985.025n

* CHECK dout1_46 Vdout1_46ck196 = 0.9 time = 985
.meas tran vdout1_46ck196 FIND v(dout1_46) AT=985.025n

* CHECK dout1_47 Vdout1_47ck196 = 0.9 time = 985
.meas tran vdout1_47ck196 FIND v(dout1_47) AT=985.025n

* CHECK dout1_48 Vdout1_48ck196 = 0 time = 985
.meas tran vdout1_48ck196 FIND v(dout1_48) AT=985.025n

* CHECK dout1_49 Vdout1_49ck196 = 0.9 time = 985
.meas tran vdout1_49ck196 FIND v(dout1_49) AT=985.025n

* CHECK dout1_50 Vdout1_50ck196 = 0.9 time = 985
.meas tran vdout1_50ck196 FIND v(dout1_50) AT=985.025n

* CHECK dout1_51 Vdout1_51ck196 = 0.9 time = 985
.meas tran vdout1_51ck196 FIND v(dout1_51) AT=985.025n

* CHECK dout1_52 Vdout1_52ck196 = 0.9 time = 985
.meas tran vdout1_52ck196 FIND v(dout1_52) AT=985.025n

* CHECK dout1_53 Vdout1_53ck196 = 0 time = 985
.meas tran vdout1_53ck196 FIND v(dout1_53) AT=985.025n

* CHECK dout1_54 Vdout1_54ck196 = 0 time = 985
.meas tran vdout1_54ck196 FIND v(dout1_54) AT=985.025n

* CHECK dout1_55 Vdout1_55ck196 = 0 time = 985
.meas tran vdout1_55ck196 FIND v(dout1_55) AT=985.025n

* CHECK dout1_56 Vdout1_56ck196 = 0.9 time = 985
.meas tran vdout1_56ck196 FIND v(dout1_56) AT=985.025n

* CHECK dout1_57 Vdout1_57ck196 = 0 time = 985
.meas tran vdout1_57ck196 FIND v(dout1_57) AT=985.025n

* CHECK dout1_58 Vdout1_58ck196 = 0.9 time = 985
.meas tran vdout1_58ck196 FIND v(dout1_58) AT=985.025n

* CHECK dout1_59 Vdout1_59ck196 = 0.9 time = 985
.meas tran vdout1_59ck196 FIND v(dout1_59) AT=985.025n

* CHECK dout1_60 Vdout1_60ck196 = 0 time = 985
.meas tran vdout1_60ck196 FIND v(dout1_60) AT=985.025n

* CHECK dout1_61 Vdout1_61ck196 = 0 time = 985
.meas tran vdout1_61ck196 FIND v(dout1_61) AT=985.025n

* CHECK dout1_62 Vdout1_62ck196 = 0.9 time = 985
.meas tran vdout1_62ck196 FIND v(dout1_62) AT=985.025n

* CHECK dout1_63 Vdout1_63ck196 = 0 time = 985
.meas tran vdout1_63ck196 FIND v(dout1_63) AT=985.025n

* CHECK dout1_64 Vdout1_64ck196 = 0.9 time = 985
.meas tran vdout1_64ck196 FIND v(dout1_64) AT=985.025n

* CHECK dout1_65 Vdout1_65ck196 = 0 time = 985
.meas tran vdout1_65ck196 FIND v(dout1_65) AT=985.025n

* CHECK dout1_66 Vdout1_66ck196 = 0 time = 985
.meas tran vdout1_66ck196 FIND v(dout1_66) AT=985.025n

* CHECK dout1_67 Vdout1_67ck196 = 0 time = 985
.meas tran vdout1_67ck196 FIND v(dout1_67) AT=985.025n

* CHECK dout1_68 Vdout1_68ck196 = 0.9 time = 985
.meas tran vdout1_68ck196 FIND v(dout1_68) AT=985.025n

* CHECK dout1_69 Vdout1_69ck196 = 0.9 time = 985
.meas tran vdout1_69ck196 FIND v(dout1_69) AT=985.025n

* CHECK dout1_70 Vdout1_70ck196 = 0.9 time = 985
.meas tran vdout1_70ck196 FIND v(dout1_70) AT=985.025n

* CHECK dout1_71 Vdout1_71ck196 = 0.9 time = 985
.meas tran vdout1_71ck196 FIND v(dout1_71) AT=985.025n

* CHECK dout1_72 Vdout1_72ck196 = 0.9 time = 985
.meas tran vdout1_72ck196 FIND v(dout1_72) AT=985.025n

* CHECK dout1_73 Vdout1_73ck196 = 0 time = 985
.meas tran vdout1_73ck196 FIND v(dout1_73) AT=985.025n

* CHECK dout1_74 Vdout1_74ck196 = 0.9 time = 985
.meas tran vdout1_74ck196 FIND v(dout1_74) AT=985.025n

* CHECK dout1_75 Vdout1_75ck196 = 0 time = 985
.meas tran vdout1_75ck196 FIND v(dout1_75) AT=985.025n

* CHECK dout1_76 Vdout1_76ck196 = 0 time = 985
.meas tran vdout1_76ck196 FIND v(dout1_76) AT=985.025n

* CHECK dout1_77 Vdout1_77ck196 = 0 time = 985
.meas tran vdout1_77ck196 FIND v(dout1_77) AT=985.025n

* CHECK dout1_78 Vdout1_78ck196 = 0.9 time = 985
.meas tran vdout1_78ck196 FIND v(dout1_78) AT=985.025n

* CHECK dout1_79 Vdout1_79ck196 = 0 time = 985
.meas tran vdout1_79ck196 FIND v(dout1_79) AT=985.025n

* CHECK dout1_80 Vdout1_80ck196 = 0.9 time = 985
.meas tran vdout1_80ck196 FIND v(dout1_80) AT=985.025n

* CHECK dout1_81 Vdout1_81ck196 = 0 time = 985
.meas tran vdout1_81ck196 FIND v(dout1_81) AT=985.025n

* CHECK dout1_82 Vdout1_82ck196 = 0 time = 985
.meas tran vdout1_82ck196 FIND v(dout1_82) AT=985.025n

* CHECK dout1_83 Vdout1_83ck196 = 0.9 time = 985
.meas tran vdout1_83ck196 FIND v(dout1_83) AT=985.025n

* CHECK dout1_84 Vdout1_84ck196 = 0 time = 985
.meas tran vdout1_84ck196 FIND v(dout1_84) AT=985.025n

* CHECK dout1_85 Vdout1_85ck196 = 0 time = 985
.meas tran vdout1_85ck196 FIND v(dout1_85) AT=985.025n

* CHECK dout1_86 Vdout1_86ck196 = 0.9 time = 985
.meas tran vdout1_86ck196 FIND v(dout1_86) AT=985.025n

* CHECK dout1_87 Vdout1_87ck196 = 0.9 time = 985
.meas tran vdout1_87ck196 FIND v(dout1_87) AT=985.025n

* CHECK dout1_88 Vdout1_88ck196 = 0.9 time = 985
.meas tran vdout1_88ck196 FIND v(dout1_88) AT=985.025n

* CHECK dout1_89 Vdout1_89ck196 = 0 time = 985
.meas tran vdout1_89ck196 FIND v(dout1_89) AT=985.025n

* CHECK dout1_90 Vdout1_90ck196 = 0.9 time = 985
.meas tran vdout1_90ck196 FIND v(dout1_90) AT=985.025n

* CHECK dout1_91 Vdout1_91ck196 = 0.9 time = 985
.meas tran vdout1_91ck196 FIND v(dout1_91) AT=985.025n

* CHECK dout1_92 Vdout1_92ck196 = 0.9 time = 985
.meas tran vdout1_92ck196 FIND v(dout1_92) AT=985.025n

* CHECK dout1_93 Vdout1_93ck196 = 0.9 time = 985
.meas tran vdout1_93ck196 FIND v(dout1_93) AT=985.025n

* CHECK dout1_94 Vdout1_94ck196 = 0.9 time = 985
.meas tran vdout1_94ck196 FIND v(dout1_94) AT=985.025n

* CHECK dout1_95 Vdout1_95ck196 = 0.9 time = 985
.meas tran vdout1_95ck196 FIND v(dout1_95) AT=985.025n

* CHECK dout1_0 Vdout1_0ck201 = 0 time = 1010
.meas tran vdout1_0ck201 FIND v(dout1_0) AT=1010.025n

* CHECK dout1_1 Vdout1_1ck201 = 0 time = 1010
.meas tran vdout1_1ck201 FIND v(dout1_1) AT=1010.025n

* CHECK dout1_2 Vdout1_2ck201 = 0 time = 1010
.meas tran vdout1_2ck201 FIND v(dout1_2) AT=1010.025n

* CHECK dout1_3 Vdout1_3ck201 = 0 time = 1010
.meas tran vdout1_3ck201 FIND v(dout1_3) AT=1010.025n

* CHECK dout1_4 Vdout1_4ck201 = 0 time = 1010
.meas tran vdout1_4ck201 FIND v(dout1_4) AT=1010.025n

* CHECK dout1_5 Vdout1_5ck201 = 0.9 time = 1010
.meas tran vdout1_5ck201 FIND v(dout1_5) AT=1010.025n

* CHECK dout1_6 Vdout1_6ck201 = 0.9 time = 1010
.meas tran vdout1_6ck201 FIND v(dout1_6) AT=1010.025n

* CHECK dout1_7 Vdout1_7ck201 = 0 time = 1010
.meas tran vdout1_7ck201 FIND v(dout1_7) AT=1010.025n

* CHECK dout1_8 Vdout1_8ck201 = 0.9 time = 1010
.meas tran vdout1_8ck201 FIND v(dout1_8) AT=1010.025n

* CHECK dout1_9 Vdout1_9ck201 = 0 time = 1010
.meas tran vdout1_9ck201 FIND v(dout1_9) AT=1010.025n

* CHECK dout1_10 Vdout1_10ck201 = 0.9 time = 1010
.meas tran vdout1_10ck201 FIND v(dout1_10) AT=1010.025n

* CHECK dout1_11 Vdout1_11ck201 = 0 time = 1010
.meas tran vdout1_11ck201 FIND v(dout1_11) AT=1010.025n

* CHECK dout1_12 Vdout1_12ck201 = 0 time = 1010
.meas tran vdout1_12ck201 FIND v(dout1_12) AT=1010.025n

* CHECK dout1_13 Vdout1_13ck201 = 0.9 time = 1010
.meas tran vdout1_13ck201 FIND v(dout1_13) AT=1010.025n

* CHECK dout1_14 Vdout1_14ck201 = 0.9 time = 1010
.meas tran vdout1_14ck201 FIND v(dout1_14) AT=1010.025n

* CHECK dout1_15 Vdout1_15ck201 = 0.9 time = 1010
.meas tran vdout1_15ck201 FIND v(dout1_15) AT=1010.025n

* CHECK dout1_16 Vdout1_16ck201 = 0 time = 1010
.meas tran vdout1_16ck201 FIND v(dout1_16) AT=1010.025n

* CHECK dout1_17 Vdout1_17ck201 = 0 time = 1010
.meas tran vdout1_17ck201 FIND v(dout1_17) AT=1010.025n

* CHECK dout1_18 Vdout1_18ck201 = 0 time = 1010
.meas tran vdout1_18ck201 FIND v(dout1_18) AT=1010.025n

* CHECK dout1_19 Vdout1_19ck201 = 0.9 time = 1010
.meas tran vdout1_19ck201 FIND v(dout1_19) AT=1010.025n

* CHECK dout1_20 Vdout1_20ck201 = 0.9 time = 1010
.meas tran vdout1_20ck201 FIND v(dout1_20) AT=1010.025n

* CHECK dout1_21 Vdout1_21ck201 = 0 time = 1010
.meas tran vdout1_21ck201 FIND v(dout1_21) AT=1010.025n

* CHECK dout1_22 Vdout1_22ck201 = 0 time = 1010
.meas tran vdout1_22ck201 FIND v(dout1_22) AT=1010.025n

* CHECK dout1_23 Vdout1_23ck201 = 0 time = 1010
.meas tran vdout1_23ck201 FIND v(dout1_23) AT=1010.025n

* CHECK dout1_24 Vdout1_24ck201 = 0.9 time = 1010
.meas tran vdout1_24ck201 FIND v(dout1_24) AT=1010.025n

* CHECK dout1_25 Vdout1_25ck201 = 0.9 time = 1010
.meas tran vdout1_25ck201 FIND v(dout1_25) AT=1010.025n

* CHECK dout1_26 Vdout1_26ck201 = 0.9 time = 1010
.meas tran vdout1_26ck201 FIND v(dout1_26) AT=1010.025n

* CHECK dout1_27 Vdout1_27ck201 = 0 time = 1010
.meas tran vdout1_27ck201 FIND v(dout1_27) AT=1010.025n

* CHECK dout1_28 Vdout1_28ck201 = 0 time = 1010
.meas tran vdout1_28ck201 FIND v(dout1_28) AT=1010.025n

* CHECK dout1_29 Vdout1_29ck201 = 0.9 time = 1010
.meas tran vdout1_29ck201 FIND v(dout1_29) AT=1010.025n

* CHECK dout1_30 Vdout1_30ck201 = 0 time = 1010
.meas tran vdout1_30ck201 FIND v(dout1_30) AT=1010.025n

* CHECK dout1_31 Vdout1_31ck201 = 0.9 time = 1010
.meas tran vdout1_31ck201 FIND v(dout1_31) AT=1010.025n

* CHECK dout1_32 Vdout1_32ck201 = 0.9 time = 1010
.meas tran vdout1_32ck201 FIND v(dout1_32) AT=1010.025n

* CHECK dout1_33 Vdout1_33ck201 = 0.9 time = 1010
.meas tran vdout1_33ck201 FIND v(dout1_33) AT=1010.025n

* CHECK dout1_34 Vdout1_34ck201 = 0 time = 1010
.meas tran vdout1_34ck201 FIND v(dout1_34) AT=1010.025n

* CHECK dout1_35 Vdout1_35ck201 = 0.9 time = 1010
.meas tran vdout1_35ck201 FIND v(dout1_35) AT=1010.025n

* CHECK dout1_36 Vdout1_36ck201 = 0 time = 1010
.meas tran vdout1_36ck201 FIND v(dout1_36) AT=1010.025n

* CHECK dout1_37 Vdout1_37ck201 = 0 time = 1010
.meas tran vdout1_37ck201 FIND v(dout1_37) AT=1010.025n

* CHECK dout1_38 Vdout1_38ck201 = 0 time = 1010
.meas tran vdout1_38ck201 FIND v(dout1_38) AT=1010.025n

* CHECK dout1_39 Vdout1_39ck201 = 0.9 time = 1010
.meas tran vdout1_39ck201 FIND v(dout1_39) AT=1010.025n

* CHECK dout1_40 Vdout1_40ck201 = 0 time = 1010
.meas tran vdout1_40ck201 FIND v(dout1_40) AT=1010.025n

* CHECK dout1_41 Vdout1_41ck201 = 0 time = 1010
.meas tran vdout1_41ck201 FIND v(dout1_41) AT=1010.025n

* CHECK dout1_42 Vdout1_42ck201 = 0.9 time = 1010
.meas tran vdout1_42ck201 FIND v(dout1_42) AT=1010.025n

* CHECK dout1_43 Vdout1_43ck201 = 0 time = 1010
.meas tran vdout1_43ck201 FIND v(dout1_43) AT=1010.025n

* CHECK dout1_44 Vdout1_44ck201 = 0.9 time = 1010
.meas tran vdout1_44ck201 FIND v(dout1_44) AT=1010.025n

* CHECK dout1_45 Vdout1_45ck201 = 0 time = 1010
.meas tran vdout1_45ck201 FIND v(dout1_45) AT=1010.025n

* CHECK dout1_46 Vdout1_46ck201 = 0.9 time = 1010
.meas tran vdout1_46ck201 FIND v(dout1_46) AT=1010.025n

* CHECK dout1_47 Vdout1_47ck201 = 0.9 time = 1010
.meas tran vdout1_47ck201 FIND v(dout1_47) AT=1010.025n

* CHECK dout1_48 Vdout1_48ck201 = 0 time = 1010
.meas tran vdout1_48ck201 FIND v(dout1_48) AT=1010.025n

* CHECK dout1_49 Vdout1_49ck201 = 0.9 time = 1010
.meas tran vdout1_49ck201 FIND v(dout1_49) AT=1010.025n

* CHECK dout1_50 Vdout1_50ck201 = 0.9 time = 1010
.meas tran vdout1_50ck201 FIND v(dout1_50) AT=1010.025n

* CHECK dout1_51 Vdout1_51ck201 = 0.9 time = 1010
.meas tran vdout1_51ck201 FIND v(dout1_51) AT=1010.025n

* CHECK dout1_52 Vdout1_52ck201 = 0.9 time = 1010
.meas tran vdout1_52ck201 FIND v(dout1_52) AT=1010.025n

* CHECK dout1_53 Vdout1_53ck201 = 0 time = 1010
.meas tran vdout1_53ck201 FIND v(dout1_53) AT=1010.025n

* CHECK dout1_54 Vdout1_54ck201 = 0 time = 1010
.meas tran vdout1_54ck201 FIND v(dout1_54) AT=1010.025n

* CHECK dout1_55 Vdout1_55ck201 = 0 time = 1010
.meas tran vdout1_55ck201 FIND v(dout1_55) AT=1010.025n

* CHECK dout1_56 Vdout1_56ck201 = 0.9 time = 1010
.meas tran vdout1_56ck201 FIND v(dout1_56) AT=1010.025n

* CHECK dout1_57 Vdout1_57ck201 = 0 time = 1010
.meas tran vdout1_57ck201 FIND v(dout1_57) AT=1010.025n

* CHECK dout1_58 Vdout1_58ck201 = 0.9 time = 1010
.meas tran vdout1_58ck201 FIND v(dout1_58) AT=1010.025n

* CHECK dout1_59 Vdout1_59ck201 = 0.9 time = 1010
.meas tran vdout1_59ck201 FIND v(dout1_59) AT=1010.025n

* CHECK dout1_60 Vdout1_60ck201 = 0 time = 1010
.meas tran vdout1_60ck201 FIND v(dout1_60) AT=1010.025n

* CHECK dout1_61 Vdout1_61ck201 = 0 time = 1010
.meas tran vdout1_61ck201 FIND v(dout1_61) AT=1010.025n

* CHECK dout1_62 Vdout1_62ck201 = 0.9 time = 1010
.meas tran vdout1_62ck201 FIND v(dout1_62) AT=1010.025n

* CHECK dout1_63 Vdout1_63ck201 = 0 time = 1010
.meas tran vdout1_63ck201 FIND v(dout1_63) AT=1010.025n

* CHECK dout1_64 Vdout1_64ck201 = 0.9 time = 1010
.meas tran vdout1_64ck201 FIND v(dout1_64) AT=1010.025n

* CHECK dout1_65 Vdout1_65ck201 = 0 time = 1010
.meas tran vdout1_65ck201 FIND v(dout1_65) AT=1010.025n

* CHECK dout1_66 Vdout1_66ck201 = 0 time = 1010
.meas tran vdout1_66ck201 FIND v(dout1_66) AT=1010.025n

* CHECK dout1_67 Vdout1_67ck201 = 0 time = 1010
.meas tran vdout1_67ck201 FIND v(dout1_67) AT=1010.025n

* CHECK dout1_68 Vdout1_68ck201 = 0.9 time = 1010
.meas tran vdout1_68ck201 FIND v(dout1_68) AT=1010.025n

* CHECK dout1_69 Vdout1_69ck201 = 0.9 time = 1010
.meas tran vdout1_69ck201 FIND v(dout1_69) AT=1010.025n

* CHECK dout1_70 Vdout1_70ck201 = 0.9 time = 1010
.meas tran vdout1_70ck201 FIND v(dout1_70) AT=1010.025n

* CHECK dout1_71 Vdout1_71ck201 = 0.9 time = 1010
.meas tran vdout1_71ck201 FIND v(dout1_71) AT=1010.025n

* CHECK dout1_72 Vdout1_72ck201 = 0.9 time = 1010
.meas tran vdout1_72ck201 FIND v(dout1_72) AT=1010.025n

* CHECK dout1_73 Vdout1_73ck201 = 0 time = 1010
.meas tran vdout1_73ck201 FIND v(dout1_73) AT=1010.025n

* CHECK dout1_74 Vdout1_74ck201 = 0.9 time = 1010
.meas tran vdout1_74ck201 FIND v(dout1_74) AT=1010.025n

* CHECK dout1_75 Vdout1_75ck201 = 0 time = 1010
.meas tran vdout1_75ck201 FIND v(dout1_75) AT=1010.025n

* CHECK dout1_76 Vdout1_76ck201 = 0 time = 1010
.meas tran vdout1_76ck201 FIND v(dout1_76) AT=1010.025n

* CHECK dout1_77 Vdout1_77ck201 = 0 time = 1010
.meas tran vdout1_77ck201 FIND v(dout1_77) AT=1010.025n

* CHECK dout1_78 Vdout1_78ck201 = 0.9 time = 1010
.meas tran vdout1_78ck201 FIND v(dout1_78) AT=1010.025n

* CHECK dout1_79 Vdout1_79ck201 = 0 time = 1010
.meas tran vdout1_79ck201 FIND v(dout1_79) AT=1010.025n

* CHECK dout1_80 Vdout1_80ck201 = 0.9 time = 1010
.meas tran vdout1_80ck201 FIND v(dout1_80) AT=1010.025n

* CHECK dout1_81 Vdout1_81ck201 = 0 time = 1010
.meas tran vdout1_81ck201 FIND v(dout1_81) AT=1010.025n

* CHECK dout1_82 Vdout1_82ck201 = 0 time = 1010
.meas tran vdout1_82ck201 FIND v(dout1_82) AT=1010.025n

* CHECK dout1_83 Vdout1_83ck201 = 0.9 time = 1010
.meas tran vdout1_83ck201 FIND v(dout1_83) AT=1010.025n

* CHECK dout1_84 Vdout1_84ck201 = 0 time = 1010
.meas tran vdout1_84ck201 FIND v(dout1_84) AT=1010.025n

* CHECK dout1_85 Vdout1_85ck201 = 0 time = 1010
.meas tran vdout1_85ck201 FIND v(dout1_85) AT=1010.025n

* CHECK dout1_86 Vdout1_86ck201 = 0.9 time = 1010
.meas tran vdout1_86ck201 FIND v(dout1_86) AT=1010.025n

* CHECK dout1_87 Vdout1_87ck201 = 0.9 time = 1010
.meas tran vdout1_87ck201 FIND v(dout1_87) AT=1010.025n

* CHECK dout1_88 Vdout1_88ck201 = 0.9 time = 1010
.meas tran vdout1_88ck201 FIND v(dout1_88) AT=1010.025n

* CHECK dout1_89 Vdout1_89ck201 = 0 time = 1010
.meas tran vdout1_89ck201 FIND v(dout1_89) AT=1010.025n

* CHECK dout1_90 Vdout1_90ck201 = 0.9 time = 1010
.meas tran vdout1_90ck201 FIND v(dout1_90) AT=1010.025n

* CHECK dout1_91 Vdout1_91ck201 = 0.9 time = 1010
.meas tran vdout1_91ck201 FIND v(dout1_91) AT=1010.025n

* CHECK dout1_92 Vdout1_92ck201 = 0.9 time = 1010
.meas tran vdout1_92ck201 FIND v(dout1_92) AT=1010.025n

* CHECK dout1_93 Vdout1_93ck201 = 0.9 time = 1010
.meas tran vdout1_93ck201 FIND v(dout1_93) AT=1010.025n

* CHECK dout1_94 Vdout1_94ck201 = 0.9 time = 1010
.meas tran vdout1_94ck201 FIND v(dout1_94) AT=1010.025n

* CHECK dout1_95 Vdout1_95ck201 = 0.9 time = 1010
.meas tran vdout1_95ck201 FIND v(dout1_95) AT=1010.025n

* CHECK dout1_0 Vdout1_0ck203 = 0.9 time = 1020
.meas tran vdout1_0ck203 FIND v(dout1_0) AT=1020.025n

* CHECK dout1_1 Vdout1_1ck203 = 0.9 time = 1020
.meas tran vdout1_1ck203 FIND v(dout1_1) AT=1020.025n

* CHECK dout1_2 Vdout1_2ck203 = 0 time = 1020
.meas tran vdout1_2ck203 FIND v(dout1_2) AT=1020.025n

* CHECK dout1_3 Vdout1_3ck203 = 0 time = 1020
.meas tran vdout1_3ck203 FIND v(dout1_3) AT=1020.025n

* CHECK dout1_4 Vdout1_4ck203 = 0 time = 1020
.meas tran vdout1_4ck203 FIND v(dout1_4) AT=1020.025n

* CHECK dout1_5 Vdout1_5ck203 = 0 time = 1020
.meas tran vdout1_5ck203 FIND v(dout1_5) AT=1020.025n

* CHECK dout1_6 Vdout1_6ck203 = 0.9 time = 1020
.meas tran vdout1_6ck203 FIND v(dout1_6) AT=1020.025n

* CHECK dout1_7 Vdout1_7ck203 = 0.9 time = 1020
.meas tran vdout1_7ck203 FIND v(dout1_7) AT=1020.025n

* CHECK dout1_8 Vdout1_8ck203 = 0.9 time = 1020
.meas tran vdout1_8ck203 FIND v(dout1_8) AT=1020.025n

* CHECK dout1_9 Vdout1_9ck203 = 0 time = 1020
.meas tran vdout1_9ck203 FIND v(dout1_9) AT=1020.025n

* CHECK dout1_10 Vdout1_10ck203 = 0.9 time = 1020
.meas tran vdout1_10ck203 FIND v(dout1_10) AT=1020.025n

* CHECK dout1_11 Vdout1_11ck203 = 0.9 time = 1020
.meas tran vdout1_11ck203 FIND v(dout1_11) AT=1020.025n

* CHECK dout1_12 Vdout1_12ck203 = 0 time = 1020
.meas tran vdout1_12ck203 FIND v(dout1_12) AT=1020.025n

* CHECK dout1_13 Vdout1_13ck203 = 0.9 time = 1020
.meas tran vdout1_13ck203 FIND v(dout1_13) AT=1020.025n

* CHECK dout1_14 Vdout1_14ck203 = 0 time = 1020
.meas tran vdout1_14ck203 FIND v(dout1_14) AT=1020.025n

* CHECK dout1_15 Vdout1_15ck203 = 0 time = 1020
.meas tran vdout1_15ck203 FIND v(dout1_15) AT=1020.025n

* CHECK dout1_16 Vdout1_16ck203 = 0.9 time = 1020
.meas tran vdout1_16ck203 FIND v(dout1_16) AT=1020.025n

* CHECK dout1_17 Vdout1_17ck203 = 0.9 time = 1020
.meas tran vdout1_17ck203 FIND v(dout1_17) AT=1020.025n

* CHECK dout1_18 Vdout1_18ck203 = 0 time = 1020
.meas tran vdout1_18ck203 FIND v(dout1_18) AT=1020.025n

* CHECK dout1_19 Vdout1_19ck203 = 0 time = 1020
.meas tran vdout1_19ck203 FIND v(dout1_19) AT=1020.025n

* CHECK dout1_20 Vdout1_20ck203 = 0 time = 1020
.meas tran vdout1_20ck203 FIND v(dout1_20) AT=1020.025n

* CHECK dout1_21 Vdout1_21ck203 = 0.9 time = 1020
.meas tran vdout1_21ck203 FIND v(dout1_21) AT=1020.025n

* CHECK dout1_22 Vdout1_22ck203 = 0 time = 1020
.meas tran vdout1_22ck203 FIND v(dout1_22) AT=1020.025n

* CHECK dout1_23 Vdout1_23ck203 = 0 time = 1020
.meas tran vdout1_23ck203 FIND v(dout1_23) AT=1020.025n

* CHECK dout1_24 Vdout1_24ck203 = 0.9 time = 1020
.meas tran vdout1_24ck203 FIND v(dout1_24) AT=1020.025n

* CHECK dout1_25 Vdout1_25ck203 = 0.9 time = 1020
.meas tran vdout1_25ck203 FIND v(dout1_25) AT=1020.025n

* CHECK dout1_26 Vdout1_26ck203 = 0 time = 1020
.meas tran vdout1_26ck203 FIND v(dout1_26) AT=1020.025n

* CHECK dout1_27 Vdout1_27ck203 = 0 time = 1020
.meas tran vdout1_27ck203 FIND v(dout1_27) AT=1020.025n

* CHECK dout1_28 Vdout1_28ck203 = 0 time = 1020
.meas tran vdout1_28ck203 FIND v(dout1_28) AT=1020.025n

* CHECK dout1_29 Vdout1_29ck203 = 0.9 time = 1020
.meas tran vdout1_29ck203 FIND v(dout1_29) AT=1020.025n

* CHECK dout1_30 Vdout1_30ck203 = 0 time = 1020
.meas tran vdout1_30ck203 FIND v(dout1_30) AT=1020.025n

* CHECK dout1_31 Vdout1_31ck203 = 0.9 time = 1020
.meas tran vdout1_31ck203 FIND v(dout1_31) AT=1020.025n

* CHECK dout1_32 Vdout1_32ck203 = 0 time = 1020
.meas tran vdout1_32ck203 FIND v(dout1_32) AT=1020.025n

* CHECK dout1_33 Vdout1_33ck203 = 0 time = 1020
.meas tran vdout1_33ck203 FIND v(dout1_33) AT=1020.025n

* CHECK dout1_34 Vdout1_34ck203 = 0 time = 1020
.meas tran vdout1_34ck203 FIND v(dout1_34) AT=1020.025n

* CHECK dout1_35 Vdout1_35ck203 = 0 time = 1020
.meas tran vdout1_35ck203 FIND v(dout1_35) AT=1020.025n

* CHECK dout1_36 Vdout1_36ck203 = 0.9 time = 1020
.meas tran vdout1_36ck203 FIND v(dout1_36) AT=1020.025n

* CHECK dout1_37 Vdout1_37ck203 = 0.9 time = 1020
.meas tran vdout1_37ck203 FIND v(dout1_37) AT=1020.025n

* CHECK dout1_38 Vdout1_38ck203 = 0 time = 1020
.meas tran vdout1_38ck203 FIND v(dout1_38) AT=1020.025n

* CHECK dout1_39 Vdout1_39ck203 = 0 time = 1020
.meas tran vdout1_39ck203 FIND v(dout1_39) AT=1020.025n

* CHECK dout1_40 Vdout1_40ck203 = 0 time = 1020
.meas tran vdout1_40ck203 FIND v(dout1_40) AT=1020.025n

* CHECK dout1_41 Vdout1_41ck203 = 0 time = 1020
.meas tran vdout1_41ck203 FIND v(dout1_41) AT=1020.025n

* CHECK dout1_42 Vdout1_42ck203 = 0 time = 1020
.meas tran vdout1_42ck203 FIND v(dout1_42) AT=1020.025n

* CHECK dout1_43 Vdout1_43ck203 = 0.9 time = 1020
.meas tran vdout1_43ck203 FIND v(dout1_43) AT=1020.025n

* CHECK dout1_44 Vdout1_44ck203 = 0.9 time = 1020
.meas tran vdout1_44ck203 FIND v(dout1_44) AT=1020.025n

* CHECK dout1_45 Vdout1_45ck203 = 0 time = 1020
.meas tran vdout1_45ck203 FIND v(dout1_45) AT=1020.025n

* CHECK dout1_46 Vdout1_46ck203 = 0 time = 1020
.meas tran vdout1_46ck203 FIND v(dout1_46) AT=1020.025n

* CHECK dout1_47 Vdout1_47ck203 = 0.9 time = 1020
.meas tran vdout1_47ck203 FIND v(dout1_47) AT=1020.025n

* CHECK dout1_48 Vdout1_48ck203 = 0 time = 1020
.meas tran vdout1_48ck203 FIND v(dout1_48) AT=1020.025n

* CHECK dout1_49 Vdout1_49ck203 = 0.9 time = 1020
.meas tran vdout1_49ck203 FIND v(dout1_49) AT=1020.025n

* CHECK dout1_50 Vdout1_50ck203 = 0.9 time = 1020
.meas tran vdout1_50ck203 FIND v(dout1_50) AT=1020.025n

* CHECK dout1_51 Vdout1_51ck203 = 0.9 time = 1020
.meas tran vdout1_51ck203 FIND v(dout1_51) AT=1020.025n

* CHECK dout1_52 Vdout1_52ck203 = 0.9 time = 1020
.meas tran vdout1_52ck203 FIND v(dout1_52) AT=1020.025n

* CHECK dout1_53 Vdout1_53ck203 = 0 time = 1020
.meas tran vdout1_53ck203 FIND v(dout1_53) AT=1020.025n

* CHECK dout1_54 Vdout1_54ck203 = 0 time = 1020
.meas tran vdout1_54ck203 FIND v(dout1_54) AT=1020.025n

* CHECK dout1_55 Vdout1_55ck203 = 0.9 time = 1020
.meas tran vdout1_55ck203 FIND v(dout1_55) AT=1020.025n

* CHECK dout1_56 Vdout1_56ck203 = 0.9 time = 1020
.meas tran vdout1_56ck203 FIND v(dout1_56) AT=1020.025n

* CHECK dout1_57 Vdout1_57ck203 = 0.9 time = 1020
.meas tran vdout1_57ck203 FIND v(dout1_57) AT=1020.025n

* CHECK dout1_58 Vdout1_58ck203 = 0.9 time = 1020
.meas tran vdout1_58ck203 FIND v(dout1_58) AT=1020.025n

* CHECK dout1_59 Vdout1_59ck203 = 0.9 time = 1020
.meas tran vdout1_59ck203 FIND v(dout1_59) AT=1020.025n

* CHECK dout1_60 Vdout1_60ck203 = 0.9 time = 1020
.meas tran vdout1_60ck203 FIND v(dout1_60) AT=1020.025n

* CHECK dout1_61 Vdout1_61ck203 = 0 time = 1020
.meas tran vdout1_61ck203 FIND v(dout1_61) AT=1020.025n

* CHECK dout1_62 Vdout1_62ck203 = 0.9 time = 1020
.meas tran vdout1_62ck203 FIND v(dout1_62) AT=1020.025n

* CHECK dout1_63 Vdout1_63ck203 = 0.9 time = 1020
.meas tran vdout1_63ck203 FIND v(dout1_63) AT=1020.025n

* CHECK dout1_64 Vdout1_64ck203 = 0 time = 1020
.meas tran vdout1_64ck203 FIND v(dout1_64) AT=1020.025n

* CHECK dout1_65 Vdout1_65ck203 = 0 time = 1020
.meas tran vdout1_65ck203 FIND v(dout1_65) AT=1020.025n

* CHECK dout1_66 Vdout1_66ck203 = 0.9 time = 1020
.meas tran vdout1_66ck203 FIND v(dout1_66) AT=1020.025n

* CHECK dout1_67 Vdout1_67ck203 = 0 time = 1020
.meas tran vdout1_67ck203 FIND v(dout1_67) AT=1020.025n

* CHECK dout1_68 Vdout1_68ck203 = 0 time = 1020
.meas tran vdout1_68ck203 FIND v(dout1_68) AT=1020.025n

* CHECK dout1_69 Vdout1_69ck203 = 0.9 time = 1020
.meas tran vdout1_69ck203 FIND v(dout1_69) AT=1020.025n

* CHECK dout1_70 Vdout1_70ck203 = 0 time = 1020
.meas tran vdout1_70ck203 FIND v(dout1_70) AT=1020.025n

* CHECK dout1_71 Vdout1_71ck203 = 0.9 time = 1020
.meas tran vdout1_71ck203 FIND v(dout1_71) AT=1020.025n

* CHECK dout1_72 Vdout1_72ck203 = 0 time = 1020
.meas tran vdout1_72ck203 FIND v(dout1_72) AT=1020.025n

* CHECK dout1_73 Vdout1_73ck203 = 0 time = 1020
.meas tran vdout1_73ck203 FIND v(dout1_73) AT=1020.025n

* CHECK dout1_74 Vdout1_74ck203 = 0 time = 1020
.meas tran vdout1_74ck203 FIND v(dout1_74) AT=1020.025n

* CHECK dout1_75 Vdout1_75ck203 = 0 time = 1020
.meas tran vdout1_75ck203 FIND v(dout1_75) AT=1020.025n

* CHECK dout1_76 Vdout1_76ck203 = 0.9 time = 1020
.meas tran vdout1_76ck203 FIND v(dout1_76) AT=1020.025n

* CHECK dout1_77 Vdout1_77ck203 = 0 time = 1020
.meas tran vdout1_77ck203 FIND v(dout1_77) AT=1020.025n

* CHECK dout1_78 Vdout1_78ck203 = 0 time = 1020
.meas tran vdout1_78ck203 FIND v(dout1_78) AT=1020.025n

* CHECK dout1_79 Vdout1_79ck203 = 0 time = 1020
.meas tran vdout1_79ck203 FIND v(dout1_79) AT=1020.025n

* CHECK dout1_80 Vdout1_80ck203 = 0.9 time = 1020
.meas tran vdout1_80ck203 FIND v(dout1_80) AT=1020.025n

* CHECK dout1_81 Vdout1_81ck203 = 0 time = 1020
.meas tran vdout1_81ck203 FIND v(dout1_81) AT=1020.025n

* CHECK dout1_82 Vdout1_82ck203 = 0 time = 1020
.meas tran vdout1_82ck203 FIND v(dout1_82) AT=1020.025n

* CHECK dout1_83 Vdout1_83ck203 = 0.9 time = 1020
.meas tran vdout1_83ck203 FIND v(dout1_83) AT=1020.025n

* CHECK dout1_84 Vdout1_84ck203 = 0 time = 1020
.meas tran vdout1_84ck203 FIND v(dout1_84) AT=1020.025n

* CHECK dout1_85 Vdout1_85ck203 = 0 time = 1020
.meas tran vdout1_85ck203 FIND v(dout1_85) AT=1020.025n

* CHECK dout1_86 Vdout1_86ck203 = 0 time = 1020
.meas tran vdout1_86ck203 FIND v(dout1_86) AT=1020.025n

* CHECK dout1_87 Vdout1_87ck203 = 0 time = 1020
.meas tran vdout1_87ck203 FIND v(dout1_87) AT=1020.025n

* CHECK dout1_88 Vdout1_88ck203 = 0 time = 1020
.meas tran vdout1_88ck203 FIND v(dout1_88) AT=1020.025n

* CHECK dout1_89 Vdout1_89ck203 = 0.9 time = 1020
.meas tran vdout1_89ck203 FIND v(dout1_89) AT=1020.025n

* CHECK dout1_90 Vdout1_90ck203 = 0 time = 1020
.meas tran vdout1_90ck203 FIND v(dout1_90) AT=1020.025n

* CHECK dout1_91 Vdout1_91ck203 = 0.9 time = 1020
.meas tran vdout1_91ck203 FIND v(dout1_91) AT=1020.025n

* CHECK dout1_92 Vdout1_92ck203 = 0 time = 1020
.meas tran vdout1_92ck203 FIND v(dout1_92) AT=1020.025n

* CHECK dout1_93 Vdout1_93ck203 = 0 time = 1020
.meas tran vdout1_93ck203 FIND v(dout1_93) AT=1020.025n

* CHECK dout1_94 Vdout1_94ck203 = 0 time = 1020
.meas tran vdout1_94ck203 FIND v(dout1_94) AT=1020.025n

* CHECK dout1_95 Vdout1_95ck203 = 0.9 time = 1020
.meas tran vdout1_95ck203 FIND v(dout1_95) AT=1020.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
